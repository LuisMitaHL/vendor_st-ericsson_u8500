;PER file generated from ready 
;by script version 1.13 20-October-10
;Author : N. PERRIN - Modified : F.GOHIER

config 16. 8.
width  40. 8.

;==============================================================
tree "B2R2"
;==============================================================
base ad:0xa0200a00
tree "BLT_CTL"
group 0--3
line.long 0 "BLT_CTL"
bitfld.long 0 28. " Big_not_little "  "0 ,1 "
bitfld.long 0 29. " Step_By_Step "  "0 ,1 "
bitfld.long 0 31. " GLOBAL_soft_reset "  "0 ,1 "
tree.end

base ad:0xa0200a04
tree "BLT_ITS"
group 0--3
line.long 0 "BLT_ITS"
bitfld.long 0 0. " CQ1_completed "  "0 ,1 "
bitfld.long 0 1. " CQ1_retriggered "  "0 ,1 "
bitfld.long 0 2. " CQ1_Node_Notif "  "0 ,1 "
bitfld.long 0 3. " CQ1_Repaced "  "0 ,1 "
bitfld.long 0 4. " CQ2_completed "  "0 ,1 "
bitfld.long 0 5. " CQ2_retriggered "  "0 ,1 "
bitfld.long 0 6. " CQ2_Node_Notif "  "0 ,1 "
bitfld.long 0 7. " CQ2_Repaced "  "0 ,1 "
bitfld.long 0 12. " AQ1_LNA_Reached "  "0 ,1 "
bitfld.long 0 13. " AQ1_Stopped "  "0 ,1 "
bitfld.long 0 14. " AQ1_Node_repeat "  "0 ,1 "
bitfld.long 0 15. " AQ1_Node_Notif "  "0 ,1 "
bitfld.long 0 16. " AQ2_LNA_Reached "  "0 ,1 "
bitfld.long 0 17. " AQ2_Stopped "  "0 ,1 "
bitfld.long 0 18. " AQ2_Node_repeat "  "0 ,1 "
bitfld.long 0 19. " AQ2_Node_Notif "  "0 ,1 "
bitfld.long 0 20. " AQ3_LNA_Reached "  "0 ,1 "
bitfld.long 0 21. " AQ3_Stopped "  "0 ,1 "
bitfld.long 0 22. " AQ3_Node_repeat "  "0 ,1 "
bitfld.long 0 23. " AQ3_Node_Notif "  "0 ,1 "
bitfld.long 0 24. " AQ4_LNA_Reached "  "0 ,1 "
bitfld.long 0 25. " AQ4_Stopped "  "0 ,1 "
bitfld.long 0 26. " AQ4_Node_repeat "  "0 ,1 "
bitfld.long 0 27. " AQ4_Node_Notif "  "0 ,1 "
bitfld.long 0 31. " RLD_ERROR "  "0 ,1 "
tree.end

base ad:0xa0200a08
tree "BLT_STA1"
group 0--3
line.long 0 "BLT_STA1"
bitfld.long 0 0. " BDISP_IDLE "  "0 ,1 "
tree.end

base ad:0xa0200a10
tree "BLT_SSBA1"
group 0--3
line.long 0 "BLT_SSBA1"
bitfld.long 0 0.--25. " SSBA1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA1_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a14
tree "BLT_SSBA2"
group 0--3
line.long 0 "BLT_SSBA2"
bitfld.long 0 0.--25. " SSBA2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA2_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a18
tree "BLT_SSBA3"
group 0--3
line.long 0 "BLT_SSBA3"
bitfld.long 0 0.--25. " SSBA3_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA3_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a1c
tree "BLT_SSBA4"
group 0--3
line.long 0 "BLT_SSBA4"
bitfld.long 0 0.--25. " SSBA4_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA4_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a20
tree "BLT_SSBA5"
group 0--3
line.long 0 "BLT_SSBA5"
bitfld.long 0 0.--25. " SSBA5_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA5_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a24
tree "BLT_SSBA6"
group 0--3
line.long 0 "BLT_SSBA6"
bitfld.long 0 0.--25. " SSBA6_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA6_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a28
tree "BLT_SSBA7"
group 0--3
line.long 0 "BLT_SSBA7"
bitfld.long 0 0.--25. " SSBA7_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA7_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a2c
tree "BLT_SSBA8"
group 0--3
line.long 0 "BLT_SSBA8"
bitfld.long 0 0.--25. " SSBA8_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA8_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200aa0
tree "BLT_SSBA9"
group 0--3
line.long 0 "BLT_SSBA9"
bitfld.long 0 0.--25. " SSBA9_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA9_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200aa4
tree "BLT_SSBA10"
group 0--3
line.long 0 "BLT_SSBA10"
bitfld.long 0 0.--25. " SSBA10_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA10_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200aa8
tree "BLT_SSBA11"
group 0--3
line.long 0 "BLT_SSBA11"
bitfld.long 0 0.--25. " SSBA11_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA11_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200aac
tree "BLT_SSBA12"
group 0--3
line.long 0 "BLT_SSBA12"
bitfld.long 0 0.--25. " SSBA12_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA12_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200ab0
tree "BLT_SSBA13"
group 0--3
line.long 0 "BLT_SSBA13"
bitfld.long 0 0.--25. " SSBA13_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA13_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200ab4
tree "BLT_SSBA14"
group 0--3
line.long 0 "BLT_SSBA14"
bitfld.long 0 0.--25. " SSBA14_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA14_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200ab8
tree "BLT_SSBA15"
group 0--3
line.long 0 "BLT_SSBA15"
bitfld.long 0 0.--25. " SSBA15_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA15_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200abc
tree "BLT_SSBA16"
group 0--3
line.long 0 "BLT_SSBA16"
bitfld.long 0 0.--25. " SSBA16_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA16_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a30
tree "BLT_STBA1"
group 0--3
line.long 0 "BLT_STBA1"
bitfld.long 0 0.--25. " STBA1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA1_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a34
tree "BLT_STBA2"
group 0--3
line.long 0 "BLT_STBA2"
bitfld.long 0 0.--25. " STBA2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA2_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a38
tree "BLT_STBA3"
group 0--3
line.long 0 "BLT_STBA3"
bitfld.long 0 0.--25. " STBA3_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA3_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a3c
tree "BLT_STBA4"
group 0--3
line.long 0 "BLT_STBA4"
bitfld.long 0 0.--25. " STBA4_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA4_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a40
tree "BLT_CQ1_TRIG_IP"
group 0--3
line.long 0 "BLT_CQ1_TRIG_IP"
bitfld.long 0 0.--25. " CQ1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " TRIG_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a50
tree "BLT_CQ2_TRIG_IP"
group 0--3
line.long 0 "BLT_CQ2_TRIG_IP"
bitfld.long 0 0.--25. " CQ2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " TRIG_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a44
tree "BLT_CQ1_TRIG_CTL"
group 0--3
line.long 0 "BLT_CQ1_TRIG_CTL"
bitfld.long 0 0.--11. " Trigger_line_num "  " "
bitfld.long 0 12.--15. " Trig_cond "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " Retrig_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
tree.end

base ad:0xa0200a54
tree "BLT_CQ2_TRIG_CTL"
group 0--3
line.long 0 "BLT_CQ2_TRIG_CTL"
bitfld.long 0 0.--11. " Trigger_line_num "  " "
bitfld.long 0 12.--15. " Trig_cond "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " Retrig_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
tree.end

base ad:0xa0200a48
tree "BLT_CQ1_PACE_CTL"
group 0--3
line.long 0 "BLT_CQ1_PACE_CTL"
bitfld.long 0 0.--11. " Pace_start "  " "
bitfld.long 0 16.--27. " Pace_Count "  " "
bitfld.long 0 31. " Dynamic_Pace "  "0 ,1 "
tree.end

base ad:0xa0200a58
tree "BLT_CQ2_PACE_CTL"
group 0--3
line.long 0 "BLT_CQ2_PACE_CTL"
bitfld.long 0 0.--11. " Pace_start "  " "
bitfld.long 0 16.--27. " Pace_Count "  " "
bitfld.long 0 31. " Dynamic_Pace "  "0 ,1 "
tree.end

base ad:0xa0200a4c
tree "BLT_CQ1_IP"
rgroup 0--3
line.long 0 "BLT_CQ1_IP"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a5c
tree "BLT_CQ2_IP"
rgroup 0--3
line.long 0 "BLT_CQ2_IP"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a60
tree "BLT_AQ1_CTL"
group 0--3
line.long 0 "BLT_AQ1_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
tree.end

base ad:0xa0200a70
tree "BLT_AQ2_CTL"
group 0--3
line.long 0 "BLT_AQ2_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
tree.end

base ad:0xa0200a80
tree "BLT_AQ3_CTL"
group 0--3
line.long 0 "BLT_AQ3_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
tree.end

base ad:0xa0200a90
tree "BLT_AQ4_CTL"
group 0--3
line.long 0 "BLT_AQ4_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
tree.end

base ad:0xa0200a64
tree "BLT_AQ1_IP"
group 0--3
line.long 0 "BLT_AQ1_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a74
tree "BLT_AQ2_IP"
group 0--3
line.long 0 "BLT_AQ2_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a84
tree "BLT_AQ3_IP"
group 0--3
line.long 0 "BLT_AQ3_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a94
tree "BLT_AQ4_IP"
group 0--3
line.long 0 "BLT_AQ4_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a68
tree "BLT_AQ1_LNA"
group 0--3
line.long 0 "BLT_AQ1_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a78
tree "BLT_AQ2_LNA"
group 0--3
line.long 0 "BLT_AQ2_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a88
tree "BLT_AQ3_LNA"
group 0--3
line.long 0 "BLT_AQ3_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a98
tree "BLT_AQ4_LNA"
group 0--3
line.long 0 "BLT_AQ4_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a6c
tree "BLT_AQ1_STA"
rgroup 0--3
line.long 0 "BLT_AQ1_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a7c
tree "BLT_AQ2_STA"
rgroup 0--3
line.long 0 "BLT_AQ2_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a8c
tree "BLT_AQ3_STA"
rgroup 0--3
line.long 0 "BLT_AQ3_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200a9c
tree "BLT_AQ4_STA"
rgroup 0--3
line.long 0 "BLT_AQ4_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200ac0
tree "BLT_SGA1"
group 0--3
line.long 0 "BLT_SGA1"
hexfld.byte 0 " Alpha1 "
hexfld.byte 1 " Alpha2 "
hexfld.byte 2 " Alpha3 "
hexfld.byte 3 " Alpha4 "
tree.end

base ad:0xa0200ac4
tree "BLT_SGA2"
group 0--3
line.long 0 "BLT_SGA2"
hexfld.byte 0 " Alpha5 "
hexfld.byte 1 " Alpha6 "
hexfld.byte 2 " Alpha7 "
hexfld.byte 3 " Alpha8 "
tree.end

base ad:0xa0200ad0
tree "BLT_ITM0"
group 0--3
line.long 0 "BLT_ITM0"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
tree.end

base ad:0xa0200ad4
tree "BLT_ITM1"
group 0--3
line.long 0 "BLT_ITM1"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
tree.end

base ad:0xa0200ad8
tree "BLT_ITM2"
group 0--3
line.long 0 "BLT_ITM2"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
tree.end

base ad:0xa0200adc
tree "BLT_ITM3"
group 0--3
line.long 0 "BLT_ITM3"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
tree.end

base ad:0xa0200af4
tree "BLT_DFV1"
group 0--3
line.long 0 "BLT_DFV1"
bitfld.long 0 0.--11. " DFV1_Line_count "  " "
bitfld.long 0 12. " DFV1_ITM0_IT "  "0 ,1 "
bitfld.long 0 13. " DFV1_ITM1_IT "  "0 ,1 "
bitfld.long 0 14. " DFV1_ITM2_IT "  "0 ,1 "
bitfld.long 0 15. " DFV1_ITM3_IT "  "0 ,1 "
bitfld.long 0 16. " DFV1_AQ1_IT "  "0 ,1 "
bitfld.long 0 17. " DFV1_AQ2_IT "  "0 ,1 "
bitfld.long 0 18. " DFV1_AQ3_IT "  "0 ,1 "
bitfld.long 0 19. " DFV1_AQ4_IT "  "0 ,1 "
bitfld.long 0 20. " DFV1_CQ1_IT "  "0 ,1 "
bitfld.long 0 21. " DFV1_CQ2_IT "  "0 ,1 "
bitfld.long 0 24. " DFV1_GPO "  "0 ,1 "
bitfld.long 0 28. " DFV1_req "  "0 ,1 "
bitfld.long 0 29. " DFV1_ntop_bot "  "0 ,1 "
bitfld.long 0 30. " DFV1_Vsync "  "0 ,1 "
bitfld.long 0 31. " DFV1_Mode_En "  "0 ,1 "
tree.end

base ad:0xa0200af0
tree "BLT_DFV2"
group 0--3
line.long 0 "BLT_DFV2"
bitfld.long 0 0.--11. " DFV2_Line_count "  " "
bitfld.long 0 28. " DFV2_req "  "0 ,1 "
bitfld.long 0 29. " DFV2_ntop_bot "  "0 ,1 "
bitfld.long 0 30. " DFV2_Vsync "  "0 ,1 "
bitfld.long 0 31. " DFV2_Mode_En "  "0 ,1 "
tree.end

base ad:0xa0200af8
tree "BLT_PRI"
group 0--3
line.long 0 "BLT_PRI"
bitfld.long 0 0.--3. " CQ1_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " CQ2_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " AQ1_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " AQ2_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " AQ3_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " AQ4_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0200900
tree "BLT_SSBA17"
group 0--3
line.long 0 "BLT_SSBA17"
bitfld.long 0 0.--25. " SSBA17_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA17_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200904
tree "BLT_SSBA18"
group 0--3
line.long 0 "BLT_SSBA18"
bitfld.long 0 0.--25. " SSBA18_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA18_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200908
tree "BLT_SSBA19"
group 0--3
line.long 0 "BLT_SSBA19"
bitfld.long 0 0.--25. " SSBA19_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA19_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa020090c
tree "BLT_SSBA20"
group 0--3
line.long 0 "BLT_SSBA20"
bitfld.long 0 0.--25. " SSBA20_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA20_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200910
tree "BLT_SSBA21"
group 0--3
line.long 0 "BLT_SSBA21"
bitfld.long 0 0.--25. " SSBA21_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA21_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200914
tree "BLT_SSBA22"
group 0--3
line.long 0 "BLT_SSBA22"
bitfld.long 0 0.--25. " SSBA22_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA22_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200918
tree "BLT_SSBA23"
group 0--3
line.long 0 "BLT_SSBA23"
bitfld.long 0 0.--25. " SSBA23_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA23_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa020091c
tree "BLT_SSBA24"
group 0--3
line.long 0 "BLT_SSBA24"
bitfld.long 0 0.--25. " SSBA24_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA24_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200940
tree "BLT_STBA5"
group 0--3
line.long 0 "BLT_STBA5"
bitfld.long 0 0.--25. " STBA5_Mem_address "  " "
bitfld.long 0 26.--31. " STBA5_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200944
tree "BLT_STBA6"
group 0--3
line.long 0 "BLT_STBA6"
bitfld.long 0 0.--25. " STBA6_Mem_address "  " "
bitfld.long 0 26.--31. " STBA6_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200948
tree "BLT_STBA7"
group 0--3
line.long 0 "BLT_STBA7"
bitfld.long 0 0.--25. " STBA7_Mem_address "  " "
bitfld.long 0 26.--31. " STBA7_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa020094c
tree "BLT_STBA8"
group 0--3
line.long 0 "BLT_STBA8"
bitfld.long 0 0.--25. " STBA8_Mem_address "  " "
bitfld.long 0 26.--31. " STBA8_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200b04
tree "PLUGS1_OP2"
group 0--3
line.long 0 "PLUGS1_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0200b24
tree "PLUGS2_OP2"
group 0--3
line.long 0 "PLUGS2_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0200b44
tree "PLUGS3_OP2"
group 0--3
line.long 0 "PLUGS3_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0200b08
tree "PLUGS1_CHZ"
group 0--3
line.long 0 "PLUGS1_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0200b28
tree "PLUGS2_CHZ"
group 0--3
line.long 0 "PLUGS2_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0200b48
tree "PLUGS3_CHZ"
group 0--3
line.long 0 "PLUGS3_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0200b0c
tree "PLUGS1_MSZ"
group 0--3
line.long 0 "PLUGS1_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " MinSpaceBetweenReq "
tree.end

base ad:0xa0200b2c
tree "PLUGS2_MSZ"
group 0--3
line.long 0 "PLUGS2_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " MinSpaceBetweenReq "
tree.end

base ad:0xa0200b4c
tree "PLUGS3_MSZ"
group 0--3
line.long 0 "PLUGS3_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " MinSpaceBetweenReq "
tree.end

base ad:0xa0200b10
tree "PLUGS1_PGZ"
group 0--3
line.long 0 "PLUGS1_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0200b30
tree "PLUGS2_PGZ"
group 0--3
line.long 0 "PLUGS2_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0200b50
tree "PLUGS3_PGZ"
group 0--3
line.long 0 "PLUGS3_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0200b84
tree "PLUGT_OP2"
group 0--3
line.long 0 "PLUGT_OP2"
bitfld.long 0 0.--2. " Max_code "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0200b88
tree "PLUGT_CHZ"
group 0--3
line.long 0 "PLUGT_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0200b8c
tree "PLUGT_MSZ"
group 0--3
line.long 0 "PLUGT_MSZ"
bitfld.long 0 0.--2. " Message_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " MinSpaceBetweenReq "
tree.end

base ad:0xa0200b90
tree "PLUGT_PGZ"
group 0--3
line.long 0 "PLUGT_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0200c00
tree "BLT_NIP"
group 0--3
line.long 0 "BLT_NIP"
bitfld.long 0 0.--25. " NIP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " NIP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200c04
tree "BLT_CIC"
group 0--3
line.long 0 "BLT_CIC"
bitfld.long 0 2. " Group2 "  "0 ,1 "
bitfld.long 0 3. " Group3 "  "0 ,1 "
bitfld.long 0 4. " Group4 "  "0 ,1 "
bitfld.long 0 5. " Group5 "  "0 ,1 "
bitfld.long 0 6. " Group6 "  "0 ,1 "
bitfld.long 0 7. " Group7 "  "0 ,1 "
bitfld.long 0 8. " Group8 "  "0 ,1 "
bitfld.long 0 9. " Group9 "  "0 ,1 "
bitfld.long 0 10. " Group10 "  "0 ,1 "
bitfld.long 0 11. " Group11 "  "0 ,1 "
bitfld.long 0 12. " Group12 "  "0 ,1 "
bitfld.long 0 13. " Group13 "  "0 ,1 "
bitfld.long 0 14. " Group14 "  "0 ,1 "
bitfld.long 0 15. " Group15 "  "0 ,1 "
bitfld.long 0 16. " Group16 "  "0 ,1 "
bitfld.long 0 17. " Group17 "  "0 ,1 "
bitfld.long 0 18. " Group18 "  "0 ,1 "
tree.end

base ad:0xa0200c08
tree "BLT_INS"
group 0--3
line.long 0 "BLT_INS"
bitfld.long 0 0.--2. " SOURCE1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--4. " SOURCE2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " SOURCE3 "  "0 ,1 "
bitfld.long 0 6. " IVMX "  "0 ,1 "
bitfld.long 0 7. " CLUTOP "  "0 ,1 "
bitfld.long 0 8. " 2DRESCALE "  "0 ,1 "
bitfld.long 0 9. " FILCK_FILT "  "0 ,1 "
bitfld.long 0 10. " RECT_CLIP "  "0 ,1 "
bitfld.long 0 11. " CKEY "  "0 ,1 "
bitfld.long 0 12. " OVMX "  "0 ,1 "
bitfld.long 0 13. " DEI "  "0 ,1 "
bitfld.long 0 14. " PLANE_MASK "  "0 ,1 "
bitfld.long 0 15. " XYL "  "0 ,1 "
bitfld.long 0 16. " DOT "  "0 ,1 "
bitfld.long 0 17. " VC1R "  "0 ,1 "
bitfld.long 0 18. " ROTATION "  "0 ,1 "
bitfld.long 0 30. " Pace_down "  "0 ,1 "
bitfld.long 0 31. " BlitCompIRQ "  "0 ,1 "
tree.end

base ad:0xa0200c0c
tree "BLT_ACK"
group 0--3
line.long 0 "BLT_ACK"
bitfld.long 0 0.--3. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " SWAP_FG_BG "  "0 ,1 "
hexfld.byte 1 " GALPHA_ROPID "
bitfld.long 0 16.--21. " ACK_CKEY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--23. " CKEY_SEL "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0200c10
tree "BLT_TBA"
group 0--3
line.long 0 "BLT_TBA"
bitfld.long 0 0.--25. " TBA_mem_addr "  " "
bitfld.long 0 26.--31. " TBA_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200c14
tree "BLT_TTY"
group 0--3
line.long 0 "BLT_TTY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 26. " RGB_ROUND "  "0 ,1 "
bitfld.long 0 27. " CHROMA_notLUMA "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
tree.end

base ad:0xa0200c18
tree "BLT_TXY"
group 0--3
line.long 0 "BLT_TXY"
hexfld.word 0 " XCOORD "
hexfld.word 2 " YCOORD "
tree.end

base ad:0xa0200c1c
tree "BLT_TSZ"
group 0--3
line.long 0 "BLT_TSZ"
bitfld.long 0 0.--11. " WIN_WIDTH "  " "
bitfld.long 0 16.--27. " WIN_HEIGHT "  " "
tree.end

base ad:0xa0200c20
tree "BLT_S1CF"
group 0--3
line.long 0 "BLT_S1CF"
hexfld.long 0 " SRC1_COLOR_FILL "
tree.end

base ad:0xa0200c24
tree "BLT_S2CF"
group 0--3
line.long 0 "BLT_S2CF"
hexfld.long 0 " SRC2_COLOR_FILL "
tree.end

base ad:0xa0200c28
tree "BLT_S1BA"
group 0--3
line.long 0 "BLT_S1BA"
bitfld.long 0 0.--25. " S1BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S1BA_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200c2c
tree "BLT_S1TY"
group 0--3
line.long 0 "BLT_S1TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 22. " A1_SUBST "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 27. " ROTATION "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 29. " RGB_EXP "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
tree.end

base ad:0xa0200c30
tree "BLT_S1XY"
group 0--3
line.long 0 "BLT_S1XY"
hexfld.word 0 " XCOORD "
hexfld.word 2 " YCOORD "
tree.end

base ad:0xa0200c38
tree "BLT_S2BA"
group 0--3
line.long 0 "BLT_S2BA"
bitfld.long 0 0.--25. " S2BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S2BA_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200c3c
tree "BLT_S2TY"
group 0--3
line.long 0 "BLT_S2TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 22. " A1_SUBST "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 26. " CHROMA_LEFT "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 29. " RGB_EXP "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
tree.end

base ad:0xa0200c40
tree "BLT_S2XY"
group 0--3
line.long 0 "BLT_S2XY"
hexfld.word 0 " XCOORD "
hexfld.word 2 " YCOORD "
tree.end

base ad:0xa0200c44
tree "BLT_S2SZ"
group 0--3
line.long 0 "BLT_S2SZ"
bitfld.long 0 0.--11. " SRC2_WIN_WIDTH "  " "
bitfld.long 0 16.--27. " SRC2_WIN_HEIGHT "  " "
tree.end

base ad:0xa0200c48
tree "BLT_S3BA"
group 0--3
line.long 0 "BLT_S3BA"
bitfld.long 0 0.--25. " S3BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S3BA_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200c4c
tree "BLT_S3TY"
group 0--3
line.long 0 "BLT_S3TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " VSO "  "0 ,1 "
bitfld.long 0 25. " HSO "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
tree.end

base ad:0xa0200c50
tree "BLT_S3XY"
group 0--3
line.long 0 "BLT_S3XY"
hexfld.word 0 " XCOORD "
hexfld.word 2 " YCOORD "
tree.end

base ad:0xa0200c54
tree "BLT_S3SZ"
group 0--3
line.long 0 "BLT_S3SZ"
bitfld.long 0 0.--11. " SRC3_WIN_WIDTH "  " "
bitfld.long 0 16.--27. " SRC3_WIN_HEIGHT "  " "
tree.end

base ad:0xa0200c58
tree "BLT_CWO"
group 0--3
line.long 0 "BLT_CWO"
bitfld.long 0 0.--14. " XDO "  " "
bitfld.long 0 16.--26. " YDO "  " "
bitfld.long 0 27. " INTNL "  "0 ,1 "
tree.end

base ad:0xa0200c5c
tree "BLT_CWS"
group 0--3
line.long 0 "BLT_CWS"
bitfld.long 0 0.--14. " XDS "  " "
bitfld.long 0 16.--26. " YDS "  " "
tree.end

base ad:0xa0200c60
tree "BLT_CCO"
group 0--3
line.long 0 "BLT_CCO"
bitfld.long 0 15. " CLUT_NS2_1S1 "  "0 ,1 "
bitfld.long 0 16.--17. " CLUT_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " CLUT_UPDATE "  "0 ,1 "
bitfld.long 0 19.--22. " CLUT_ERRDIFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0200c64
tree "BLT_CML"
group 0--3
line.long 0 "BLT_CML"
bitfld.long 0 4.--25. " CML_MEM_ADDR "  " "
bitfld.long 0 26.--31. " CML_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200c68
tree "BLT_FCTL"
group 0--3
line.long 0 "BLT_FCTL"
bitfld.long 0 0.--2. " 2DHF_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " 2DVF_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12. " AB_Right "  "0 ,1 "
bitfld.long 0 13. " AB_Left "  "0 ,1 "
bitfld.long 0 14. " AB_BOT "  "0 ,1 "
bitfld.long 0 15. " AB_TOP "  "0 ,1 "
bitfld.long 0 24.--25. " Luma_2Dhf_mode "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " Luma_2Dvf_mode "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0200c6c
tree "BLT_PMK"
group 0--3
line.long 0 "BLT_PMK"
bitfld.long 0 0. " PLANE_MASK "  "0 ,1 "
tree.end

base ad:0xa0200c70
tree "BLT_RSF"
group 0--3
line.long 0 "BLT_RSF"
hexfld.word 0 " HSRC_INC "
hexfld.word 2 " VSRC_INC "
tree.end

base ad:0xa0200c74
tree "BLT_RZI"
group 0--3
line.long 0 "BLT_RZI"
bitfld.long 0 0.--9. " HSRC_INIT "  " "
bitfld.long 0 12.--14. " Hnb_repeat "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--25. " VSRC_INIT "  " "
bitfld.long 0 28.--30. " Vnb_repeat "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0200c78
tree "BLT_HFP"
group 0--3
line.long 0 "BLT_HFP"
bitfld.long 0 0.--25. " HFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " HFP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200c7c
tree "BLT_VFP"
group 0--3
line.long 0 "BLT_VFP"
bitfld.long 0 0.--25. " VFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " VFP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200c80
tree "BLT_Y_RSF"
group 0--3
line.long 0 "BLT_Y_RSF"
hexfld.word 0 " Luma_HSRC_INC "
hexfld.word 2 " Luma_VSRC_INC "
tree.end

base ad:0xa0200c84
tree "BLT_Y_RZI"
group 0--3
line.long 0 "BLT_Y_RZI"
bitfld.long 0 0.--9. " Hsrc_init_luma "  " "
bitfld.long 0 12.--14. " Hnb_repeat_luma "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--25. " Vsrc_init_luma "  " "
bitfld.long 0 28.--30. " Vnb_repeat_Luma "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0200c88
tree "BLT_Y_HFP"
group 0--3
line.long 0 "BLT_Y_HFP"
bitfld.long 0 0.--25. " Y_HFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " Y_Hfp_Bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200c8c
tree "BLT_Y_VFP"
group 0--3
line.long 0 "BLT_Y_VFP"
bitfld.long 0 0.--25. " Y_VFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " Y_Vfp_Bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0200ca0
tree "BLT_KEY1"
group 0--3
line.long 0 "BLT_KEY1"
hexfld.byte 0 " BLUE_MIN "
hexfld.byte 1 " GREEN_MIN "
hexfld.byte 2 " RED_MIN "
hexfld.byte 3 " ALPHA0 "
tree.end

base ad:0xa0200ca4
tree "BLT_KEY2"
group 0--3
line.long 0 "BLT_KEY2"
hexfld.byte 0 " BLUE_MAX "
hexfld.byte 1 " GREEN_MAX "
hexfld.byte 2 " RED_MAX "
hexfld.byte 3 " ALPHA1 "
tree.end

base ad:0xa0200cb0
tree "BLT_SAR"
group 0--3
line.long 0 "BLT_SAR"
bitfld.long 0 0.--4. " S1_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " S2_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " S3_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--27. " T_STBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " A_SGA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0200cb4
tree "BLT_USR"
group 0--3
line.long 0 "BLT_USR"
hexfld.long 0 " GENERAL_PURPOSE "
tree.end

base ad:0xa0200cc0
tree "BLT_IVMX0"
group 0--3
line.long 0 "BLT_IVMX0"
bitfld.long 0 0.--9. " Coeff13 "  " "
bitfld.long 0 10.--20. " Coeff12 "  " "
bitfld.long 0 21.--31. " Coeff11 "  " "
tree.end

base ad:0xa0200cc4
tree "BLT_IVMX1"
group 0--3
line.long 0 "BLT_IVMX1"
bitfld.long 0 0.--9. " Coeff23 "  " "
bitfld.long 0 10.--20. " Coeff22 "  " "
bitfld.long 0 21.--31. " Coeff21 "  " "
tree.end

base ad:0xa0200cc8
tree "BLT_IVMX2"
group 0--3
line.long 0 "BLT_IVMX2"
bitfld.long 0 0.--9. " Coeff33 "  " "
bitfld.long 0 10.--20. " Coeff32 "  " "
bitfld.long 0 21.--31. " Coeff31 "  " "
tree.end

base ad:0xa0200ccc
tree "BLT_IVMX3"
group 0--3
line.long 0 "BLT_IVMX3"
bitfld.long 0 0.--9. " Offset3 "  " "
bitfld.long 0 10.--19. " Offset2 "  " "
bitfld.long 0 20.--29. " Offset1 "  " "
tree.end

base ad:0xa0200cd0
tree "BLT_OVMX0"
group 0--3
line.long 0 "BLT_OVMX0"
bitfld.long 0 0.--9. " Coeff13 "  " "
bitfld.long 0 10.--20. " Coeff12 "  " "
bitfld.long 0 21.--31. " Coeff11 "  " "
tree.end

base ad:0xa0200cd4
tree "BLT_OVMX1"
group 0--3
line.long 0 "BLT_OVMX1"
bitfld.long 0 0.--9. " Coeff23 "  " "
bitfld.long 0 10.--20. " Coeff22 "  " "
bitfld.long 0 21.--31. " Coeff21 "  " "
tree.end

base ad:0xa0200cd8
tree "BLT_OVMX2"
group 0--3
line.long 0 "BLT_OVMX2"
bitfld.long 0 0.--9. " Coeff33 "  " "
bitfld.long 0 10.--20. " Coeff32 "  " "
bitfld.long 0 21.--31. " Coeff31 "  " "
tree.end

base ad:0xa0200cdc
tree "BLT_OVMX3"
group 0--3
line.long 0 "BLT_OVMX3"
bitfld.long 0 0.--9. " Offset3 "  " "
bitfld.long 0 10.--19. " Offset2 "  " "
bitfld.long 0 20.--29. " Offset1 "  " "
tree.end

base ad:0xa0200ce8
tree "BLT_VC1R"
group 0--3
line.long 0 "BLT_VC1R"
bitfld.long 0 0.--2. " Luma_coeff "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " Luma_Map "  "0 ,1 "
bitfld.long 0 4.--6. " Chroma_coeff "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " Chroma_map "  "0 ,1 "
tree.end

base ad:0xa0200e00
tree "BLT_HFC0"
group 0--3
line.long 0 "BLT_HFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
tree.end

base ad:0xa0200e04
tree "BLT_HFC1"
group 0--3
line.long 0 "BLT_HFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K5 "
hexfld.byte 2 " K6 "
hexfld.byte 3 " K7 "
tree.end

base ad:0xa0200e08
tree "BLT_HFC2"
group 0--3
line.long 0 "BLT_HFC2"
hexfld.byte 0 " K10 "
hexfld.byte 1 " K11 "
hexfld.byte 2 " K12 "
hexfld.byte 3 " K13 "
tree.end

base ad:0xa0200e0c
tree "BLT_HFC3"
group 0--3
line.long 0 "BLT_HFC3"
hexfld.byte 0 " K14 "
hexfld.byte 1 " K15 "
hexfld.byte 2 " K16 "
hexfld.byte 3 " K17 "
tree.end

base ad:0xa0200e10
tree "BLT_HFC4"
group 0--3
line.long 0 "BLT_HFC4"
hexfld.byte 0 " K20 "
hexfld.byte 1 " K21 "
hexfld.byte 2 " K22 "
hexfld.byte 3 " K23 "
tree.end

base ad:0xa0200e14
tree "BLT_HFC5"
group 0--3
line.long 0 "BLT_HFC5"
hexfld.byte 0 " K24 "
hexfld.byte 1 " K25 "
hexfld.byte 2 " K26 "
hexfld.byte 3 " K27 "
tree.end

base ad:0xa0200e18
tree "BLT_HFC6"
group 0--3
line.long 0 "BLT_HFC6"
hexfld.byte 0 " K30 "
hexfld.byte 1 " K31 "
hexfld.byte 2 " K32 "
hexfld.byte 3 " K33 "
tree.end

base ad:0xa0200e1c
tree "BLT_HFC7"
group 0--3
line.long 0 "BLT_HFC7"
hexfld.byte 0 " K34 "
hexfld.byte 1 " K35 "
hexfld.byte 2 " K36 "
hexfld.byte 3 " K37 "
tree.end

base ad:0xa0200e20
tree "BLT_HFC8"
group 0--3
line.long 0 "BLT_HFC8"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
tree.end

base ad:0xa0200e24
tree "BLT_HFC9"
group 0--3
line.long 0 "BLT_HFC9"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K45 "
hexfld.byte 2 " K46 "
hexfld.byte 3 " K47 "
tree.end

base ad:0xa0200e28
tree "BLT_HFC10"
group 0--3
line.long 0 "BLT_HFC10"
hexfld.byte 0 " K50 "
hexfld.byte 1 " K51 "
hexfld.byte 2 " K52 "
hexfld.byte 3 " K53 "
tree.end

base ad:0xa0200e2c
tree "BLT_HFC11"
group 0--3
line.long 0 "BLT_HFC11"
hexfld.byte 0 " K54 "
hexfld.byte 1 " K55 "
hexfld.byte 2 " K56 "
hexfld.byte 3 " K57 "
tree.end

base ad:0xa0200e30
tree "BLT_HFC12"
group 0--3
line.long 0 "BLT_HFC12"
hexfld.byte 0 " K60 "
hexfld.byte 1 " K61 "
hexfld.byte 2 " K62 "
hexfld.byte 3 " K63 "
tree.end

base ad:0xa0200e34
tree "BLT_HFC13"
group 0--3
line.long 0 "BLT_HFC13"
hexfld.byte 0 " K64 "
hexfld.byte 1 " K65 "
hexfld.byte 2 " K66 "
hexfld.byte 3 " K67 "
tree.end

base ad:0xa0200e38
tree "BLT_HFC14"
group 0--3
line.long 0 "BLT_HFC14"
hexfld.byte 0 " K70 "
hexfld.byte 1 " K71 "
hexfld.byte 2 " K72 "
hexfld.byte 3 " K73 "
tree.end

base ad:0xa0200e3c
tree "BLT_HFC15"
group 0--3
line.long 0 "BLT_HFC15"
hexfld.byte 0 " K74 "
hexfld.byte 1 " K75 "
hexfld.byte 2 " K76 "
hexfld.byte 3 " K77 "
tree.end

base ad:0xa0200e90
tree "BLT_VFC0"
group 0--3
line.long 0 "BLT_VFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
tree.end

base ad:0xa0200e94
tree "BLT_VFC1"
group 0--3
line.long 0 "BLT_VFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K10 "
hexfld.byte 2 " K11 "
hexfld.byte 3 " K12 "
tree.end

base ad:0xa0200e98
tree "BLT_VFC2"
group 0--3
line.long 0 "BLT_VFC2"
hexfld.byte 0 " K13 "
hexfld.byte 1 " K14 "
hexfld.byte 2 " K20 "
hexfld.byte 3 " K21 "
tree.end

base ad:0xa0200e9c
tree "BLT_VFC3"
group 0--3
line.long 0 "BLT_VFC3"
hexfld.byte 0 " K22 "
hexfld.byte 1 " K23 "
hexfld.byte 2 " K24 "
hexfld.byte 3 " K30 "
tree.end

base ad:0xa0200ea0
tree "BLT_VFC4"
group 0--3
line.long 0 "BLT_VFC4"
hexfld.byte 0 " K31 "
hexfld.byte 1 " K32 "
hexfld.byte 2 " K33 "
hexfld.byte 3 " K34 "
tree.end

base ad:0xa0200ea4
tree "BLT_VFC5"
group 0--3
line.long 0 "BLT_VFC5"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
tree.end

base ad:0xa0200ea8
tree "BLT_VFC6"
group 0--3
line.long 0 "BLT_VFC6"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K50 "
hexfld.byte 2 " K51 "
hexfld.byte 3 " K52 "
tree.end

base ad:0xa0200eac
tree "BLT_VFC7"
group 0--3
line.long 0 "BLT_VFC7"
hexfld.byte 0 " K53 "
hexfld.byte 1 " K54 "
hexfld.byte 2 " K60 "
hexfld.byte 3 " K61 "
tree.end

base ad:0xa0200eb0
tree "BLT_VFC8"
group 0--3
line.long 0 "BLT_VFC8"
hexfld.byte 0 " K62 "
hexfld.byte 1 " K63 "
hexfld.byte 2 " K64 "
hexfld.byte 3 " K70 "
tree.end

base ad:0xa0200eb4
tree "BLT_VFC9"
group 0--3
line.long 0 "BLT_VFC9"
hexfld.byte 0 " K71 "
hexfld.byte 1 " K72 "
hexfld.byte 2 " K73 "
hexfld.byte 3 " K74 "
tree.end

base ad:0xa0200d00
tree "BLT_Y_HFC0"
group 0--3
line.long 0 "BLT_Y_HFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
tree.end

base ad:0xa0200d04
tree "BLT_Y_HFC1"
group 0--3
line.long 0 "BLT_Y_HFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K5 "
hexfld.byte 2 " K6 "
hexfld.byte 3 " K7 "
tree.end

base ad:0xa0200d08
tree "BLT_Y_HFC2"
group 0--3
line.long 0 "BLT_Y_HFC2"
hexfld.byte 0 " K10 "
hexfld.byte 1 " K11 "
hexfld.byte 2 " K12 "
hexfld.byte 3 " K13 "
tree.end

base ad:0xa0200d0c
tree "BLT_Y_HFC3"
group 0--3
line.long 0 "BLT_Y_HFC3"
hexfld.byte 0 " K14 "
hexfld.byte 1 " K15 "
hexfld.byte 2 " K16 "
hexfld.byte 3 " K17 "
tree.end

base ad:0xa0200d10
tree "BLT_Y_HFC4"
group 0--3
line.long 0 "BLT_Y_HFC4"
hexfld.byte 0 " K20 "
hexfld.byte 1 " K21 "
hexfld.byte 2 " K22 "
hexfld.byte 3 " K23 "
tree.end

base ad:0xa0200d14
tree "BLT_Y_HFC5"
group 0--3
line.long 0 "BLT_Y_HFC5"
hexfld.byte 0 " K24 "
hexfld.byte 1 " K25 "
hexfld.byte 2 " K26 "
hexfld.byte 3 " K27 "
tree.end

base ad:0xa0200d18
tree "BLT_Y_HFC6"
group 0--3
line.long 0 "BLT_Y_HFC6"
hexfld.byte 0 " K30 "
hexfld.byte 1 " K31 "
hexfld.byte 2 " K32 "
hexfld.byte 3 " K33 "
tree.end

base ad:0xa0200d1c
tree "BLT_Y_HFC7"
group 0--3
line.long 0 "BLT_Y_HFC7"
hexfld.byte 0 " K34 "
hexfld.byte 1 " K35 "
hexfld.byte 2 " K36 "
hexfld.byte 3 " K37 "
tree.end

base ad:0xa0200d20
tree "BLT_Y_HFC8"
group 0--3
line.long 0 "BLT_Y_HFC8"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
tree.end

base ad:0xa0200d24
tree "BLT_Y_HFC9"
group 0--3
line.long 0 "BLT_Y_HFC9"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K45 "
hexfld.byte 2 " K46 "
hexfld.byte 3 " K47 "
tree.end

base ad:0xa0200d28
tree "BLT_Y_HFC10"
group 0--3
line.long 0 "BLT_Y_HFC10"
hexfld.byte 0 " K50 "
hexfld.byte 1 " K51 "
hexfld.byte 2 " K52 "
hexfld.byte 3 " K53 "
tree.end

base ad:0xa0200d2c
tree "BLT_Y_HFC11"
group 0--3
line.long 0 "BLT_Y_HFC11"
hexfld.byte 0 " K54 "
hexfld.byte 1 " K55 "
hexfld.byte 2 " K56 "
hexfld.byte 3 " K57 "
tree.end

base ad:0xa0200d30
tree "BLT_Y_HFC12"
group 0--3
line.long 0 "BLT_Y_HFC12"
hexfld.byte 0 " K60 "
hexfld.byte 1 " K61 "
hexfld.byte 2 " K62 "
hexfld.byte 3 " K63 "
tree.end

base ad:0xa0200d34
tree "BLT_Y_HFC13"
group 0--3
line.long 0 "BLT_Y_HFC13"
hexfld.byte 0 " K64 "
hexfld.byte 1 " K65 "
hexfld.byte 2 " K66 "
hexfld.byte 3 " K67 "
tree.end

base ad:0xa0200d38
tree "BLT_Y_HFC14"
group 0--3
line.long 0 "BLT_Y_HFC14"
hexfld.byte 0 " K70 "
hexfld.byte 1 " K71 "
hexfld.byte 2 " K72 "
hexfld.byte 3 " K73 "
tree.end

base ad:0xa0200d3c
tree "BLT_Y_HFC15"
group 0--3
line.long 0 "BLT_Y_HFC15"
hexfld.byte 0 " K74 "
hexfld.byte 1 " K75 "
hexfld.byte 2 " K76 "
hexfld.byte 3 " K77 "
tree.end

base ad:0xa0200d90
tree "BLT_Y_VFC0"
group 0--3
line.long 0 "BLT_Y_VFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
tree.end

base ad:0xa0200d94
tree "BLT_Y_VFC1"
group 0--3
line.long 0 "BLT_Y_VFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K10 "
hexfld.byte 2 " K11 "
hexfld.byte 3 " K12 "
tree.end

base ad:0xa0200d98
tree "BLT_Y_VFC2"
group 0--3
line.long 0 "BLT_Y_VFC2"
hexfld.byte 0 " K13 "
hexfld.byte 1 " K14 "
hexfld.byte 2 " K20 "
hexfld.byte 3 " K21 "
tree.end

base ad:0xa0200d9c
tree "BLT_Y_VFC3"
group 0--3
line.long 0 "BLT_Y_VFC3"
hexfld.byte 0 " K22 "
hexfld.byte 1 " K23 "
hexfld.byte 2 " K24 "
hexfld.byte 3 " K30 "
tree.end

base ad:0xa0200da0
tree "BLT_Y_VFC4"
group 0--3
line.long 0 "BLT_Y_VFC4"
hexfld.byte 0 " K31 "
hexfld.byte 1 " K32 "
hexfld.byte 2 " K33 "
hexfld.byte 3 " K34 "
tree.end

base ad:0xa0200da4
tree "BLT_Y_VFC5"
group 0--3
line.long 0 "BLT_Y_VFC5"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
tree.end

base ad:0xa0200da8
tree "BLT_Y_VFC6"
group 0--3
line.long 0 "BLT_Y_VFC6"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K50 "
hexfld.byte 2 " K51 "
hexfld.byte 3 " K52 "
tree.end

base ad:0xa0200dac
tree "BLT_Y_VFC7"
group 0--3
line.long 0 "BLT_Y_VFC7"
hexfld.byte 0 " K53 "
hexfld.byte 1 " K54 "
hexfld.byte 2 " K60 "
hexfld.byte 3 " K61 "
tree.end

base ad:0xa0200db0
tree "BLT_Y_VFC8"
group 0--3
line.long 0 "BLT_Y_VFC8"
hexfld.byte 0 " K62 "
hexfld.byte 1 " K63 "
hexfld.byte 2 " K64 "
hexfld.byte 3 " K70 "
tree.end

base ad:0xa0200db4
tree "BLT_Y_VFC9"
group 0--3
line.long 0 "BLT_Y_VFC9"
hexfld.byte 0 " K71 "
hexfld.byte 1 " K72 "
hexfld.byte 2 " K73 "
hexfld.byte 3 " K74 "
tree.end

tree.end

;==============================================================
tree "CDETECT"
;==============================================================
base ad:0x8015f000
tree "PSEL_NBR"
rgroup 0--3
line.long 0 "PSEL_NBR"
bitfld.long 0 0.--2. " PSEL_NBR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8015f004
tree "INT_CTRL"
group 0--3
line.long 0 "INT_CTRL"
bitfld.long 0 0.--4. " ATT_IRQ_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " DET_IRQ_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " LONG_BREAK_IRQ_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8015f008
tree "INT_S1"
wgroup 0--3
line.long 0 "INT_S1"
bitfld.long 0 0.--4. " ATT_IRQ_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " DET_IRQ_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " LONG_BREAK_IRQ_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8015f00c
tree "INT_S0"
wgroup 0--3
line.long 0 "INT_S0"
bitfld.long 0 0.--4. " ATT_IRQ_DIS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " DET_IRQ_DIS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " LONG_BREAK_IRQ_DIS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8015f010
tree "INT_STAT"
rgroup 0--3
line.long 0 "INT_STAT"
bitfld.long 0 0.--4. " ATT_IRQ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " DET_IRQ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " LONG_BREAK_IRQ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8015f014
tree "INT_GOAWAY"
wgroup 0--3
line.long 0 "INT_GOAWAY"
bitfld.long 0 0.--4. " ATT_IRQ_CLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " DET_IRQ_CLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " LONG_BREAK_IRQ_CLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8015f018
tree "DET_CTRL"
group 0--3
line.long 0 "DET_CTRL"
bitfld.long 0 0.--4. " DETECT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8015f01c
tree "DET_S1"
wgroup 0--3
line.long 0 "DET_S1"
bitfld.long 0 0.--4. " DETECT_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8015f020
tree "DET_S0"
wgroup 0--3
line.long 0 "DET_S0"
bitfld.long 0 0.--4. " DETECT_DIS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8015f040
tree "OWNER_U0"
group 0--3
line.long 0 "OWNER_U0"
bitfld.long 0 0.--2. " OWNER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8015f044
tree "OWNER_U1"
group 0--3
line.long 0 "OWNER_U1"
bitfld.long 0 0.--2. " OWNER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8015f048
tree "OWNER_U2"
group 0--3
line.long 0 "OWNER_U2"
bitfld.long 0 0.--2. " OWNER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8015f04c
tree "OWNER_U3"
group 0--3
line.long 0 "OWNER_U3"
bitfld.long 0 0.--2. " OWNER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8015f050
tree "OWNER_U4"
group 0--3
line.long 0 "OWNER_U4"
bitfld.long 0 0.--2. " OWNER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8015f060
tree "ATTACHED_WM_U0"
group 0--3
line.long 0 "ATTACHED_WM_U0"
hexfld.word 0 " ATTACHED_WM "
tree.end

base ad:0x8015f064
tree "ATTACHED_WM_U1"
group 0--3
line.long 0 "ATTACHED_WM_U1"
hexfld.word 0 " ATTACHED_WM "
tree.end

base ad:0x8015f068
tree "ATTACHED_WM_U2"
group 0--3
line.long 0 "ATTACHED_WM_U2"
hexfld.word 0 " ATTACHED_WM "
tree.end

base ad:0x8015f06c
tree "ATTACHED_WM_U3"
group 0--3
line.long 0 "ATTACHED_WM_U3"
hexfld.word 0 " ATTACHED_WM "
tree.end

base ad:0x8015f070
tree "ATTACHED_WM_U4"
group 0--3
line.long 0 "ATTACHED_WM_U4"
hexfld.word 0 " ATTACHED_WM "
tree.end

base ad:0x8015f080
tree "INPUT_OVERRIDE_U0"
group 0--3
line.long 0 "INPUT_OVERRIDE_U0"
bitfld.long 0 0.--1. " INPUT_OVERRIDE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8015f084
tree "INPUT_OVERRIDE_U1"
group 0--3
line.long 0 "INPUT_OVERRIDE_U1"
bitfld.long 0 0.--1. " INPUT_OVERRIDE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8015f088
tree "INPUT_OVERRIDE_U2"
group 0--3
line.long 0 "INPUT_OVERRIDE_U2"
bitfld.long 0 0.--1. " INPUT_OVERRIDE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8015f08c
tree "INPUT_OVERRIDE_U3"
group 0--3
line.long 0 "INPUT_OVERRIDE_U3"
bitfld.long 0 0.--1. " INPUT_OVERRIDE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8015f090
tree "INPUT_OVERRIDE_U4"
group 0--3
line.long 0 "INPUT_OVERRIDE_U4"
bitfld.long 0 0.--1. " INPUT_OVERRIDE "  "0 ,1 ,2 ,3 "
tree.end

tree.end

;==============================================================
tree "CLK_RST1"
;==============================================================
base ad:0xa002f000
tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
tree.end

base ad:0xa002f004
tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
tree.end

base ad:0xa002f008
tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
tree.end

base ad:0xa002f00c
tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
tree.end

base ad:0xa002f010
tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
tree.end

base ad:0xa002f014
tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
tree.end

base ad:0xa002f018
tree "PRCC_K_SOFTRST_SET"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 0. " K_SOFTTRST_SET0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTTRST_SET1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTTRST_SET2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTTRST_SET3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTTRST_SET4 "  "0 ,1 "
tree.end

base ad:0xa002f01c
tree "PRCC_K_SOFTRST_CLR"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 0. " K_SOFTTRST_CLR0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTTRST_CLR1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTTRST_CLR2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTTRST_CLR3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTTRST_CLR4 "  "0 ,1 "
tree.end

base ad:0xa002f020
tree "PRCC_K_RST_STATUS"
rgroup 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 0. " K_RST_STATUS0 "  "0 ,1 "
bitfld.long 0 1. " K_RST_STATUS1 "  "0 ,1 "
bitfld.long 0 2. " K_RST_STATUS2 "  "0 ,1 "
bitfld.long 0 3. " K_RST_STATUS3 "  "0 ,1 "
bitfld.long 0 4. " K_RST_STATUS4 "  "0 ,1 "
tree.end

base ad:0xa002ffe0
tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0xa002ffe4
tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa002ffe8
tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa002ffec
tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0xa002fff0
tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
tree.end

base ad:0xa002fff4
tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
tree.end

base ad:0xa002fff8
tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
tree.end

base ad:0xa002fffc
tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
tree.end

tree.end

;==============================================================
tree "CLK_RST2"
;==============================================================
base ad:0xa001f000
tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
tree.end

base ad:0xa001f004
tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
tree.end

base ad:0xa001f010
tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
tree.end

base ad:0xa001ffe0
tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0xa001ffe4
tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa001ffe8
tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa001ffec
tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0xa001fff0
tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
tree.end

base ad:0xa001fff4
tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
tree.end

base ad:0xa001fff8
tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
tree.end

base ad:0xa001fffc
tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
tree.end

tree.end

;==============================================================
tree "CLK_RST3"
;==============================================================
base ad:0x8014f000
tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
tree.end

base ad:0x8014f004
tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
tree.end

base ad:0x8014f008
tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
tree.end

base ad:0x8014f00c
tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
tree.end

base ad:0x8014f010
tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
tree.end

base ad:0x8014f014
tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
tree.end

base ad:0x8014f018
tree "PRCC_K_SOFTRST_SET"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 0. " K_SOFTTRST_SET0 "  "0 ,1 "
tree.end

base ad:0x8014f01c
tree "PRCC_K_SOFTRST_CLR"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 0. " K_SOFTTRST_CLR0 "  "0 ,1 "
tree.end

base ad:0x8014f020
tree "PRCC_K_RST_STATUS"
rgroup 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 0. " K_RST_STATUS0 "  "0 ,1 "
tree.end

base ad:0x8014ffe0
tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x8014ffe4
tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8014ffe8
tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8014ffec
tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x8014fff0
tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
tree.end

base ad:0x8014fff4
tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
tree.end

base ad:0x8014fff8
tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
tree.end

base ad:0x8014fffc
tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
tree.end

base ad:0x8014f180
tree "TUBE"
group 0--3
line.long 0 "TUBE"
hexfld.long 0 " TUBE "
tree.end

base ad:0x8014f1a0
tree "TUBE_HEX"
group 0--3
line.long 0 "TUBE_HEX"
hexfld.long 0 " TUBE "
tree.end

base ad:0x8014f1c0
tree "TUBE_DEC"
group 0--3
line.long 0 "TUBE_DEC"
hexfld.long 0 " TUBE "
tree.end

tree.end

;==============================================================
tree "CLK_RST5"
;==============================================================
base ad:0x8011f000
tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERCKEN8 "  "0 ,1 "
bitfld.long 0 9. " PERCKEN9 "  "0 ,1 "
bitfld.long 0 10. " PERCKEN10 "  "0 ,1 "
bitfld.long 0 11. " PERCKEN11 "  "0 ,1 "
bitfld.long 0 12. " PERCKEN12 "  "0 ,1 "
bitfld.long 0 13. " PERCKEN13 "  "0 ,1 "
bitfld.long 0 14. " PERCKEN14 "  "0 ,1 "
bitfld.long 0 15. " PERCKEN15 "  "0 ,1 "
tree.end

base ad:0x8011f004
tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERCKDIS8 "  "0 ,1 "
bitfld.long 0 9. " PERCKDIS9 "  "0 ,1 "
bitfld.long 0 10. " PERCKDIS10 "  "0 ,1 "
bitfld.long 0 11. " PERCKDIS11 "  "0 ,1 "
bitfld.long 0 12. " PERCKDIS12 "  "0 ,1 "
bitfld.long 0 13. " PERCKDIS13 "  "0 ,1 "
bitfld.long 0 14. " PERCKDIS14 "  "0 ,1 "
bitfld.long 0 15. " PERCKDIS15 "  "0 ,1 "
tree.end

base ad:0x8011f008
tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERKCKEN8 "  "0 ,1 "
bitfld.long 0 9. " PERKCKEN9 "  "0 ,1 "
bitfld.long 0 10. " PERKCKEN10 "  "0 ,1 "
tree.end

base ad:0x8011f00c
tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERKCKDIS8 "  "0 ,1 "
bitfld.long 0 9. " PERKCKDIS9 "  "0 ,1 "
bitfld.long 0 10. " PERKCKDIS10 "  "0 ,1 "
tree.end

base ad:0x8011f010
tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERCKSR8 "  "0 ,1 "
bitfld.long 0 9. " PERCKSR9 "  "0 ,1 "
bitfld.long 0 10. " PERCKSR10 "  "0 ,1 "
bitfld.long 0 11. " PERCKSR11 "  "0 ,1 "
bitfld.long 0 12. " PERCKSR12 "  "0 ,1 "
bitfld.long 0 13. " PERCKSR13 "  "0 ,1 "
bitfld.long 0 14. " PERCKSR14 "  "0 ,1 "
bitfld.long 0 15. " PERCKSR15 "  "0 ,1 "
tree.end

base ad:0x8011f014
tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERKCKSR8 "  "0 ,1 "
bitfld.long 0 9. " PERKCKSR9 "  "0 ,1 "
bitfld.long 0 10. " PERKCKSR10 "  "0 ,1 "
tree.end

base ad:0x8011f018
tree "PRCC_K_SOFTRST_SET"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 0. " K_SOFTTRST_SET0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTTRST_SET1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTTRST_SET2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTTRST_SET3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTTRST_SET4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTTRST_SET5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTTRST_SET6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTTRST_SET7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTTRST_SET8 "  "0 ,1 "
bitfld.long 0 9. " K_SOFTTRST_SET9 "  "0 ,1 "
tree.end

base ad:0x8011f01c
tree "PRCC_K_SOFTRST_CLR"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 0. " K_SOFTTRST_CLR0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTTRST_CLR1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTTRST_CLR2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTTRST_CLR3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTTRST_CLR4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTTRST_CLR5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTTRST_CLR6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTTRST_CLR7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTTRST_CLR8 "  "0 ,1 "
bitfld.long 0 9. " K_SOFTTRST_CLR9 "  "0 ,1 "
tree.end

base ad:0x8011f020
tree "PRCC_K_RST_STATUS"
rgroup 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 0. " K_RST_STATUS0 "  "0 ,1 "
bitfld.long 0 1. " K_RST_STATUS1 "  "0 ,1 "
bitfld.long 0 2. " K_RST_STATUS2 "  "0 ,1 "
bitfld.long 0 3. " K_RST_STATUS3 "  "0 ,1 "
bitfld.long 0 4. " K_RST_STATUS4 "  "0 ,1 "
bitfld.long 0 5. " K_RST_STATUS5 "  "0 ,1 "
bitfld.long 0 6. " K_RST_STATUS6 "  "0 ,1 "
bitfld.long 0 7. " K_RST_STATUS7 "  "0 ,1 "
bitfld.long 0 8. " K_RST_STATUS8 "  "0 ,1 "
bitfld.long 0 9. " K_RST_STATUS9 "  "0 ,1 "
tree.end

base ad:0x8011ffe0
tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x8011ffe4
tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8011ffe8
tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8011ffec
tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x8011fff0
tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
tree.end

base ad:0x8011fff4
tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
tree.end

base ad:0x8011fff8
tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
tree.end

base ad:0x8011fffc
tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
tree.end

tree.end

;==============================================================
tree "CLK_RST6"
;==============================================================
base ad:0x8012f000
tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
tree.end

base ad:0x8012f004
tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
tree.end

base ad:0x8012f008
tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
tree.end

base ad:0x8012f00c
tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
tree.end

base ad:0x8012f010
tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
tree.end

base ad:0x8012f014
tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
tree.end

base ad:0x8012f018
tree "PRCC_K_SOFTRST_SET"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 0. " K_SOFTTRST_SET0 "  "0 ,1 "
tree.end

base ad:0x8012f01c
tree "PRCC_K_SOFTRST_CLR"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 0. " K_SOFTTRST_CLR0 "  "0 ,1 "
tree.end

base ad:0x8012f020
tree "PRCC_K_RST_STATUS"
rgroup 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 0. " K_RST_STATUS0 "  "0 ,1 "
tree.end

base ad:0x8012ffe0
tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x8012ffe4
tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8012ffe8
tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8012ffec
tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x8012fff0
tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
tree.end

base ad:0x8012fff4
tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
tree.end

base ad:0x8012fff8
tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
tree.end

base ad:0x8012fffc
tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
tree.end

tree.end

;==============================================================
tree "CPUTW"
;==============================================================
base ad:0xa0410600
tree "CPUTW_TLR"
group 0--3
line.long 0 "CPUTW_TLR"
hexfld.long 0 " TLD "
tree.end

base ad:0xa0410604
tree "CPUTW_TCOUNTERR"
group 0--3
line.long 0 "CPUTW_TCOUNTERR"
hexfld.long 0 " TCD "
tree.end

base ad:0xa0410608
tree "CPUTW_TCONTROLR"
group 0--3
line.long 0 "CPUTW_TCONTROLR"
bitfld.long 0 0. " CPUTWTCONTROLRTE "  "0 ,1 "
bitfld.long 0 1. " CPUTWTCONTROLRAR "  "0 ,1 "
bitfld.long 0 2. " CPUTWTCONTROLRITE "  "0 ,1 "
hexfld.byte 1 " CPUTWTCONTROLRPRESCALER "
tree.end

base ad:0xa041060c
tree "CPUTW_TISR"
group 0--3
line.long 0 "CPUTW_TISR"
bitfld.long 0 0. " CPUTWTISREF "  "0 ,1 "
tree.end

base ad:0xa0410620
tree "CPUTW_WLR"
group 0--3
line.long 0 "CPUTW_WLR"
hexfld.long 0 " WLD "
tree.end

base ad:0xa0410624
tree "CPUTW_WCOUNTERR"
group 0--3
line.long 0 "CPUTW_WCOUNTERR"
hexfld.long 0 " WCD "
tree.end

base ad:0xa0410628
tree "CPUTW_WCONTROLR"
group 0--3
line.long 0 "CPUTW_WCONTROLR"
bitfld.long 0 0. " CPUTWWCONTROLRWE "  "0 ,1 "
bitfld.long 0 1. " CPUTWWCONTROLRAR "  "0 ,1 "
bitfld.long 0 2. " CPUTWWCONTROLRITE "  "0 ,1 "
bitfld.long 0 3. " CPUTWWCONTROLRWDM "  "0 ,1 "
hexfld.byte 1 " CPUTWTCONTROLRPRESCALER "
tree.end

base ad:0xa041062c
tree "CPUTW_WISR"
group 0--3
line.long 0 "CPUTW_WISR"
bitfld.long 0 0. " CPUTWWISREF "  "0 ,1 "
tree.end

base ad:0xa0410630
tree "CPUTW_WRSR"
group 0--3
line.long 0 "CPUTW_WRSR"
bitfld.long 0 0. " CPUTWWRSRRF "  "0 ,1 "
tree.end

base ad:0xa0410634
tree "CPUTW_WDR"
wgroup 0--3
line.long 0 "CPUTW_WDR"
hexfld.long 0 " WDD "
tree.end

tree.end

;==============================================================
tree "CR"
;==============================================================
base ad:0x80128000
tree "CR_REG0"
group 0--3
line.long 0 "CR_REG0"
bitfld.long 0 4. " HC0DMA "  "0 ,1 "
bitfld.long 0 5. " HC1DMA "  "0 ,1 "
bitfld.long 0 6. " TRIGIO "  "0 ,1 "
bitfld.long 0 7. " MSSINTMSK "  "0 ,1 "
bitfld.long 0 8.--12. " MDMTPDATSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " MDMTPCTL "  "0 ,1 "
bitfld.long 0 18.--21. " SBAGD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 22.--25. " SBAGT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 30. " FSMCFBCLK "  "0 ,1 "
tree.end

base ad:0x80128004
tree "CR_REG1"
group 0--7
line.long 0 "CR_REG1"
bitfld.long 0 0. " ICN_DEC_ERROR_ITMASK "  "0 ,1 "
bitfld.long 0 1. " ICN_DEC_ERROR_ITCLR "  "0 ,1 "
bitfld.long 0 2. " ICN_POWER_MODE_B2R2_CFG "  "0 ,1 "
bitfld.long 0 3. " ICN_POWER_MODE_DISP_CFG "  "0 ,1 "
bitfld.long 0 4. " ICN_POWER_MODE_DDRLOLAT_CFG "  "0 ,1 "
bitfld.long 0 5. " ICN_POWER_MODE_DDRHIBW1_CFG "  "0 ,1 "
bitfld.long 0 6. " ICN_POWER_MODE_DDHIBW2_CFG "  "0 ,1 "
bitfld.long 0 7. " ICN_POWER_MODE_SVA_S_CFG "  "0 ,1 "
bitfld.long 0 8. " ICN_POWER_MODE_SIA_S_CFG "  "0 ,1 "
bitfld.long 0 9. " ICN_POWER_MODE_SGA_S_CFG "  "0 ,1 "
hexfld.byte 2 " RT_CHANNEL "
bitfld.long 0 24. " RT_CHANNEL_EN "  "0 ,1 "
tree.end

base ad:0x80128020
tree "CR_XDBG"
group 0--3
line.long 0 "CR_XDBG"
bitfld.long 0 0. " XDBGEN "  "0 ,1 "
bitfld.long 0 1. " EXTBRKEn "  "0 ,1 "
bitfld.long 0 2.--3. " XDBGMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " ASSERTION_MODE "  "0 ,1 "
bitfld.long 0 12. " STATUS "  "0 ,1 "
tree.end

base ad:0x80128024
tree "CR_XDBG_BRKINEN"
group 0--3
line.long 0 "CR_XDBG_BRKINEN"
bitfld.long 0 0. " BRKINEN "  "0 ,1 "
tree.end

base ad:0x8012802c
tree "CR_USB"
group 0--3
line.long 0 "CR_USB"
bitfld.long 0 0. " XGATE "  "0 ,1 "
tree.end

base ad:0x80128fe0
tree "CRPeriphID0"
rgroup 0--3
line.long 0 "CRPeriphID0"
hexfld.byte 0 " PARTNUMBER0 "
tree.end

base ad:0x80128fe4
tree "CRPeriphID1"
rgroup 0--3
line.long 0 "CRPeriphID1"
bitfld.long 0 0.--3. " PARTNUMBER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " DESIGNER0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80128fe8
tree "CRPeriphID2"
rgroup 0--3
line.long 0 "CRPeriphID2"
bitfld.long 0 0.--3. " DESIGNER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " REVISION "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80128fec
tree "CRPeriphID3"
rgroup 0--3
line.long 0 "CRPeriphID3"
hexfld.byte 0 " CONFIGURATION "
tree.end

base ad:0x80128ff0
tree "CRPCellID0"
rgroup 0--3
line.long 0 "CRPCellID0"
hexfld.byte 0 " CRPCELLID0 "
tree.end

base ad:0x80128ff4
tree "CRPCellID1"
rgroup 0--3
line.long 0 "CRPCellID1"
hexfld.byte 0 " CRPCELLID1 "
tree.end

base ad:0x80128ff8
tree "CRPCellID2"
rgroup 0--3
line.long 0 "CRPCellID2"
hexfld.byte 0 " CRPCellID2 "
tree.end

base ad:0x80128ffc
tree "CRPCellID3"
rgroup 0--3
line.long 0 "CRPCellID3"
hexfld.byte 0 " CRPCELLID3 "
tree.end

tree.end

;==============================================================
tree "CRYP (2 instances)"
;==============================================================
base ad:0x8012a000
;********************************************
tree "CRYP-0"
;********************************************
base ad:0x8012a000
tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGODIR "  "0 ,1 "
bitfld.long 0 3.--5. " ALGOMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--7. " DATATYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " KEYSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " KEYRDEN "  "0 ,1 "
bitfld.long 0 11. " KSE "  "0 ,1 "
bitfld.long 0 12. " START "  "0 ,1 "
bitfld.long 0 13. " INIT "  "0 ,1 "
bitfld.long 0 14. " FFLUSH "  "0 ,1 "
bitfld.long 0 15. " CRYPEN "  "0 ,1 "
bitfld.long 0 16. " SECONDLAST "  "0 ,1 "
bitfld.long 0 20. " ENS "  "0 ,1 "
bitfld.long 0 24. " LOAD_SSKEY "  "0 ,1 "
bitfld.long 0 25. " GRK "  "0 ,1 "
bitfld.long 0 26. " LRK "  "0 ,1 "
bitfld.long 0 31. " KEYLOCK "  "0 ,1 "
tree.end

base ad:0x8012a004
tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " IFEM "  "0 ,1 "
bitfld.long 0 1. " IFNF "  "0 ,1 "
bitfld.long 0 2. " OFNE "  "0 ,1 "
bitfld.long 0 3. " OFFU "  "0 ,1 "
bitfld.long 0 4. " BUSY "  "0 ,1 "
tree.end

base ad:0x8012a008
tree "0DIN"
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
tree.end

base ad:0x8012a00c
tree "0DINSIZE"
group 0--3
line.long 0 "DINSIZE"
bitfld.long 0 0.--3. " DINSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8012a010
tree "0DOUT"
rgroup 0--3
line.long 0 "DOUT"
hexfld.long 0 " DATA "
tree.end

base ad:0x8012a014
tree "0DOUTSIZE"
rgroup 0--3
line.long 0 "DOUTSIZE"
bitfld.long 0 0.--3. " DOUTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8012a018
tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " DMAINEN "  "0 ,1 "
bitfld.long 0 1. " DMAOUTEN "  "0 ,1 "
tree.end

base ad:0x8012a01c
tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " INIM "  "0 ,1 "
bitfld.long 0 1. " OUTIM "  "0 ,1 "
tree.end

base ad:0x8012a020
tree "0RIS"
group 0--3
line.long 0 "RIS"
bitfld.long 0 0. " INRIS "  "0 ,1 "
bitfld.long 0 1. " OUTRIS "  "0 ,1 "
tree.end

base ad:0x8012a024
tree "0MIS"
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " INMIS "  "0 ,1 "
bitfld.long 0 1. " OUTMIS "  "0 ,1 "
tree.end

base ad:0x8012a028
tree "0K1L"
group 0--3
line.long 0 "K1L"
bitfld.long 0 0. " K31 "  "0 ,1 "
bitfld.long 0 1. " K30 "  "0 ,1 "
bitfld.long 0 2. " K29 "  "0 ,1 "
bitfld.long 0 3. " K28 "  "0 ,1 "
bitfld.long 0 4. " K27 "  "0 ,1 "
bitfld.long 0 5. " K26 "  "0 ,1 "
bitfld.long 0 6. " K25 "  "0 ,1 "
bitfld.long 0 7. " K24 "  "0 ,1 "
bitfld.long 0 8. " K23 "  "0 ,1 "
bitfld.long 0 9. " K22 "  "0 ,1 "
bitfld.long 0 10. " K21 "  "0 ,1 "
bitfld.long 0 11. " K20 "  "0 ,1 "
bitfld.long 0 12. " K19 "  "0 ,1 "
bitfld.long 0 13. " K18 "  "0 ,1 "
bitfld.long 0 14. " K17 "  "0 ,1 "
bitfld.long 0 15. " K16 "  "0 ,1 "
bitfld.long 0 16. " K15 "  "0 ,1 "
bitfld.long 0 17. " K14 "  "0 ,1 "
bitfld.long 0 18. " K13 "  "0 ,1 "
bitfld.long 0 19. " K12 "  "0 ,1 "
bitfld.long 0 20. " K11 "  "0 ,1 "
bitfld.long 0 21. " K10 "  "0 ,1 "
bitfld.long 0 22. " K9 "  "0 ,1 "
bitfld.long 0 23. " K8 "  "0 ,1 "
bitfld.long 0 24. " K7 "  "0 ,1 "
bitfld.long 0 25. " K6 "  "0 ,1 "
bitfld.long 0 26. " K5 "  "0 ,1 "
bitfld.long 0 27. " K4 "  "0 ,1 "
bitfld.long 0 28. " K3 "  "0 ,1 "
bitfld.long 0 29. " K2 "  "0 ,1 "
bitfld.long 0 30. " K1 "  "0 ,1 "
bitfld.long 0 31. " K0 "  "0 ,1 "
tree.end

base ad:0x8012a02c
tree "0K1R"
group 0--3
line.long 0 "K1R"
bitfld.long 0 0. " K63 "  "0 ,1 "
bitfld.long 0 1. " K62 "  "0 ,1 "
bitfld.long 0 2. " K61 "  "0 ,1 "
bitfld.long 0 3. " K60 "  "0 ,1 "
bitfld.long 0 4. " K59 "  "0 ,1 "
bitfld.long 0 5. " K58 "  "0 ,1 "
bitfld.long 0 6. " K57 "  "0 ,1 "
bitfld.long 0 7. " K56 "  "0 ,1 "
bitfld.long 0 8. " K55 "  "0 ,1 "
bitfld.long 0 9. " K54 "  "0 ,1 "
bitfld.long 0 10. " K53 "  "0 ,1 "
bitfld.long 0 11. " K52 "  "0 ,1 "
bitfld.long 0 12. " K51 "  "0 ,1 "
bitfld.long 0 13. " K50 "  "0 ,1 "
bitfld.long 0 14. " K49 "  "0 ,1 "
bitfld.long 0 15. " K48 "  "0 ,1 "
bitfld.long 0 16. " K47 "  "0 ,1 "
bitfld.long 0 17. " K46 "  "0 ,1 "
bitfld.long 0 18. " K45 "  "0 ,1 "
bitfld.long 0 19. " K44 "  "0 ,1 "
bitfld.long 0 20. " K43 "  "0 ,1 "
bitfld.long 0 21. " K42 "  "0 ,1 "
bitfld.long 0 22. " K41 "  "0 ,1 "
bitfld.long 0 23. " K40 "  "0 ,1 "
bitfld.long 0 24. " K39 "  "0 ,1 "
bitfld.long 0 25. " K38 "  "0 ,1 "
bitfld.long 0 26. " K37 "  "0 ,1 "
bitfld.long 0 27. " K36 "  "0 ,1 "
bitfld.long 0 28. " K35 "  "0 ,1 "
bitfld.long 0 29. " K34 "  "0 ,1 "
bitfld.long 0 30. " K33 "  "0 ,1 "
bitfld.long 0 31. " K32 "  "0 ,1 "
tree.end

base ad:0x8012a030
tree "0K2L"
group 0--3
line.long 0 "K2L"
bitfld.long 0 0. " K95 "  "0 ,1 "
bitfld.long 0 1. " K94 "  "0 ,1 "
bitfld.long 0 2. " K93 "  "0 ,1 "
bitfld.long 0 3. " K92 "  "0 ,1 "
bitfld.long 0 4. " K91 "  "0 ,1 "
bitfld.long 0 5. " K90 "  "0 ,1 "
bitfld.long 0 6. " K89 "  "0 ,1 "
bitfld.long 0 7. " K88 "  "0 ,1 "
bitfld.long 0 8. " K87 "  "0 ,1 "
bitfld.long 0 9. " K86 "  "0 ,1 "
bitfld.long 0 10. " K85 "  "0 ,1 "
bitfld.long 0 11. " K84 "  "0 ,1 "
bitfld.long 0 12. " K83 "  "0 ,1 "
bitfld.long 0 13. " K82 "  "0 ,1 "
bitfld.long 0 14. " K81 "  "0 ,1 "
bitfld.long 0 15. " K80 "  "0 ,1 "
bitfld.long 0 16. " K79 "  "0 ,1 "
bitfld.long 0 17. " K78 "  "0 ,1 "
bitfld.long 0 18. " K77 "  "0 ,1 "
bitfld.long 0 19. " K76 "  "0 ,1 "
bitfld.long 0 20. " K75 "  "0 ,1 "
bitfld.long 0 21. " K74 "  "0 ,1 "
bitfld.long 0 22. " K73 "  "0 ,1 "
bitfld.long 0 23. " K72 "  "0 ,1 "
bitfld.long 0 24. " K71 "  "0 ,1 "
bitfld.long 0 25. " K70 "  "0 ,1 "
bitfld.long 0 26. " K69 "  "0 ,1 "
bitfld.long 0 27. " K68 "  "0 ,1 "
bitfld.long 0 28. " K67 "  "0 ,1 "
bitfld.long 0 29. " K66 "  "0 ,1 "
bitfld.long 0 30. " K65 "  "0 ,1 "
bitfld.long 0 31. " K64 "  "0 ,1 "
tree.end

base ad:0x8012a034
tree "0K2R"
group 0--3
line.long 0 "K2R"
bitfld.long 0 0. " K127 "  "0 ,1 "
bitfld.long 0 1. " K126 "  "0 ,1 "
bitfld.long 0 2. " K125 "  "0 ,1 "
bitfld.long 0 3. " K124 "  "0 ,1 "
bitfld.long 0 4. " K123 "  "0 ,1 "
bitfld.long 0 5. " K122 "  "0 ,1 "
bitfld.long 0 6. " K121 "  "0 ,1 "
bitfld.long 0 7. " K120 "  "0 ,1 "
bitfld.long 0 8. " K119 "  "0 ,1 "
bitfld.long 0 9. " K118 "  "0 ,1 "
bitfld.long 0 10. " K117 "  "0 ,1 "
bitfld.long 0 11. " K116 "  "0 ,1 "
bitfld.long 0 12. " K115 "  "0 ,1 "
bitfld.long 0 13. " K114 "  "0 ,1 "
bitfld.long 0 14. " K113 "  "0 ,1 "
bitfld.long 0 15. " K112 "  "0 ,1 "
bitfld.long 0 16. " K111 "  "0 ,1 "
bitfld.long 0 17. " K110 "  "0 ,1 "
bitfld.long 0 18. " K109 "  "0 ,1 "
bitfld.long 0 19. " K108 "  "0 ,1 "
bitfld.long 0 20. " K107 "  "0 ,1 "
bitfld.long 0 21. " K106 "  "0 ,1 "
bitfld.long 0 22. " K105 "  "0 ,1 "
bitfld.long 0 23. " K104 "  "0 ,1 "
bitfld.long 0 24. " K103 "  "0 ,1 "
bitfld.long 0 25. " K102 "  "0 ,1 "
bitfld.long 0 26. " K101 "  "0 ,1 "
bitfld.long 0 27. " K100 "  "0 ,1 "
bitfld.long 0 28. " K99 "  "0 ,1 "
bitfld.long 0 29. " K98 "  "0 ,1 "
bitfld.long 0 30. " K97 "  "0 ,1 "
bitfld.long 0 31. " K96 "  "0 ,1 "
tree.end

base ad:0x8012a038
tree "0K3L"
group 0--3
line.long 0 "K3L"
bitfld.long 0 0. " K159 "  "0 ,1 "
bitfld.long 0 1. " K158 "  "0 ,1 "
bitfld.long 0 2. " K157 "  "0 ,1 "
bitfld.long 0 3. " K156 "  "0 ,1 "
bitfld.long 0 4. " K155 "  "0 ,1 "
bitfld.long 0 5. " K154 "  "0 ,1 "
bitfld.long 0 6. " K153 "  "0 ,1 "
bitfld.long 0 7. " K152 "  "0 ,1 "
bitfld.long 0 8. " K151 "  "0 ,1 "
bitfld.long 0 9. " K150 "  "0 ,1 "
bitfld.long 0 10. " K149 "  "0 ,1 "
bitfld.long 0 11. " K148 "  "0 ,1 "
bitfld.long 0 12. " K147 "  "0 ,1 "
bitfld.long 0 13. " K146 "  "0 ,1 "
bitfld.long 0 14. " K145 "  "0 ,1 "
bitfld.long 0 15. " K144 "  "0 ,1 "
bitfld.long 0 16. " K143 "  "0 ,1 "
bitfld.long 0 17. " K142 "  "0 ,1 "
bitfld.long 0 18. " K141 "  "0 ,1 "
bitfld.long 0 19. " K140 "  "0 ,1 "
bitfld.long 0 20. " K139 "  "0 ,1 "
bitfld.long 0 21. " K138 "  "0 ,1 "
bitfld.long 0 22. " K137 "  "0 ,1 "
bitfld.long 0 23. " K136 "  "0 ,1 "
bitfld.long 0 24. " K135 "  "0 ,1 "
bitfld.long 0 25. " K134 "  "0 ,1 "
bitfld.long 0 26. " K133 "  "0 ,1 "
bitfld.long 0 27. " K132 "  "0 ,1 "
bitfld.long 0 28. " K131 "  "0 ,1 "
bitfld.long 0 29. " K130 "  "0 ,1 "
bitfld.long 0 30. " K129 "  "0 ,1 "
bitfld.long 0 31. " K128 "  "0 ,1 "
tree.end

base ad:0x8012a03c
tree "0K3R"
group 0--3
line.long 0 "K3R"
bitfld.long 0 0. " K191 "  "0 ,1 "
bitfld.long 0 1. " K190 "  "0 ,1 "
bitfld.long 0 2. " K189 "  "0 ,1 "
bitfld.long 0 3. " K188 "  "0 ,1 "
bitfld.long 0 4. " K187 "  "0 ,1 "
bitfld.long 0 5. " K186 "  "0 ,1 "
bitfld.long 0 6. " K185 "  "0 ,1 "
bitfld.long 0 7. " K184 "  "0 ,1 "
bitfld.long 0 8. " K183 "  "0 ,1 "
bitfld.long 0 9. " K182 "  "0 ,1 "
bitfld.long 0 10. " K181 "  "0 ,1 "
bitfld.long 0 11. " K180 "  "0 ,1 "
bitfld.long 0 12. " K179 "  "0 ,1 "
bitfld.long 0 13. " K178 "  "0 ,1 "
bitfld.long 0 14. " K177 "  "0 ,1 "
bitfld.long 0 15. " K176 "  "0 ,1 "
bitfld.long 0 16. " K175 "  "0 ,1 "
bitfld.long 0 17. " K174 "  "0 ,1 "
bitfld.long 0 18. " K173 "  "0 ,1 "
bitfld.long 0 19. " K172 "  "0 ,1 "
bitfld.long 0 20. " K171 "  "0 ,1 "
bitfld.long 0 21. " K170 "  "0 ,1 "
bitfld.long 0 22. " K169 "  "0 ,1 "
bitfld.long 0 23. " K168 "  "0 ,1 "
bitfld.long 0 24. " K167 "  "0 ,1 "
bitfld.long 0 25. " K166 "  "0 ,1 "
bitfld.long 0 26. " K165 "  "0 ,1 "
bitfld.long 0 27. " K164 "  "0 ,1 "
bitfld.long 0 28. " K163 "  "0 ,1 "
bitfld.long 0 29. " K162 "  "0 ,1 "
bitfld.long 0 30. " K161 "  "0 ,1 "
bitfld.long 0 31. " K160 "  "0 ,1 "
tree.end

base ad:0x8012a040
tree "0K4L"
group 0--3
line.long 0 "K4L"
bitfld.long 0 0. " K223 "  "0 ,1 "
bitfld.long 0 1. " K222 "  "0 ,1 "
bitfld.long 0 2. " K221 "  "0 ,1 "
bitfld.long 0 3. " K220 "  "0 ,1 "
bitfld.long 0 4. " K219 "  "0 ,1 "
bitfld.long 0 5. " K218 "  "0 ,1 "
bitfld.long 0 6. " K217 "  "0 ,1 "
bitfld.long 0 7. " K216 "  "0 ,1 "
bitfld.long 0 8. " K215 "  "0 ,1 "
bitfld.long 0 9. " K214 "  "0 ,1 "
bitfld.long 0 10. " K213 "  "0 ,1 "
bitfld.long 0 11. " K212 "  "0 ,1 "
bitfld.long 0 12. " K211 "  "0 ,1 "
bitfld.long 0 13. " K210 "  "0 ,1 "
bitfld.long 0 14. " K209 "  "0 ,1 "
bitfld.long 0 15. " K208 "  "0 ,1 "
bitfld.long 0 16. " K207 "  "0 ,1 "
bitfld.long 0 17. " K206 "  "0 ,1 "
bitfld.long 0 18. " K205 "  "0 ,1 "
bitfld.long 0 19. " K204 "  "0 ,1 "
bitfld.long 0 20. " K203 "  "0 ,1 "
bitfld.long 0 21. " K202 "  "0 ,1 "
bitfld.long 0 22. " K201 "  "0 ,1 "
bitfld.long 0 23. " K200 "  "0 ,1 "
bitfld.long 0 24. " K199 "  "0 ,1 "
bitfld.long 0 25. " K198 "  "0 ,1 "
bitfld.long 0 26. " K197 "  "0 ,1 "
bitfld.long 0 27. " K196 "  "0 ,1 "
bitfld.long 0 28. " K195 "  "0 ,1 "
bitfld.long 0 29. " K194 "  "0 ,1 "
bitfld.long 0 30. " K193 "  "0 ,1 "
bitfld.long 0 31. " K192 "  "0 ,1 "
tree.end

base ad:0x8012a044
tree "0K4R"
group 0--3
line.long 0 "K4R"
bitfld.long 0 0. " K255 "  "0 ,1 "
bitfld.long 0 1. " K254 "  "0 ,1 "
bitfld.long 0 2. " K253 "  "0 ,1 "
bitfld.long 0 3. " K252 "  "0 ,1 "
bitfld.long 0 4. " K251 "  "0 ,1 "
bitfld.long 0 5. " K250 "  "0 ,1 "
bitfld.long 0 6. " K249 "  "0 ,1 "
bitfld.long 0 7. " K248 "  "0 ,1 "
bitfld.long 0 8. " K247 "  "0 ,1 "
bitfld.long 0 9. " K246 "  "0 ,1 "
bitfld.long 0 10. " K245 "  "0 ,1 "
bitfld.long 0 11. " K244 "  "0 ,1 "
bitfld.long 0 12. " K243 "  "0 ,1 "
bitfld.long 0 13. " K242 "  "0 ,1 "
bitfld.long 0 14. " K241 "  "0 ,1 "
bitfld.long 0 15. " K240 "  "0 ,1 "
bitfld.long 0 16. " K239 "  "0 ,1 "
bitfld.long 0 17. " K238 "  "0 ,1 "
bitfld.long 0 18. " K237 "  "0 ,1 "
bitfld.long 0 19. " K236 "  "0 ,1 "
bitfld.long 0 20. " K235 "  "0 ,1 "
bitfld.long 0 21. " K234 "  "0 ,1 "
bitfld.long 0 22. " K233 "  "0 ,1 "
bitfld.long 0 23. " K232 "  "0 ,1 "
bitfld.long 0 24. " K231 "  "0 ,1 "
bitfld.long 0 25. " K230 "  "0 ,1 "
bitfld.long 0 26. " K229 "  "0 ,1 "
bitfld.long 0 27. " K228 "  "0 ,1 "
bitfld.long 0 28. " K227 "  "0 ,1 "
bitfld.long 0 29. " K226 "  "0 ,1 "
bitfld.long 0 30. " K225 "  "0 ,1 "
bitfld.long 0 31. " K224 "  "0 ,1 "
tree.end

base ad:0x8012a048
tree "0IV0L"
group 0--3
line.long 0 "IV0L"
bitfld.long 0 0. " IV32 "  "0 ,1 "
bitfld.long 0 1. " IV31 "  "0 ,1 "
bitfld.long 0 2. " IV30 "  "0 ,1 "
bitfld.long 0 3. " IV29 "  "0 ,1 "
bitfld.long 0 4. " IV28 "  "0 ,1 "
bitfld.long 0 5. " IV27 "  "0 ,1 "
bitfld.long 0 6. " IV26 "  "0 ,1 "
bitfld.long 0 7. " IV25 "  "0 ,1 "
bitfld.long 0 8. " IV24 "  "0 ,1 "
bitfld.long 0 9. " IV23 "  "0 ,1 "
bitfld.long 0 10. " IV22 "  "0 ,1 "
bitfld.long 0 11. " IV21 "  "0 ,1 "
bitfld.long 0 12. " IV20 "  "0 ,1 "
bitfld.long 0 13. " IV19 "  "0 ,1 "
bitfld.long 0 14. " IV18 "  "0 ,1 "
bitfld.long 0 15. " IV17 "  "0 ,1 "
bitfld.long 0 16. " IV16 "  "0 ,1 "
bitfld.long 0 17. " IV15 "  "0 ,1 "
bitfld.long 0 18. " IV14 "  "0 ,1 "
bitfld.long 0 19. " IV13 "  "0 ,1 "
bitfld.long 0 20. " IV12 "  "0 ,1 "
bitfld.long 0 21. " IV11 "  "0 ,1 "
bitfld.long 0 22. " IV10 "  "0 ,1 "
bitfld.long 0 23. " IV9 "  "0 ,1 "
bitfld.long 0 24. " IV8 "  "0 ,1 "
bitfld.long 0 25. " IV7 "  "0 ,1 "
bitfld.long 0 26. " IV6 "  "0 ,1 "
bitfld.long 0 27. " IV5 "  "0 ,1 "
bitfld.long 0 28. " IV4 "  "0 ,1 "
bitfld.long 0 29. " IV3 "  "0 ,1 "
bitfld.long 0 30. " IV2 "  "0 ,1 "
bitfld.long 0 31. " IV1 "  "0 ,1 "
tree.end

base ad:0x8012a04c
tree "0IV0R"
group 0--3
line.long 0 "IV0R"
bitfld.long 0 0. " IV64 "  "0 ,1 "
bitfld.long 0 1. " IV63 "  "0 ,1 "
bitfld.long 0 2. " IV62 "  "0 ,1 "
bitfld.long 0 3. " IV61 "  "0 ,1 "
bitfld.long 0 4. " IV60 "  "0 ,1 "
bitfld.long 0 5. " IV59 "  "0 ,1 "
bitfld.long 0 6. " IV58 "  "0 ,1 "
bitfld.long 0 7. " IV57 "  "0 ,1 "
bitfld.long 0 8. " IV56 "  "0 ,1 "
bitfld.long 0 9. " IV55 "  "0 ,1 "
bitfld.long 0 10. " IV54 "  "0 ,1 "
bitfld.long 0 11. " IV53 "  "0 ,1 "
bitfld.long 0 12. " IV52 "  "0 ,1 "
bitfld.long 0 13. " IV51 "  "0 ,1 "
bitfld.long 0 14. " IV50 "  "0 ,1 "
bitfld.long 0 15. " IV49 "  "0 ,1 "
bitfld.long 0 16. " IV48 "  "0 ,1 "
bitfld.long 0 17. " IV47 "  "0 ,1 "
bitfld.long 0 18. " IV46 "  "0 ,1 "
bitfld.long 0 19. " IV45 "  "0 ,1 "
bitfld.long 0 20. " IV44 "  "0 ,1 "
bitfld.long 0 21. " IV43 "  "0 ,1 "
bitfld.long 0 22. " IV42 "  "0 ,1 "
bitfld.long 0 23. " IV41 "  "0 ,1 "
bitfld.long 0 24. " IV40 "  "0 ,1 "
bitfld.long 0 25. " IV39 "  "0 ,1 "
bitfld.long 0 26. " IV38 "  "0 ,1 "
bitfld.long 0 27. " IV37 "  "0 ,1 "
bitfld.long 0 28. " IV36 "  "0 ,1 "
bitfld.long 0 29. " IV35 "  "0 ,1 "
bitfld.long 0 30. " IV34 "  "0 ,1 "
bitfld.long 0 31. " IV33 "  "0 ,1 "
tree.end

base ad:0x8012a050
tree "0IV1L"
group 0--3
line.long 0 "IV1L"
bitfld.long 0 0. " IV96 "  "0 ,1 "
bitfld.long 0 1. " IV95 "  "0 ,1 "
bitfld.long 0 2. " IV94 "  "0 ,1 "
bitfld.long 0 3. " IV93 "  "0 ,1 "
bitfld.long 0 4. " IV92 "  "0 ,1 "
bitfld.long 0 5. " IV91 "  "0 ,1 "
bitfld.long 0 6. " IV90 "  "0 ,1 "
bitfld.long 0 7. " IV89 "  "0 ,1 "
bitfld.long 0 8. " IV88 "  "0 ,1 "
bitfld.long 0 9. " IV87 "  "0 ,1 "
bitfld.long 0 10. " IV86 "  "0 ,1 "
bitfld.long 0 11. " IV85 "  "0 ,1 "
bitfld.long 0 12. " IV84 "  "0 ,1 "
bitfld.long 0 13. " IV83 "  "0 ,1 "
bitfld.long 0 14. " IV82 "  "0 ,1 "
bitfld.long 0 15. " IV81 "  "0 ,1 "
bitfld.long 0 16. " IV80 "  "0 ,1 "
bitfld.long 0 17. " IV79 "  "0 ,1 "
bitfld.long 0 18. " IV78 "  "0 ,1 "
bitfld.long 0 19. " IV77 "  "0 ,1 "
bitfld.long 0 20. " IV76 "  "0 ,1 "
bitfld.long 0 21. " IV75 "  "0 ,1 "
bitfld.long 0 22. " IV74 "  "0 ,1 "
bitfld.long 0 23. " IV73 "  "0 ,1 "
bitfld.long 0 24. " IV72 "  "0 ,1 "
bitfld.long 0 25. " IV71 "  "0 ,1 "
bitfld.long 0 26. " IV70 "  "0 ,1 "
bitfld.long 0 27. " IV69 "  "0 ,1 "
bitfld.long 0 28. " IV68 "  "0 ,1 "
bitfld.long 0 29. " IV67 "  "0 ,1 "
bitfld.long 0 30. " IV66 "  "0 ,1 "
bitfld.long 0 31. " IV65 "  "0 ,1 "
tree.end

base ad:0x8012a054
tree "0IV1R"
group 0--3
line.long 0 "IV1R"
bitfld.long 0 0. " IV128 "  "0 ,1 "
bitfld.long 0 1. " IV127 "  "0 ,1 "
bitfld.long 0 2. " IV126 "  "0 ,1 "
bitfld.long 0 3. " IV125 "  "0 ,1 "
bitfld.long 0 4. " IV124 "  "0 ,1 "
bitfld.long 0 5. " IV123 "  "0 ,1 "
bitfld.long 0 6. " IV122 "  "0 ,1 "
bitfld.long 0 7. " IV121 "  "0 ,1 "
bitfld.long 0 8. " IV120 "  "0 ,1 "
bitfld.long 0 9. " IV119 "  "0 ,1 "
bitfld.long 0 10. " IV118 "  "0 ,1 "
bitfld.long 0 11. " IV117 "  "0 ,1 "
bitfld.long 0 12. " IV116 "  "0 ,1 "
bitfld.long 0 13. " IV115 "  "0 ,1 "
bitfld.long 0 14. " IV114 "  "0 ,1 "
bitfld.long 0 15. " IV113 "  "0 ,1 "
bitfld.long 0 16. " IV112 "  "0 ,1 "
bitfld.long 0 17. " IV111 "  "0 ,1 "
bitfld.long 0 18. " IV110 "  "0 ,1 "
bitfld.long 0 19. " IV109 "  "0 ,1 "
bitfld.long 0 20. " IV108 "  "0 ,1 "
bitfld.long 0 21. " IV107 "  "0 ,1 "
bitfld.long 0 22. " IV106 "  "0 ,1 "
bitfld.long 0 23. " IV105 "  "0 ,1 "
bitfld.long 0 24. " IV104 "  "0 ,1 "
bitfld.long 0 25. " IV103 "  "0 ,1 "
bitfld.long 0 26. " IV102 "  "0 ,1 "
bitfld.long 0 27. " IV101 "  "0 ,1 "
bitfld.long 0 28. " IV100 "  "0 ,1 "
bitfld.long 0 29. " IV99 "  "0 ,1 "
bitfld.long 0 30. " IV98 "  "0 ,1 "
bitfld.long 0 31. " IV97 "  "0 ,1 "
tree.end

base ad:0x8012a080
tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0x8012a084
tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMAIUTC "  "0 ,1 "
bitfld.long 0 1. " DMAOUTC "  "0 ,1 "
bitfld.long 0 2. " DECPROT "  "0 ,1 "
tree.end

base ad:0x8012a088
tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMAINBREQ "  "0 ,1 "
bitfld.long 0 1. " DMAOUTBREQ "  "0 ,1 "
bitfld.long 0 2. " DMAOUTSREQ "  "0 ,1 "
bitfld.long 0 3. " ININTR "  "0 ,1 "
bitfld.long 0 4. " OUTINTR "  "0 ,1 "
tree.end

base ad:0x8012afe0
tree "0CRYPPeriphID0"
rgroup 0--3
line.long 0 "CRYPPeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x8012afe4
tree "0CRYPPeriphID1"
rgroup 0--3
line.long 0 "CRYPPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8012afe8
tree "0CRYPPeriphID2"
rgroup 0--3
line.long 0 "CRYPPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8012afec
tree "0CRYPPeriphID3"
rgroup 0--3
line.long 0 "CRYPPeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x8012aff0
tree "0CRYPPCellID0"
rgroup 0--3
line.long 0 "CRYPPCellID0"
hexfld.byte 0 " CRYPPCellID0 "
tree.end

base ad:0x8012aff4
tree "0CRYPPCellID1"
rgroup 0--3
line.long 0 "CRYPPCellID1"
hexfld.byte 0 " CRYPPCellID1 "
tree.end

base ad:0x8012aff8
tree "0CRYPPCellID2"
rgroup 0--3
line.long 0 "CRYPPCellID2"
hexfld.byte 0 " CRYPPCellID2 "
tree.end

base ad:0x8012affc
tree "0CRYPPCellID3"
rgroup 0--3
line.long 0 "CRYPPCellID3"
hexfld.byte 0 " CRYPPCellID3 "
tree.end

tree.end

base ad:0x8012b000
;********************************************
tree "CRYP-1"
;********************************************
base ad:0x8012b000
tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGODIR "  "0 ,1 "
bitfld.long 0 3.--5. " ALGOMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--7. " DATATYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " KEYSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " KEYRDEN "  "0 ,1 "
bitfld.long 0 11. " KSE "  "0 ,1 "
bitfld.long 0 12. " START "  "0 ,1 "
bitfld.long 0 13. " INIT "  "0 ,1 "
bitfld.long 0 14. " FFLUSH "  "0 ,1 "
bitfld.long 0 15. " CRYPEN "  "0 ,1 "
bitfld.long 0 16. " SECONDLAST "  "0 ,1 "
bitfld.long 0 20. " ENS "  "0 ,1 "
bitfld.long 0 24. " LOAD_SSKEY "  "0 ,1 "
bitfld.long 0 25. " GRK "  "0 ,1 "
bitfld.long 0 26. " LRK "  "0 ,1 "
bitfld.long 0 31. " KEYLOCK "  "0 ,1 "
tree.end

base ad:0x8012b004
tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " IFEM "  "0 ,1 "
bitfld.long 0 1. " IFNF "  "0 ,1 "
bitfld.long 0 2. " OFNE "  "0 ,1 "
bitfld.long 0 3. " OFFU "  "0 ,1 "
bitfld.long 0 4. " BUSY "  "0 ,1 "
tree.end

base ad:0x8012b008
tree "1DIN"
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
tree.end

base ad:0x8012b00c
tree "1DINSIZE"
group 0--3
line.long 0 "DINSIZE"
bitfld.long 0 0.--3. " DINSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8012b010
tree "1DOUT"
rgroup 0--3
line.long 0 "DOUT"
hexfld.long 0 " DATA "
tree.end

base ad:0x8012b014
tree "1DOUTSIZE"
rgroup 0--3
line.long 0 "DOUTSIZE"
bitfld.long 0 0.--3. " DOUTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8012b018
tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " DMAINEN "  "0 ,1 "
bitfld.long 0 1. " DMAOUTEN "  "0 ,1 "
tree.end

base ad:0x8012b01c
tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " INIM "  "0 ,1 "
bitfld.long 0 1. " OUTIM "  "0 ,1 "
tree.end

base ad:0x8012b020
tree "1RIS"
group 0--3
line.long 0 "RIS"
bitfld.long 0 0. " INRIS "  "0 ,1 "
bitfld.long 0 1. " OUTRIS "  "0 ,1 "
tree.end

base ad:0x8012b024
tree "1MIS"
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " INMIS "  "0 ,1 "
bitfld.long 0 1. " OUTMIS "  "0 ,1 "
tree.end

base ad:0x8012b028
tree "1K1L"
group 0--3
line.long 0 "K1L"
bitfld.long 0 0. " K31 "  "0 ,1 "
bitfld.long 0 1. " K30 "  "0 ,1 "
bitfld.long 0 2. " K29 "  "0 ,1 "
bitfld.long 0 3. " K28 "  "0 ,1 "
bitfld.long 0 4. " K27 "  "0 ,1 "
bitfld.long 0 5. " K26 "  "0 ,1 "
bitfld.long 0 6. " K25 "  "0 ,1 "
bitfld.long 0 7. " K24 "  "0 ,1 "
bitfld.long 0 8. " K23 "  "0 ,1 "
bitfld.long 0 9. " K22 "  "0 ,1 "
bitfld.long 0 10. " K21 "  "0 ,1 "
bitfld.long 0 11. " K20 "  "0 ,1 "
bitfld.long 0 12. " K19 "  "0 ,1 "
bitfld.long 0 13. " K18 "  "0 ,1 "
bitfld.long 0 14. " K17 "  "0 ,1 "
bitfld.long 0 15. " K16 "  "0 ,1 "
bitfld.long 0 16. " K15 "  "0 ,1 "
bitfld.long 0 17. " K14 "  "0 ,1 "
bitfld.long 0 18. " K13 "  "0 ,1 "
bitfld.long 0 19. " K12 "  "0 ,1 "
bitfld.long 0 20. " K11 "  "0 ,1 "
bitfld.long 0 21. " K10 "  "0 ,1 "
bitfld.long 0 22. " K9 "  "0 ,1 "
bitfld.long 0 23. " K8 "  "0 ,1 "
bitfld.long 0 24. " K7 "  "0 ,1 "
bitfld.long 0 25. " K6 "  "0 ,1 "
bitfld.long 0 26. " K5 "  "0 ,1 "
bitfld.long 0 27. " K4 "  "0 ,1 "
bitfld.long 0 28. " K3 "  "0 ,1 "
bitfld.long 0 29. " K2 "  "0 ,1 "
bitfld.long 0 30. " K1 "  "0 ,1 "
bitfld.long 0 31. " K0 "  "0 ,1 "
tree.end

base ad:0x8012b02c
tree "1K1R"
group 0--3
line.long 0 "K1R"
bitfld.long 0 0. " K63 "  "0 ,1 "
bitfld.long 0 1. " K62 "  "0 ,1 "
bitfld.long 0 2. " K61 "  "0 ,1 "
bitfld.long 0 3. " K60 "  "0 ,1 "
bitfld.long 0 4. " K59 "  "0 ,1 "
bitfld.long 0 5. " K58 "  "0 ,1 "
bitfld.long 0 6. " K57 "  "0 ,1 "
bitfld.long 0 7. " K56 "  "0 ,1 "
bitfld.long 0 8. " K55 "  "0 ,1 "
bitfld.long 0 9. " K54 "  "0 ,1 "
bitfld.long 0 10. " K53 "  "0 ,1 "
bitfld.long 0 11. " K52 "  "0 ,1 "
bitfld.long 0 12. " K51 "  "0 ,1 "
bitfld.long 0 13. " K50 "  "0 ,1 "
bitfld.long 0 14. " K49 "  "0 ,1 "
bitfld.long 0 15. " K48 "  "0 ,1 "
bitfld.long 0 16. " K47 "  "0 ,1 "
bitfld.long 0 17. " K46 "  "0 ,1 "
bitfld.long 0 18. " K45 "  "0 ,1 "
bitfld.long 0 19. " K44 "  "0 ,1 "
bitfld.long 0 20. " K43 "  "0 ,1 "
bitfld.long 0 21. " K42 "  "0 ,1 "
bitfld.long 0 22. " K41 "  "0 ,1 "
bitfld.long 0 23. " K40 "  "0 ,1 "
bitfld.long 0 24. " K39 "  "0 ,1 "
bitfld.long 0 25. " K38 "  "0 ,1 "
bitfld.long 0 26. " K37 "  "0 ,1 "
bitfld.long 0 27. " K36 "  "0 ,1 "
bitfld.long 0 28. " K35 "  "0 ,1 "
bitfld.long 0 29. " K34 "  "0 ,1 "
bitfld.long 0 30. " K33 "  "0 ,1 "
bitfld.long 0 31. " K32 "  "0 ,1 "
tree.end

base ad:0x8012b030
tree "1K2L"
group 0--3
line.long 0 "K2L"
bitfld.long 0 0. " K95 "  "0 ,1 "
bitfld.long 0 1. " K94 "  "0 ,1 "
bitfld.long 0 2. " K93 "  "0 ,1 "
bitfld.long 0 3. " K92 "  "0 ,1 "
bitfld.long 0 4. " K91 "  "0 ,1 "
bitfld.long 0 5. " K90 "  "0 ,1 "
bitfld.long 0 6. " K89 "  "0 ,1 "
bitfld.long 0 7. " K88 "  "0 ,1 "
bitfld.long 0 8. " K87 "  "0 ,1 "
bitfld.long 0 9. " K86 "  "0 ,1 "
bitfld.long 0 10. " K85 "  "0 ,1 "
bitfld.long 0 11. " K84 "  "0 ,1 "
bitfld.long 0 12. " K83 "  "0 ,1 "
bitfld.long 0 13. " K82 "  "0 ,1 "
bitfld.long 0 14. " K81 "  "0 ,1 "
bitfld.long 0 15. " K80 "  "0 ,1 "
bitfld.long 0 16. " K79 "  "0 ,1 "
bitfld.long 0 17. " K78 "  "0 ,1 "
bitfld.long 0 18. " K77 "  "0 ,1 "
bitfld.long 0 19. " K76 "  "0 ,1 "
bitfld.long 0 20. " K75 "  "0 ,1 "
bitfld.long 0 21. " K74 "  "0 ,1 "
bitfld.long 0 22. " K73 "  "0 ,1 "
bitfld.long 0 23. " K72 "  "0 ,1 "
bitfld.long 0 24. " K71 "  "0 ,1 "
bitfld.long 0 25. " K70 "  "0 ,1 "
bitfld.long 0 26. " K69 "  "0 ,1 "
bitfld.long 0 27. " K68 "  "0 ,1 "
bitfld.long 0 28. " K67 "  "0 ,1 "
bitfld.long 0 29. " K66 "  "0 ,1 "
bitfld.long 0 30. " K65 "  "0 ,1 "
bitfld.long 0 31. " K64 "  "0 ,1 "
tree.end

base ad:0x8012b034
tree "1K2R"
group 0--3
line.long 0 "K2R"
bitfld.long 0 0. " K127 "  "0 ,1 "
bitfld.long 0 1. " K126 "  "0 ,1 "
bitfld.long 0 2. " K125 "  "0 ,1 "
bitfld.long 0 3. " K124 "  "0 ,1 "
bitfld.long 0 4. " K123 "  "0 ,1 "
bitfld.long 0 5. " K122 "  "0 ,1 "
bitfld.long 0 6. " K121 "  "0 ,1 "
bitfld.long 0 7. " K120 "  "0 ,1 "
bitfld.long 0 8. " K119 "  "0 ,1 "
bitfld.long 0 9. " K118 "  "0 ,1 "
bitfld.long 0 10. " K117 "  "0 ,1 "
bitfld.long 0 11. " K116 "  "0 ,1 "
bitfld.long 0 12. " K115 "  "0 ,1 "
bitfld.long 0 13. " K114 "  "0 ,1 "
bitfld.long 0 14. " K113 "  "0 ,1 "
bitfld.long 0 15. " K112 "  "0 ,1 "
bitfld.long 0 16. " K111 "  "0 ,1 "
bitfld.long 0 17. " K110 "  "0 ,1 "
bitfld.long 0 18. " K109 "  "0 ,1 "
bitfld.long 0 19. " K108 "  "0 ,1 "
bitfld.long 0 20. " K107 "  "0 ,1 "
bitfld.long 0 21. " K106 "  "0 ,1 "
bitfld.long 0 22. " K105 "  "0 ,1 "
bitfld.long 0 23. " K104 "  "0 ,1 "
bitfld.long 0 24. " K103 "  "0 ,1 "
bitfld.long 0 25. " K102 "  "0 ,1 "
bitfld.long 0 26. " K101 "  "0 ,1 "
bitfld.long 0 27. " K100 "  "0 ,1 "
bitfld.long 0 28. " K99 "  "0 ,1 "
bitfld.long 0 29. " K98 "  "0 ,1 "
bitfld.long 0 30. " K97 "  "0 ,1 "
bitfld.long 0 31. " K96 "  "0 ,1 "
tree.end

base ad:0x8012b038
tree "1K3L"
group 0--3
line.long 0 "K3L"
bitfld.long 0 0. " K159 "  "0 ,1 "
bitfld.long 0 1. " K158 "  "0 ,1 "
bitfld.long 0 2. " K157 "  "0 ,1 "
bitfld.long 0 3. " K156 "  "0 ,1 "
bitfld.long 0 4. " K155 "  "0 ,1 "
bitfld.long 0 5. " K154 "  "0 ,1 "
bitfld.long 0 6. " K153 "  "0 ,1 "
bitfld.long 0 7. " K152 "  "0 ,1 "
bitfld.long 0 8. " K151 "  "0 ,1 "
bitfld.long 0 9. " K150 "  "0 ,1 "
bitfld.long 0 10. " K149 "  "0 ,1 "
bitfld.long 0 11. " K148 "  "0 ,1 "
bitfld.long 0 12. " K147 "  "0 ,1 "
bitfld.long 0 13. " K146 "  "0 ,1 "
bitfld.long 0 14. " K145 "  "0 ,1 "
bitfld.long 0 15. " K144 "  "0 ,1 "
bitfld.long 0 16. " K143 "  "0 ,1 "
bitfld.long 0 17. " K142 "  "0 ,1 "
bitfld.long 0 18. " K141 "  "0 ,1 "
bitfld.long 0 19. " K140 "  "0 ,1 "
bitfld.long 0 20. " K139 "  "0 ,1 "
bitfld.long 0 21. " K138 "  "0 ,1 "
bitfld.long 0 22. " K137 "  "0 ,1 "
bitfld.long 0 23. " K136 "  "0 ,1 "
bitfld.long 0 24. " K135 "  "0 ,1 "
bitfld.long 0 25. " K134 "  "0 ,1 "
bitfld.long 0 26. " K133 "  "0 ,1 "
bitfld.long 0 27. " K132 "  "0 ,1 "
bitfld.long 0 28. " K131 "  "0 ,1 "
bitfld.long 0 29. " K130 "  "0 ,1 "
bitfld.long 0 30. " K129 "  "0 ,1 "
bitfld.long 0 31. " K128 "  "0 ,1 "
tree.end

base ad:0x8012b03c
tree "1K3R"
group 0--3
line.long 0 "K3R"
bitfld.long 0 0. " K191 "  "0 ,1 "
bitfld.long 0 1. " K190 "  "0 ,1 "
bitfld.long 0 2. " K189 "  "0 ,1 "
bitfld.long 0 3. " K188 "  "0 ,1 "
bitfld.long 0 4. " K187 "  "0 ,1 "
bitfld.long 0 5. " K186 "  "0 ,1 "
bitfld.long 0 6. " K185 "  "0 ,1 "
bitfld.long 0 7. " K184 "  "0 ,1 "
bitfld.long 0 8. " K183 "  "0 ,1 "
bitfld.long 0 9. " K182 "  "0 ,1 "
bitfld.long 0 10. " K181 "  "0 ,1 "
bitfld.long 0 11. " K180 "  "0 ,1 "
bitfld.long 0 12. " K179 "  "0 ,1 "
bitfld.long 0 13. " K178 "  "0 ,1 "
bitfld.long 0 14. " K177 "  "0 ,1 "
bitfld.long 0 15. " K176 "  "0 ,1 "
bitfld.long 0 16. " K175 "  "0 ,1 "
bitfld.long 0 17. " K174 "  "0 ,1 "
bitfld.long 0 18. " K173 "  "0 ,1 "
bitfld.long 0 19. " K172 "  "0 ,1 "
bitfld.long 0 20. " K171 "  "0 ,1 "
bitfld.long 0 21. " K170 "  "0 ,1 "
bitfld.long 0 22. " K169 "  "0 ,1 "
bitfld.long 0 23. " K168 "  "0 ,1 "
bitfld.long 0 24. " K167 "  "0 ,1 "
bitfld.long 0 25. " K166 "  "0 ,1 "
bitfld.long 0 26. " K165 "  "0 ,1 "
bitfld.long 0 27. " K164 "  "0 ,1 "
bitfld.long 0 28. " K163 "  "0 ,1 "
bitfld.long 0 29. " K162 "  "0 ,1 "
bitfld.long 0 30. " K161 "  "0 ,1 "
bitfld.long 0 31. " K160 "  "0 ,1 "
tree.end

base ad:0x8012b040
tree "1K4L"
group 0--3
line.long 0 "K4L"
bitfld.long 0 0. " K223 "  "0 ,1 "
bitfld.long 0 1. " K222 "  "0 ,1 "
bitfld.long 0 2. " K221 "  "0 ,1 "
bitfld.long 0 3. " K220 "  "0 ,1 "
bitfld.long 0 4. " K219 "  "0 ,1 "
bitfld.long 0 5. " K218 "  "0 ,1 "
bitfld.long 0 6. " K217 "  "0 ,1 "
bitfld.long 0 7. " K216 "  "0 ,1 "
bitfld.long 0 8. " K215 "  "0 ,1 "
bitfld.long 0 9. " K214 "  "0 ,1 "
bitfld.long 0 10. " K213 "  "0 ,1 "
bitfld.long 0 11. " K212 "  "0 ,1 "
bitfld.long 0 12. " K211 "  "0 ,1 "
bitfld.long 0 13. " K210 "  "0 ,1 "
bitfld.long 0 14. " K209 "  "0 ,1 "
bitfld.long 0 15. " K208 "  "0 ,1 "
bitfld.long 0 16. " K207 "  "0 ,1 "
bitfld.long 0 17. " K206 "  "0 ,1 "
bitfld.long 0 18. " K205 "  "0 ,1 "
bitfld.long 0 19. " K204 "  "0 ,1 "
bitfld.long 0 20. " K203 "  "0 ,1 "
bitfld.long 0 21. " K202 "  "0 ,1 "
bitfld.long 0 22. " K201 "  "0 ,1 "
bitfld.long 0 23. " K200 "  "0 ,1 "
bitfld.long 0 24. " K199 "  "0 ,1 "
bitfld.long 0 25. " K198 "  "0 ,1 "
bitfld.long 0 26. " K197 "  "0 ,1 "
bitfld.long 0 27. " K196 "  "0 ,1 "
bitfld.long 0 28. " K195 "  "0 ,1 "
bitfld.long 0 29. " K194 "  "0 ,1 "
bitfld.long 0 30. " K193 "  "0 ,1 "
bitfld.long 0 31. " K192 "  "0 ,1 "
tree.end

base ad:0x8012b044
tree "1K4R"
group 0--3
line.long 0 "K4R"
bitfld.long 0 0. " K255 "  "0 ,1 "
bitfld.long 0 1. " K254 "  "0 ,1 "
bitfld.long 0 2. " K253 "  "0 ,1 "
bitfld.long 0 3. " K252 "  "0 ,1 "
bitfld.long 0 4. " K251 "  "0 ,1 "
bitfld.long 0 5. " K250 "  "0 ,1 "
bitfld.long 0 6. " K249 "  "0 ,1 "
bitfld.long 0 7. " K248 "  "0 ,1 "
bitfld.long 0 8. " K247 "  "0 ,1 "
bitfld.long 0 9. " K246 "  "0 ,1 "
bitfld.long 0 10. " K245 "  "0 ,1 "
bitfld.long 0 11. " K244 "  "0 ,1 "
bitfld.long 0 12. " K243 "  "0 ,1 "
bitfld.long 0 13. " K242 "  "0 ,1 "
bitfld.long 0 14. " K241 "  "0 ,1 "
bitfld.long 0 15. " K240 "  "0 ,1 "
bitfld.long 0 16. " K239 "  "0 ,1 "
bitfld.long 0 17. " K238 "  "0 ,1 "
bitfld.long 0 18. " K237 "  "0 ,1 "
bitfld.long 0 19. " K236 "  "0 ,1 "
bitfld.long 0 20. " K235 "  "0 ,1 "
bitfld.long 0 21. " K234 "  "0 ,1 "
bitfld.long 0 22. " K233 "  "0 ,1 "
bitfld.long 0 23. " K232 "  "0 ,1 "
bitfld.long 0 24. " K231 "  "0 ,1 "
bitfld.long 0 25. " K230 "  "0 ,1 "
bitfld.long 0 26. " K229 "  "0 ,1 "
bitfld.long 0 27. " K228 "  "0 ,1 "
bitfld.long 0 28. " K227 "  "0 ,1 "
bitfld.long 0 29. " K226 "  "0 ,1 "
bitfld.long 0 30. " K225 "  "0 ,1 "
bitfld.long 0 31. " K224 "  "0 ,1 "
tree.end

base ad:0x8012b048
tree "1IV0L"
group 0--3
line.long 0 "IV0L"
bitfld.long 0 0. " IV32 "  "0 ,1 "
bitfld.long 0 1. " IV31 "  "0 ,1 "
bitfld.long 0 2. " IV30 "  "0 ,1 "
bitfld.long 0 3. " IV29 "  "0 ,1 "
bitfld.long 0 4. " IV28 "  "0 ,1 "
bitfld.long 0 5. " IV27 "  "0 ,1 "
bitfld.long 0 6. " IV26 "  "0 ,1 "
bitfld.long 0 7. " IV25 "  "0 ,1 "
bitfld.long 0 8. " IV24 "  "0 ,1 "
bitfld.long 0 9. " IV23 "  "0 ,1 "
bitfld.long 0 10. " IV22 "  "0 ,1 "
bitfld.long 0 11. " IV21 "  "0 ,1 "
bitfld.long 0 12. " IV20 "  "0 ,1 "
bitfld.long 0 13. " IV19 "  "0 ,1 "
bitfld.long 0 14. " IV18 "  "0 ,1 "
bitfld.long 0 15. " IV17 "  "0 ,1 "
bitfld.long 0 16. " IV16 "  "0 ,1 "
bitfld.long 0 17. " IV15 "  "0 ,1 "
bitfld.long 0 18. " IV14 "  "0 ,1 "
bitfld.long 0 19. " IV13 "  "0 ,1 "
bitfld.long 0 20. " IV12 "  "0 ,1 "
bitfld.long 0 21. " IV11 "  "0 ,1 "
bitfld.long 0 22. " IV10 "  "0 ,1 "
bitfld.long 0 23. " IV9 "  "0 ,1 "
bitfld.long 0 24. " IV8 "  "0 ,1 "
bitfld.long 0 25. " IV7 "  "0 ,1 "
bitfld.long 0 26. " IV6 "  "0 ,1 "
bitfld.long 0 27. " IV5 "  "0 ,1 "
bitfld.long 0 28. " IV4 "  "0 ,1 "
bitfld.long 0 29. " IV3 "  "0 ,1 "
bitfld.long 0 30. " IV2 "  "0 ,1 "
bitfld.long 0 31. " IV1 "  "0 ,1 "
tree.end

base ad:0x8012b04c
tree "1IV0R"
group 0--3
line.long 0 "IV0R"
bitfld.long 0 0. " IV64 "  "0 ,1 "
bitfld.long 0 1. " IV63 "  "0 ,1 "
bitfld.long 0 2. " IV62 "  "0 ,1 "
bitfld.long 0 3. " IV61 "  "0 ,1 "
bitfld.long 0 4. " IV60 "  "0 ,1 "
bitfld.long 0 5. " IV59 "  "0 ,1 "
bitfld.long 0 6. " IV58 "  "0 ,1 "
bitfld.long 0 7. " IV57 "  "0 ,1 "
bitfld.long 0 8. " IV56 "  "0 ,1 "
bitfld.long 0 9. " IV55 "  "0 ,1 "
bitfld.long 0 10. " IV54 "  "0 ,1 "
bitfld.long 0 11. " IV53 "  "0 ,1 "
bitfld.long 0 12. " IV52 "  "0 ,1 "
bitfld.long 0 13. " IV51 "  "0 ,1 "
bitfld.long 0 14. " IV50 "  "0 ,1 "
bitfld.long 0 15. " IV49 "  "0 ,1 "
bitfld.long 0 16. " IV48 "  "0 ,1 "
bitfld.long 0 17. " IV47 "  "0 ,1 "
bitfld.long 0 18. " IV46 "  "0 ,1 "
bitfld.long 0 19. " IV45 "  "0 ,1 "
bitfld.long 0 20. " IV44 "  "0 ,1 "
bitfld.long 0 21. " IV43 "  "0 ,1 "
bitfld.long 0 22. " IV42 "  "0 ,1 "
bitfld.long 0 23. " IV41 "  "0 ,1 "
bitfld.long 0 24. " IV40 "  "0 ,1 "
bitfld.long 0 25. " IV39 "  "0 ,1 "
bitfld.long 0 26. " IV38 "  "0 ,1 "
bitfld.long 0 27. " IV37 "  "0 ,1 "
bitfld.long 0 28. " IV36 "  "0 ,1 "
bitfld.long 0 29. " IV35 "  "0 ,1 "
bitfld.long 0 30. " IV34 "  "0 ,1 "
bitfld.long 0 31. " IV33 "  "0 ,1 "
tree.end

base ad:0x8012b050
tree "1IV1L"
group 0--3
line.long 0 "IV1L"
bitfld.long 0 0. " IV96 "  "0 ,1 "
bitfld.long 0 1. " IV95 "  "0 ,1 "
bitfld.long 0 2. " IV94 "  "0 ,1 "
bitfld.long 0 3. " IV93 "  "0 ,1 "
bitfld.long 0 4. " IV92 "  "0 ,1 "
bitfld.long 0 5. " IV91 "  "0 ,1 "
bitfld.long 0 6. " IV90 "  "0 ,1 "
bitfld.long 0 7. " IV89 "  "0 ,1 "
bitfld.long 0 8. " IV88 "  "0 ,1 "
bitfld.long 0 9. " IV87 "  "0 ,1 "
bitfld.long 0 10. " IV86 "  "0 ,1 "
bitfld.long 0 11. " IV85 "  "0 ,1 "
bitfld.long 0 12. " IV84 "  "0 ,1 "
bitfld.long 0 13. " IV83 "  "0 ,1 "
bitfld.long 0 14. " IV82 "  "0 ,1 "
bitfld.long 0 15. " IV81 "  "0 ,1 "
bitfld.long 0 16. " IV80 "  "0 ,1 "
bitfld.long 0 17. " IV79 "  "0 ,1 "
bitfld.long 0 18. " IV78 "  "0 ,1 "
bitfld.long 0 19. " IV77 "  "0 ,1 "
bitfld.long 0 20. " IV76 "  "0 ,1 "
bitfld.long 0 21. " IV75 "  "0 ,1 "
bitfld.long 0 22. " IV74 "  "0 ,1 "
bitfld.long 0 23. " IV73 "  "0 ,1 "
bitfld.long 0 24. " IV72 "  "0 ,1 "
bitfld.long 0 25. " IV71 "  "0 ,1 "
bitfld.long 0 26. " IV70 "  "0 ,1 "
bitfld.long 0 27. " IV69 "  "0 ,1 "
bitfld.long 0 28. " IV68 "  "0 ,1 "
bitfld.long 0 29. " IV67 "  "0 ,1 "
bitfld.long 0 30. " IV66 "  "0 ,1 "
bitfld.long 0 31. " IV65 "  "0 ,1 "
tree.end

base ad:0x8012b054
tree "1IV1R"
group 0--3
line.long 0 "IV1R"
bitfld.long 0 0. " IV128 "  "0 ,1 "
bitfld.long 0 1. " IV127 "  "0 ,1 "
bitfld.long 0 2. " IV126 "  "0 ,1 "
bitfld.long 0 3. " IV125 "  "0 ,1 "
bitfld.long 0 4. " IV124 "  "0 ,1 "
bitfld.long 0 5. " IV123 "  "0 ,1 "
bitfld.long 0 6. " IV122 "  "0 ,1 "
bitfld.long 0 7. " IV121 "  "0 ,1 "
bitfld.long 0 8. " IV120 "  "0 ,1 "
bitfld.long 0 9. " IV119 "  "0 ,1 "
bitfld.long 0 10. " IV118 "  "0 ,1 "
bitfld.long 0 11. " IV117 "  "0 ,1 "
bitfld.long 0 12. " IV116 "  "0 ,1 "
bitfld.long 0 13. " IV115 "  "0 ,1 "
bitfld.long 0 14. " IV114 "  "0 ,1 "
bitfld.long 0 15. " IV113 "  "0 ,1 "
bitfld.long 0 16. " IV112 "  "0 ,1 "
bitfld.long 0 17. " IV111 "  "0 ,1 "
bitfld.long 0 18. " IV110 "  "0 ,1 "
bitfld.long 0 19. " IV109 "  "0 ,1 "
bitfld.long 0 20. " IV108 "  "0 ,1 "
bitfld.long 0 21. " IV107 "  "0 ,1 "
bitfld.long 0 22. " IV106 "  "0 ,1 "
bitfld.long 0 23. " IV105 "  "0 ,1 "
bitfld.long 0 24. " IV104 "  "0 ,1 "
bitfld.long 0 25. " IV103 "  "0 ,1 "
bitfld.long 0 26. " IV102 "  "0 ,1 "
bitfld.long 0 27. " IV101 "  "0 ,1 "
bitfld.long 0 28. " IV100 "  "0 ,1 "
bitfld.long 0 29. " IV99 "  "0 ,1 "
bitfld.long 0 30. " IV98 "  "0 ,1 "
bitfld.long 0 31. " IV97 "  "0 ,1 "
tree.end

base ad:0x8012b080
tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0x8012b084
tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMAIUTC "  "0 ,1 "
bitfld.long 0 1. " DMAOUTC "  "0 ,1 "
bitfld.long 0 2. " DECPROT "  "0 ,1 "
tree.end

base ad:0x8012b088
tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMAINBREQ "  "0 ,1 "
bitfld.long 0 1. " DMAOUTBREQ "  "0 ,1 "
bitfld.long 0 2. " DMAOUTSREQ "  "0 ,1 "
bitfld.long 0 3. " ININTR "  "0 ,1 "
bitfld.long 0 4. " OUTINTR "  "0 ,1 "
tree.end

base ad:0x8012bfe0
tree "1CRYPPeriphID0"
rgroup 0--3
line.long 0 "CRYPPeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x8012bfe4
tree "1CRYPPeriphID1"
rgroup 0--3
line.long 0 "CRYPPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8012bfe8
tree "1CRYPPeriphID2"
rgroup 0--3
line.long 0 "CRYPPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8012bfec
tree "1CRYPPeriphID3"
rgroup 0--3
line.long 0 "CRYPPeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x8012bff0
tree "1CRYPPCellID0"
rgroup 0--3
line.long 0 "CRYPPCellID0"
hexfld.byte 0 " CRYPPCellID0 "
tree.end

base ad:0x8012bff4
tree "1CRYPPCellID1"
rgroup 0--3
line.long 0 "CRYPPCellID1"
hexfld.byte 0 " CRYPPCellID1 "
tree.end

base ad:0x8012bff8
tree "1CRYPPCellID2"
rgroup 0--3
line.long 0 "CRYPPCellID2"
hexfld.byte 0 " CRYPPCellID2 "
tree.end

base ad:0x8012bffc
tree "1CRYPPCellID3"
rgroup 0--3
line.long 0 "CRYPPCellID3"
hexfld.byte 0 " CRYPPCellID3 "
tree.end

tree.end

tree.end

;==============================================================
tree "DBAHN"
;==============================================================
base ad:0x80156000
tree "DENALI_CTL_00"
group 0--3
line.long 0 "DENALI_CTL_00"
bitfld.long 0 0. " ACTIVE_AGING "  "0 ,1 "
bitfld.long 0 8. " ADDR_CMP_EN "  "0 ,1 "
bitfld.long 0 16. " AP "  "0 ,1 "
bitfld.long 0 24. " AREFRESH "  "0 ,1 "
tree.end

base ad:0x80156004
tree "DENALI_CTL_01"
group 0--3
line.long 0 "DENALI_CTL_01"
bitfld.long 0 0. " AUTO_REFRESH_MODE "  "0 ,1 "
bitfld.long 0 8. " AXI0_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 16. " AXI1_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 24. " AXI2_BDW_OVFLOW "  "0 ,1 "
tree.end

base ad:0x80156008
tree "DENALI_CTL_02"
group 0--3
line.long 0 "DENALI_CTL_02"
bitfld.long 0 0. " AXI3_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 8. " BANK_SPLIT_EN "  "0 ,1 "
bitfld.long 0 16. " CONCURRENTAP "  "0 ,1 "
bitfld.long 0 24. " DLLLOCKREG "  "0 ,1 "
tree.end

base ad:0x8015600c
tree "DENALI_CTL_03"
group 0--3
line.long 0 "DENALI_CTL_03"
bitfld.long 0 0. " DLL_BYPASS_MODE "  "0 ,1 "
bitfld.long 0 8. " DRIVE_DQ_DQ "  "0 ,1 "
bitfld.long 0 16. " ENABLE_QUICK_SREFRESH "  "0 ,1 "
tree.end

base ad:0x80156010
tree "DENALI_CTL_04"
group 0--3
line.long 0 "DENALI_CTL_04"
bitfld.long 0 0. " FAST_WRITE "  "0 ,1 "
bitfld.long 0 8. " INTRPTAPBURST "  "0 ,1 "
bitfld.long 0 16. " INTRPTREADA "  "0 ,1 "
bitfld.long 0 24. " INTRPTWRITEA "  "0 ,1 "
tree.end

base ad:0x80156014
tree "DENALI_CTL_05"
group 0--3
line.long 0 "DENALI_CTL_05"
bitfld.long 0 0. " NO_CMD_INIT "  "0 ,1 "
bitfld.long 0 8. " PLACEMENT_EN "  "0 ,1 "
bitfld.long 0 16. " POWER_DOWN "  "0 ,1 "
bitfld.long 0 24. " PRIORITY_EN "  "0 ,1 "
tree.end

base ad:0x80156018
tree "DENALI_CTL_06"
group 0--3
line.long 0 "DENALI_CTL_06"
bitfld.long 0 0. " PWRUP_SREFRESH_EXIT "  "0 ,1 "
bitfld.long 0 8. " RD2RD_TURN "  "0 ,1 "
bitfld.long 0 16. " REDUC "  "0 ,1 "
bitfld.long 0 24. " REG_DIMM_ENABLE "  "0 ,1 "
tree.end

base ad:0x8015601c
tree "DENALI_CTL_07"
group 0--3
line.long 0 "DENALI_CTL_07"
bitfld.long 0 0. " RW_SAME_EN "  "0 ,1 "
bitfld.long 0 8. " SREFRESH "  "0 ,1 "
bitfld.long 0 16. " START "  "0 ,1 "
bitfld.long 0 24. " SWAP_EN "  "0 ,1 "
tree.end

base ad:0x80156020
tree "DENALI_CTL_08"
group 0--3
line.long 0 "DENALI_CTL_08"
bitfld.long 0 0. " TRAS_LOCKOUT "  "0 ,1 "
bitfld.long 0 8. " TREF_ENABLE "  "0 ,1 "
bitfld.long 0 16. " WRITEINTERP "  "0 ,1 "
bitfld.long 0 24. " WRITE_MODEREG "  "0 ,1 "
tree.end

base ad:0x80156024
tree "DENALI_CTL_09"
group 0--3
line.long 0 "DENALI_CTL_09"
bitfld.long 0 0.--2. " WRLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " AXI0_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI0_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI0_W_PRIORITY "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80156028
tree "DENALI_CTL_10"
group 0--3
line.long 0 "DENALI_CTL_10"
bitfld.long 0 0.--1. " AXI1_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI1_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI1_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI2_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8015602c
tree "DENALI_CTL_11"
group 0--3
line.long 0 "DENALI_CTL_11"
bitfld.long 0 0.--1. " AXI2_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI2_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI3_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI3_R_PRIORITY "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80156030
tree "DENALI_CTL_12"
group 0--3
line.long 0 "DENALI_CTL_12"
bitfld.long 0 0.--1. " AXI3_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " CS_MAP "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " LOWPOWER_REFRESH_ENABLE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80156034
tree "DENALI_CTL_13"
group 0--3
line.long 0 "DENALI_CTL_13"
bitfld.long 0 0.--1. " MAX_CS_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TEMRS "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " WRTPRCT_ENABLE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80156038
tree "DENALI_CTL_14"
group 0--3
line.long 0 "DENALI_CTL_14"
bitfld.long 0 0.--2. " ARB_CMD_Q_THRESHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " BSTLEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " CASLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " CKE_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8015603c
tree "DENALI_CTL_15"
group 0--3
line.long 0 "DENALI_CTL_15"
bitfld.long 0 8.--10. " PORT_DATA_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " Q_FULLNESS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TCKE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80156040
tree "DENALI_CTL_16"
group 0--3
line.long 0 "DENALI_CTL_16"
bitfld.long 0 0.--2. " TDFI_CTRL_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDFI_DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " TDFI_DRAM_CLK_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TRRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80156044
tree "DENALI_CTL_17"
group 0--3
line.long 0 "DENALI_CTL_17"
bitfld.long 0 0.--3. " TWTR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--28. " CASLAT_LIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x80156048
tree "DENALI_CTL_18"
group 0--3
line.long 0 "DENALI_CTL_18"
bitfld.long 0 0.--3. " CASLAT_LIN_GATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " COMMAND_AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " INITAREF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAX_COL_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8015604c
tree "DENALI_CTL_19"
group 0--3
line.long 0 "DENALI_CTL_19"
bitfld.long 0 0.--3. " MAX_ROW_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " PORT_CMD_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_CTRLUPD_MIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80156050
tree "DENALI_CTL_20"
group 0--3
line.long 0 "DENALI_CTL_20"
bitfld.long 0 0.--3. " TDFI_PHY_RDLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TDFI_PHY_WRLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDFI_PHY_WRLAT_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_RDDATA_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80156054
tree "DENALI_CTL_21"
group 0--3
line.long 0 "DENALI_CTL_21"
bitfld.long 0 0.--4. " TDFI_RDDATA_EN_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " TRP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " TWR_INT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--30. " DLL_LOCK "  " "
tree.end

base ad:0x80156058
tree "DENALI_CTL_22"
group 0--3
line.long 0 "DENALI_CTL_22"
bitfld.long 0 0.--4. " LOWPOWER_AUTO_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " LOWPOWER_CONTROL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--21. " OUT_OF_RANGE_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24.--28. " TMRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8015605c
tree "DENALI_CTL_23"
group 0--3
line.long 0 "DENALI_CTL_23"
bitfld.long 0 0.--5. " TRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8.--14. " AXI0_BDW "  " "
bitfld.long 0 16.--22. " AXI0_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI1_BDW "  " "
tree.end

base ad:0x80156060
tree "DENALI_CTL_24"
group 0--3
line.long 0 "DENALI_CTL_24"
bitfld.long 0 0.--6. " AXI1_CURRENT_BDW "  " "
bitfld.long 0 8.--14. " AXI2_BDW "  " "
bitfld.long 0 16.--22. " AXI2_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI3_BDW "  " "
tree.end

base ad:0x80156064
tree "DENALI_CTL_25"
rgroup 0--3
line.long 0 "DENALI_CTL_25"
bitfld.long 0 0.--6. " AXI3_CURRENT_BDW "  " "
bitfld.long 0 16.--22. " OUT_OF_RANGE_LENGTH "  " "
bitfld.long 0 24.--30. " WRTPRCT_ERROR_LENGTH "  " "
tree.end

base ad:0x80156068
tree "DENALI_CTL_26"
group 0--3
line.long 0 "DENALI_CTL_26"
hexfld.byte 2 " TRAS_MIN "
hexfld.byte 3 " TRCD_INT "
tree.end

base ad:0x8015606c
tree "DENALI_CTL_27"
group 0--3
line.long 0 "DENALI_CTL_27"
hexfld.byte 0 " TRFC "
bitfld.long 0 8.--17. " OUT_OF_RANGE_SOURCE_ID "  " "
tree.end

base ad:0x80156070
tree "DENALI_CTL_28"
rgroup 0--3
line.long 0 "DENALI_CTL_28"
bitfld.long 0 0.--11. " PORT_CMD_ERROR_ID "  " "
bitfld.long 0 16.--27. " PORT_DATA_ERROR_ID "  " "
tree.end

base ad:0x80156074
tree "DENALI_CTL_29"
rgroup 0--3
line.long 0 "DENALI_CTL_29"
hexfld.word 0 " TDFI_CTRLUPD_MAX "
hexfld.word 2 " TDFI_PHYUPD_RESP "
tree.end

base ad:0x80156078
tree "DENALI_CTL_30"
group 0--3
line.long 0 "DENALI_CTL_30"
hexfld.word 0 " TDFI_PHYUPD_TYPE0 "
hexfld.word 2 " TREF "
tree.end

base ad:0x8015607c
tree "DENALI_CTL_31"
rgroup 0--3
line.long 0 "DENALI_CTL_31"
tree.end

base ad:0x80156080
tree "DENALI_CTL_32"
group 0--3
line.long 0 "DENALI_CTL_32"
hexfld.word 2 " AXI0_EN_SIZE_LT_WIDTH_INSTR "
tree.end

base ad:0x80156084
tree "DENALI_CTL_33"
group 0--3
line.long 0 "DENALI_CTL_33"
hexfld.word 0 " AXI1_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 2 " AXI2_EN_SIZE_LT_WIDTH_INSTR "
tree.end

base ad:0x80156088
tree "DENALI_CTL_34"
group 0--3
line.long 0 "DENALI_CTL_34"
hexfld.word 0 " AXI3_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 2 " LOWPOWER_EXTERNAL_CNT "
tree.end

base ad:0x8015608c
tree "DENALI_CTL_35"
group 0--3
line.long 0 "DENALI_CTL_35"
hexfld.word 0 " LOWPOWER_INTERNAL_CNT "
hexfld.word 2 " LOWPOWER_POWER_DOWN_CNT "
tree.end

base ad:0x80156090
tree "DENALI_CTL_36"
group 0--3
line.long 0 "DENALI_CTL_36"
hexfld.word 0 " LOWPOWER_REFRESH_HOLD "
hexfld.word 2 " LOWPOWER_SELF_REFRESH_CNT "
tree.end

base ad:0x80156094
tree "DENALI_CTL_37"
group 0--3
line.long 0 "DENALI_CTL_37"
hexfld.word 0 " TDLL "
hexfld.word 2 " TPDEX "
tree.end

base ad:0x80156098
tree "DENALI_CTL_38"
group 0--3
line.long 0 "DENALI_CTL_38"
hexfld.word 0 " TRAS_MAX "
hexfld.word 2 " TXSNR "
tree.end

base ad:0x8015609c
tree "DENALI_CTL_39"
group 0--3
line.long 0 "DENALI_CTL_39"
hexfld.word 0 " TXSR "
hexfld.word 2 " VERSION "
tree.end

base ad:0x801560a0
tree "DENALI_CTL_40"
group 0--3
line.long 0 "DENALI_CTL_40"
bitfld.long 0 0.--23. " TINIT "  " "
tree.end

base ad:0x801560a4
tree "DENALI_CTL_41"
rgroup 0--3
line.long 0 "DENALI_CTL_41"
hexfld.long 0 " OUT_OF_RANGE_ADDR "
tree.end

base ad:0x801560a8
tree "DENALI_CTL_42"
rgroup 0--3
line.long 0 "DENALI_CTL_42"
hexfld.long 0 " PORT_CMD_ERROR_ADDR "
tree.end

base ad:0x801560ac
tree "DENALI_CTL_43"
rgroup 0--3
line.long 0 "DENALI_CTL_43"
hexfld.long 0 " WRTPRCT_ERROR_ADDRESS "
tree.end

base ad:0x801560b0
tree "DENALI_CTL_44"
group 0--3
line.long 0 "DENALI_CTL_44"
hexfld.long 0 " WRTPRCT_LOWER_ADDRESS_0 "
tree.end

base ad:0x801560b4
tree "DENALI_CTL_45"
group 0--3
line.long 0 "DENALI_CTL_45"
hexfld.long 0 " WRTPRCT_LOWER_ADDRESS_1 "
tree.end

base ad:0x801560b8
tree "DENALI_CTL_46"
group 0--3
line.long 0 "DENALI_CTL_46"
hexfld.long 0 " WRTPRCT_UPPER_ADDRESS_0 "
tree.end

base ad:0x801560bc
tree "DENALI_CTL_47"
group 0--3
line.long 0 "DENALI_CTL_47"
hexfld.long 0 " WRTPRCT_UPPER_ADDRESS_1 "
tree.end

base ad:0x801560ec
tree "DENALI_CTL_59"
group 0--3
line.long 0 "DENALI_CTL_59"
hexfld.long 0 " PHY_ADD "
tree.end

base ad:0x801560f0
tree "DENALI_CTL_60"
group 0--3
line.long 0 "DENALI_CTL_60"
hexfld.long 0 " PHY_CFG "
tree.end

base ad:0x801560f4
tree "DENALI_CTL_61"
rgroup 0--3
line.long 0 "DENALI_CTL_61"
hexfld.long 0 " PHY_STS "
tree.end

base ad:0x801560f8
tree "DENALI_CTL_62"
rgroup 0--3
line.long 0 "DENALI_CTL_62"
tree.end

base ad:0x801560fc
tree "DENALI_CTL_63"
group 0--3
line.long 0 "DENALI_CTL_63"
bitfld.long 0 0.--2. " WRLAT_ADJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " W2R_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " W2R_SAMECS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--27. " DRAM_CLASS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80156100
tree "DENALI_CTL_64"
group 0--3
line.long 0 "DENALI_CTL_64"
bitfld.long 0 0.--4. " RDLAT_ADJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.byte 1 " DLL_RST_ADJ_DLY "
hexfld.byte 2 " TMOD "
tree.end

base ad:0x80156104
tree "DENALI_CTL_65"
group 0--3
line.long 0 "DENALI_CTL_65"
tree.end

base ad:0x80156108
tree "DENALI_CTL_66"
group 0--3
line.long 0 "DENALI_CTL_66"
tree.end

base ad:0x8015610c
tree "DENALI_CTL_67"
group 0--3
line.long 0 "DENALI_CTL_67"
hexfld.word 0 " DLL_RST_DELAY "
tree.end

base ad:0x80156120
tree "DENALI_CTL_72"
group 0--3
line.long 0 "DENALI_CTL_72"
hexfld.long 0 " USER_DEF_REG_2 "
tree.end

base ad:0x80156124
tree "DENALI_CTL_73"
group 0--3
line.long 0 "DENALI_CTL_73"
bitfld.long 0 26. " DEBUG_DFI_TRIGGER_IS_WRITE "  "0 ,1 "
bitfld.long 0 27. " DENALI_JTAG_CONTROL_ENABLE "  "0 ,1 "
bitfld.long 0 28. " DENALI_JTAG_TRSTN "  "0 ,1 "
bitfld.long 0 29. " DENALI_JTAG_TCK "  "0 ,1 "
bitfld.long 0 30. " DENALI_JTAG_TMS "  "0 ,1 "
bitfld.long 0 31. " DENALI_JTAG_TDI "  "0 ,1 "
tree.end

base ad:0x80156128
tree "DENALI_CTL_74"
group 0--3
line.long 0 "DENALI_CTL_74"
hexfld.long 0 " USER_DEF_REG_RO_2 "
tree.end

base ad:0x8015612c
tree "DENALI_CTL_75"
rgroup 0--3
line.long 0 "DENALI_CTL_75"
bitfld.long 0 30. " DFI_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 31. " DENALI_JTAG_TDO "  "0 ,1 "
tree.end

base ad:0x80156130
tree "DENALI_CTL_76"
rgroup 0--3
line.long 0 "DENALI_CTL_76"
bitfld.long 0 8. " DQS_N_EN "  "0 ,1 "
bitfld.long 0 24. " LPDDR2_S4 "  "0 ,1 "
tree.end

base ad:0x80156134
tree "DENALI_CTL_77"
group 0--3
line.long 0 "DENALI_CTL_77"
bitfld.long 0 0.--1. " TDQSCK_MAX "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TDQSCK_MIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--26. " R2R_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80156138
tree "DENALI_CTL_78"
group 0--3
line.long 0 "DENALI_CTL_78"
bitfld.long 0 0.--1. " TDQSCK_MAX "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TDQSCK_MIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--28. " TCCD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8015613c
tree "DENALI_CTL_79"
group 0--3
line.long 0 "DENALI_CTL_79"
bitfld.long 0 0.--2. " TRTP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " W2W_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " W2W_SAMECS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--28. " TMRR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x80156140
tree "DENALI_CTL_80"
group 0--3
line.long 0 "DENALI_CTL_80"
bitfld.long 0 8.--11. " ZQ_ON_SREF_EXIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " ZQ_REQ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--29. " TFAW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x80156144
tree "DENALI_CTL_81"
group 0--3
line.long 0 "DENALI_CTL_81"
hexfld.byte 0 " REFRESH_PER_ZQ "
bitfld.long 0 8.--17. " INT_MASK "  " "
tree.end

base ad:0x80156148
tree "DENALI_CTL_82"
group 0--3
line.long 0 "DENALI_CTL_82"
bitfld.long 0 0.--9. " INT_STATUS "  " "
bitfld.long 0 16.--27. " ZQCL "  " "
tree.end

base ad:0x8015614c
tree "DENALI_CTL_83"
group 0--3
line.long 0 "DENALI_CTL_83"
bitfld.long 0 0.--11. " ZQCS "  " "
bitfld.long 0 16.--27. " ZQINIT "  " "
tree.end

base ad:0x80156150
tree "DENALI_CTL_84"
group 0--3
line.long 0 "DENALI_CTL_84"
bitfld.long 0 0.--11. " ZQRESET "  " "
bitfld.long 0 16.--30. " MR0_DATA_0 "  " "
tree.end

base ad:0x80156154
tree "DENALI_CTL_85"
group 0--3
line.long 0 "DENALI_CTL_85"
bitfld.long 0 0.--14. " MR0_DATA_1 "  " "
bitfld.long 0 16.--30. " MR16_DATA_0 "  " "
tree.end

base ad:0x80156158
tree "DENALI_CTL_86"
group 0--3
line.long 0 "DENALI_CTL_86"
bitfld.long 0 0.--14. " MR16_DATA_1 "  " "
bitfld.long 0 16.--30. " MR17_DATA_0 "  " "
tree.end

base ad:0x8015615c
tree "DENALI_CTL_87"
group 0--3
line.long 0 "DENALI_CTL_87"
bitfld.long 0 0.--14. " MR17_DATA_1 "  " "
bitfld.long 0 16.--30. " MR1_DATA_0 "  " "
tree.end

base ad:0x80156160
tree "DENALI_CTL_88"
group 0--3
line.long 0 "DENALI_CTL_88"
bitfld.long 0 0.--14. " MR1_DATA_1 "  " "
bitfld.long 0 16.--30. " MR2_DATA_0 "  " "
tree.end

base ad:0x80156164
tree "DENALI_CTL_89"
group 0--3
line.long 0 "DENALI_CTL_89"
bitfld.long 0 0.--14. " MR2_DATA_1 "  " "
bitfld.long 0 16.--30. " MR3_DATA_0 "  " "
tree.end

base ad:0x80156168
tree "DENALI_CTL_90"
group 0--3
line.long 0 "DENALI_CTL_90"
bitfld.long 0 0.--14. " MR3_DATA_1 "  " "
hexfld.word 2 " PERIPHERAL_MRR_DATA "
tree.end

base ad:0x8015616c
tree "DENALI_CTL_91"
group 0--3
line.long 0 "DENALI_CTL_91"
bitfld.long 0 0.--16. " READ_MODEREG "  " "
tree.end

base ad:0x80156170
tree "DENALI_CTL_92"
group 0--3
line.long 0 "DENALI_CTL_92"
bitfld.long 0 0.--23. " TINIT3 "  " "
tree.end

base ad:0x80156174
tree "DENALI_CTL_93"
group 0--3
line.long 0 "DENALI_CTL_93"
bitfld.long 0 0.--23. " TINIT4 "  " "
tree.end

base ad:0x80156178
tree "DENALI_CTL_94"
group 0--3
line.long 0 "DENALI_CTL_94"
bitfld.long 0 0.--23. " TINIT5 "  " "
bitfld.long 0 24. " CONCURRENTAP_WR_ONLY "  "0 ,1 "
tree.end

base ad:0x8015617c
tree "DENALI_CTL_95"
group 0--3
line.long 0 "DENALI_CTL_95"
bitfld.long 0 0. " CONFIG_ERROR "  "0 ,1 "
bitfld.long 0 8. " EIGHT_BANK_MODE_0 "  "0 ,1 "
bitfld.long 0 16. " EIGHT_BANK_MODE_1 "  "0 ,1 "
bitfld.long 0 24. " RESYNC_DLL "  "0 ,1 "
tree.end

base ad:0x80156180
tree "DENALI_CTL_96"
group 0--3
line.long 0 "DENALI_CTL_96"
bitfld.long 0 0. " RESYNC_DLL_PER_AREF_EN "  "0 ,1 "
bitfld.long 0 8. " ZQCS_ROTATE "  "0 ,1 "
bitfld.long 0 16. " ZQ_IN_PROGRESS "  "0 ,1 "
bitfld.long 0 24.--26. " ADDR_PINS_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80156184
tree "DENALI_CTL_97"
group 0--3
line.long 0 "DENALI_CTL_97"
bitfld.long 0 0.--2. " ADDR_PINS_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " COLUMN_SIZE_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " COLUMN_SIZE_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--27. " APREBIT_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80156188
tree "DENALI_CTL_98"
group 0--3
line.long 0 "DENALI_CTL_98"
bitfld.long 0 0.--3. " APREBIT_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--12. " TRP_AB_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " TRP_AB_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8015618c
tree "DENALI_CTL_99"
group 0--3
line.long 0 "DENALI_CTL_99"
bitfld.long 0 0.--8. " INT_ACK "  " "
hexfld.word 2 " CS_MSK_0 "
tree.end

base ad:0x80156190
tree "DENALI_CTL_100"
group 0--3
line.long 0 "DENALI_CTL_100"
hexfld.word 0 " CS_MSK_1 "
hexfld.word 2 " CS_VAL_0 "
tree.end

base ad:0x80156194
tree "DENALI_CTL_101"
group 0--3
line.long 0 "DENALI_CTL_101"
hexfld.word 0 " CS_VAL_1 "
bitfld.long 0 16.--18. " TBST_INT_INTERVAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--27. " CKSRE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80156198
tree "DENALI_CTL_102"
group 0--3
line.long 0 "DENALI_CTL_102"
bitfld.long 0 0.--3. " CKSRX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--12. " TCKESR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--29. " TREF_INTERVAL "  " "
tree.end

base ad:0x8015619c
tree "DENALI_CTL_103"
group 0--3
line.long 0 "DENALI_CTL_103"
hexfld.word 0 " TDFI_PHYUPD_TYPE1 "
hexfld.word 2 " TDFI_PHYUPD_TYPE2 "
tree.end

base ad:0x801561a0
tree "DENALI_CTL_104"
group 0--3
line.long 0 "DENALI_CTL_104"
hexfld.word 0 " TDFI_PHYUPD_TYPE3 "
tree.end

base ad:0x801561a4
tree "DENALI_CTL_105"
group 0--3
line.long 0 "DENALI_CTL_105"
hexfld.long 0 " USER_DEF_REG_10 "
tree.end

base ad:0x801561a8
tree "DENALI_CTL_106"
group 0--3
line.long 0 "DENALI_CTL_106"
hexfld.long 0 " USER_DEF_REG_11 "
tree.end

base ad:0x801561ac
tree "DENALI_CTL_107"
group 0--3
line.long 0 "DENALI_CTL_107"
hexfld.long 0 " USER_DEF_REG_12 "
tree.end

base ad:0x801561b0
tree "DENALI_CTL_108"
group 0--3
line.long 0 "DENALI_CTL_108"
hexfld.long 0 " USER_DEF_REG_13 "
tree.end

base ad:0x801561b4
tree "DENALI_CTL_109"
group 0--3
line.long 0 "DENALI_CTL_109"
hexfld.long 0 " USER_DEF_REG_14 "
tree.end

base ad:0x801561b8
tree "DENALI_CTL_110"
group 0--3
line.long 0 "DENALI_CTL_110"
hexfld.long 0 " USER_DEF_REG_15 "
tree.end

base ad:0x801561bc
tree "DENALI_CTL_111"
group 0--3
line.long 0 "DENALI_CTL_111"
hexfld.long 0 " USER_DEF_REG_16 "
tree.end

base ad:0x801561c0
tree "DENALI_CTL_112"
group 0--3
line.long 0 "DENALI_CTL_112"
hexfld.long 0 " USER_DEF_REG_17 "
tree.end

base ad:0x801561c4
tree "DENALI_CTL_113"
group 0--3
line.long 0 "DENALI_CTL_113"
hexfld.long 0 " USER_DEF_REG_18 "
tree.end

base ad:0x801561c8
tree "DENALI_CTL_114"
group 0--3
line.long 0 "DENALI_CTL_114"
hexfld.long 0 " USER_DEF_REG_19 "
tree.end

base ad:0x801561cc
tree "DENALI_CTL_115"
group 0--3
line.long 0 "DENALI_CTL_115"
hexfld.long 0 " USER_DEF_REG_20 "
tree.end

base ad:0x801561d0
tree "DENALI_CTL_116"
group 0--3
line.long 0 "DENALI_CTL_116"
hexfld.long 0 " USER_DEF_REG_21 "
tree.end

base ad:0x801561d4
tree "DENALI_CTL_117"
group 0--3
line.long 0 "DENALI_CTL_117"
hexfld.long 0 " USER_DEF_REG_22 "
tree.end

base ad:0x801561d8
tree "DENALI_CTL_118"
group 0--3
line.long 0 "DENALI_CTL_118"
hexfld.long 0 " USER_DEF_REG_23 "
tree.end

base ad:0x801561dc
tree "DENALI_CTL_119"
group 0--3
line.long 0 "DENALI_CTL_119"
hexfld.long 0 " USER_DEF_REG_24 "
tree.end

base ad:0x801561e0
tree "DENALI_CTL_120"
group 0--3
line.long 0 "DENALI_CTL_120"
hexfld.long 0 " USER_DEF_REG_25 "
tree.end

base ad:0x801561e4
tree "DENALI_CTL_121"
group 0--3
line.long 0 "DENALI_CTL_121"
hexfld.long 0 " USER_DEF_REG_26 "
tree.end

base ad:0x801561e8
tree "DENALI_CTL_122"
group 0--3
line.long 0 "DENALI_CTL_122"
hexfld.long 0 " USER_DEF_REG_27 "
tree.end

base ad:0x801561ec
tree "DENALI_CTL_123"
group 0--3
line.long 0 "DENALI_CTL_123"
hexfld.long 0 " USER_DEF_REG_28 "
tree.end

base ad:0x801561f0
tree "DENALI_CTL_124"
group 0--3
line.long 0 "DENALI_CTL_124"
hexfld.long 0 " USER_DEF_REG_29 "
tree.end

base ad:0x801561f4
tree "DENALI_CTL_125"
group 0--3
line.long 0 "DENALI_CTL_125"
hexfld.long 0 " USER_DEF_REG_30 "
tree.end

base ad:0x801561f8
tree "DENALI_CTL_126"
group 0--3
line.long 0 "DENALI_CTL_126"
hexfld.long 0 " USER_DEF_REG_31 "
tree.end

base ad:0x801561fc
tree "DENALI_CTL_127"
group 0--3
line.long 0 "DENALI_CTL_127"
hexfld.long 0 " USER_DEF_REG_4 "
tree.end

base ad:0x80156200
tree "DENALI_CTL_128"
group 0--3
line.long 0 "DENALI_CTL_128"
hexfld.long 0 " USER_DEF_REG_5 "
tree.end

base ad:0x80156204
tree "DENALI_CTL_129"
group 0--3
line.long 0 "DENALI_CTL_129"
hexfld.long 0 " USER_DEF_REG_6 "
tree.end

base ad:0x80156208
tree "DENALI_CTL_130"
group 0--3
line.long 0 "DENALI_CTL_130"
hexfld.long 0 " USER_DEF_REG_7 "
tree.end

base ad:0x8015620c
tree "DENALI_CTL_131"
group 0--3
line.long 0 "DENALI_CTL_131"
hexfld.long 0 " USER_DEF_REG_8 "
tree.end

base ad:0x80156210
tree "DENALI_CTL_132"
group 0--3
line.long 0 "DENALI_CTL_132"
hexfld.long 0 " USER_DEF_REG_9 "
tree.end

base ad:0x80156230
tree "DENALI_CTL_140"
group 0--3
line.long 0 "DENALI_CTL_140"
bitfld.long 0 0. " SEMAPHORE "  "0 ,1 "
tree.end

base ad:0x80156234
tree "DENALI_CTL_141"
group 0--3
line.long 0 "DENALI_CTL_141"
hexfld.long 0 " USER_DEF_REG_32 "
tree.end

base ad:0x80156238
tree "DENALI_CTL_142"
group 0--3
line.long 0 "DENALI_CTL_142"
hexfld.long 0 " USER_DEF_REG_33 "
tree.end

base ad:0x8015623c
tree "DENALI_CTL_143"
group 0--3
line.long 0 "DENALI_CTL_143"
hexfld.long 0 " USER_DEF_REG_34 "
tree.end

base ad:0x80156240
tree "DENALI_CTL_144"
group 0--3
line.long 0 "DENALI_CTL_144"
hexfld.long 0 " USER_DEF_REG_35 "
tree.end

base ad:0x80156244
tree "DENALI_CTL_145"
rgroup 0--3
line.long 0 "DENALI_CTL_145"
bitfld.long 0 0. " SECERR_INT_ACK "  "0 ,1 "
bitfld.long 0 4.--5. " SECERR_INT_MASK "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " SECERR_INT_STATUS "  "0 ,1 ,2 ,3 "
hexfld.word 2 " SECERR_COUNTER "
tree.end

base ad:0x80156248
tree "DENALI_CTL_146"
rgroup 0--3
line.long 0 "DENALI_CTL_146"
hexfld.long 0 " SECERR_ADDRESS "
tree.end

base ad:0x8015624c
tree "DENALI_CTL_147"
rgroup 0--3
line.long 0 "DENALI_CTL_147"
bitfld.long 0 0.--9. " SECERR_ID "  " "
bitfld.long 0 10.--11. " SECERR_PORT "  "0 ,1 ,2 ,3 "
bitfld.long 0 16. " SECERR_TYPE "  "0 ,1 "
hexfld.byte 3 " SECERR_LENGTH "
tree.end

tree.end

;==============================================================
tree "DMC"
;==============================================================
base ad:0x80156000
tree "SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " MCS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " MW "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " MDDR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " MC "  "0 ,1 ,2 ,3 "
bitfld.long 0 9. " MB "  "0 ,1 "
bitfld.long 0 10.--11. " EM "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80156004
tree "CMD"
group 0--3
line.long 0 "CMD"
bitfld.long 0 0.--2. " MCCMD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80156008
tree "DCMD"
group 0--3
line.long 0 "DCMD"
bitfld.long 0 0.--13. " ADDR13TO0 "  " "
bitfld.long 0 16.--17. " BKADDR "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " MCMD "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " CNBR "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8015600c
tree "MCFG"
group 0--3
line.long 0 "MCFG"
bitfld.long 0 0.--2. " CLMNBR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " ROWNBR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6. " APPOS "  "0 ,1 "
bitfld.long 0 7.--12. " PWDPRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 13. " APWD "  "0 ,1 "
bitfld.long 0 14. " STPMCK "  "0 ,1 "
bitfld.long 0 15.--17. " MBURST "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 18.--20. " QOSMB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 21.--22. " ACTCHP "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80156010
tree "RPR"
group 0--3
line.long 0 "RPR"
bitfld.long 0 0.--14. " REFRESHPRD "  " "
tree.end

base ad:0x80156014
tree "CASLTC"
group 0--3
line.long 0 "CASLTC"
bitfld.long 0 0. " CASHLF "  "0 ,1 "
bitfld.long 0 1.--2. " CASLTC "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80156018
tree "DQSS"
group 0--3
line.long 0 "DQSS"
bitfld.long 0 0.--1. " DQS "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8015601c
tree "MRD"
group 0--3
line.long 0 "MRD"
bitfld.long 0 0.--6. " MRD "  " "
tree.end

base ad:0x80156020
tree "RAS"
group 0--3
line.long 0 "RAS"
bitfld.long 0 0.--3. " RAS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80156024
tree "RC"
group 0--3
line.long 0 "RC"
bitfld.long 0 0.--3. " RC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80156028
tree "RCD"
group 0--3
line.long 0 "RCD"
bitfld.long 0 0.--2. " RCD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " SRCD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8015602c
tree "RFC"
group 0--3
line.long 0 "RFC"
bitfld.long 0 0.--4. " RFC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--9. " SRFC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x80156030
tree "RP"
group 0--3
line.long 0 "RP"
bitfld.long 0 0.--2. " RP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " SRP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80156034
tree "RRD"
group 0--3
line.long 0 "RRD"
bitfld.long 0 0.--3. " RRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80156038
tree "WR"
group 0--3
line.long 0 "WR"
bitfld.long 0 0.--2. " WR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8015603c
tree "WTR"
group 0--3
line.long 0 "WTR"
bitfld.long 0 0.--2. " WTR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80156040
tree "XP"
group 0--3
line.long 0 "XP"
hexfld.byte 0 " XP "
tree.end

base ad:0x80156044
tree "XSR"
group 0--3
line.long 0 "XSR"
hexfld.byte 0 " XSR "
tree.end

base ad:0x80156048
tree "ESR"
group 0--3
line.long 0 "ESR"
hexfld.byte 0 " ESR "
tree.end

base ad:0x80156100
tree "ID0CFG"
group 0--3
line.long 0 "ID0CFG"
bitfld.long 0 0. " QOSEN0 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN0 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX0 "  " "
tree.end

base ad:0x80156104
tree "ID1CFG"
group 0--3
line.long 0 "ID1CFG"
bitfld.long 0 0. " QOSEN1 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN1 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX1 "  " "
tree.end

base ad:0x80156108
tree "ID2CFG"
group 0--3
line.long 0 "ID2CFG"
bitfld.long 0 0. " QOSEN2 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN2 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX2 "  " "
tree.end

base ad:0x8015610c
tree "ID3CFG"
group 0--3
line.long 0 "ID3CFG"
bitfld.long 0 0. " QOSEN3 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN3 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX3 "  " "
tree.end

base ad:0x80156110
tree "ID4CFG"
group 0--3
line.long 0 "ID4CFG"
bitfld.long 0 0. " QOSEN4 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN4 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX4 "  " "
tree.end

base ad:0x80156114
tree "ID5CFG"
group 0--3
line.long 0 "ID5CFG"
bitfld.long 0 0. " QOSEN5 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN5 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX5 "  " "
tree.end

base ad:0x80156118
tree "ID6CFG"
group 0--3
line.long 0 "ID6CFG"
bitfld.long 0 0. " QOSEN6 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN6 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX6 "  " "
tree.end

base ad:0x8015611c
tree "ID7CFG"
group 0--3
line.long 0 "ID7CFG"
bitfld.long 0 0. " QOSEN7 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN7 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX7 "  " "
tree.end

base ad:0x80156120
tree "ID8CFG"
group 0--3
line.long 0 "ID8CFG"
bitfld.long 0 0. " QOSEN8 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN8 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX8 "  " "
tree.end

base ad:0x80156124
tree "ID9CFG"
group 0--3
line.long 0 "ID9CFG"
bitfld.long 0 0. " QOSEN9 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN9 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX9 "  " "
tree.end

base ad:0x80156128
tree "ID10CFG"
group 0--3
line.long 0 "ID10CFG"
bitfld.long 0 0. " QOSEN10 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN10 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX10 "  " "
tree.end

base ad:0x8015612c
tree "ID11CFG"
group 0--3
line.long 0 "ID11CFG"
bitfld.long 0 0. " QOSEN11 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN11 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX11 "  " "
tree.end

base ad:0x80156130
tree "ID12CFG"
group 0--3
line.long 0 "ID12CFG"
bitfld.long 0 0. " QOSEN12 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN12 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX12 "  " "
tree.end

base ad:0x80156134
tree "ID13CFG"
group 0--3
line.long 0 "ID13CFG"
bitfld.long 0 0. " QOSEN13 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN13 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX13 "  " "
tree.end

base ad:0x80156138
tree "ID14CFG"
group 0--3
line.long 0 "ID14CFG"
bitfld.long 0 0. " QOSEN14 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN14 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX14 "  " "
tree.end

base ad:0x8015613c
tree "ID15CFG"
group 0--3
line.long 0 "ID15CFG"
bitfld.long 0 0. " QOSEN15 "  "0 ,1 "
bitfld.long 0 1. " QOSMIN15 "  "0 ,1 "
bitfld.long 0 2.--9. " QOSMAX15 "  " "
tree.end

base ad:0x80156200
tree "CHIP0CFG"
group 0--3
line.long 0 "CHIP0CFG"
hexfld.byte 0 " ADDRMSK0 "
hexfld.byte 1 " ADDRMTCH0 "
bitfld.long 0 16. " BRC0 "  "0 ,1 "
tree.end

base ad:0x80156204
tree "CHIP1CFG"
group 0--3
line.long 0 "CHIP1CFG"
hexfld.byte 0 " ADDRMSK1 "
hexfld.byte 1 " ADDRMTCH1 "
bitfld.long 0 16. " BRC1 "  "0 ,1 "
tree.end

base ad:0x80156208
tree "CHIP2CFG"
group 0--3
line.long 0 "CHIP2CFG"
hexfld.byte 0 " ADDRMSK2 "
hexfld.byte 1 " ADDRMTCH2 "
bitfld.long 0 16. " BRC2 "  "0 ,1 "
tree.end

base ad:0x8015620c
tree "CHIP3CFG"
group 0--3
line.long 0 "CHIP3CFG"
hexfld.byte 0 " ADDRMSK3 "
hexfld.byte 1 " ADDRMTCH3 "
bitfld.long 0 16. " BRC3 "  "0 ,1 "
tree.end

base ad:0x80156300
tree "US"
group 0--3
line.long 0 "US"
bitfld.long 0 0. " Lock "  "0 ,1 "
tree.end

base ad:0x80156304
tree "UC"
group 0--3
line.long 0 "UC"
bitfld.long 0 0. " DLLEN "  "0 ,1 "
bitfld.long 0 1.--4. " CTRL_LOCK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 5.--13. " CTRL_COMMAND "  " "
bitfld.long 0 14. " Memory_dll "  "0 ,1 "
bitfld.long 0 15. " Memory_ddr "  "0 ,1 "
bitfld.long 0 16.--24. " COMMAND_OFFSET "  " "
tree.end

base ad:0x80156308
tree "US1"
group 0--3
line.long 0 "US1"
hexfld.byte 0 " USER1_CONFIG "
tree.end

base ad:0x80156e00
tree "INTCFG"
group 0--3
line.long 0 "INTCFG"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0x80156e04
tree "INTIP"
group 0--3
line.long 0 "INTIP"
bitfld.long 0 0. " CSYSREQ "  "0 ,1 "
bitfld.long 0 1. " EBIGRANT "  "0 ,1 "
bitfld.long 0 2. " EBIBACKOFF "  "0 ,1 "
bitfld.long 0 3. " USEEBI "  "0 ,1 "
bitfld.long 0 4. " ASYNC "  "0 ,1 "
bitfld.long 0 5. " MSYNC "  "0 ,1 "
bitfld.long 0 6. " CKEINIT "  "0 ,1 "
bitfld.long 0 7. " DQMINIT "  "0 ,1 "
bitfld.long 0 8.--23. " QOSOVERRIDE "  " "
tree.end

base ad:0x80156e08
tree "INTOP"
group 0--3
line.long 0 "INTOP"
bitfld.long 0 0. " CACTIVE "  "0 ,1 "
bitfld.long 0 1. " CSYSACK "  "0 ,1 "
bitfld.long 0 2. " EBIREQ "  "0 ,1 "
tree.end

base ad:0x80156fe0
tree "PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x80156fe4
tree "PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80156fe8
tree "PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80156fec
tree "PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Conguration "
tree.end

base ad:0x80156ff0
tree "PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " LCDPCellID0 "
tree.end

base ad:0x80156ff4
tree "PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " LCDPCellID1 "
tree.end

base ad:0x80156ff8
tree "PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " LCDPCellID2 "
tree.end

base ad:0x80156ffc
tree "PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " LCDPCellID3 "
tree.end

tree.end

;==============================================================
tree "DSI (2 instances)"
;==============================================================
base ad:0xa0402000
;********************************************
tree "DSI-2"
;********************************************
base ad:0xa0402000
tree "2MCTL_INTEGRATION_MODE"
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
tree.end

base ad:0xa0402004
tree "2MCTL_MAIN_DATA_CTL"
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF1_MODE "  "0 ,1 "
bitfld.long 0 2. " VID_EN "  "0 ,1 "
bitfld.long 0 3. " TVG_SEL "  "0 ,1 "
bitfld.long 0 4. " TBG_SEL "  "0 ,1 "
bitfld.long 0 5. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 6. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 7. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 8. " READ_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_EN "  "0 ,1 "
bitfld.long 0 10. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 11. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 12. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 13. " DISP_EOT_GEN "  "0 ,1 "
tree.end

base ad:0xa0402008
tree "2MCTL_MAIN_PHY_CTL"
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 2. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 3. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 6.--9. " WAIT_BURST_TIME "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10. " CLK_FORCE_STOP "  "0 ,1 "
tree.end

base ad:0xa040200c
tree "2MCTL_PLL_CTL"
group 0--3
line.long 0 "MCTL_PLL_CTL"
hexfld.byte 0 " PLL_MULT "
bitfld.long 0 8.--13. " PLL_OUT_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--16. " PLL_IN_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17. " PLL_SEL_DIV2 "  "0 ,1 "
bitfld.long 0 18. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 31. " PLL_MASTER "  "0 ,1 "
tree.end

base ad:0xa0402010
tree "2MCTL_LANE_STS"
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " DATLANE1_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " DATLANE2_STATE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0402014
tree "2MCTL_DPHY_TIMEOUT"
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT"
bitfld.long 0 0.--3. " CLK_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--17. " HSTX_TO_VAL "  " "
bitfld.long 0 18.--31. " LPRX_TO_VAL "  " "
tree.end

base ad:0xa0402018
tree "2MCTL_ULPOUT_TIME"
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
tree.end

base ad:0xa040201c
tree "2MCTL_DPHY_STATIC"
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6.--11. " UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0402020
tree "2MCTL_MAIN_EN"
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 7. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 8. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " IF1_EN "  "0 ,1 "
bitfld.long 0 10. " IF2_EN "  "0 ,1 "
tree.end

base ad:0xa0402024
tree "2MCTL_MAIN_STS"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK "  "0 ,1 "
tree.end

base ad:0xa0402028
tree "2MCTL_DPHY_ERR"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2 "  "0 ,1 "
tree.end

base ad:0xa0402030
tree "2INT_VID_RDDATA"
group 0--3
line.long 0 "INT_VID_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
tree.end

base ad:0xa0402034
tree "2INT_VID_GNT"
group 0--3
line.long 0 "INT_VID_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
tree.end

base ad:0xa0402038
tree "2INT_CMD_RDDATA"
group 0--3
line.long 0 "INT_CMD_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
tree.end

base ad:0xa040203c
tree "2INT_CMD_GNT"
group 0--3
line.long 0 "INT_CMD_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
tree.end

base ad:0xa0402040
tree "2INT_INTERRUPT_CTL"
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
tree.end

base ad:0xa0402050
tree "2CMD_MODE_CTL"
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " IF2_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 5. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 6. " ARB_MODE "  "0 ,1 "
bitfld.long 0 7. " ARB_PRI "  "0 ,1 "
hexfld.byte 1 " FIL_VALUE "
bitfld.long 0 16.--25. " TE_TIMEOUT "  " "
tree.end

base ad:0xa0402054
tree "2CMD_MODE_STS"
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING "  "0 ,1 "
tree.end

base ad:0xa0402060
tree "2DIRECT_CMD_SEND"
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
tree.end

base ad:0xa0402064
tree "2DIRECT_CMD_MAIN_SETTINGS"
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--15. " CMD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--20. " CMD_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 24.--27. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0402068
tree "2DIRECT_CMD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 2 " ACK_VAL "
tree.end

base ad:0xa040206c
tree "2DIRECT_CMD_RD_INIT"
group 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
hexfld.word 0 " CMD_RD_INIT "
tree.end

base ad:0xa0402070
tree "2DIRECT_CMD_WRDAT0"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT0"
bitfld.long 0 0. " WRDAT0 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT1 "  " "
bitfld.long 0 9.--16. " WRDAT2 "  " "
bitfld.long 0 17.--24. " WRDAT3 "  " "
tree.end

base ad:0xa0402074
tree "2DIRECT_CMD_WRDAT1"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT1"
bitfld.long 0 0. " WRDAT4 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT5 "  " "
bitfld.long 0 9.--16. " WRDAT6 "  " "
bitfld.long 0 17.--24. " WRDAT7 "  " "
tree.end

base ad:0xa0402078
tree "2DIRECT_CMD_WRDAT2"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT2"
bitfld.long 0 0. " WRDAT8 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT9 "  " "
bitfld.long 0 9.--16. " WRDAT10 "  " "
bitfld.long 0 17.--24. " WRDAT11 "  " "
tree.end

base ad:0xa040207c
tree "2DIRECT_CMD_WRDAT3"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT3"
bitfld.long 0 0. " WRDAT12 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT13 "  " "
bitfld.long 0 9.--16. " WRDAT14 "  " "
bitfld.long 0 17.--24. " WRDAT15 "  " "
tree.end

base ad:0xa0402080
tree "2DIRECT_CMD_RDDAT"
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
hexfld.byte 0 " RDDAT0 "
hexfld.byte 1 " RDDAT1 "
hexfld.byte 2 " RDDAT2 "
hexfld.byte 3 " RDDAT3 "
tree.end

base ad:0xa0402084
tree "2DIRECT_CMD_RD_PROPERTY"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
hexfld.word 0 " RD_SIZE "
bitfld.long 0 16.--17. " RD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
tree.end

base ad:0xa0402088
tree "2DIRECT_CMD_RD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
tree.end

base ad:0xa0402090
tree "2VID_MAIN_CTL"
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STOP_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " VID_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--11. " HEADER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--13. " VID_PIXEL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " BURST_MODE "  "0 ,1 "
bitfld.long 0 15. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 16. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 17.--18. " REG_BLKLINE_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 19.--20. " REG_BLKEOL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--22. " RECOVERY_MODE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0402094
tree "2VID_VSIZE"
group 0--3
line.long 0 "VID_VSIZE"
bitfld.long 0 0.--3. " VSA_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " VBP_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " VFP_LENGTH "
bitfld.long 0 16.--26. " VACT_LENGTH "  " "
tree.end

base ad:0xa0402098
tree "2VID_HSIZE1"
group 0--3
line.long 0 "VID_HSIZE1"
hexfld.byte 0 " HSA_LENGTH "
hexfld.byte 1 " HBP_LENGTH "
bitfld.long 0 16.--26. " HFP_LENGTH "  " "
tree.end

base ad:0xa040209c
tree "2VID_HSIZE2"
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--12. " RGB_SIZE "  " "
tree.end

base ad:0xa04020a0
tree "2VID_BLKSIZE1"
group 0--3
line.long 0 "VID_BLKSIZE1"
bitfld.long 0 0.--12. " BLKLINE_EVENT_PCK "  " "
bitfld.long 0 13.--25. " BLKEOL_PCK "  " "
tree.end

base ad:0xa04020a4
tree "2VID_BLKSIZE2"
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
tree.end

base ad:0xa04020a8
tree "2VID_PCK_TIME"
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
tree.end

base ad:0xa04020ac
tree "2VID_DPHY_TIME"
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
tree.end

base ad:0xa04020b0
tree "2VID_ERR_COLOR"
group 0--3
line.long 0 "VID_ERR_COLOR"
hexfld.byte 0 " COL_RED "
hexfld.byte 1 " COL_GREEN "
hexfld.byte 2 " COL_BLUE "
hexfld.byte 3 " PAD_VAL "
tree.end

base ad:0xa04020b4
tree "2VID_VPOS"
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--12. " LINE_VAL "  " "
tree.end

base ad:0xa04020b8
tree "2VID_HPOS"
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
tree.end

base ad:0xa04020bc
tree "2VID_MODE_STS"
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY "  "0 ,1 "
tree.end

base ad:0xa04020c0
tree "2VID_VCA_SETTING1"
group 0--3
line.long 0 "VID_VCA_SETTING1"
hexfld.word 0 " MAX_BURST_LIMIT "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
tree.end

base ad:0xa04020c4
tree "2VID_VCA_SETTING2"
group 0--3
line.long 0 "VID_VCA_SETTING2"
hexfld.word 0 " EXACT_BURST_LIMIT "
hexfld.word 2 " MAX_LINE_LIMIT "
tree.end

base ad:0xa04020c8
tree "2TVG_CTL"
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " TVG_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa04020cc
tree "2TVG_IMG_SIZE"
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--12. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--26. " TVG_NBLINE "  " "
tree.end

base ad:0xa04020d0
tree "2TVG_COLOR1"
group 0--3
line.long 0 "TVG_COLOR1"
hexfld.byte 0 " COL1_RED "
hexfld.byte 1 " COL1_GREEN "
hexfld.byte 2 " COL1_BLUE "
tree.end

base ad:0xa04020d4
tree "2TVG_COLOR2"
group 0--3
line.long 0 "TVG_COLOR2"
hexfld.byte 0 " COL2_RED "
hexfld.byte 1 " COL2_GREEN "
hexfld.byte 2 " COL2_BLUE "
tree.end

base ad:0xa04020d8
tree "2TVG_STS"
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
tree.end

base ad:0xa04020e0
tree "2TBG_CTL"
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa04020e4
tree "2TBG_SETTING"
group 0--3
line.long 0 "TBG_SETTING"
hexfld.word 0 " TBG_DATA "
bitfld.long 0 16.--27. " TBG_CPT "  " "
tree.end

base ad:0xa04020e8
tree "2TBG_STS"
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
tree.end

base ad:0xa04020f0
tree "2MCTL_MAIN_STS_CTL"
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 21. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " CRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " VRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
tree.end

base ad:0xa04020f4
tree "2CMD_MODE_STS_CTL"
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SDI1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SDI2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 21. " CSM_RUNNING_EDGE "  "0 ,1 "
tree.end

base ad:0xa04020f8
tree "2DIRECT_CMD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
tree.end

base ad:0xa04020fc
tree "2DIRECT_CMD_RD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
tree.end

base ad:0xa0402100
tree "2VID_MODE_STS_CTL"
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGTH_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 26. " VSG_RECOVERY_EDGE "  "0 ,1 "
tree.end

base ad:0xa0402104
tree "2TG_STS_CTL"
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
tree.end

base ad:0xa0402108
tree "2MCTL_DPHY_ERR_CTL"
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL"
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 22. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 26. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 27. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 28. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 29. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 30. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 31. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
tree.end

base ad:0xa0402110
tree "2MCTL_MAIN_STS_CLR"
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
tree.end

base ad:0xa0402114
tree "2CMD_MODE_STS_CLR"
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_CLR "  "0 ,1 "
tree.end

base ad:0xa0402118
tree "2DIRECT_CMD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
tree.end

base ad:0xa040211c
tree "2DIRECT_CMD_RD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
tree.end

base ad:0xa0402120
tree "2VID_MODE_STS_CLR"
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_CLR "  "0 ,1 "
tree.end

base ad:0xa0402124
tree "2TG_STS_CLR"
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
tree.end

base ad:0xa0402128
tree "2MCTL_DPHY_ERR_CLR"
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
tree.end

base ad:0xa0402130
tree "2MCTL_MAIN_STS_FLAG"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
tree.end

base ad:0xa0402134
tree "2CMD_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_FLAG "  "0 ,1 "
tree.end

base ad:0xa0402138
tree "2DIRECT_CMD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
tree.end

base ad:0xa040213c
tree "2DIRECT_CMD_RD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
tree.end

base ad:0xa0402140
tree "2VID_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 10. " FLAG_VSG_RECOVERY "  "0 ,1 "
tree.end

base ad:0xa0402144
tree "2TG_STS_FLAG"
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
tree.end

base ad:0xa0402148
tree "2MCTL_DPHY_ERR_FLAG"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
tree.end

base ad:0xa0402150
tree "2DPHY_LANES_TRIM"
group 0--3
line.long 0 "DPHY_LANES_TRIM"
bitfld.long 0 0.--1. " dl1_skew "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " dl1_cd_off "  "0 ,1 "
bitfld.long 0 3. " dl1_hstx_slewrate_down "  "0 ,1 "
bitfld.long 0 4. " dl1_hstx_slewrate_up "  "0 ,1 "
bitfld.long 0 5. " dl1_test_reserved_1 "  "0 ,1 "
bitfld.long 0 6.--7. " cl_skew "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " cl_lp_rx_vil "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " cl_lp_tx_slewrate "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " cl_specs_90_81b "  "0 ,1 "
bitfld.long 0 13. " cl_hstx_slewrate_down "  "0 ,1 "
bitfld.long 0 14. " cl_hstx_slewrate_up "  "0 ,1 "
bitfld.long 0 15. " cl_test_reserved_1 "  "0 ,1 "
bitfld.long 0 16.--17. " dl2_skew "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " dl2_hstx_slewrate_down "  "0 ,1 "
bitfld.long 0 19. " dl2_hstx_slewrate_up "  "0 ,1 "
bitfld.long 0 20. " dl2_test_reserved_1 "  "0 ,1 "
tree.end

base ad:0xa0402ff0
tree "2ID_REG"
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " H "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--19. " PRODUCT_ID "  " "
bitfld.long 0 20.--31. " VENDOR_ID "  " "
tree.end

base ad:0xa0402ff4
tree "2IP_CONF"
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " FIFO_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

tree.end

base ad:0xa0401000
;********************************************
tree "DSI-1"
;********************************************
base ad:0xa0401000
tree "1MCTL_INTEGRATION_MODE"
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
tree.end

base ad:0xa0401004
tree "1MCTL_MAIN_DATA_CTL"
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF1_MODE "  "0 ,1 "
bitfld.long 0 2. " VID_EN "  "0 ,1 "
bitfld.long 0 3. " TVG_SEL "  "0 ,1 "
bitfld.long 0 4. " TBG_SEL "  "0 ,1 "
bitfld.long 0 5. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 6. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 7. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 8. " READ_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_EN "  "0 ,1 "
bitfld.long 0 10. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 11. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 12. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 13. " DISP_EOT_GEN "  "0 ,1 "
tree.end

base ad:0xa0401008
tree "1MCTL_MAIN_PHY_CTL"
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 2. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 3. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 6.--9. " WAIT_BURST_TIME "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10. " CLK_FORCE_STOP "  "0 ,1 "
tree.end

base ad:0xa040100c
tree "1MCTL_PLL_CTL"
group 0--3
line.long 0 "MCTL_PLL_CTL"
hexfld.byte 0 " PLL_MULT "
bitfld.long 0 8.--13. " PLL_OUT_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--16. " PLL_IN_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17. " PLL_SEL_DIV2 "  "0 ,1 "
bitfld.long 0 18. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 31. " PLL_MASTER "  "0 ,1 "
tree.end

base ad:0xa0401010
tree "1MCTL_LANE_STS"
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " DATLANE1_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " DATLANE2_STATE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0401014
tree "1MCTL_DPHY_TIMEOUT"
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT"
bitfld.long 0 0.--3. " CLK_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--17. " HSTX_TO_VAL "  " "
bitfld.long 0 18.--31. " LPRX_TO_VAL "  " "
tree.end

base ad:0xa0401018
tree "1MCTL_ULPOUT_TIME"
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
tree.end

base ad:0xa040101c
tree "1MCTL_DPHY_STATIC"
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6.--11. " UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0401020
tree "1MCTL_MAIN_EN"
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 7. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 8. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " IF1_EN "  "0 ,1 "
bitfld.long 0 10. " IF2_EN "  "0 ,1 "
tree.end

base ad:0xa0401024
tree "1MCTL_MAIN_STS"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK "  "0 ,1 "
tree.end

base ad:0xa0401028
tree "1MCTL_DPHY_ERR"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2 "  "0 ,1 "
tree.end

base ad:0xa0401030
tree "1INT_VID_RDDATA"
group 0--3
line.long 0 "INT_VID_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
tree.end

base ad:0xa0401034
tree "1INT_VID_GNT"
group 0--3
line.long 0 "INT_VID_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
tree.end

base ad:0xa0401038
tree "1INT_CMD_RDDATA"
group 0--3
line.long 0 "INT_CMD_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
tree.end

base ad:0xa040103c
tree "1INT_CMD_GNT"
group 0--3
line.long 0 "INT_CMD_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
tree.end

base ad:0xa0401040
tree "1INT_INTERRUPT_CTL"
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
tree.end

base ad:0xa0401050
tree "1CMD_MODE_CTL"
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " IF2_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 5. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 6. " ARB_MODE "  "0 ,1 "
bitfld.long 0 7. " ARB_PRI "  "0 ,1 "
hexfld.byte 1 " FIL_VALUE "
bitfld.long 0 16.--25. " TE_TIMEOUT "  " "
tree.end

base ad:0xa0401054
tree "1CMD_MODE_STS"
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING "  "0 ,1 "
tree.end

base ad:0xa0401060
tree "1DIRECT_CMD_SEND"
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
tree.end

base ad:0xa0401064
tree "1DIRECT_CMD_MAIN_SETTINGS"
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--15. " CMD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--20. " CMD_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 24.--27. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0401068
tree "1DIRECT_CMD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 2 " ACK_VAL "
tree.end

base ad:0xa040106c
tree "1DIRECT_CMD_RD_INIT"
group 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
hexfld.word 0 " CMD_RD_INIT "
tree.end

base ad:0xa0401070
tree "1DIRECT_CMD_WRDAT0"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT0"
bitfld.long 0 0. " WRDAT0 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT1 "  " "
bitfld.long 0 9.--16. " WRDAT2 "  " "
bitfld.long 0 17.--24. " WRDAT3 "  " "
tree.end

base ad:0xa0401074
tree "1DIRECT_CMD_WRDAT1"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT1"
bitfld.long 0 0. " WRDAT4 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT5 "  " "
bitfld.long 0 9.--16. " WRDAT6 "  " "
bitfld.long 0 17.--24. " WRDAT7 "  " "
tree.end

base ad:0xa0401078
tree "1DIRECT_CMD_WRDAT2"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT2"
bitfld.long 0 0. " WRDAT8 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT9 "  " "
bitfld.long 0 9.--16. " WRDAT10 "  " "
bitfld.long 0 17.--24. " WRDAT11 "  " "
tree.end

base ad:0xa040107c
tree "1DIRECT_CMD_WRDAT3"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT3"
bitfld.long 0 0. " WRDAT12 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT13 "  " "
bitfld.long 0 9.--16. " WRDAT14 "  " "
bitfld.long 0 17.--24. " WRDAT15 "  " "
tree.end

base ad:0xa0401080
tree "1DIRECT_CMD_RDDAT"
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
hexfld.byte 0 " RDDAT0 "
hexfld.byte 1 " RDDAT1 "
hexfld.byte 2 " RDDAT2 "
hexfld.byte 3 " RDDAT3 "
tree.end

base ad:0xa0401084
tree "1DIRECT_CMD_RD_PROPERTY"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
hexfld.word 0 " RD_SIZE "
bitfld.long 0 16.--17. " RD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
tree.end

base ad:0xa0401088
tree "1DIRECT_CMD_RD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
tree.end

base ad:0xa0401090
tree "1VID_MAIN_CTL"
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STOP_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " VID_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--11. " HEADER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--13. " VID_PIXEL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " BURST_MODE "  "0 ,1 "
bitfld.long 0 15. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 16. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 17.--18. " REG_BLKLINE_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 19.--20. " REG_BLKEOL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--22. " RECOVERY_MODE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0401094
tree "1VID_VSIZE"
group 0--3
line.long 0 "VID_VSIZE"
bitfld.long 0 0.--3. " VSA_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " VBP_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " VFP_LENGTH "
bitfld.long 0 16.--26. " VACT_LENGTH "  " "
tree.end

base ad:0xa0401098
tree "1VID_HSIZE1"
group 0--3
line.long 0 "VID_HSIZE1"
hexfld.byte 0 " HSA_LENGTH "
hexfld.byte 1 " HBP_LENGTH "
bitfld.long 0 16.--26. " HFP_LENGTH "  " "
tree.end

base ad:0xa040109c
tree "1VID_HSIZE2"
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--12. " RGB_SIZE "  " "
tree.end

base ad:0xa04010a0
tree "1VID_BLKSIZE1"
group 0--3
line.long 0 "VID_BLKSIZE1"
bitfld.long 0 0.--12. " BLKLINE_EVENT_PCK "  " "
bitfld.long 0 13.--25. " BLKEOL_PCK "  " "
tree.end

base ad:0xa04010a4
tree "1VID_BLKSIZE2"
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
tree.end

base ad:0xa04010a8
tree "1VID_PCK_TIME"
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
tree.end

base ad:0xa04010ac
tree "1VID_DPHY_TIME"
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
tree.end

base ad:0xa04010b0
tree "1VID_ERR_COLOR"
group 0--3
line.long 0 "VID_ERR_COLOR"
hexfld.byte 0 " COL_RED "
hexfld.byte 1 " COL_GREEN "
hexfld.byte 2 " COL_BLUE "
hexfld.byte 3 " PAD_VAL "
tree.end

base ad:0xa04010b4
tree "1VID_VPOS"
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--12. " LINE_VAL "  " "
tree.end

base ad:0xa04010b8
tree "1VID_HPOS"
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
tree.end

base ad:0xa04010bc
tree "1VID_MODE_STS"
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY "  "0 ,1 "
tree.end

base ad:0xa04010c0
tree "1VID_VCA_SETTING1"
group 0--3
line.long 0 "VID_VCA_SETTING1"
hexfld.word 0 " MAX_BURST_LIMIT "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
tree.end

base ad:0xa04010c4
tree "1VID_VCA_SETTING2"
group 0--3
line.long 0 "VID_VCA_SETTING2"
hexfld.word 0 " EXACT_BURST_LIMIT "
hexfld.word 2 " MAX_LINE_LIMIT "
tree.end

base ad:0xa04010c8
tree "1TVG_CTL"
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " TVG_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa04010cc
tree "1TVG_IMG_SIZE"
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--12. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--26. " TVG_NBLINE "  " "
tree.end

base ad:0xa04010d0
tree "1TVG_COLOR1"
group 0--3
line.long 0 "TVG_COLOR1"
hexfld.byte 0 " COL1_RED "
hexfld.byte 1 " COL1_GREEN "
hexfld.byte 2 " COL1_BLUE "
tree.end

base ad:0xa04010d4
tree "1TVG_COLOR2"
group 0--3
line.long 0 "TVG_COLOR2"
hexfld.byte 0 " COL2_RED "
hexfld.byte 1 " COL2_GREEN "
hexfld.byte 2 " COL2_BLUE "
tree.end

base ad:0xa04010d8
tree "1TVG_STS"
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
tree.end

base ad:0xa04010e0
tree "1TBG_CTL"
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa04010e4
tree "1TBG_SETTING"
group 0--3
line.long 0 "TBG_SETTING"
hexfld.word 0 " TBG_DATA "
bitfld.long 0 16.--27. " TBG_CPT "  " "
tree.end

base ad:0xa04010e8
tree "1TBG_STS"
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
tree.end

base ad:0xa04010f0
tree "1MCTL_MAIN_STS_CTL"
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 21. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " CRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " VRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
tree.end

base ad:0xa04010f4
tree "1CMD_MODE_STS_CTL"
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SDI1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SDI2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 21. " CSM_RUNNING_EDGE "  "0 ,1 "
tree.end

base ad:0xa04010f8
tree "1DIRECT_CMD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
tree.end

base ad:0xa04010fc
tree "1DIRECT_CMD_RD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
tree.end

base ad:0xa0401100
tree "1VID_MODE_STS_CTL"
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGTH_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 26. " VSG_RECOVERY_EDGE "  "0 ,1 "
tree.end

base ad:0xa0401104
tree "1TG_STS_CTL"
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
tree.end

base ad:0xa0401108
tree "1MCTL_DPHY_ERR_CTL"
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL"
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 22. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 26. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 27. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 28. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 29. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 30. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 31. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
tree.end

base ad:0xa0401110
tree "1MCTL_MAIN_STS_CLR"
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
tree.end

base ad:0xa0401114
tree "1CMD_MODE_STS_CLR"
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_CLR "  "0 ,1 "
tree.end

base ad:0xa0401118
tree "1DIRECT_CMD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
tree.end

base ad:0xa040111c
tree "1DIRECT_CMD_RD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
tree.end

base ad:0xa0401120
tree "1VID_MODE_STS_CLR"
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_CLR "  "0 ,1 "
tree.end

base ad:0xa0401124
tree "1TG_STS_CLR"
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
tree.end

base ad:0xa0401128
tree "1MCTL_DPHY_ERR_CLR"
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
tree.end

base ad:0xa0401130
tree "1MCTL_MAIN_STS_FLAG"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
tree.end

base ad:0xa0401134
tree "1CMD_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_FLAG "  "0 ,1 "
tree.end

base ad:0xa0401138
tree "1DIRECT_CMD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
tree.end

base ad:0xa040113c
tree "1DIRECT_CMD_RD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
tree.end

base ad:0xa0401140
tree "1VID_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 10. " FLAG_VSG_RECOVERY "  "0 ,1 "
tree.end

base ad:0xa0401144
tree "1TG_STS_FLAG"
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
tree.end

base ad:0xa0401148
tree "1MCTL_DPHY_ERR_FLAG"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
tree.end

base ad:0xa0401150
tree "1DPHY_LANES_TRIM"
group 0--3
line.long 0 "DPHY_LANES_TRIM"
bitfld.long 0 0.--1. " dl1_skew "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " dl1_cd_off "  "0 ,1 "
bitfld.long 0 3. " dl1_hstx_slewrate_down "  "0 ,1 "
bitfld.long 0 4. " dl1_hstx_slewrate_up "  "0 ,1 "
bitfld.long 0 5. " dl1_test_reserved_1 "  "0 ,1 "
bitfld.long 0 6.--7. " cl_skew "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " cl_lp_rx_vil "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " cl_lp_tx_slewrate "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " cl_specs_90_81b "  "0 ,1 "
bitfld.long 0 13. " cl_hstx_slewrate_down "  "0 ,1 "
bitfld.long 0 14. " cl_hstx_slewrate_up "  "0 ,1 "
bitfld.long 0 15. " cl_test_reserved_1 "  "0 ,1 "
bitfld.long 0 16.--17. " dl2_skew "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " dl2_hstx_slewrate_down "  "0 ,1 "
bitfld.long 0 19. " dl2_hstx_slewrate_up "  "0 ,1 "
bitfld.long 0 20. " dl2_test_reserved_1 "  "0 ,1 "
tree.end

base ad:0xa0401ff0
tree "1ID_REG"
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " H "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--19. " PRODUCT_ID "  " "
bitfld.long 0 20.--31. " VENDOR_ID "  " "
tree.end

base ad:0xa0401ff4
tree "1IP_CONF"
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " FIFO_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

tree.end

tree.end

;==============================================================
tree "DSITB (3 instances)"
;==============================================================
base ad:0x63b00000
;********************************************
tree "DSITB-2"
;********************************************
base ad:0x63b00000
tree "2DPHY_RX_CFG_C"
group 0--3
line.long 0 "DPHY_RX_CFG_C"
bitfld.long 0 0. " c_swap_pins "  "0 ,1 "
bitfld.long 0 1. " c_hs_invert "  "0 ,1 "
bitfld.long 0 2. " c_enable "  "0 ,1 "
bitfld.long 0 3.--8. " c_ui_x4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 9. " spec_90_81b "  "0 ,1 "
tree.end

base ad:0x63b00004
tree "2DPHY_RX_CFG_D1"
group 0--3
line.long 0 "DPHY_RX_CFG_D1"
bitfld.long 0 0. " d1_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d1_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d1_enable "  "0 ,1 "
bitfld.long 0 3. " d1_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d1_force_rx_mode "  "0 ,1 "
tree.end

base ad:0x63b00008
tree "2DPHY_RX_CFG_D2"
group 0--3
line.long 0 "DPHY_RX_CFG_D2"
bitfld.long 0 0. " d2_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d2_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d2_enable "  "0 ,1 "
bitfld.long 0 3. " d2_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d2_force_rx_mode "  "0 ,1 "
tree.end

base ad:0x63b0000c
tree "2DPHY_RX_ERR_D1"
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D1"
bitfld.long 0 0. " d1_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d1_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d1_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d1_err_esc "  "0 ,1 "
bitfld.long 0 4. " d1_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d1_err_control "  "0 ,1 "
bitfld.long 0 6. " d1_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d1_err_contention_lp1 "  "0 ,1 "
tree.end

base ad:0x63b00010
tree "2DPHY_RX_ERR_D2"
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D2"
bitfld.long 0 0. " d2_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d2_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d2_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d2_err_esc "  "0 ,1 "
bitfld.long 0 4. " d2_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d2_err_control "  "0 ,1 "
bitfld.long 0 6. " d2_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d2_err_contention_lp1 "  "0 ,1 "
tree.end

base ad:0x63b00014
tree "2ADDR_BANK_1_MSB"
group 0--3
line.long 0 "ADDR_BANK_1_MSB"
hexfld.word 0 " addr_bank_1_msb "
tree.end

base ad:0x63b00018
tree "2ADDR_BANK_1_LSB"
group 0--3
line.long 0 "ADDR_BANK_1_LSB"
hexfld.word 0 " addr_bank_1_lsb "
tree.end

base ad:0x63b0001c
tree "2ADDR_BANK_2_MSB"
group 0--3
line.long 0 "ADDR_BANK_2_MSB"
hexfld.word 0 " addr_bank_2_msb "
tree.end

base ad:0x63b00020
tree "2ADDR_BANK_2_LSB"
group 0--3
line.long 0 "ADDR_BANK_2_LSB"
hexfld.word 0 " addr_bank_2_lsb "
tree.end

base ad:0x63b00024
tree "2ADDR_BANK_3_MSB"
group 0--3
line.long 0 "ADDR_BANK_3_MSB"
hexfld.word 0 " addr_bank_3_msb "
tree.end

base ad:0x63b00028
tree "2ADDR_BANK_3_LSB"
group 0--3
line.long 0 "ADDR_BANK_3_LSB"
hexfld.word 0 " addr_bank_3_lsb "
tree.end

base ad:0x63b0002c
tree "2ADDR_BANK_4_MSB"
group 0--3
line.long 0 "ADDR_BANK_4_MSB"
hexfld.word 0 " addr_bank_4_msb "
tree.end

base ad:0x63b00030
tree "2ADDR_BANK_4_LSB"
group 0--3
line.long 0 "ADDR_BANK_4_LSB"
hexfld.word 0 " addr_bank_4_lsb "
tree.end

base ad:0x63b00034
tree "2ADDR_BANK_5_MSB"
group 0--3
line.long 0 "ADDR_BANK_5_MSB"
hexfld.word 0 " addr_bank_5_msb "
tree.end

base ad:0x63b00038
tree "2ADDR_BANK_5_LSB"
group 0--3
line.long 0 "ADDR_BANK_5_LSB"
hexfld.word 0 " addr_bank_5_lsb "
tree.end

base ad:0x63b0003c
tree "2LM_CFG"
group 0--3
line.long 0 "LM_CFG"
bitfld.long 0 0. " dual_lane_en "  "0 ,1 "
tree.end

base ad:0x63b00040
tree "2RTM_CFG_1"
group 0--3
line.long 0 "RTM_CFG_1"
bitfld.long 0 0. " ack_with_error "  "0 ,1 "
bitfld.long 0 1.--4. " trigger_value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x63b00044
tree "2RTM_CFG_2"
group 0--3
line.long 0 "RTM_CFG_2"
hexfld.byte 0 " read_data "
bitfld.long 0 8.--12. " data_number "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x63b00048
tree "2RTM_CFG_3"
group 0--3
line.long 0 "RTM_CFG_3"
hexfld.word 0 " error_report "
tree.end

base ad:0x63b0004c
tree "2TESTER_CFG"
group 0--3
line.long 0 "TESTER_CFG"
bitfld.long 0 0. " soft_rst_n "  "0 ,1 "
bitfld.long 0 1. " isolate_tester "  "0 ,1 "
tree.end

base ad:0x63b00400
tree "2EXT_MEM"
group 0--3
line.long 0 "EXT_MEM"
bitfld.long 0 0. " EXT_MEM "  "0 ,1 "
tree.end

tree.end

base ad:0x63b80000
;********************************************
tree "DSITB-0"
;********************************************
base ad:0x63b80000
tree "0DPHY_RX_CFG_C"
group 0--3
line.long 0 "DPHY_RX_CFG_C"
bitfld.long 0 0. " c_swap_pins "  "0 ,1 "
bitfld.long 0 1. " c_hs_invert "  "0 ,1 "
bitfld.long 0 2. " c_enable "  "0 ,1 "
bitfld.long 0 3.--8. " c_ui_x4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 9. " spec_90_81b "  "0 ,1 "
tree.end

base ad:0x63b80004
tree "0DPHY_RX_CFG_D1"
group 0--3
line.long 0 "DPHY_RX_CFG_D1"
bitfld.long 0 0. " d1_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d1_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d1_enable "  "0 ,1 "
bitfld.long 0 3. " d1_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d1_force_rx_mode "  "0 ,1 "
tree.end

base ad:0x63b80008
tree "0DPHY_RX_CFG_D2"
group 0--3
line.long 0 "DPHY_RX_CFG_D2"
bitfld.long 0 0. " d2_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d2_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d2_enable "  "0 ,1 "
bitfld.long 0 3. " d2_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d2_force_rx_mode "  "0 ,1 "
tree.end

base ad:0x63b8000c
tree "0DPHY_RX_ERR_D1"
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D1"
bitfld.long 0 0. " d1_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d1_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d1_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d1_err_esc "  "0 ,1 "
bitfld.long 0 4. " d1_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d1_err_control "  "0 ,1 "
bitfld.long 0 6. " d1_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d1_err_contention_lp1 "  "0 ,1 "
tree.end

base ad:0x63b80010
tree "0DPHY_RX_ERR_D2"
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D2"
bitfld.long 0 0. " d2_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d2_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d2_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d2_err_esc "  "0 ,1 "
bitfld.long 0 4. " d2_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d2_err_control "  "0 ,1 "
bitfld.long 0 6. " d2_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d2_err_contention_lp1 "  "0 ,1 "
tree.end

base ad:0x63b80014
tree "0ADDR_BANK_1_MSB"
group 0--3
line.long 0 "ADDR_BANK_1_MSB"
hexfld.word 0 " addr_bank_1_msb "
tree.end

base ad:0x63b80018
tree "0ADDR_BANK_1_LSB"
group 0--3
line.long 0 "ADDR_BANK_1_LSB"
hexfld.word 0 " addr_bank_1_lsb "
tree.end

base ad:0x63b8001c
tree "0ADDR_BANK_2_MSB"
group 0--3
line.long 0 "ADDR_BANK_2_MSB"
hexfld.word 0 " addr_bank_2_msb "
tree.end

base ad:0x63b80020
tree "0ADDR_BANK_2_LSB"
group 0--3
line.long 0 "ADDR_BANK_2_LSB"
hexfld.word 0 " addr_bank_2_lsb "
tree.end

base ad:0x63b80024
tree "0ADDR_BANK_3_MSB"
group 0--3
line.long 0 "ADDR_BANK_3_MSB"
hexfld.word 0 " addr_bank_3_msb "
tree.end

base ad:0x63b80028
tree "0ADDR_BANK_3_LSB"
group 0--3
line.long 0 "ADDR_BANK_3_LSB"
hexfld.word 0 " addr_bank_3_lsb "
tree.end

base ad:0x63b8002c
tree "0ADDR_BANK_4_MSB"
group 0--3
line.long 0 "ADDR_BANK_4_MSB"
hexfld.word 0 " addr_bank_4_msb "
tree.end

base ad:0x63b80030
tree "0ADDR_BANK_4_LSB"
group 0--3
line.long 0 "ADDR_BANK_4_LSB"
hexfld.word 0 " addr_bank_4_lsb "
tree.end

base ad:0x63b80034
tree "0ADDR_BANK_5_MSB"
group 0--3
line.long 0 "ADDR_BANK_5_MSB"
hexfld.word 0 " addr_bank_5_msb "
tree.end

base ad:0x63b80038
tree "0ADDR_BANK_5_LSB"
group 0--3
line.long 0 "ADDR_BANK_5_LSB"
hexfld.word 0 " addr_bank_5_lsb "
tree.end

base ad:0x63b8003c
tree "0LM_CFG"
group 0--3
line.long 0 "LM_CFG"
bitfld.long 0 0. " dual_lane_en "  "0 ,1 "
tree.end

base ad:0x63b80040
tree "0RTM_CFG_1"
group 0--3
line.long 0 "RTM_CFG_1"
bitfld.long 0 0. " ack_with_error "  "0 ,1 "
bitfld.long 0 1.--4. " trigger_value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x63b80044
tree "0RTM_CFG_2"
group 0--3
line.long 0 "RTM_CFG_2"
hexfld.byte 0 " read_data "
bitfld.long 0 8.--12. " data_number "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x63b80048
tree "0RTM_CFG_3"
group 0--3
line.long 0 "RTM_CFG_3"
hexfld.word 0 " error_report "
tree.end

base ad:0x63b8004c
tree "0TESTER_CFG"
group 0--3
line.long 0 "TESTER_CFG"
bitfld.long 0 0. " soft_rst_n "  "0 ,1 "
bitfld.long 0 1. " isolate_tester "  "0 ,1 "
tree.end

base ad:0x63b80400
tree "0EXT_MEM"
group 0--3
line.long 0 "EXT_MEM"
bitfld.long 0 0. " EXT_MEM "  "0 ,1 "
tree.end

tree.end

base ad:0x63b80000
;********************************************
tree "DSITB-1"
;********************************************
base ad:0x63b80000
tree "1DPHY_RX_CFG_C"
group 0--3
line.long 0 "DPHY_RX_CFG_C"
bitfld.long 0 0. " c_swap_pins "  "0 ,1 "
bitfld.long 0 1. " c_hs_invert "  "0 ,1 "
bitfld.long 0 2. " c_enable "  "0 ,1 "
bitfld.long 0 3.--8. " c_ui_x4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 9. " spec_90_81b "  "0 ,1 "
tree.end

base ad:0x63b80004
tree "1DPHY_RX_CFG_D1"
group 0--3
line.long 0 "DPHY_RX_CFG_D1"
bitfld.long 0 0. " d1_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d1_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d1_enable "  "0 ,1 "
bitfld.long 0 3. " d1_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d1_force_rx_mode "  "0 ,1 "
tree.end

base ad:0x63b80008
tree "1DPHY_RX_CFG_D2"
group 0--3
line.long 0 "DPHY_RX_CFG_D2"
bitfld.long 0 0. " d2_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d2_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d2_enable "  "0 ,1 "
bitfld.long 0 3. " d2_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d2_force_rx_mode "  "0 ,1 "
tree.end

base ad:0x63b8000c
tree "1DPHY_RX_ERR_D1"
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D1"
bitfld.long 0 0. " d1_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d1_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d1_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d1_err_esc "  "0 ,1 "
bitfld.long 0 4. " d1_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d1_err_control "  "0 ,1 "
bitfld.long 0 6. " d1_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d1_err_contention_lp1 "  "0 ,1 "
tree.end

base ad:0x63b80010
tree "1DPHY_RX_ERR_D2"
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D2"
bitfld.long 0 0. " d2_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d2_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d2_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d2_err_esc "  "0 ,1 "
bitfld.long 0 4. " d2_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d2_err_control "  "0 ,1 "
bitfld.long 0 6. " d2_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d2_err_contention_lp1 "  "0 ,1 "
tree.end

base ad:0x63b80014
tree "1ADDR_BANK_1_MSB"
group 0--3
line.long 0 "ADDR_BANK_1_MSB"
hexfld.word 0 " addr_bank_1_msb "
tree.end

base ad:0x63b80018
tree "1ADDR_BANK_1_LSB"
group 0--3
line.long 0 "ADDR_BANK_1_LSB"
hexfld.word 0 " addr_bank_1_lsb "
tree.end

base ad:0x63b8001c
tree "1ADDR_BANK_2_MSB"
group 0--3
line.long 0 "ADDR_BANK_2_MSB"
hexfld.word 0 " addr_bank_2_msb "
tree.end

base ad:0x63b80020
tree "1ADDR_BANK_2_LSB"
group 0--3
line.long 0 "ADDR_BANK_2_LSB"
hexfld.word 0 " addr_bank_2_lsb "
tree.end

base ad:0x63b80024
tree "1ADDR_BANK_3_MSB"
group 0--3
line.long 0 "ADDR_BANK_3_MSB"
hexfld.word 0 " addr_bank_3_msb "
tree.end

base ad:0x63b80028
tree "1ADDR_BANK_3_LSB"
group 0--3
line.long 0 "ADDR_BANK_3_LSB"
hexfld.word 0 " addr_bank_3_lsb "
tree.end

base ad:0x63b8002c
tree "1ADDR_BANK_4_MSB"
group 0--3
line.long 0 "ADDR_BANK_4_MSB"
hexfld.word 0 " addr_bank_4_msb "
tree.end

base ad:0x63b80030
tree "1ADDR_BANK_4_LSB"
group 0--3
line.long 0 "ADDR_BANK_4_LSB"
hexfld.word 0 " addr_bank_4_lsb "
tree.end

base ad:0x63b80034
tree "1ADDR_BANK_5_MSB"
group 0--3
line.long 0 "ADDR_BANK_5_MSB"
hexfld.word 0 " addr_bank_5_msb "
tree.end

base ad:0x63b80038
tree "1ADDR_BANK_5_LSB"
group 0--3
line.long 0 "ADDR_BANK_5_LSB"
hexfld.word 0 " addr_bank_5_lsb "
tree.end

base ad:0x63b8003c
tree "1LM_CFG"
group 0--3
line.long 0 "LM_CFG"
bitfld.long 0 0. " dual_lane_en "  "0 ,1 "
tree.end

base ad:0x63b80040
tree "1RTM_CFG_1"
group 0--3
line.long 0 "RTM_CFG_1"
bitfld.long 0 0. " ack_with_error "  "0 ,1 "
bitfld.long 0 1.--4. " trigger_value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x63b80044
tree "1RTM_CFG_2"
group 0--3
line.long 0 "RTM_CFG_2"
hexfld.byte 0 " read_data "
bitfld.long 0 8.--12. " data_number "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x63b80048
tree "1RTM_CFG_3"
group 0--3
line.long 0 "RTM_CFG_3"
hexfld.word 0 " error_report "
tree.end

base ad:0x63b8004c
tree "1TESTER_CFG"
group 0--3
line.long 0 "TESTER_CFG"
bitfld.long 0 0. " soft_rst_n "  "0 ,1 "
bitfld.long 0 1. " isolate_tester "  "0 ,1 "
tree.end

base ad:0x63b80400
tree "1EXT_MEM"
group 0--3
line.long 0 "EXT_MEM"
bitfld.long 0 0. " EXT_MEM "  "0 ,1 "
tree.end

tree.end

tree.end

;==============================================================
tree "ETB11"
;==============================================================
base eapb:0x801c4004
tree "RAM_Depth"
rgroup 0--3
line.long 0 "RAM_Depth"
hexfld.long 0 " RDP "
tree.end

base eapb:0x801c400c
tree "Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " FULL "  "0 ,1 "
bitfld.long 0 1. " TRIGGERED "  "0 ,1 "
bitfld.long 0 2. " ACQCOMP "  "0 ,1 "
bitfld.long 0 3. " FTEMPTY "  "0 ,1 "
tree.end

base eapb:0x801c4010
tree "RAM_Data"
group 0--3
line.long 0 "RAM_Data"
hexfld.long 0 " RAM_READ_DATA "
tree.end

base eapb:0x801c4014
tree "RAM_Read_Pointer"
group 0--3
line.long 0 "RAM_Read_Pointer"
bitfld.long 0 0.--1. " RAM_Read_Pointer "  "0 ,1 ,2 ,3 "
tree.end

base eapb:0x801c4018
tree "RAM_Write_Pointer"
group 0--3
line.long 0 "RAM_Write_Pointer"
bitfld.long 0 0.--1. " RAM_Write_Pointer "  "0 ,1 ,2 ,3 "
tree.end

base eapb:0x801c401c
tree "Trigger_Counter"
group 0--3
line.long 0 "Trigger_Counter"
bitfld.long 0 0.--1. " Trigger_Counter "  "0 ,1 ,2 ,3 "
tree.end

base eapb:0x801c4020
tree "Control"
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " TRACECAPTEN "  "0 ,1 "
tree.end

base eapb:0x801c4024
tree "RAM_WRITE"
wgroup 0--3
line.long 0 "RAM_WRITE"
hexfld.long 0 " RAM_WRITE_DATA "
tree.end

base eapb:0x801c4300
tree "FFSR"
rgroup 0--3
line.long 0 "FFSR"
bitfld.long 0 0. " FLINPROG "  "0 ,1 "
bitfld.long 0 1. " FTSTOPPED "  "0 ,1 "
tree.end

base eapb:0x801c4304
tree "DESCRIPTION"
group 0--3
line.long 0 "DESCRIPTION"
bitfld.long 0 0. " ENFTC "  "0 ,1 "
bitfld.long 0 1. " ENFCONT "  "0 ,1 "
bitfld.long 0 4. " FONFLIN "  "0 ,1 "
bitfld.long 0 5. " FONTRIG "  "0 ,1 "
bitfld.long 0 6. " FONMAN "  "0 ,1 "
bitfld.long 0 8. " TRIGIN "  "0 ,1 "
bitfld.long 0 9. " TRIGEVT "  "0 ,1 "
bitfld.long 0 10. " TRGFL "  "0 ,1 "
bitfld.long 0 12. " STOPFL "  "0 ,1 "
bitfld.long 0 13. " STOPTRIG "  "0 ,1 "
tree.end

base eapb:0x801c4ee0
tree "ITMISCOP0"
group 0--3
line.long 0 "ITMISCOP0"
bitfld.long 0 0. " ACQCOMP "  "0 ,1 "
bitfld.long 0 1. " FULL "  "0 ,1 "
tree.end

base eapb:0x801c4ee4
tree "ITTRFLINACK"
group 0--3
line.long 0 "ITTRFLINACK"
bitfld.long 0 0. " TRIGNACK "  "0 ,1 "
bitfld.long 0 1. " FLUSHINACK "  "0 ,1 "
tree.end

base eapb:0x801c4ee8
tree "ITTRFLIN"
group 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0. " TRIGIN "  "0 ,1 "
bitfld.long 0 1. " FLUSHIN "  "0 ,1 "
tree.end

base eapb:0x801c4eec
tree "ITATBDATA0"
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ATDATA0 "  "0 ,1 "
bitfld.long 0 1. " ATDATA7 "  "0 ,1 "
bitfld.long 0 2. " ATDATA15 "  "0 ,1 "
bitfld.long 0 3. " ATDATA23 "  "0 ,1 "
bitfld.long 0 4. " ATDATA31 "  "0 ,1 "
tree.end

base eapb:0x801c4ef0
tree "ITATBCTR2"
group 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ATREADYS "  "0 ,1 "
bitfld.long 0 1. " AFVALIDS "  "0 ,1 "
tree.end

base eapb:0x801c4ef4
tree "ITATBCTR1"
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0.--6. " ATID "  " "
tree.end

base eapb:0x801c4ef8
tree "ITATBCTR0"
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ATVALID "  "0 ,1 "
bitfld.long 0 1. " AFREADY "  "0 ,1 "
bitfld.long 0 8.--9. " ATBYTES "  "0 ,1 ,2 ,3 "
tree.end

base eapb:0x801c4f00
tree "IMCR"
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " IMCR "  "0 ,1 "
tree.end

base eapb:0x801c4fa0
tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0. " CTSR "  "0 ,1 "
tree.end

base eapb:0x801c4fa4
tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0. " CTCR "  "0 ,1 "
tree.end

base eapb:0x801c4fb0
tree "LAR"
group 0--3
line.long 0 "LAR"
bitfld.long 0 0. " LAR "  "0 ,1 "
tree.end

base eapb:0x801c4fb4
tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0. " LSR "  "0 ,1 "
tree.end

base eapb:0x801c4fb8
tree "ASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0. " ASR "  "0 ,1 "
tree.end

base eapb:0x801c4fc8
tree "DID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0. " DID "  "0 ,1 "
tree.end

base eapb:0x801c4fcc
tree "DTIR"
rgroup 0--3
line.long 0 "DTIR"
bitfld.long 0 0. " DTIR "  "0 ,1 "
tree.end

base eapb:0x801c4fd0
tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0. " PERIPHERAL_ID4 "  "0 ,1 "
tree.end

base eapb:0x801c4fd4
tree "PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
tree.end

base eapb:0x801c4fd8
tree "PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
tree.end

base eapb:0x801c4fdc
tree "PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
tree.end

base eapb:0x801c4fe0
tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0. " PERIPHERAL_ID0 "  "0 ,1 "
tree.end

base eapb:0x801c4fe4
tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0. " PERIPHERAL_ID1 "  "0 ,1 "
tree.end

base eapb:0x801c4fe8
tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0. " PERIPHERAL_ID2 "  "0 ,1 "
tree.end

base eapb:0x801c4fec
tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0. " PERIPHERAL_ID3 "  "0 ,1 "
tree.end

base eapb:0x801c4ff0
tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
tree.end

base eapb:0x801c4ff4
tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0. " COMPONENT_ID1 "  "0 ,1 "
tree.end

base eapb:0x801c4ff8
tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0. " COMPONENT_ID2 "  "0 ,1 "
tree.end

base eapb:0x801c4ffc
tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0. " COMPONENT_ID3 "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "FSMC"
;==============================================================
base ad:0xa0020000
tree "FSMC_BCR0"
group 0--3
line.long 0 "FSMC_BCR0"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " FORCEBUSTURN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 16.--18. " CPAGESIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
tree.end

base ad:0xa0020008
tree "FSMC_BCR1"
group 0--3
line.long 0 "FSMC_BCR1"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " FORCEBUSTURN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 16.--18. " CPAGESIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
tree.end

base ad:0xa0020010
tree "FSMC_BCR2"
group 0--3
line.long 0 "FSMC_BCR2"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " FORCEBUSTURN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 16.--18. " CPAGESIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
tree.end

base ad:0xa0020018
tree "FSMC_BCR3"
group 0--3
line.long 0 "FSMC_BCR3"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " FORCEBUSTURN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 16.--18. " CPAGESIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
tree.end

base ad:0xa0020004
tree "FSMC_BTR0"
group 0--3
line.long 0 "FSMC_BTR0"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa002000c
tree "FSMC_BTR1"
group 0--3
line.long 0 "FSMC_BTR1"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0020014
tree "FSMC_BTR2"
group 0--3
line.long 0 "FSMC_BTR2"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa002001c
tree "FSMC_BTR3"
group 0--3
line.long 0 "FSMC_BTR3"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0020040
tree "FSMC_PCR0"
group 0--3
line.long 0 "FSMC_PCR0"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0020060
tree "FSMC_PCR1"
group 0--3
line.long 0 "FSMC_PCR1"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0020080
tree "FSMC_PCR2"
group 0--3
line.long 0 "FSMC_PCR2"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa00200a0
tree "FSMC_PCR3"
group 0--3
line.long 0 "FSMC_PCR3"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0020044
tree "FSMC_SR0"
group 0--3
line.long 0 "FSMC_SR0"
bitfld.long 0 6. " FEMPT "  "0 ,1 "
bitfld.long 0 7.--9. " ECCTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--13. " ERRFOUND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14. " CODTYPE "  "0 ,1 "
bitfld.long 0 15. " CODRDY "  "0 ,1 "
bitfld.long 0 16. " B13BCH8 "  "0 ,1 "
tree.end

base ad:0xa0020064
tree "FSMC_SR1"
group 0--3
line.long 0 "FSMC_SR1"
bitfld.long 0 6. " FEMPT "  "0 ,1 "
bitfld.long 0 7. " ECCTYPE "  "0 ,1 "
bitfld.long 0 8. " ERRFOUND "  "0 ,1 "
bitfld.long 0 9. " CODTYPE "  "0 ,1 "
bitfld.long 0 10. " CODRDY "  "0 ,1 "
bitfld.long 0 11. " B13BCH8 "  "0 ,1 "
tree.end

base ad:0xa0020048
tree "FSMC_PMEM0"
group 0--3
line.long 0 "FSMC_PMEM0"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
tree.end

base ad:0xa0020068
tree "FSMC_PMEM1"
group 0--3
line.long 0 "FSMC_PMEM1"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
tree.end

base ad:0xa0020088
tree "FSMC_PMEM2"
group 0--3
line.long 0 "FSMC_PMEM2"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
tree.end

base ad:0xa00200a8
tree "FSMC_PMEM3"
group 0--3
line.long 0 "FSMC_PMEM3"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
tree.end

base ad:0xa002004c
tree "FSMC_PATT0"
group 0--3
line.long 0 "FSMC_PATT0"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
tree.end

base ad:0xa002006c
tree "FSMC_PATT1"
group 0--3
line.long 0 "FSMC_PATT1"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
tree.end

base ad:0xa002008c
tree "FSMC_PATT2"
group 0--3
line.long 0 "FSMC_PATT2"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
tree.end

base ad:0xa00200ac
tree "FSMC_PATT3"
group 0--3
line.long 0 "FSMC_PATT3"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
tree.end

base ad:0xa0020050
tree "FSMC_PIO0"
group 0--3
line.long 0 "FSMC_PIO0"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
tree.end

base ad:0xa0020070
tree "FSMC_PIO1"
group 0--3
line.long 0 "FSMC_PIO1"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
tree.end

base ad:0xa0020054
tree "FSMC_ECCR00"
rgroup 0--3
line.long 0 "FSMC_ECCR00"
hexfld.long 0 " ECC "
tree.end

base ad:0xa0020058
tree "FSMC_ECCR01"
rgroup 0--3
line.long 0 "FSMC_ECCR01"
hexfld.long 0 " ECC "
tree.end

base ad:0xa002005c
tree "FSMC_ECCR02"
rgroup 0--3
line.long 0 "FSMC_ECCR02"
hexfld.long 0 " ECC "
tree.end

base ad:0xa0020074
tree "FSMC_ECCR10"
rgroup 0--3
line.long 0 "FSMC_ECCR10"
hexfld.long 0 " ECC "
tree.end

base ad:0xa0020078
tree "FSMC_ECCR11"
rgroup 0--3
line.long 0 "FSMC_ECCR11"
hexfld.long 0 " ECC "
tree.end

base ad:0xa002007c
tree "FSMC_ECCR12"
rgroup 0--3
line.long 0 "FSMC_ECCR12"
hexfld.long 0 " ECC "
tree.end

base ad:0xa00200c0
tree "FSMC_ITCR"
group 0--3
line.long 0 "FSMC_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0xa00200c4
tree "FSMC_ITIP0"
group 0--3
line.long 0 "FSMC_ITIP0"
hexfld.long 0 " PCDAI "
tree.end

base ad:0xa00200c8
tree "FSMC_ITIP1"
group 0--3
line.long 0 "FSMC_ITIP1"
bitfld.long 0 0. " SMFBCLK "  "0 ,1 "
bitfld.long 0 1. " SMWAITn "  "0 ,1 "
bitfld.long 0 2.--3. " SMPCIRQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SMPIOIS16n "  "0 ,1 "
bitfld.long 0 7.--8. " SMPCD "  "0 ,1 ,2 ,3 "
bitfld.long 0 11.--12. " ExtDefWidth "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa00200cc
tree "FSMC_ITOP0"
group 0--3
line.long 0 "FSMC_ITOP0"
hexfld.long 0 " PCDAO "
tree.end

base ad:0xa00200d0
tree "FSMC_ITOP1"
group 0--3
line.long 0 "FSMC_ITOP1"
bitfld.long 0 0.--25. " SMAD "  " "
bitfld.long 0 26. " PC0INTR "  "0 ,1 "
bitfld.long 0 27. " PC1INTR "  "0 ,1 "
bitfld.long 0 30. " SMOEN "  "0 ,1 "
bitfld.long 0 31. " SWWEN "  "0 ,1 "
tree.end

base ad:0xa00200d4
tree "FSMC_ITOP2"
group 0--3
line.long 0 "FSMC_ITOP2"
bitfld.long 0 0. " SMPREGN "  "0 ,1 "
bitfld.long 0 1. " SMPRST0N "  "0 ,1 "
bitfld.long 0 2. " SMPRST1N "  "0 ,1 "
bitfld.long 0 5. " SMPCDIRN "  "0 ,1 "
bitfld.long 0 6. " SMPC1EN "  "0 ,1 "
bitfld.long 0 7. " SMPC2EN "  "0 ,1 "
bitfld.long 0 8. " SMPIORN "  "0 ,1 "
bitfld.long 0 9. " SMPIOWN "  "0 ,1 "
bitfld.long 0 10. " SMADVN "  "0 ,1 "
bitfld.long 0 11. " SMCKO "  "0 ,1 "
bitfld.long 0 12. " SMBE0n "  "0 ,1 "
bitfld.long 0 13. " SMBE1n "  "0 ,1 "
bitfld.long 0 14. " SMBE2n "  "0 ,1 "
bitfld.long 0 15. " SMBE3n "  "0 ,1 "
bitfld.long 0 16. " SMPS0N "  "0 ,1 "
bitfld.long 0 17. " SMPS1N "  "0 ,1 "
tree.end

base ad:0xa00200d8
tree "FSMC_ITOP3"
group 0--3
line.long 0 "FSMC_ITOP3"
bitfld.long 0 0. " SMCS0N "  "0 ,1 "
bitfld.long 0 1. " SMCS1N "  "0 ,1 "
bitfld.long 0 2. " SMCS2N "  "0 ,1 "
bitfld.long 0 3. " SMCS3N "  "0 ,1 "
bitfld.long 0 4. " SMFWP0N "  "0 ,1 "
bitfld.long 0 5. " SMFWP1N "  "0 ,1 "
bitfld.long 0 6. " SMFWP2N "  "0 ,1 "
bitfld.long 0 7. " SMFWP3N "  "0 ,1 "
bitfld.long 0 8. " SMFRST0N "  "0 ,1 "
bitfld.long 0 9. " SMFRST1N "  "0 ,1 "
bitfld.long 0 10. " SMFRST2N "  "0 ,1 "
bitfld.long 0 11. " SMFRST3N "  "0 ,1 "
tree.end

base ad:0xa0020104
tree "FSMC_BWTR0"
group 0--3
line.long 0 "FSMC_BWTR0"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa002010c
tree "FSMC_BWTR1"
group 0--3
line.long 0 "FSMC_BWTR1"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0020114
tree "FSMC_BWTR2"
group 0--3
line.long 0 "FSMC_BWTR2"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0020fe0
tree "FSMC_PeriphID0"
rgroup 0--3
line.long 0 "FSMC_PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0xa0020fe4
tree "FSMC_PeriphID1"
rgroup 0--3
line.long 0 "FSMC_PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0020fe8
tree "FSMC_PeriphID2"
rgroup 0--3
line.long 0 "FSMC_PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0020fec
tree "FSMC_PeriphID3"
rgroup 0--3
line.long 0 "FSMC_PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0xa0020ff0
tree "FSMC_PCellID0"
rgroup 0--3
line.long 0 "FSMC_PCellID0"
bitfld.long 0 0. " _PCellID0 "  "0 ,1 "
tree.end

base ad:0xa0020ff4
tree "FSMC_PCellID1"
rgroup 0--3
line.long 0 "FSMC_PCellID1"
bitfld.long 0 0. " _BCRPCellID1 "  "0 ,1 "
tree.end

base ad:0xa0020ff8
tree "FSMC_PCellID2"
rgroup 0--3
line.long 0 "FSMC_PCellID2"
bitfld.long 0 0. " _BCRPCellID2 "  "0 ,1 "
tree.end

base ad:0xa0020ffc
tree "FSMC_PCellID3"
rgroup 0--3
line.long 0 "FSMC_PCellID3"
bitfld.long 0 0. " _BCRPCellID3 "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "G12"
;==============================================================
base ad:0xa0320000
tree "G2D_BASE0"
wgroup 0--3
line.long 0 "G2D_BASE0"
bitfld.long 0 0. " G2D_BASE0 "  "0 ,1 "
tree.end

base ad:0xa0320004
tree "G2D_CFG0"
wgroup 0--3
line.long 0 "G2D_CFG0"
bitfld.long 0 0. " G2D_CFG0 "  "0 ,1 "
tree.end

base ad:0xa0320008
tree "G2D_BASE1"
wgroup 0--3
line.long 0 "G2D_BASE1"
bitfld.long 0 0. " G2D_BASE1 "  "0 ,1 "
tree.end

base ad:0xa032000c
tree "G2D_CFG1"
wgroup 0--3
line.long 0 "G2D_CFG1"
bitfld.long 0 0. " G2D_CFG1 "  "0 ,1 "
tree.end

base ad:0xa0320010
tree "G2D_BASE2"
wgroup 0--3
line.long 0 "G2D_BASE2"
bitfld.long 0 0. " G2D_BASE2 "  "0 ,1 "
tree.end

base ad:0xa0320014
tree "G2D_CFG2"
wgroup 0--3
line.long 0 "G2D_CFG2"
bitfld.long 0 0. " G2D_CFG2 "  "0 ,1 "
tree.end

base ad:0xa0320018
tree "G2D_BASE3"
wgroup 0--3
line.long 0 "G2D_BASE3"
bitfld.long 0 0. " G2D_BASE3 "  "0 ,1 "
tree.end

base ad:0xa032001c
tree "G2D_CFG3"
wgroup 0--3
line.long 0 "G2D_CFG3"
bitfld.long 0 0. " G2D_CFG3 "  "0 ,1 "
tree.end

base ad:0xa0320020
tree "G2D_SCISSORX"
wgroup 0--3
line.long 0 "G2D_SCISSORX"
bitfld.long 0 0. " G2D_SCISSORX "  "0 ,1 "
tree.end

base ad:0xa0320024
tree "G2D_SCISSORY"
wgroup 0--3
line.long 0 "G2D_SCISSORY"
bitfld.long 0 0. " G2D_SCISSORY "  "0 ,1 "
tree.end

base ad:0xa0320028
tree "G2D_FOREGROUND"
wgroup 0--3
line.long 0 "G2D_FOREGROUND"
bitfld.long 0 0. " G2D_FOREGROUND "  "0 ,1 "
tree.end

base ad:0xa032002c
tree "G2D_BACKGROUND"
wgroup 0--3
line.long 0 "G2D_BACKGROUND"
bitfld.long 0 0. " G2D_BACKGROUND "  "0 ,1 "
tree.end

base ad:0xa0320030
tree "G2D_ALPHABLEND"
wgroup 0--3
line.long 0 "G2D_ALPHABLEND"
bitfld.long 0 0. " G2D_ALPHABLEND "  "0 ,1 "
tree.end

base ad:0xa0320034
tree "G2D_ROP"
wgroup 0--3
line.long 0 "G2D_ROP"
bitfld.long 0 0. " G2D_ROP "  "0 ,1 "
tree.end

base ad:0xa0320038
tree "G2D_CONFIG"
wgroup 0--3
line.long 0 "G2D_CONFIG"
bitfld.long 0 0. " G2D_CONFIG "  "0 ,1 "
tree.end

base ad:0xa032003c
tree "G2D_INPUT"
wgroup 0--3
line.long 0 "G2D_INPUT"
bitfld.long 0 0. " G2D_INPUT "  "0 ,1 "
tree.end

base ad:0xa0320040
tree "G2D_MASK"
wgroup 0--3
line.long 0 "G2D_MASK"
bitfld.long 0 0. " G2D_MASK "  "0 ,1 "
tree.end

base ad:0xa0320044
tree "G2D_BLENDERCFG"
wgroup 0--3
line.long 0 "G2D_BLENDERCFG"
bitfld.long 0 0. " G2D_BLENDERCFG "  "0 ,1 "
tree.end

base ad:0xa0320050
tree "G2D_BLEND_A0"
wgroup 0--3
line.long 0 "G2D_BLEND_A0"
bitfld.long 0 0. " G2D_BLEND_A0 "  "0 ,1 "
tree.end

base ad:0xa0320054
tree "G2D_BLEND_A1"
wgroup 0--3
line.long 0 "G2D_BLEND_A1"
bitfld.long 0 0. " G2D_BLEND_A1 "  "0 ,1 "
tree.end

base ad:0xa0320058
tree "G2D_BLEND_A2"
wgroup 0--3
line.long 0 "G2D_BLEND_A2"
bitfld.long 0 0. " G2D_BLEND_A2 "  "0 ,1 "
tree.end

base ad:0xa032005c
tree "G2D_BLEND_A3"
wgroup 0--3
line.long 0 "G2D_BLEND_A3"
bitfld.long 0 0. " G2D_BLEND_A3 "  "0 ,1 "
tree.end

base ad:0xa0320060
tree "G2D_BLEND_C0"
wgroup 0--3
line.long 0 "G2D_BLEND_C0"
bitfld.long 0 0. " G2D_BLEND_C0 "  "0 ,1 "
tree.end

base ad:0xa0320064
tree "G2D_BLEND_C1"
wgroup 0--3
line.long 0 "G2D_BLEND_C1"
bitfld.long 0 0. " G2D_BLEND_C1 "  "0 ,1 "
tree.end

base ad:0xa0320068
tree "G2D_BLEND_C2"
wgroup 0--3
line.long 0 "G2D_BLEND_C2"
bitfld.long 0 0. " G2D_BLEND_C2 "  "0 ,1 "
tree.end

base ad:0xa032006c
tree "G2D_BLEND_C3"
wgroup 0--3
line.long 0 "G2D_BLEND_C3"
bitfld.long 0 0. " G2D_BLEND_C3 "  "0 ,1 "
tree.end

base ad:0xa0320070
tree "G2D_BLEND_C4"
wgroup 0--3
line.long 0 "G2D_BLEND_C4"
bitfld.long 0 0. " G2D_BLEND_C4 "  "0 ,1 "
tree.end

base ad:0xa0320074
tree "G2D_BLEND_C5"
wgroup 0--3
line.long 0 "G2D_BLEND_C5"
bitfld.long 0 0. " G2D_BLEND_C5 "  "0 ,1 "
tree.end

base ad:0xa0320078
tree "G2D_BLEND_C6"
wgroup 0--3
line.long 0 "G2D_BLEND_C6"
bitfld.long 0 0. " G2D_BLEND_C6 "  "0 ,1 "
tree.end

base ad:0xa032007c
tree "G2D_BLEND_C7"
wgroup 0--3
line.long 0 "G2D_BLEND_C7"
bitfld.long 0 0. " G2D_BLEND_C7 "  "0 ,1 "
tree.end

base ad:0xa0320080
tree "VGV1_VTX0"
wgroup 0--3
line.long 0 "VGV1_VTX0"
bitfld.long 0 0. " VGV1_VTX0 "  "0 ,1 "
tree.end

base ad:0xa0320084
tree "VGV1_VTX1"
wgroup 0--3
line.long 0 "VGV1_VTX1"
bitfld.long 0 0. " VGV1_VTX1 "  "0 ,1 "
tree.end

base ad:0xa0320088
tree "VGV1_TILEOFS"
wgroup 0--3
line.long 0 "VGV1_TILEOFS"
bitfld.long 0 0. " VGV1_TILEOFS "  "0 ,1 "
tree.end

base ad:0xa032008c
tree "VGV1_FILL"
wgroup 0--3
line.long 0 "VGV1_FILL"
bitfld.long 0 0. " VGV1_FILL "  "0 ,1 "
tree.end

base ad:0xa0320090
tree "VGV1_SCISSORX"
wgroup 0--3
line.long 0 "VGV1_SCISSORX"
bitfld.long 0 0. " VGV1_SCISSORX "  "0 ,1 "
tree.end

base ad:0xa0320094
tree "VGV1_SCISSORY"
wgroup 0--3
line.long 0 "VGV1_SCISSORY"
bitfld.long 0 0. " VGV1_SCISSORY "  "0 ,1 "
tree.end

base ad:0xa032009c
tree "VGV1_CFG1"
wgroup 0--3
line.long 0 "VGV1_CFG1"
bitfld.long 0 0. " VGV1_CFG1 "  "0 ,1 "
tree.end

base ad:0xa03200a0
tree "VGV1_CFG2"
wgroup 0--3
line.long 0 "VGV1_CFG2"
bitfld.long 0 0. " VGV1_CFG2 "  "0 ,1 "
tree.end

base ad:0xa03200a4
tree "VGV1_DIRTYBASE"
wgroup 0--3
line.long 0 "VGV1_DIRTYBASE"
bitfld.long 0 0. " VGV1_DIRTYBASE "  "0 ,1 "
tree.end

base ad:0xa03200a8
tree "VGV1_CBASE1"
wgroup 0--3
line.long 0 "VGV1_CBASE1"
bitfld.long 0 0. " VGV1_CBASE1 "  "0 ,1 "
tree.end

base ad:0xa03200ac
tree "VGV1_UBASE2"
wgroup 0--3
line.long 0 "VGV1_UBASE2"
bitfld.long 0 0. " VGV1_UBASE2 "  "0 ,1 "
tree.end

base ad:0xa0320100
tree "VGV2_C1X"
wgroup 0--3
line.long 0 "VGV2_C1X"
bitfld.long 0 0. " VGV2_C1X "  "0 ,1 "
tree.end

base ad:0xa0320104
tree "VGV2_C1Y"
wgroup 0--3
line.long 0 "VGV2_C1Y"
bitfld.long 0 0. " VGV2_C1Y "  "0 ,1 "
tree.end

base ad:0xa0320108
tree "VGV2_C2X"
wgroup 0--3
line.long 0 "VGV2_C2X"
bitfld.long 0 0. " VGV2_C2X "  "0 ,1 "
tree.end

base ad:0xa032010c
tree "VGV2_C2Y"
wgroup 0--3
line.long 0 "VGV2_C2Y"
bitfld.long 0 0. " VGV2_C2Y "  "0 ,1 "
tree.end

base ad:0xa0320110
tree "VGV2_C3X"
wgroup 0--3
line.long 0 "VGV2_C3X"
bitfld.long 0 0. " VGV2_C3X "  "0 ,1 "
tree.end

base ad:0xa0320114
tree "VGV2_C3Y"
wgroup 0--3
line.long 0 "VGV2_C3Y"
bitfld.long 0 0. " VGV2_C3Y "  "0 ,1 "
tree.end

base ad:0xa0320118
tree "VGV2_C4X"
wgroup 0--3
line.long 0 "VGV2_C4X"
bitfld.long 0 0. " VGV2_C4X "  "0 ,1 "
tree.end

base ad:0xa032011c
tree "VGV2_C4Y"
wgroup 0--3
line.long 0 "VGV2_C4Y"
bitfld.long 0 0. " VGV2_C4Y "  "0 ,1 "
tree.end

base ad:0xa0320120
tree "VGV2_C1XREL"
wgroup 0--3
line.long 0 "VGV2_C1XREL"
bitfld.long 0 0. " VGV2_C1XREL "  "0 ,1 "
tree.end

base ad:0xa0320124
tree "VGV2_C1YREL"
wgroup 0--3
line.long 0 "VGV2_C1YREL"
bitfld.long 0 0. " VGV2_C1YREL "  "0 ,1 "
tree.end

base ad:0xa0320128
tree "VGV2_C2XREL"
wgroup 0--3
line.long 0 "VGV2_C2XREL"
bitfld.long 0 0. " VGV2_C2XREL "  "0 ,1 "
tree.end

base ad:0xa032012c
tree "VGV2_C2YREL"
wgroup 0--3
line.long 0 "VGV2_C2YREL"
bitfld.long 0 0. " VGV2_C2YREL "  "0 ,1 "
tree.end

base ad:0xa0320130
tree "VGV2_C3XREL"
wgroup 0--3
line.long 0 "VGV2_C3XREL"
bitfld.long 0 0. " VGV2_C3XREL "  "0 ,1 "
tree.end

base ad:0xa0320134
tree "VGV2_C3YREL"
wgroup 0--3
line.long 0 "VGV2_C3YREL"
bitfld.long 0 0. " VGV2_C3YREL "  "0 ,1 "
tree.end

base ad:0xa0320138
tree "VGV2_C4XREL"
wgroup 0--3
line.long 0 "VGV2_C4XREL"
bitfld.long 0 0. " VGV2_C4XREL "  "0 ,1 "
tree.end

base ad:0xa032013c
tree "VGV2_C4YREL"
wgroup 0--3
line.long 0 "VGV2_C4YREL"
bitfld.long 0 0. " VGV2_C4YREL "  "0 ,1 "
tree.end

base ad:0xa0320140
tree "VGV2_XFXX"
wgroup 0--3
line.long 0 "VGV2_XFXX"
bitfld.long 0 0. " VGV2_XFXX "  "0 ,1 "
tree.end

base ad:0xa0320144
tree "VGV2_XFYX"
wgroup 0--3
line.long 0 "VGV2_XFYX"
bitfld.long 0 0. " VGV2_XFYX "  "0 ,1 "
tree.end

base ad:0xa0320148
tree "VGV2_XFXY"
wgroup 0--3
line.long 0 "VGV2_XFXY"
bitfld.long 0 0. " VGV2_XFXY "  "0 ,1 "
tree.end

base ad:0xa032014c
tree "VGV2_XFYY"
wgroup 0--3
line.long 0 "VGV2_XFYY"
bitfld.long 0 0. " VGV2_XFYY "  "0 ,1 "
tree.end

base ad:0xa0320150
tree "VGV2_XFXA"
wgroup 0--3
line.long 0 "VGV2_XFXA"
bitfld.long 0 0. " VGV2_XFXA "  "0 ,1 "
tree.end

base ad:0xa0320154
tree "VGV2_XFYA"
wgroup 0--3
line.long 0 "VGV2_XFYA"
bitfld.long 0 0. " VGV2_XFYA "  "0 ,1 "
tree.end

base ad:0xa0320158
tree "VGV2_XFSTXX"
wgroup 0--3
line.long 0 "VGV2_XFSTXX"
bitfld.long 0 0. " VGV2_XFSTXX "  "0 ,1 "
tree.end

base ad:0xa032015c
tree "VGV2_XFSTYX"
wgroup 0--3
line.long 0 "VGV2_XFSTYX"
bitfld.long 0 0. " VGV2_XFSTYX "  "0 ,1 "
tree.end

base ad:0xa0320160
tree "VGV2_XFSTXY"
wgroup 0--3
line.long 0 "VGV2_XFSTXY"
bitfld.long 0 0. " VGV2_XFSTXY "  "0 ,1 "
tree.end

base ad:0xa0320164
tree "VGV2_XFSTYY"
wgroup 0--3
line.long 0 "VGV2_XFSTYY"
bitfld.long 0 0. " VGV2_XFSTYY "  "0 ,1 "
tree.end

base ad:0xa0320168
tree "VGV2_BBOXMINX"
wgroup 0--3
line.long 0 "VGV2_BBOXMINX"
bitfld.long 0 0. " VGV2_BBOXMINX "  "0 ,1 "
tree.end

base ad:0xa032016c
tree "VGV2_BBOXMINY"
wgroup 0--3
line.long 0 "VGV2_BBOXMINY"
bitfld.long 0 0. " VGV2_BBOXMINY "  "0 ,1 "
tree.end

base ad:0xa0320170
tree "VGV2_BBOXMAXX"
wgroup 0--3
line.long 0 "VGV2_BBOXMAXX"
bitfld.long 0 0. " VGV2_BBOXMAXX "  "0 ,1 "
tree.end

base ad:0xa0320174
tree "VGV2_BBOXMAXY"
wgroup 0--3
line.long 0 "VGV2_BBOXMAXY"
bitfld.long 0 0. " VGV2_BBOXMAXY "  "0 ,1 "
tree.end

base ad:0xa0320178
tree "VGV2_SCALE"
wgroup 0--3
line.long 0 "VGV2_SCALE"
bitfld.long 0 0. " VGV2_SCALE "  "0 ,1 "
tree.end

base ad:0xa032017c
tree "VGV2_BIAS"
wgroup 0--3
line.long 0 "VGV2_BIAS"
bitfld.long 0 0. " VGV2_BIAS "  "0 ,1 "
tree.end

base ad:0xa0320180
tree "VGV2_ACCURACY"
wgroup 0--3
line.long 0 "VGV2_ACCURACY"
bitfld.long 0 0. " VGV2_ACCURACY "  "0 ,1 "
tree.end

base ad:0xa0320184
tree "VGV2_THINRADIUS"
wgroup 0--3
line.long 0 "VGV2_THINRADIUS"
bitfld.long 0 0. " VGV2_THINRADIUS "  "0 ,1 "
tree.end

base ad:0xa0320188
tree "VGV2_ARCCOS"
wgroup 0--3
line.long 0 "VGV2_ARCCOS"
bitfld.long 0 0. " VGV2_ARCCOS "  "0 ,1 "
tree.end

base ad:0xa032018c
tree "VGV2_ARCSIN"
wgroup 0--3
line.long 0 "VGV2_ARCSIN"
bitfld.long 0 0. " VGV2_ARCSIN "  "0 ,1 "
tree.end

base ad:0xa0320190
tree "VGV2_ARCTAN"
wgroup 0--3
line.long 0 "VGV2_ARCTAN"
bitfld.long 0 0. " VGV2_ARCTAN "  "0 ,1 "
tree.end

base ad:0xa0320194
tree "VGV2_RADIUS"
wgroup 0--3
line.long 0 "VGV2_RADIUS"
bitfld.long 0 0. " VGV2_RADIUS "  "0 ,1 "
tree.end

base ad:0xa0320198
tree "VGV2_MITER"
wgroup 0--3
line.long 0 "VGV2_MITER"
bitfld.long 0 0. " VGV2_MITER "  "0 ,1 "
tree.end

base ad:0xa03201a0
tree "VGV2_CLIP"
wgroup 0--3
line.long 0 "VGV2_CLIP"
bitfld.long 0 0. " VGV2_CLIP "  "0 ,1 "
tree.end

base ad:0xa03201b8
tree "VGV2_MODE"
wgroup 0--3
line.long 0 "VGV2_MODE"
bitfld.long 0 0. " VGV2_MODE "  "0 ,1 "
tree.end

base ad:0xa03201bc
tree "VGV2_ACTION"
wgroup 0--3
line.long 0 "VGV2_ACTION"
bitfld.long 0 0. " VGV2_ACTION "  "0 ,1 "
tree.end

base ad:0xa03201c0
tree "VGV3_CONTROL"
wgroup 0--3
line.long 0 "VGV3_CONTROL"
bitfld.long 0 0. " VGV3_CONTROL "  "0 ,1 "
tree.end

base ad:0xa03201c4
tree "VGV3_MODE"
wgroup 0--3
line.long 0 "VGV3_MODE"
bitfld.long 0 0. " VGV3_MODE "  "0 ,1 "
tree.end

base ad:0xa03201c8
tree "VGV3_WRITEADDR"
wgroup 0--3
line.long 0 "VGV3_WRITEADDR"
bitfld.long 0 0. " VGV3_WRITEADDR "  "0 ,1 "
tree.end

base ad:0xa03201cc
tree "VGV3_WRITE"
wgroup 0--3
line.long 0 "VGV3_WRITE"
bitfld.long 0 0. " VGV3_WRITE "  "0 ,1 "
tree.end

base ad:0xa03201d0
tree "VGV3_WRITEIFPAUSED"
wgroup 0--3
line.long 0 "VGV3_WRITEIFPAUSED"
bitfld.long 0 0. " VGV3_WRITEIFPAUSED "  "0 ,1 "
tree.end

base ad:0xa03201d4
tree "VGV3_NEXTADDR"
wgroup 0--3
line.long 0 "VGV3_NEXTADDR"
bitfld.long 0 0. " VGV3_NEXTADDR "  "0 ,1 "
tree.end

base ad:0xa03201d8
tree "VGV3_NEXTCMD"
wgroup 0--3
line.long 0 "VGV3_NEXTCMD"
bitfld.long 0 0. " VGV3_NEXTCMD "  "0 ,1 "
tree.end

base ad:0xa03201dc
tree "VGV3_VGBYPASS"
wgroup 0--3
line.long 0 "VGV3_VGBYPASS"
bitfld.long 0 0. " VGV3_VGBYPASS "  "0 ,1 "
tree.end

base ad:0xa03201e0
tree "VGV3_WRITES8"
wgroup 0--3
line.long 0 "VGV3_WRITES8"
bitfld.long 0 0. " VGV3_WRITES8 "  "0 ,1 "
tree.end

base ad:0xa03201e4
tree "VGV3_WRITES16"
wgroup 0--3
line.long 0 "VGV3_WRITES16"
bitfld.long 0 0. " VGV3_WRITES16 "  "0 ,1 "
tree.end

base ad:0xa03201e8
tree "VGV3_WRITES32"
wgroup 0--3
line.long 0 "VGV3_WRITES32"
bitfld.long 0 0. " VGV3_WRITES32 "  "0 ,1 "
tree.end

base ad:0xa03201ec
tree "VGV3_WRITEF32"
wgroup 0--3
line.long 0 "VGV3_WRITEF32"
bitfld.long 0 0. " VGV3_WRITEF32 "  "0 ,1 "
tree.end

base ad:0xa03201f0
tree "VGV3_WRITERAW"
wgroup 0--3
line.long 0 "VGV3_WRITERAW"
bitfld.long 0 0. " VGV3_WRITERAW "  "0 ,1 "
tree.end

base ad:0xa03201f4
tree "VGV3_WRITEDMI"
wgroup 0--3
line.long 0 "VGV3_WRITEDMI"
bitfld.long 0 0. " VGV3_WRITEDMI "  "0 ,1 "
tree.end

base ad:0xa03202c0
tree "G2D_CONST0"
wgroup 0--3
line.long 0 "G2D_CONST0"
bitfld.long 0 0. " G2D_CONST0 "  "0 ,1 "
tree.end

base ad:0xa03202c4
tree "G2D_CONST1"
wgroup 0--3
line.long 0 "G2D_CONST1"
bitfld.long 0 0. " G2D_CONST1 "  "0 ,1 "
tree.end

base ad:0xa03202c8
tree "G2D_CONST2"
wgroup 0--3
line.long 0 "G2D_CONST2"
bitfld.long 0 0. " G2D_CONST2 "  "0 ,1 "
tree.end

base ad:0xa03202cc
tree "G2D_CONST3"
wgroup 0--3
line.long 0 "G2D_CONST3"
bitfld.long 0 0. " G2D_CONST3 "  "0 ,1 "
tree.end

base ad:0xa03202d0
tree "G2D_CONST4"
wgroup 0--3
line.long 0 "G2D_CONST4"
bitfld.long 0 0. " G2D_CONST4 "  "0 ,1 "
tree.end

base ad:0xa03202d4
tree "G2D_CONST5"
wgroup 0--3
line.long 0 "G2D_CONST5"
bitfld.long 0 0. " G2D_CONST5 "  "0 ,1 "
tree.end

base ad:0xa03202d8
tree "G2D_CONST6"
wgroup 0--3
line.long 0 "G2D_CONST6"
bitfld.long 0 0. " G2D_CONST6 "  "0 ,1 "
tree.end

base ad:0xa03202dc
tree "G2D_CONST7"
wgroup 0--3
line.long 0 "G2D_CONST7"
bitfld.long 0 0. " G2D_CONST7 "  "0 ,1 "
tree.end

base ad:0xa0320300
tree "GRADW_CONST0"
wgroup 0--3
line.long 0 "GRADW_CONST0"
bitfld.long 0 0. " GRADW_CONST0 "  "0 ,1 "
tree.end

base ad:0xa0320304
tree "GRADW_CONST1"
wgroup 0--3
line.long 0 "GRADW_CONST1"
bitfld.long 0 0. " GRADW_CONST1 "  "0 ,1 "
tree.end

base ad:0xa0320308
tree "GRADW_CONST2"
wgroup 0--3
line.long 0 "GRADW_CONST2"
bitfld.long 0 0. " GRADW_CONST2 "  "0 ,1 "
tree.end

base ad:0xa032030c
tree "GRADW_CONST3"
wgroup 0--3
line.long 0 "GRADW_CONST3"
bitfld.long 0 0. " GRADW_CONST3 "  "0 ,1 "
tree.end

base ad:0xa0320310
tree "GRADW_CONST4"
wgroup 0--3
line.long 0 "GRADW_CONST4"
bitfld.long 0 0. " GRADW_CONST4 "  "0 ,1 "
tree.end

base ad:0xa0320314
tree "GRADW_CONST5"
wgroup 0--3
line.long 0 "GRADW_CONST5"
bitfld.long 0 0. " GRADW_CONST5 "  "0 ,1 "
tree.end

base ad:0xa0320318
tree "GRADW_CONST6"
wgroup 0--3
line.long 0 "GRADW_CONST6"
bitfld.long 0 0. " GRADW_CONST6 "  "0 ,1 "
tree.end

base ad:0xa032031c
tree "GRADW_CONST7"
wgroup 0--3
line.long 0 "GRADW_CONST7"
bitfld.long 0 0. " GRADW_CONST7 "  "0 ,1 "
tree.end

base ad:0xa0320320
tree "GRADW_CONST8"
wgroup 0--3
line.long 0 "GRADW_CONST8"
bitfld.long 0 0. " GRADW_CONST8 "  "0 ,1 "
tree.end

base ad:0xa0320324
tree "GRADW_CONST9"
wgroup 0--3
line.long 0 "GRADW_CONST9"
bitfld.long 0 0. " GRADW_CONST9 "  "0 ,1 "
tree.end

base ad:0xa0320328
tree "GRADW_CONSTA"
wgroup 0--3
line.long 0 "GRADW_CONSTA"
bitfld.long 0 0. " GRADW_CONSTA "  "0 ,1 "
tree.end

base ad:0xa032032c
tree "GRADW_CONSTB"
wgroup 0--3
line.long 0 "GRADW_CONSTB"
bitfld.long 0 0. " GRADW_CONSTB "  "0 ,1 "
tree.end

base ad:0xa0320340
tree "G2D_GRADIENT"
wgroup 0--3
line.long 0 "G2D_GRADIENT"
bitfld.long 0 0. " G2D_GRADIENT "  "0 ,1 "
tree.end

base ad:0xa0320344
tree "GRADW_TEXCFG"
wgroup 0--3
line.long 0 "GRADW_TEXCFG"
bitfld.long 0 0. " GRADW_TEXCFG "  "0 ,1 "
tree.end

base ad:0xa0320348
tree "GRADW_TEXSIZE"
wgroup 0--3
line.long 0 "GRADW_TEXSIZE"
bitfld.long 0 0. " GRADW_TEXSIZE "  "0 ,1 "
tree.end

base ad:0xa032034c
tree "GRADW_TEXBASE"
wgroup 0--3
line.long 0 "GRADW_TEXBASE"
bitfld.long 0 0. " GRADW_TEXBASE "  "0 ,1 "
tree.end

base ad:0xa0320350
tree "GRADW_BORDERCOLOR"
wgroup 0--3
line.long 0 "GRADW_BORDERCOLOR"
bitfld.long 0 0. " GRADW_BORDERCOLOR "  "0 ,1 "
tree.end

base ad:0xa0320380
tree "GRADW_INST0"
wgroup 0--3
line.long 0 "GRADW_INST0"
bitfld.long 0 0. " GRADW_INST0 "  "0 ,1 "
tree.end

base ad:0xa0320384
tree "GRADW_INST1"
wgroup 0--3
line.long 0 "GRADW_INST1"
bitfld.long 0 0. " GRADW_INST1 "  "0 ,1 "
tree.end

base ad:0xa0320388
tree "GRADW_INST2"
wgroup 0--3
line.long 0 "GRADW_INST2"
bitfld.long 0 0. " GRADW_INST2 "  "0 ,1 "
tree.end

base ad:0xa032038c
tree "GRADW_INST3"
wgroup 0--3
line.long 0 "GRADW_INST3"
bitfld.long 0 0. " GRADW_INST3 "  "0 ,1 "
tree.end

base ad:0xa0320390
tree "GRADW_INST4"
wgroup 0--3
line.long 0 "GRADW_INST4"
bitfld.long 0 0. " GRADW_INST4 "  "0 ,1 "
tree.end

base ad:0xa0320394
tree "GRADW_INST5"
wgroup 0--3
line.long 0 "GRADW_INST5"
bitfld.long 0 0. " GRADW_INST5 "  "0 ,1 "
tree.end

base ad:0xa0320398
tree "GRADW_INST6"
wgroup 0--3
line.long 0 "GRADW_INST6"
bitfld.long 0 0. " GRADW_INST6 "  "0 ,1 "
tree.end

base ad:0xa032039c
tree "GRADW_INST7"
wgroup 0--3
line.long 0 "GRADW_INST7"
bitfld.long 0 0. " GRADW_INST7 "  "0 ,1 "
tree.end

base ad:0xa03203c0
tree "G2D_XY"
wgroup 0--3
line.long 0 "G2D_XY"
bitfld.long 0 0. " G2D_XY "  "0 ,1 "
tree.end

base ad:0xa03203c4
tree "G2D_WIDTHHEIGHT"
wgroup 0--3
line.long 0 "G2D_WIDTHHEIGHT"
bitfld.long 0 0. " G2D_WIDTHHEIGHT "  "0 ,1 "
tree.end

base ad:0xa03203c8
tree "G2D_SXY"
wgroup 0--3
line.long 0 "G2D_SXY"
bitfld.long 0 0. " G2D_SXY "  "0 ,1 "
tree.end

base ad:0xa03203cc
tree "G2D_SXY2"
wgroup 0--3
line.long 0 "G2D_SXY2"
bitfld.long 0 0. " G2D_SXY2 "  "0 ,1 "
tree.end

base ad:0xa03203d0
tree "G2D_VGSPAN"
wgroup 0--3
line.long 0 "G2D_VGSPAN"
bitfld.long 0 0. " G2D_VGSPAN "  "0 ,1 "
tree.end

base ad:0xa03203f8
tree "G2D_IDLE"
wgroup 0--3
line.long 0 "G2D_IDLE"
bitfld.long 0 0. " G2D_IDLE "  "0 ,1 "
tree.end

base ad:0xa03203fc
tree "G2D_COLOR"
wgroup 0--3
line.long 0 "G2D_COLOR"
bitfld.long 0 0. " G2D_COLOR "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "GIC"
;==============================================================
base ad:0xa0410100
tree "CPU_ICR"
group 0--3
line.long 0 "CPU_ICR"
bitfld.long 0 0. " CPUICREN "  "0 ,1 "
bitfld.long 0 1. " CPUICRENNS "  "0 ,1 "
bitfld.long 0 2. " CPUICRACKCTL "  "0 ,1 "
bitfld.long 0 3. " CPUICRFIQEN "  "0 ,1 "
bitfld.long 0 4. " CPUICRSBPR "  "0 ,1 "
tree.end

base ad:0xa0410104
tree "PMR"
group 0--3
line.long 0 "PMR"
bitfld.long 0 3.--7. " PMRPRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0410108
tree "BPR"
group 0--3
line.long 0 "BPR"
bitfld.long 0 0.--2. " BPRBP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa041010c
tree "IAR"
rgroup 0--3
line.long 0 "IAR"
bitfld.long 0 0.--9. " IARACKINTID "  " "
bitfld.long 0 10.--12. " IARSOURCECPUID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0410110
tree "EOIR"
wgroup 0--3
line.long 0 "EOIR"
bitfld.long 0 0.--9. " EOIREOIINTID "  " "
bitfld.long 0 10.--12. " EOIRSOURCECPUID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0410114
tree "RPR"
rgroup 0--3
line.long 0 "RPR"
hexfld.byte 0 " RPRPRIORITY "
tree.end

base ad:0xa0410118
tree "HPIR"
rgroup 0--3
line.long 0 "HPIR"
bitfld.long 0 0.--9. " HPIRPENDINTID "  " "
bitfld.long 0 10.--12. " HPIRSOURCECPUID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa041011c
tree "ANSBPR"
group 0--3
line.long 0 "ANSBPR"
bitfld.long 0 0.--2. " ANSBPRBP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa04101fc
tree "CPU_IIIR"
rgroup 0--3
line.long 0 "CPU_IIIR"
bitfld.long 0 0.--11. " CPUIIIRIMPLEMENTOR "  " "
bitfld.long 0 12.--15. " CPUIIIRRN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " CPUIIIRAV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--31. " CPUIIIRPN "  " "
tree.end

base ad:0xa0411000
tree "IDCR"
group 0--3
line.long 0 "IDCR"
bitfld.long 0 0. " IDCEN "  "0 ,1 "
tree.end

base ad:0xa0411004
tree "ICTR"
rgroup 0--3
line.long 0 "ICTR"
bitfld.long 0 0.--4. " ICTITLN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " ICTCPUN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " ICTDOM "  "0 ,1 "
bitfld.long 0 11.--15. " ICTLSPI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411008
tree "DIIR"
rgroup 0--3
line.long 0 "DIIR"
bitfld.long 0 0.--11. " DIIIMPL "  " "
bitfld.long 0 12.--23. " DIIRN "  " "
hexfld.byte 3 " DIIIMPL_DEFINED "
tree.end

base ad:0xa0411080
tree "IS0R"
group 0--3
line.long 0 "IS0R"
hexfld.long 0 " IS0 "
tree.end

base ad:0xa0411084
tree "IS1R"
group 0--3
line.long 0 "IS1R"
hexfld.long 0 " IS1 "
tree.end

base ad:0xa0411088
tree "IS2R"
group 0--3
line.long 0 "IS2R"
hexfld.long 0 " IS2 "
tree.end

base ad:0xa041108c
tree "IS3R"
group 0--3
line.long 0 "IS3R"
hexfld.long 0 " IS3 "
tree.end

base ad:0xa0411090
tree "IS4R"
group 0--3
line.long 0 "IS4R"
hexfld.long 0 " IS4 "
tree.end

base ad:0xa0411094
tree "IS5R"
group 0--3
line.long 0 "IS5R"
hexfld.long 0 " IS5 "
tree.end

base ad:0xa0411098
tree "IS6R"
group 0--3
line.long 0 "IS6R"
hexfld.long 0 " IS6 "
tree.end

base ad:0xa041109c
tree "IS7R"
group 0--3
line.long 0 "IS7R"
hexfld.long 0 " IS7 "
tree.end

base ad:0xa04110a0
tree "IS8R"
group 0--3
line.long 0 "IS8R"
hexfld.long 0 " IS8 "
tree.end

base ad:0xa04110a4
tree "IS9R"
group 0--3
line.long 0 "IS9R"
hexfld.long 0 " IS9 "
tree.end

base ad:0xa04110a8
tree "IS10R"
group 0--3
line.long 0 "IS10R"
hexfld.long 0 " IS10 "
tree.end

base ad:0xa04110ac
tree "IS11R"
group 0--3
line.long 0 "IS11R"
hexfld.long 0 " IS11 "
tree.end

base ad:0xa04110b0
tree "IS12R"
group 0--3
line.long 0 "IS12R"
hexfld.long 0 " IS12 "
tree.end

base ad:0xa04110b4
tree "IS13R"
group 0--3
line.long 0 "IS13R"
hexfld.long 0 " IS13 "
tree.end

base ad:0xa04110b8
tree "IS14R"
group 0--3
line.long 0 "IS14R"
hexfld.long 0 " IS14 "
tree.end

base ad:0xa04110bc
tree "IS15R"
group 0--3
line.long 0 "IS15R"
hexfld.long 0 " IS15 "
tree.end

base ad:0xa04110c0
tree "IS16R"
group 0--3
line.long 0 "IS16R"
hexfld.long 0 " IS16 "
tree.end

base ad:0xa04110c4
tree "IS17R"
group 0--3
line.long 0 "IS17R"
hexfld.long 0 " IS17 "
tree.end

base ad:0xa04110c8
tree "IS18R"
group 0--3
line.long 0 "IS18R"
hexfld.long 0 " IS18 "
tree.end

base ad:0xa04110cc
tree "IS19R"
group 0--3
line.long 0 "IS19R"
hexfld.long 0 " IS19 "
tree.end

base ad:0xa04110d0
tree "IS20R"
group 0--3
line.long 0 "IS20R"
hexfld.long 0 " IS20 "
tree.end

base ad:0xa04110d4
tree "IS21R"
group 0--3
line.long 0 "IS21R"
hexfld.long 0 " IS21 "
tree.end

base ad:0xa04110d8
tree "IS22R"
group 0--3
line.long 0 "IS22R"
hexfld.long 0 " IS22 "
tree.end

base ad:0xa04110dc
tree "IS23R"
group 0--3
line.long 0 "IS23R"
hexfld.long 0 " IS23 "
tree.end

base ad:0xa04110e0
tree "IS24R"
group 0--3
line.long 0 "IS24R"
hexfld.long 0 " IS24 "
tree.end

base ad:0xa04110e4
tree "IS25R"
group 0--3
line.long 0 "IS25R"
hexfld.long 0 " IS25 "
tree.end

base ad:0xa04110e8
tree "IS26R"
group 0--3
line.long 0 "IS26R"
hexfld.long 0 " IS26 "
tree.end

base ad:0xa04110ec
tree "IS27R"
group 0--3
line.long 0 "IS27R"
hexfld.long 0 " IS27 "
tree.end

base ad:0xa04110f0
tree "IS28R"
group 0--3
line.long 0 "IS28R"
hexfld.long 0 " IS28 "
tree.end

base ad:0xa04110f4
tree "IS29R"
group 0--3
line.long 0 "IS29R"
hexfld.long 0 " IS29 "
tree.end

base ad:0xa04110f8
tree "IS30R"
group 0--3
line.long 0 "IS30R"
hexfld.long 0 " IS30 "
tree.end

base ad:0xa04110fc
tree "IS31R"
group 0--3
line.long 0 "IS31R"
hexfld.long 0 " IS31 "
tree.end

base ad:0xa0411100
tree "ES0R"
group 0--3
line.long 0 "ES0R"
hexfld.long 0 " ES0 "
tree.end

base ad:0xa0411104
tree "ES1R"
group 0--3
line.long 0 "ES1R"
hexfld.long 0 " ES1 "
tree.end

base ad:0xa0411108
tree "ES2R"
group 0--3
line.long 0 "ES2R"
hexfld.long 0 " ES2 "
tree.end

base ad:0xa041110c
tree "ES3R"
group 0--3
line.long 0 "ES3R"
hexfld.long 0 " ES3 "
tree.end

base ad:0xa0411110
tree "ES4R"
group 0--3
line.long 0 "ES4R"
hexfld.long 0 " ES4 "
tree.end

base ad:0xa0411114
tree "ES5R"
group 0--3
line.long 0 "ES5R"
hexfld.long 0 " ES5 "
tree.end

base ad:0xa0411118
tree "ES6R"
group 0--3
line.long 0 "ES6R"
hexfld.long 0 " ES6 "
tree.end

base ad:0xa041111c
tree "ES7R"
group 0--3
line.long 0 "ES7R"
hexfld.long 0 " ES7 "
tree.end

base ad:0xa0411120
tree "ES8R"
group 0--3
line.long 0 "ES8R"
hexfld.long 0 " ES8 "
tree.end

base ad:0xa0411124
tree "ES9R"
group 0--3
line.long 0 "ES9R"
hexfld.long 0 " ES9 "
tree.end

base ad:0xa0411128
tree "ES10R"
group 0--3
line.long 0 "ES10R"
hexfld.long 0 " ES10 "
tree.end

base ad:0xa041112c
tree "ES11R"
group 0--3
line.long 0 "ES11R"
hexfld.long 0 " ES11 "
tree.end

base ad:0xa0411130
tree "ES12R"
group 0--3
line.long 0 "ES12R"
hexfld.long 0 " ES12 "
tree.end

base ad:0xa0411134
tree "ES13R"
group 0--3
line.long 0 "ES13R"
hexfld.long 0 " ES13 "
tree.end

base ad:0xa0411138
tree "ES14R"
group 0--3
line.long 0 "ES14R"
hexfld.long 0 " ES14 "
tree.end

base ad:0xa041113c
tree "ES15R"
group 0--3
line.long 0 "ES15R"
hexfld.long 0 " ES15 "
tree.end

base ad:0xa0411140
tree "ES16R"
group 0--3
line.long 0 "ES16R"
hexfld.long 0 " ES16 "
tree.end

base ad:0xa0411144
tree "ES17R"
group 0--3
line.long 0 "ES17R"
hexfld.long 0 " ES17 "
tree.end

base ad:0xa0411148
tree "ES18R"
group 0--3
line.long 0 "ES18R"
hexfld.long 0 " ES18 "
tree.end

base ad:0xa041114c
tree "ES19R"
group 0--3
line.long 0 "ES19R"
hexfld.long 0 " ES19 "
tree.end

base ad:0xa0411150
tree "ES20R"
group 0--3
line.long 0 "ES20R"
hexfld.long 0 " ES20 "
tree.end

base ad:0xa0411154
tree "ES21R"
group 0--3
line.long 0 "ES21R"
hexfld.long 0 " ES21 "
tree.end

base ad:0xa0411158
tree "ES22R"
group 0--3
line.long 0 "ES22R"
hexfld.long 0 " ES22 "
tree.end

base ad:0xa041115c
tree "ES23R"
group 0--3
line.long 0 "ES23R"
hexfld.long 0 " ES23 "
tree.end

base ad:0xa0411160
tree "ES24R"
group 0--3
line.long 0 "ES24R"
hexfld.long 0 " ES24 "
tree.end

base ad:0xa0411164
tree "ES25R"
group 0--3
line.long 0 "ES25R"
hexfld.long 0 " ES25 "
tree.end

base ad:0xa0411168
tree "ES26R"
group 0--3
line.long 0 "ES26R"
hexfld.long 0 " ES26 "
tree.end

base ad:0xa041116c
tree "ES27R"
group 0--3
line.long 0 "ES27R"
hexfld.long 0 " ES27 "
tree.end

base ad:0xa0411170
tree "ES28R"
group 0--3
line.long 0 "ES28R"
hexfld.long 0 " ES28 "
tree.end

base ad:0xa0411174
tree "ES29R"
group 0--3
line.long 0 "ES29R"
hexfld.long 0 " ES29 "
tree.end

base ad:0xa0411178
tree "ES30R"
group 0--3
line.long 0 "ES30R"
hexfld.long 0 " ES30 "
tree.end

base ad:0xa041117c
tree "ES31R"
group 0--3
line.long 0 "ES31R"
hexfld.long 0 " ES31 "
tree.end

base ad:0xa0411180
tree "EC0R"
group 0--3
line.long 0 "EC0R"
hexfld.long 0 " EC0 "
tree.end

base ad:0xa0411184
tree "EC1R"
group 0--3
line.long 0 "EC1R"
hexfld.long 0 " EC1 "
tree.end

base ad:0xa0411188
tree "EC2R"
group 0--3
line.long 0 "EC2R"
hexfld.long 0 " EC2 "
tree.end

base ad:0xa041118c
tree "EC3R"
group 0--3
line.long 0 "EC3R"
hexfld.long 0 " EC3 "
tree.end

base ad:0xa0411190
tree "EC4R"
group 0--3
line.long 0 "EC4R"
hexfld.long 0 " EC4 "
tree.end

base ad:0xa0411194
tree "EC5R"
group 0--3
line.long 0 "EC5R"
hexfld.long 0 " EC5 "
tree.end

base ad:0xa0411198
tree "EC6R"
group 0--3
line.long 0 "EC6R"
hexfld.long 0 " EC6 "
tree.end

base ad:0xa041119c
tree "EC7R"
group 0--3
line.long 0 "EC7R"
hexfld.long 0 " EC7 "
tree.end

base ad:0xa04111a0
tree "EC8R"
group 0--3
line.long 0 "EC8R"
hexfld.long 0 " EC8 "
tree.end

base ad:0xa04111a4
tree "EC9R"
group 0--3
line.long 0 "EC9R"
hexfld.long 0 " EC9 "
tree.end

base ad:0xa04111a8
tree "EC10R"
group 0--3
line.long 0 "EC10R"
hexfld.long 0 " EC10 "
tree.end

base ad:0xa04111ac
tree "EC11R"
group 0--3
line.long 0 "EC11R"
hexfld.long 0 " EC11 "
tree.end

base ad:0xa04111b0
tree "EC12R"
group 0--3
line.long 0 "EC12R"
hexfld.long 0 " EC12 "
tree.end

base ad:0xa04111b4
tree "EC13R"
group 0--3
line.long 0 "EC13R"
hexfld.long 0 " EC13 "
tree.end

base ad:0xa04111b8
tree "EC14R"
group 0--3
line.long 0 "EC14R"
hexfld.long 0 " EC14 "
tree.end

base ad:0xa04111bc
tree "EC15R"
group 0--3
line.long 0 "EC15R"
hexfld.long 0 " EC15 "
tree.end

base ad:0xa04111c0
tree "EC16R"
group 0--3
line.long 0 "EC16R"
hexfld.long 0 " EC16 "
tree.end

base ad:0xa04111c4
tree "EC17R"
group 0--3
line.long 0 "EC17R"
hexfld.long 0 " EC17 "
tree.end

base ad:0xa04111c8
tree "EC18R"
group 0--3
line.long 0 "EC18R"
hexfld.long 0 " EC18 "
tree.end

base ad:0xa04111cc
tree "EC19R"
group 0--3
line.long 0 "EC19R"
hexfld.long 0 " EC19 "
tree.end

base ad:0xa04111d0
tree "EC20R"
group 0--3
line.long 0 "EC20R"
hexfld.long 0 " EC20 "
tree.end

base ad:0xa04111d4
tree "EC21R"
group 0--3
line.long 0 "EC21R"
hexfld.long 0 " EC21 "
tree.end

base ad:0xa04111d8
tree "EC22R"
group 0--3
line.long 0 "EC22R"
hexfld.long 0 " EC22 "
tree.end

base ad:0xa04111dc
tree "EC23R"
group 0--3
line.long 0 "EC23R"
hexfld.long 0 " EC23 "
tree.end

base ad:0xa04111e0
tree "EC24R"
group 0--3
line.long 0 "EC24R"
hexfld.long 0 " EC24 "
tree.end

base ad:0xa04111e4
tree "EC25R"
group 0--3
line.long 0 "EC25R"
hexfld.long 0 " EC25 "
tree.end

base ad:0xa04111e8
tree "EC26R"
group 0--3
line.long 0 "EC26R"
hexfld.long 0 " EC26 "
tree.end

base ad:0xa04111ec
tree "EC27R"
group 0--3
line.long 0 "EC27R"
hexfld.long 0 " EC27 "
tree.end

base ad:0xa04111f0
tree "EC28R"
group 0--3
line.long 0 "EC28R"
hexfld.long 0 " EC28 "
tree.end

base ad:0xa04111f4
tree "EC29R"
group 0--3
line.long 0 "EC29R"
hexfld.long 0 " EC29 "
tree.end

base ad:0xa04111f8
tree "EC30R"
group 0--3
line.long 0 "EC30R"
hexfld.long 0 " EC30 "
tree.end

base ad:0xa04111fc
tree "EC31R"
group 0--3
line.long 0 "EC31R"
hexfld.long 0 " EC31 "
tree.end

base ad:0xa0411200
tree "PS0R"
group 0--3
line.long 0 "PS0R"
hexfld.long 0 " PS0 "
tree.end

base ad:0xa0411204
tree "PS1R"
group 0--3
line.long 0 "PS1R"
hexfld.long 0 " PS1 "
tree.end

base ad:0xa0411208
tree "PS2R"
group 0--3
line.long 0 "PS2R"
hexfld.long 0 " PS2 "
tree.end

base ad:0xa041120c
tree "PS3R"
group 0--3
line.long 0 "PS3R"
hexfld.long 0 " PS3 "
tree.end

base ad:0xa0411210
tree "PS4R"
group 0--3
line.long 0 "PS4R"
hexfld.long 0 " PS4 "
tree.end

base ad:0xa0411214
tree "PS5R"
group 0--3
line.long 0 "PS5R"
hexfld.long 0 " PS5 "
tree.end

base ad:0xa0411218
tree "PS6R"
group 0--3
line.long 0 "PS6R"
hexfld.long 0 " PS6 "
tree.end

base ad:0xa041121c
tree "PS7R"
group 0--3
line.long 0 "PS7R"
hexfld.long 0 " PS7 "
tree.end

base ad:0xa0411220
tree "PS8R"
group 0--3
line.long 0 "PS8R"
hexfld.long 0 " PS8 "
tree.end

base ad:0xa0411224
tree "PS9R"
group 0--3
line.long 0 "PS9R"
hexfld.long 0 " PS9 "
tree.end

base ad:0xa0411228
tree "PS10R"
group 0--3
line.long 0 "PS10R"
hexfld.long 0 " PS10 "
tree.end

base ad:0xa041122c
tree "PS11R"
group 0--3
line.long 0 "PS11R"
hexfld.long 0 " PS11 "
tree.end

base ad:0xa0411230
tree "PS12R"
group 0--3
line.long 0 "PS12R"
hexfld.long 0 " PS12 "
tree.end

base ad:0xa0411234
tree "PS13R"
group 0--3
line.long 0 "PS13R"
hexfld.long 0 " PS13 "
tree.end

base ad:0xa0411238
tree "PS14R"
group 0--3
line.long 0 "PS14R"
hexfld.long 0 " PS14 "
tree.end

base ad:0xa041123c
tree "PS15R"
group 0--3
line.long 0 "PS15R"
hexfld.long 0 " PS15 "
tree.end

base ad:0xa0411240
tree "PS16R"
group 0--3
line.long 0 "PS16R"
hexfld.long 0 " PS16 "
tree.end

base ad:0xa0411244
tree "PS17R"
group 0--3
line.long 0 "PS17R"
hexfld.long 0 " PS17 "
tree.end

base ad:0xa0411248
tree "PS18R"
group 0--3
line.long 0 "PS18R"
hexfld.long 0 " PS18 "
tree.end

base ad:0xa041124c
tree "PS19R"
group 0--3
line.long 0 "PS19R"
hexfld.long 0 " PS19 "
tree.end

base ad:0xa0411250
tree "PS20R"
group 0--3
line.long 0 "PS20R"
hexfld.long 0 " PS20 "
tree.end

base ad:0xa0411254
tree "PS21R"
group 0--3
line.long 0 "PS21R"
hexfld.long 0 " PS21 "
tree.end

base ad:0xa0411258
tree "PS22R"
group 0--3
line.long 0 "PS22R"
hexfld.long 0 " PS22 "
tree.end

base ad:0xa041125c
tree "PS23R"
group 0--3
line.long 0 "PS23R"
hexfld.long 0 " PS23 "
tree.end

base ad:0xa0411260
tree "PS24R"
group 0--3
line.long 0 "PS24R"
hexfld.long 0 " PS24 "
tree.end

base ad:0xa0411264
tree "PS25R"
group 0--3
line.long 0 "PS25R"
hexfld.long 0 " PS25 "
tree.end

base ad:0xa0411268
tree "PS26R"
group 0--3
line.long 0 "PS26R"
hexfld.long 0 " PS26 "
tree.end

base ad:0xa041126c
tree "PS27R"
group 0--3
line.long 0 "PS27R"
hexfld.long 0 " PS27 "
tree.end

base ad:0xa0411270
tree "PS28R"
group 0--3
line.long 0 "PS28R"
hexfld.long 0 " PS28 "
tree.end

base ad:0xa0411274
tree "PS29R"
group 0--3
line.long 0 "PS29R"
hexfld.long 0 " PS29 "
tree.end

base ad:0xa0411278
tree "PS30R"
group 0--3
line.long 0 "PS30R"
hexfld.long 0 " PS30 "
tree.end

base ad:0xa041127c
tree "PS31R"
group 0--3
line.long 0 "PS31R"
hexfld.long 0 " PS31 "
tree.end

base ad:0xa0411280
tree "PC0R"
group 0--3
line.long 0 "PC0R"
hexfld.long 0 " PC0 "
tree.end

base ad:0xa0411284
tree "PC1R"
group 0--3
line.long 0 "PC1R"
hexfld.long 0 " PC1 "
tree.end

base ad:0xa0411288
tree "PC2R"
group 0--3
line.long 0 "PC2R"
hexfld.long 0 " PC2 "
tree.end

base ad:0xa041128c
tree "PC3R"
group 0--3
line.long 0 "PC3R"
hexfld.long 0 " PC3 "
tree.end

base ad:0xa0411290
tree "PC4R"
group 0--3
line.long 0 "PC4R"
hexfld.long 0 " PC4 "
tree.end

base ad:0xa0411294
tree "PC5R"
group 0--3
line.long 0 "PC5R"
hexfld.long 0 " PC5 "
tree.end

base ad:0xa0411298
tree "PC6R"
group 0--3
line.long 0 "PC6R"
hexfld.long 0 " PC6 "
tree.end

base ad:0xa041129c
tree "PC7R"
group 0--3
line.long 0 "PC7R"
hexfld.long 0 " PC7 "
tree.end

base ad:0xa04112a0
tree "PC8R"
group 0--3
line.long 0 "PC8R"
hexfld.long 0 " PC8 "
tree.end

base ad:0xa04112a4
tree "PC9R"
group 0--3
line.long 0 "PC9R"
hexfld.long 0 " PC9 "
tree.end

base ad:0xa04112a8
tree "PC10R"
group 0--3
line.long 0 "PC10R"
hexfld.long 0 " PC10 "
tree.end

base ad:0xa04112ac
tree "PC11R"
group 0--3
line.long 0 "PC11R"
hexfld.long 0 " PC11 "
tree.end

base ad:0xa04112b0
tree "PC12R"
group 0--3
line.long 0 "PC12R"
hexfld.long 0 " PC12 "
tree.end

base ad:0xa04112b4
tree "PC13R"
group 0--3
line.long 0 "PC13R"
hexfld.long 0 " PC13 "
tree.end

base ad:0xa04112b8
tree "PC14R"
group 0--3
line.long 0 "PC14R"
hexfld.long 0 " PC14 "
tree.end

base ad:0xa04112bc
tree "PC15R"
group 0--3
line.long 0 "PC15R"
hexfld.long 0 " PC15 "
tree.end

base ad:0xa04112c0
tree "PC16R"
group 0--3
line.long 0 "PC16R"
hexfld.long 0 " PC16 "
tree.end

base ad:0xa04112c4
tree "PC17R"
group 0--3
line.long 0 "PC17R"
hexfld.long 0 " PC17 "
tree.end

base ad:0xa04112c8
tree "PC18R"
group 0--3
line.long 0 "PC18R"
hexfld.long 0 " PC18 "
tree.end

base ad:0xa04112cc
tree "PC19R"
group 0--3
line.long 0 "PC19R"
hexfld.long 0 " PC19 "
tree.end

base ad:0xa04112d0
tree "PC20R"
group 0--3
line.long 0 "PC20R"
hexfld.long 0 " PC20 "
tree.end

base ad:0xa04112d4
tree "PC21R"
group 0--3
line.long 0 "PC21R"
hexfld.long 0 " PC21 "
tree.end

base ad:0xa04112d8
tree "PC22R"
group 0--3
line.long 0 "PC22R"
hexfld.long 0 " PC22 "
tree.end

base ad:0xa04112dc
tree "PC23R"
group 0--3
line.long 0 "PC23R"
hexfld.long 0 " PC23 "
tree.end

base ad:0xa04112e0
tree "PC24R"
group 0--3
line.long 0 "PC24R"
hexfld.long 0 " PC24 "
tree.end

base ad:0xa04112e4
tree "PC25R"
group 0--3
line.long 0 "PC25R"
hexfld.long 0 " PC25 "
tree.end

base ad:0xa04112e8
tree "PC26R"
group 0--3
line.long 0 "PC26R"
hexfld.long 0 " PC26 "
tree.end

base ad:0xa04112ec
tree "PC27R"
group 0--3
line.long 0 "PC27R"
hexfld.long 0 " PC27 "
tree.end

base ad:0xa04112f0
tree "PC28R"
group 0--3
line.long 0 "PC28R"
hexfld.long 0 " PC28 "
tree.end

base ad:0xa04112f4
tree "PC29R"
group 0--3
line.long 0 "PC29R"
hexfld.long 0 " PC29 "
tree.end

base ad:0xa04112f8
tree "PC30R"
group 0--3
line.long 0 "PC30R"
hexfld.long 0 " PC30 "
tree.end

base ad:0xa04112fc
tree "PC31R"
group 0--3
line.long 0 "PC31R"
hexfld.long 0 " PC31 "
tree.end

base ad:0xa0411300
tree "AS0R"
rgroup 0--3
line.long 0 "AS0R"
hexfld.long 0 " AS0 "
tree.end

base ad:0xa0411304
tree "AS1R"
rgroup 0--3
line.long 0 "AS1R"
hexfld.long 0 " AS1 "
tree.end

base ad:0xa0411308
tree "AS2R"
rgroup 0--3
line.long 0 "AS2R"
hexfld.long 0 " AS2 "
tree.end

base ad:0xa041130c
tree "AS3R"
rgroup 0--3
line.long 0 "AS3R"
hexfld.long 0 " AS3 "
tree.end

base ad:0xa0411310
tree "AS4R"
rgroup 0--3
line.long 0 "AS4R"
hexfld.long 0 " AS4 "
tree.end

base ad:0xa0411314
tree "AS5R"
rgroup 0--3
line.long 0 "AS5R"
hexfld.long 0 " AS5 "
tree.end

base ad:0xa0411318
tree "AS6R"
rgroup 0--3
line.long 0 "AS6R"
hexfld.long 0 " AS6 "
tree.end

base ad:0xa041131c
tree "AS7R"
rgroup 0--3
line.long 0 "AS7R"
hexfld.long 0 " AS7 "
tree.end

base ad:0xa0411320
tree "AS8R"
rgroup 0--3
line.long 0 "AS8R"
hexfld.long 0 " AS8 "
tree.end

base ad:0xa0411324
tree "AS9R"
rgroup 0--3
line.long 0 "AS9R"
hexfld.long 0 " AS9 "
tree.end

base ad:0xa0411328
tree "AS10R"
rgroup 0--3
line.long 0 "AS10R"
hexfld.long 0 " AS10 "
tree.end

base ad:0xa041132c
tree "AS11R"
rgroup 0--3
line.long 0 "AS11R"
hexfld.long 0 " AS11 "
tree.end

base ad:0xa0411330
tree "AS12R"
rgroup 0--3
line.long 0 "AS12R"
hexfld.long 0 " AS12 "
tree.end

base ad:0xa0411334
tree "AS13R"
rgroup 0--3
line.long 0 "AS13R"
hexfld.long 0 " AS13 "
tree.end

base ad:0xa0411338
tree "AS14R"
rgroup 0--3
line.long 0 "AS14R"
hexfld.long 0 " AS14 "
tree.end

base ad:0xa041133c
tree "AS15R"
rgroup 0--3
line.long 0 "AS15R"
hexfld.long 0 " AS15 "
tree.end

base ad:0xa0411340
tree "AS16R"
rgroup 0--3
line.long 0 "AS16R"
hexfld.long 0 " AS16 "
tree.end

base ad:0xa0411344
tree "AS17R"
rgroup 0--3
line.long 0 "AS17R"
hexfld.long 0 " AS17 "
tree.end

base ad:0xa0411348
tree "AS18R"
rgroup 0--3
line.long 0 "AS18R"
hexfld.long 0 " AS18 "
tree.end

base ad:0xa041134c
tree "AS19R"
rgroup 0--3
line.long 0 "AS19R"
hexfld.long 0 " AS19 "
tree.end

base ad:0xa0411350
tree "AS20R"
rgroup 0--3
line.long 0 "AS20R"
hexfld.long 0 " AS20 "
tree.end

base ad:0xa0411354
tree "AS21R"
rgroup 0--3
line.long 0 "AS21R"
hexfld.long 0 " AS21 "
tree.end

base ad:0xa0411358
tree "AS22R"
rgroup 0--3
line.long 0 "AS22R"
hexfld.long 0 " AS22 "
tree.end

base ad:0xa041135c
tree "AS23R"
rgroup 0--3
line.long 0 "AS23R"
hexfld.long 0 " AS23 "
tree.end

base ad:0xa0411360
tree "AS24R"
rgroup 0--3
line.long 0 "AS24R"
hexfld.long 0 " AS24 "
tree.end

base ad:0xa0411364
tree "AS25R"
rgroup 0--3
line.long 0 "AS25R"
hexfld.long 0 " AS25 "
tree.end

base ad:0xa0411368
tree "AS26R"
rgroup 0--3
line.long 0 "AS26R"
hexfld.long 0 " AS26 "
tree.end

base ad:0xa041136c
tree "AS27R"
rgroup 0--3
line.long 0 "AS27R"
hexfld.long 0 " AS27 "
tree.end

base ad:0xa0411370
tree "AS28R"
rgroup 0--3
line.long 0 "AS28R"
hexfld.long 0 " AS28 "
tree.end

base ad:0xa0411374
tree "AS29R"
rgroup 0--3
line.long 0 "AS29R"
hexfld.long 0 " AS29 "
tree.end

base ad:0xa0411378
tree "AS30R"
rgroup 0--3
line.long 0 "AS30R"
hexfld.long 0 " AS30 "
tree.end

base ad:0xa041137c
tree "AS31R"
rgroup 0--3
line.long 0 "AS31R"
hexfld.long 0 " AS31 "
tree.end

base ad:0xa0411400
tree "PL0R"
group 0--3
line.long 0 "PL0R"
bitfld.long 0 3.--7. " PL0IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL0IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL0IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL0IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411404
tree "PL1R"
group 0--3
line.long 0 "PL1R"
bitfld.long 0 3.--7. " PL1IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL1IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL1IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL1IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411408
tree "PL2R"
group 0--3
line.long 0 "PL2R"
bitfld.long 0 3.--7. " PL2IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL2IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL2IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL2IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa041140c
tree "PL3R"
group 0--3
line.long 0 "PL3R"
bitfld.long 0 3.--7. " PL3IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL3IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL3IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL3IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411410
tree "PL4R"
group 0--3
line.long 0 "PL4R"
bitfld.long 0 3.--7. " PL4IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL4IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL4IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL4IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411414
tree "PL5R"
group 0--3
line.long 0 "PL5R"
bitfld.long 0 3.--7. " PL5IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL5IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL5IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL5IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411418
tree "PL6R"
group 0--3
line.long 0 "PL6R"
bitfld.long 0 3.--7. " PL6IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL6IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL6IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL6IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa041141c
tree "PL7R"
group 0--3
line.long 0 "PL7R"
bitfld.long 0 3.--7. " PL7IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL7IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL7IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL7IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411420
tree "PL8R"
group 0--3
line.long 0 "PL8R"
bitfld.long 0 3.--7. " PL8IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL8IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL8IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL8IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411424
tree "PL9R"
group 0--3
line.long 0 "PL9R"
bitfld.long 0 3.--7. " PL9IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL9IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL9IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL9IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411428
tree "PL10R"
group 0--3
line.long 0 "PL10R"
bitfld.long 0 3.--7. " PL10IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL10IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL10IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL10IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa041142c
tree "PL11R"
group 0--3
line.long 0 "PL11R"
bitfld.long 0 3.--7. " PL11IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL11IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL11IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL11IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411430
tree "PL12R"
group 0--3
line.long 0 "PL12R"
bitfld.long 0 3.--7. " PL12IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL12IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL12IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL12IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411434
tree "PL13R"
group 0--3
line.long 0 "PL13R"
bitfld.long 0 3.--7. " PL13IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL13IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL13IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL13IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411438
tree "PL14R"
group 0--3
line.long 0 "PL14R"
bitfld.long 0 3.--7. " PL14IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL14IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL14IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL14IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa041143c
tree "PL15R"
group 0--3
line.long 0 "PL15R"
bitfld.long 0 3.--7. " PL15IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL15IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL15IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL15IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411440
tree "PL16R"
group 0--3
line.long 0 "PL16R"
bitfld.long 0 3.--7. " PL16IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL16IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL16IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL16IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411444
tree "PL17R"
group 0--3
line.long 0 "PL17R"
bitfld.long 0 3.--7. " PL17IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL17IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL17IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL17IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411448
tree "PL18R"
group 0--3
line.long 0 "PL18R"
bitfld.long 0 3.--7. " PL18IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL18IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL18IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL18IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa041144c
tree "PL19R"
group 0--3
line.long 0 "PL19R"
bitfld.long 0 3.--7. " PL19IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL19IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL19IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL19IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411450
tree "PL20R"
group 0--3
line.long 0 "PL20R"
bitfld.long 0 3.--7. " PL20IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL20IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL20IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL20IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411454
tree "PL21R"
group 0--3
line.long 0 "PL21R"
bitfld.long 0 3.--7. " PL21IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL21IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL21IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL21IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411458
tree "PL22R"
group 0--3
line.long 0 "PL22R"
bitfld.long 0 3.--7. " PL22IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL22IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL22IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL22IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa041145c
tree "PL23R"
group 0--3
line.long 0 "PL23R"
bitfld.long 0 3.--7. " PL23IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL23IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL23IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL23IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411460
tree "PL24R"
group 0--3
line.long 0 "PL24R"
bitfld.long 0 3.--7. " PL24IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL24IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL24IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL24IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411464
tree "PL25R"
group 0--3
line.long 0 "PL25R"
bitfld.long 0 3.--7. " PL25IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL25IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL25IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL25IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411468
tree "PL26R"
group 0--3
line.long 0 "PL26R"
bitfld.long 0 3.--7. " PL26IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL26IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL26IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL26IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa041146c
tree "PL27R"
group 0--3
line.long 0 "PL27R"
bitfld.long 0 3.--7. " PL27IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL27IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL27IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL27IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411470
tree "PL28R"
group 0--3
line.long 0 "PL28R"
bitfld.long 0 3.--7. " PL28IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL28IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL28IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL28IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411474
tree "PL29R"
group 0--3
line.long 0 "PL29R"
bitfld.long 0 3.--7. " PL29IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL29IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL29IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL29IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411478
tree "PL30R"
group 0--3
line.long 0 "PL30R"
bitfld.long 0 3.--7. " PL30IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL30IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL30IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL30IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa041147c
tree "PL31R"
group 0--3
line.long 0 "PL31R"
bitfld.long 0 3.--7. " PL31IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL31IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL31IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL31IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0411800
tree "SPIT0R"
group 0--3
line.long 0 "SPIT0R"
hexfld.byte 0 " SPIT0INTIDNP0 "
hexfld.byte 1 " SPIT0INTIDNP1 "
hexfld.byte 2 " SPIT0INTIDNP2 "
hexfld.byte 3 " SPIT0INTIDNP3 "
tree.end

base ad:0xa0411804
tree "SPIT1R"
group 0--3
line.long 0 "SPIT1R"
hexfld.byte 0 " SPIT1INTIDNP0 "
hexfld.byte 1 " SPIT1INTIDNP1 "
hexfld.byte 2 " SPIT1INTIDNP2 "
hexfld.byte 3 " SPIT1INTIDNP3 "
tree.end

base ad:0xa0411808
tree "SPIT2R"
group 0--3
line.long 0 "SPIT2R"
hexfld.byte 0 " SPIT2INTIDNP0 "
hexfld.byte 1 " SPIT2INTIDNP1 "
hexfld.byte 2 " SPIT2INTIDNP2 "
hexfld.byte 3 " SPIT2INTIDNP3 "
tree.end

base ad:0xa041180c
tree "SPIT3R"
group 0--3
line.long 0 "SPIT3R"
hexfld.byte 0 " SPIT3INTIDNP0 "
hexfld.byte 1 " SPIT3INTIDNP1 "
hexfld.byte 2 " SPIT3INTIDNP2 "
hexfld.byte 3 " SPIT3INTIDNP3 "
tree.end

base ad:0xa0411810
tree "SPIT4R"
group 0--3
line.long 0 "SPIT4R"
hexfld.byte 0 " SPIT4INTIDNP0 "
hexfld.byte 1 " SPIT4INTIDNP1 "
hexfld.byte 2 " SPIT4INTIDNP2 "
hexfld.byte 3 " SPIT4INTIDNP3 "
tree.end

base ad:0xa0411814
tree "SPIT5R"
group 0--3
line.long 0 "SPIT5R"
hexfld.byte 0 " SPIT5INTIDNP0 "
hexfld.byte 1 " SPIT5INTIDNP1 "
hexfld.byte 2 " SPIT5INTIDNP2 "
hexfld.byte 3 " SPIT5INTIDNP3 "
tree.end

base ad:0xa0411818
tree "SPIT6R"
group 0--3
line.long 0 "SPIT6R"
hexfld.byte 0 " SPIT6INTIDNP0 "
hexfld.byte 1 " SPIT6INTIDNP1 "
hexfld.byte 2 " SPIT6INTIDNP2 "
hexfld.byte 3 " SPIT6INTIDNP3 "
tree.end

base ad:0xa041181c
tree "SPIT7R"
group 0--3
line.long 0 "SPIT7R"
hexfld.byte 0 " SPIT7INTIDNP0 "
hexfld.byte 1 " SPIT7INTIDNP1 "
hexfld.byte 2 " SPIT7INTIDNP2 "
hexfld.byte 3 " SPIT7INTIDNP3 "
tree.end

base ad:0xa0411820
tree "SPIT8R"
group 0--3
line.long 0 "SPIT8R"
hexfld.byte 0 " SPIT8INTIDNP0 "
hexfld.byte 1 " SPIT8INTIDNP1 "
hexfld.byte 2 " SPIT8INTIDNP2 "
hexfld.byte 3 " SPIT8INTIDNP3 "
tree.end

base ad:0xa0411824
tree "SPIT9R"
group 0--3
line.long 0 "SPIT9R"
hexfld.byte 0 " SPIT9INTIDNP0 "
hexfld.byte 1 " SPIT9INTIDNP1 "
hexfld.byte 2 " SPIT9INTIDNP2 "
hexfld.byte 3 " SPIT9INTIDNP3 "
tree.end

base ad:0xa0411828
tree "SPIT10R"
group 0--3
line.long 0 "SPIT10R"
hexfld.byte 0 " SPIT10INTIDNP0 "
hexfld.byte 1 " SPIT10INTIDNP1 "
hexfld.byte 2 " SPIT10INTIDNP2 "
hexfld.byte 3 " SPIT10INTIDNP3 "
tree.end

base ad:0xa041182c
tree "SPIT11R"
group 0--3
line.long 0 "SPIT11R"
hexfld.byte 0 " SPIT11INTIDNP0 "
hexfld.byte 1 " SPIT11INTIDNP1 "
hexfld.byte 2 " SPIT11INTIDNP2 "
hexfld.byte 3 " SPIT11INTIDNP3 "
tree.end

base ad:0xa0411830
tree "SPIT12R"
group 0--3
line.long 0 "SPIT12R"
hexfld.byte 0 " SPIT12INTIDNP0 "
hexfld.byte 1 " SPIT12INTIDNP1 "
hexfld.byte 2 " SPIT12INTIDNP2 "
hexfld.byte 3 " SPIT12INTIDNP3 "
tree.end

base ad:0xa0411834
tree "SPIT13R"
group 0--3
line.long 0 "SPIT13R"
hexfld.byte 0 " SPIT13INTIDNP0 "
hexfld.byte 1 " SPIT13INTIDNP1 "
hexfld.byte 2 " SPIT13INTIDNP2 "
hexfld.byte 3 " SPIT13INTIDNP3 "
tree.end

base ad:0xa0411838
tree "SPIT14R"
group 0--3
line.long 0 "SPIT14R"
hexfld.byte 0 " SPIT14INTIDNP0 "
hexfld.byte 1 " SPIT14INTIDNP1 "
hexfld.byte 2 " SPIT14INTIDNP2 "
hexfld.byte 3 " SPIT14INTIDNP3 "
tree.end

base ad:0xa041183c
tree "SPIT15R"
group 0--3
line.long 0 "SPIT15R"
hexfld.byte 0 " SPIT15INTIDNP0 "
hexfld.byte 1 " SPIT15INTIDNP1 "
hexfld.byte 2 " SPIT15INTIDNP2 "
hexfld.byte 3 " SPIT15INTIDNP3 "
tree.end

base ad:0xa0411840
tree "SPIT16R"
group 0--3
line.long 0 "SPIT16R"
hexfld.byte 0 " SPIT16INTIDNP0 "
hexfld.byte 1 " SPIT16INTIDNP1 "
hexfld.byte 2 " SPIT16INTIDNP2 "
hexfld.byte 3 " SPIT16INTIDNP3 "
tree.end

base ad:0xa0411844
tree "SPIT17R"
group 0--3
line.long 0 "SPIT17R"
hexfld.byte 0 " SPIT17INTIDNP0 "
hexfld.byte 1 " SPIT17INTIDNP1 "
hexfld.byte 2 " SPIT17INTIDNP2 "
hexfld.byte 3 " SPIT17INTIDNP3 "
tree.end

base ad:0xa0411848
tree "SPIT18R"
group 0--3
line.long 0 "SPIT18R"
hexfld.byte 0 " SPIT18INTIDNP0 "
hexfld.byte 1 " SPIT18INTIDNP1 "
hexfld.byte 2 " SPIT18INTIDNP2 "
hexfld.byte 3 " SPIT18INTIDNP3 "
tree.end

base ad:0xa041184c
tree "SPIT19R"
group 0--3
line.long 0 "SPIT19R"
hexfld.byte 0 " SPIT19INTIDNP0 "
hexfld.byte 1 " SPIT19INTIDNP1 "
hexfld.byte 2 " SPIT19INTIDNP2 "
hexfld.byte 3 " SPIT19INTIDNP3 "
tree.end

base ad:0xa0411850
tree "SPIT20R"
group 0--3
line.long 0 "SPIT20R"
hexfld.byte 0 " SPIT20INTIDNP0 "
hexfld.byte 1 " SPIT20INTIDNP1 "
hexfld.byte 2 " SPIT20INTIDNP2 "
hexfld.byte 3 " SPIT20INTIDNP3 "
tree.end

base ad:0xa0411854
tree "SPIT21R"
group 0--3
line.long 0 "SPIT21R"
hexfld.byte 0 " SPIT21INTIDNP0 "
hexfld.byte 1 " SPIT21INTIDNP1 "
hexfld.byte 2 " SPIT21INTIDNP2 "
hexfld.byte 3 " SPIT21INTIDNP3 "
tree.end

base ad:0xa0411858
tree "SPIT22R"
group 0--3
line.long 0 "SPIT22R"
hexfld.byte 0 " SPIT22INTIDNP0 "
hexfld.byte 1 " SPIT22INTIDNP1 "
hexfld.byte 2 " SPIT22INTIDNP2 "
hexfld.byte 3 " SPIT22INTIDNP3 "
tree.end

base ad:0xa041185c
tree "SPIT23R"
group 0--3
line.long 0 "SPIT23R"
hexfld.byte 0 " SPIT23INTIDNP0 "
hexfld.byte 1 " SPIT23INTIDNP1 "
hexfld.byte 2 " SPIT23INTIDNP2 "
hexfld.byte 3 " SPIT23INTIDNP3 "
tree.end

base ad:0xa0411860
tree "SPIT24R"
group 0--3
line.long 0 "SPIT24R"
hexfld.byte 0 " SPIT24INTIDNP0 "
hexfld.byte 1 " SPIT24INTIDNP1 "
hexfld.byte 2 " SPIT24INTIDNP2 "
hexfld.byte 3 " SPIT24INTIDNP3 "
tree.end

base ad:0xa0411864
tree "SPIT25R"
group 0--3
line.long 0 "SPIT25R"
hexfld.byte 0 " SPIT25INTIDNP0 "
hexfld.byte 1 " SPIT25INTIDNP1 "
hexfld.byte 2 " SPIT25INTIDNP2 "
hexfld.byte 3 " SPIT25INTIDNP3 "
tree.end

base ad:0xa0411868
tree "SPIT26R"
group 0--3
line.long 0 "SPIT26R"
hexfld.byte 0 " SPIT26INTIDNP0 "
hexfld.byte 1 " SPIT26INTIDNP1 "
hexfld.byte 2 " SPIT26INTIDNP2 "
hexfld.byte 3 " SPIT26INTIDNP3 "
tree.end

base ad:0xa041186c
tree "SPIT27R"
group 0--3
line.long 0 "SPIT27R"
hexfld.byte 0 " SPIT27INTIDNP0 "
hexfld.byte 1 " SPIT27INTIDNP1 "
hexfld.byte 2 " SPIT27INTIDNP2 "
hexfld.byte 3 " SPIT27INTIDNP3 "
tree.end

base ad:0xa0411870
tree "SPIT28R"
group 0--3
line.long 0 "SPIT28R"
hexfld.byte 0 " SPIT28INTIDNP0 "
hexfld.byte 1 " SPIT28INTIDNP1 "
hexfld.byte 2 " SPIT28INTIDNP2 "
hexfld.byte 3 " SPIT28INTIDNP3 "
tree.end

base ad:0xa0411874
tree "SPIT29R"
group 0--3
line.long 0 "SPIT29R"
hexfld.byte 0 " SPIT29INTIDNP0 "
hexfld.byte 1 " SPIT29INTIDNP1 "
hexfld.byte 2 " SPIT29INTIDNP2 "
hexfld.byte 3 " SPIT29INTIDNP3 "
tree.end

base ad:0xa0411878
tree "SPIT30R"
group 0--3
line.long 0 "SPIT30R"
hexfld.byte 0 " SPIT30INTIDNP0 "
hexfld.byte 1 " SPIT30INTIDNP1 "
hexfld.byte 2 " SPIT30INTIDNP2 "
hexfld.byte 3 " SPIT30INTIDNP3 "
tree.end

base ad:0xa041187c
tree "SPIT31R"
group 0--3
line.long 0 "SPIT31R"
hexfld.byte 0 " SPIT31INTIDNP0 "
hexfld.byte 1 " SPIT31INTIDNP1 "
hexfld.byte 2 " SPIT31INTIDNP2 "
hexfld.byte 3 " SPIT31INTIDNP3 "
tree.end

base ad:0xa0411880
tree "SPIT32R"
group 0--3
line.long 0 "SPIT32R"
hexfld.byte 0 " SPIT32INTIDNP0 "
hexfld.byte 1 " SPIT32INTIDNP1 "
hexfld.byte 2 " SPIT32INTIDNP2 "
hexfld.byte 3 " SPIT32INTIDNP3 "
tree.end

base ad:0xa0411884
tree "SPIT33R"
group 0--3
line.long 0 "SPIT33R"
hexfld.byte 0 " SPIT33INTIDNP0 "
hexfld.byte 1 " SPIT33INTIDNP1 "
hexfld.byte 2 " SPIT33INTIDNP2 "
hexfld.byte 3 " SPIT33INTIDNP3 "
tree.end

base ad:0xa0411888
tree "SPIT34R"
group 0--3
line.long 0 "SPIT34R"
hexfld.byte 0 " SPIT34INTIDNP0 "
hexfld.byte 1 " SPIT34INTIDNP1 "
hexfld.byte 2 " SPIT34INTIDNP2 "
hexfld.byte 3 " SPIT34INTIDNP3 "
tree.end

base ad:0xa041188c
tree "SPIT35R"
group 0--3
line.long 0 "SPIT35R"
hexfld.byte 0 " SPIT35INTIDNP0 "
hexfld.byte 1 " SPIT35INTIDNP1 "
hexfld.byte 2 " SPIT35INTIDNP2 "
hexfld.byte 3 " SPIT35INTIDNP3 "
tree.end

base ad:0xa0411890
tree "SPIT36R"
group 0--3
line.long 0 "SPIT36R"
hexfld.byte 0 " SPIT36INTIDNP0 "
hexfld.byte 1 " SPIT36INTIDNP1 "
hexfld.byte 2 " SPIT36INTIDNP2 "
hexfld.byte 3 " SPIT36INTIDNP3 "
tree.end

base ad:0xa0411894
tree "SPIT37R"
group 0--3
line.long 0 "SPIT37R"
hexfld.byte 0 " SPIT37INTIDNP0 "
hexfld.byte 1 " SPIT37INTIDNP1 "
hexfld.byte 2 " SPIT37INTIDNP2 "
hexfld.byte 3 " SPIT37INTIDNP3 "
tree.end

base ad:0xa0411898
tree "SPIT38R"
group 0--3
line.long 0 "SPIT38R"
hexfld.byte 0 " SPIT38INTIDNP0 "
hexfld.byte 1 " SPIT38INTIDNP1 "
hexfld.byte 2 " SPIT38INTIDNP2 "
hexfld.byte 3 " SPIT38INTIDNP3 "
tree.end

base ad:0xa041189c
tree "SPIT39R"
group 0--3
line.long 0 "SPIT39R"
hexfld.byte 0 " SPIT39INTIDNP0 "
hexfld.byte 1 " SPIT39INTIDNP1 "
hexfld.byte 2 " SPIT39INTIDNP2 "
hexfld.byte 3 " SPIT39INTIDNP3 "
tree.end

base ad:0xa04118a0
tree "SPIT40R"
group 0--3
line.long 0 "SPIT40R"
hexfld.byte 0 " SPIT40INTIDNP0 "
hexfld.byte 1 " SPIT40INTIDNP1 "
hexfld.byte 2 " SPIT40INTIDNP2 "
hexfld.byte 3 " SPIT40INTIDNP3 "
tree.end

base ad:0xa04118a4
tree "SPIT41R"
group 0--3
line.long 0 "SPIT41R"
hexfld.byte 0 " SPIT41INTIDNP0 "
hexfld.byte 1 " SPIT41INTIDNP1 "
hexfld.byte 2 " SPIT41INTIDNP2 "
hexfld.byte 3 " SPIT41INTIDNP3 "
tree.end

base ad:0xa04118a8
tree "SPIT42R"
group 0--3
line.long 0 "SPIT42R"
hexfld.byte 0 " SPIT42INTIDNP0 "
hexfld.byte 1 " SPIT42INTIDNP1 "
hexfld.byte 2 " SPIT42INTIDNP2 "
hexfld.byte 3 " SPIT42INTIDNP3 "
tree.end

base ad:0xa04118ac
tree "SPIT43R"
group 0--3
line.long 0 "SPIT43R"
hexfld.byte 0 " SPIT43INTIDNP0 "
hexfld.byte 1 " SPIT43INTIDNP1 "
hexfld.byte 2 " SPIT43INTIDNP2 "
hexfld.byte 3 " SPIT43INTIDNP3 "
tree.end

base ad:0xa04118b0
tree "SPIT44R"
group 0--3
line.long 0 "SPIT44R"
hexfld.byte 0 " SPIT44INTIDNP0 "
hexfld.byte 1 " SPIT44INTIDNP1 "
hexfld.byte 2 " SPIT44INTIDNP2 "
hexfld.byte 3 " SPIT44INTIDNP3 "
tree.end

base ad:0xa04118b4
tree "SPIT45R"
group 0--3
line.long 0 "SPIT45R"
hexfld.byte 0 " SPIT45INTIDNP0 "
hexfld.byte 1 " SPIT45INTIDNP1 "
hexfld.byte 2 " SPIT45INTIDNP2 "
hexfld.byte 3 " SPIT45INTIDNP3 "
tree.end

base ad:0xa04118b8
tree "SPIT46R"
group 0--3
line.long 0 "SPIT46R"
hexfld.byte 0 " SPIT46INTIDNP0 "
hexfld.byte 1 " SPIT46INTIDNP1 "
hexfld.byte 2 " SPIT46INTIDNP2 "
hexfld.byte 3 " SPIT46INTIDNP3 "
tree.end

base ad:0xa04118bc
tree "SPIT47R"
group 0--3
line.long 0 "SPIT47R"
hexfld.byte 0 " SPIT47INTIDNP0 "
hexfld.byte 1 " SPIT47INTIDNP1 "
hexfld.byte 2 " SPIT47INTIDNP2 "
hexfld.byte 3 " SPIT47INTIDNP3 "
tree.end

base ad:0xa04118c0
tree "SPIT48R"
group 0--3
line.long 0 "SPIT48R"
hexfld.byte 0 " SPIT48INTIDNP0 "
hexfld.byte 1 " SPIT48INTIDNP1 "
hexfld.byte 2 " SPIT48INTIDNP2 "
hexfld.byte 3 " SPIT48INTIDNP3 "
tree.end

base ad:0xa04118c4
tree "SPIT49R"
group 0--3
line.long 0 "SPIT49R"
hexfld.byte 0 " SPIT49INTIDNP0 "
hexfld.byte 1 " SPIT49INTIDNP1 "
hexfld.byte 2 " SPIT49INTIDNP2 "
hexfld.byte 3 " SPIT49INTIDNP3 "
tree.end

base ad:0xa04118c8
tree "SPIT50R"
group 0--3
line.long 0 "SPIT50R"
hexfld.byte 0 " SPIT50INTIDNP0 "
hexfld.byte 1 " SPIT50INTIDNP1 "
hexfld.byte 2 " SPIT50INTIDNP2 "
hexfld.byte 3 " SPIT50INTIDNP3 "
tree.end

base ad:0xa04118cc
tree "SPIT51R"
group 0--3
line.long 0 "SPIT51R"
hexfld.byte 0 " SPIT51INTIDNP0 "
hexfld.byte 1 " SPIT51INTIDNP1 "
hexfld.byte 2 " SPIT51INTIDNP2 "
hexfld.byte 3 " SPIT51INTIDNP3 "
tree.end

base ad:0xa04118d0
tree "SPIT52R"
group 0--3
line.long 0 "SPIT52R"
hexfld.byte 0 " SPIT52INTIDNP0 "
hexfld.byte 1 " SPIT52INTIDNP1 "
hexfld.byte 2 " SPIT52INTIDNP2 "
hexfld.byte 3 " SPIT52INTIDNP3 "
tree.end

base ad:0xa04118d4
tree "SPIT53R"
group 0--3
line.long 0 "SPIT53R"
hexfld.byte 0 " SPIT53INTIDNP0 "
hexfld.byte 1 " SPIT53INTIDNP1 "
hexfld.byte 2 " SPIT53INTIDNP2 "
hexfld.byte 3 " SPIT53INTIDNP3 "
tree.end

base ad:0xa04118d8
tree "SPIT54R"
group 0--3
line.long 0 "SPIT54R"
hexfld.byte 0 " SPIT54INTIDNP0 "
hexfld.byte 1 " SPIT54INTIDNP1 "
hexfld.byte 2 " SPIT54INTIDNP2 "
hexfld.byte 3 " SPIT54INTIDNP3 "
tree.end

base ad:0xa04118dc
tree "SPIT55R"
group 0--3
line.long 0 "SPIT55R"
hexfld.byte 0 " SPIT55INTIDNP0 "
hexfld.byte 1 " SPIT55INTIDNP1 "
hexfld.byte 2 " SPIT55INTIDNP2 "
hexfld.byte 3 " SPIT55INTIDNP3 "
tree.end

base ad:0xa04118e0
tree "SPIT56R"
group 0--3
line.long 0 "SPIT56R"
hexfld.byte 0 " SPIT56INTIDNP0 "
hexfld.byte 1 " SPIT56INTIDNP1 "
hexfld.byte 2 " SPIT56INTIDNP2 "
hexfld.byte 3 " SPIT56INTIDNP3 "
tree.end

base ad:0xa04118e4
tree "SPIT57R"
group 0--3
line.long 0 "SPIT57R"
hexfld.byte 0 " SPIT57INTIDNP0 "
hexfld.byte 1 " SPIT57INTIDNP1 "
hexfld.byte 2 " SPIT57INTIDNP2 "
hexfld.byte 3 " SPIT57INTIDNP3 "
tree.end

base ad:0xa04118e8
tree "SPIT58R"
group 0--3
line.long 0 "SPIT58R"
hexfld.byte 0 " SPIT58INTIDNP0 "
hexfld.byte 1 " SPIT58INTIDNP1 "
hexfld.byte 2 " SPIT58INTIDNP2 "
hexfld.byte 3 " SPIT58INTIDNP3 "
tree.end

base ad:0xa04118ec
tree "SPIT59R"
group 0--3
line.long 0 "SPIT59R"
hexfld.byte 0 " SPIT59INTIDNP0 "
hexfld.byte 1 " SPIT59INTIDNP1 "
hexfld.byte 2 " SPIT59INTIDNP2 "
hexfld.byte 3 " SPIT59INTIDNP3 "
tree.end

base ad:0xa04118f0
tree "SPIT60R"
group 0--3
line.long 0 "SPIT60R"
hexfld.byte 0 " SPIT60INTIDNP0 "
hexfld.byte 1 " SPIT60INTIDNP1 "
hexfld.byte 2 " SPIT60INTIDNP2 "
hexfld.byte 3 " SPIT60INTIDNP3 "
tree.end

base ad:0xa04118f4
tree "SPIT61R"
group 0--3
line.long 0 "SPIT61R"
hexfld.byte 0 " SPIT61INTIDNP0 "
hexfld.byte 1 " SPIT61INTIDNP1 "
hexfld.byte 2 " SPIT61INTIDNP2 "
hexfld.byte 3 " SPIT61INTIDNP3 "
tree.end

base ad:0xa04118f8
tree "SPIT62R"
group 0--3
line.long 0 "SPIT62R"
hexfld.byte 0 " SPIT62INTIDNP0 "
hexfld.byte 1 " SPIT62INTIDNP1 "
hexfld.byte 2 " SPIT62INTIDNP2 "
hexfld.byte 3 " SPIT62INTIDNP3 "
tree.end

base ad:0xa04118fc
tree "SPIT63R"
group 0--3
line.long 0 "SPIT63R"
hexfld.byte 0 " SPIT63INTIDNP0 "
hexfld.byte 1 " SPIT63INTIDNP1 "
hexfld.byte 2 " SPIT63INTIDNP2 "
hexfld.byte 3 " SPIT63INTIDNP3 "
tree.end

base ad:0xa0411c00
tree "IC0R"
group 0--3
line.long 0 "IC0R"
hexfld.long 0 " IC0 "
tree.end

base ad:0xa0411c04
tree "IC1R"
group 0--3
line.long 0 "IC1R"
hexfld.long 0 " IC1 "
tree.end

base ad:0xa0411c08
tree "IC2R"
group 0--3
line.long 0 "IC2R"
hexfld.long 0 " IC2 "
tree.end

base ad:0xa0411c0c
tree "IC3R"
group 0--3
line.long 0 "IC3R"
hexfld.long 0 " IC3 "
tree.end

base ad:0xa0411c10
tree "IC4R"
group 0--3
line.long 0 "IC4R"
hexfld.long 0 " IC4 "
tree.end

base ad:0xa0411c14
tree "IC5R"
group 0--3
line.long 0 "IC5R"
hexfld.long 0 " IC5 "
tree.end

base ad:0xa0411c18
tree "IC6R"
group 0--3
line.long 0 "IC6R"
hexfld.long 0 " IC6 "
tree.end

base ad:0xa0411c1c
tree "IC7R"
group 0--3
line.long 0 "IC7R"
hexfld.long 0 " IC7 "
tree.end

base ad:0xa0411c20
tree "IC8R"
group 0--3
line.long 0 "IC8R"
hexfld.long 0 " IC8 "
tree.end

base ad:0xa0411c24
tree "IC9R"
group 0--3
line.long 0 "IC9R"
hexfld.long 0 " IC9 "
tree.end

base ad:0xa0411c28
tree "IC10R"
group 0--3
line.long 0 "IC10R"
hexfld.long 0 " IC10 "
tree.end

base ad:0xa0411c2c
tree "IC11R"
group 0--3
line.long 0 "IC11R"
hexfld.long 0 " IC11 "
tree.end

base ad:0xa0411c30
tree "IC12R"
group 0--3
line.long 0 "IC12R"
hexfld.long 0 " IC12 "
tree.end

base ad:0xa0411c34
tree "IC13R"
group 0--3
line.long 0 "IC13R"
hexfld.long 0 " IC13 "
tree.end

base ad:0xa0411c38
tree "IC14R"
group 0--3
line.long 0 "IC14R"
hexfld.long 0 " IC14 "
tree.end

base ad:0xa0411c3c
tree "IC15R"
group 0--3
line.long 0 "IC15R"
hexfld.long 0 " IC15 "
tree.end

base ad:0xa0411c40
tree "IC16R"
group 0--3
line.long 0 "IC16R"
hexfld.long 0 " IC16 "
tree.end

base ad:0xa0411c44
tree "IC17R"
group 0--3
line.long 0 "IC17R"
hexfld.long 0 " IC17 "
tree.end

base ad:0xa0411c48
tree "IC18R"
group 0--3
line.long 0 "IC18R"
hexfld.long 0 " IC18 "
tree.end

base ad:0xa0411c4c
tree "IC19R"
group 0--3
line.long 0 "IC19R"
hexfld.long 0 " IC19 "
tree.end

base ad:0xa0411c50
tree "IC20R"
group 0--3
line.long 0 "IC20R"
hexfld.long 0 " IC20 "
tree.end

base ad:0xa0411c54
tree "IC21R"
group 0--3
line.long 0 "IC21R"
hexfld.long 0 " IC21 "
tree.end

base ad:0xa0411c58
tree "IC22R"
group 0--3
line.long 0 "IC22R"
hexfld.long 0 " IC22 "
tree.end

base ad:0xa0411c5c
tree "IC23R"
group 0--3
line.long 0 "IC23R"
hexfld.long 0 " IC23 "
tree.end

base ad:0xa0411c60
tree "IC24R"
group 0--3
line.long 0 "IC24R"
hexfld.long 0 " IC24 "
tree.end

base ad:0xa0411c64
tree "IC25R"
group 0--3
line.long 0 "IC25R"
hexfld.long 0 " IC25 "
tree.end

base ad:0xa0411c68
tree "IC26R"
group 0--3
line.long 0 "IC26R"
hexfld.long 0 " IC26 "
tree.end

base ad:0xa0411c6c
tree "IC27R"
group 0--3
line.long 0 "IC27R"
hexfld.long 0 " IC27 "
tree.end

base ad:0xa0411c70
tree "IC28R"
group 0--3
line.long 0 "IC28R"
hexfld.long 0 " IC28 "
tree.end

base ad:0xa0411c74
tree "IC29R"
group 0--3
line.long 0 "IC29R"
hexfld.long 0 " IC29 "
tree.end

base ad:0xa0411c78
tree "IC30R"
group 0--3
line.long 0 "IC30R"
hexfld.long 0 " IC30 "
tree.end

base ad:0xa0411c7c
tree "IC31R"
group 0--3
line.long 0 "IC31R"
hexfld.long 0 " IC31 "
tree.end

base ad:0xa0411c80
tree "IC32R"
group 0--3
line.long 0 "IC32R"
hexfld.long 0 " IC32 "
tree.end

base ad:0xa0411c84
tree "IC33R"
group 0--3
line.long 0 "IC33R"
hexfld.long 0 " IC33 "
tree.end

base ad:0xa0411c88
tree "IC34R"
group 0--3
line.long 0 "IC34R"
hexfld.long 0 " IC34 "
tree.end

base ad:0xa0411c8c
tree "IC35R"
group 0--3
line.long 0 "IC35R"
hexfld.long 0 " IC35 "
tree.end

base ad:0xa0411c90
tree "IC36R"
group 0--3
line.long 0 "IC36R"
hexfld.long 0 " IC36 "
tree.end

base ad:0xa0411c94
tree "IC37R"
group 0--3
line.long 0 "IC37R"
hexfld.long 0 " IC37 "
tree.end

base ad:0xa0411c98
tree "IC38R"
group 0--3
line.long 0 "IC38R"
hexfld.long 0 " IC38 "
tree.end

base ad:0xa0411c9c
tree "IC39R"
group 0--3
line.long 0 "IC39R"
hexfld.long 0 " IC39 "
tree.end

base ad:0xa0411ca0
tree "IC40R"
group 0--3
line.long 0 "IC40R"
hexfld.long 0 " IC40 "
tree.end

base ad:0xa0411ca4
tree "IC41R"
group 0--3
line.long 0 "IC41R"
hexfld.long 0 " IC41 "
tree.end

base ad:0xa0411ca8
tree "IC42R"
group 0--3
line.long 0 "IC42R"
hexfld.long 0 " IC42 "
tree.end

base ad:0xa0411cac
tree "IC43R"
group 0--3
line.long 0 "IC43R"
hexfld.long 0 " IC43 "
tree.end

base ad:0xa0411cb0
tree "IC44R"
group 0--3
line.long 0 "IC44R"
hexfld.long 0 " IC44 "
tree.end

base ad:0xa0411cb4
tree "IC45R"
group 0--3
line.long 0 "IC45R"
hexfld.long 0 " IC45 "
tree.end

base ad:0xa0411cb8
tree "IC46R"
group 0--3
line.long 0 "IC46R"
hexfld.long 0 " IC46 "
tree.end

base ad:0xa0411cbc
tree "IC47R"
group 0--3
line.long 0 "IC47R"
hexfld.long 0 " IC47 "
tree.end

base ad:0xa0411cc0
tree "IC48R"
group 0--3
line.long 0 "IC48R"
hexfld.long 0 " IC48 "
tree.end

base ad:0xa0411cc4
tree "IC49R"
group 0--3
line.long 0 "IC49R"
hexfld.long 0 " IC49 "
tree.end

base ad:0xa0411cc8
tree "IC50R"
group 0--3
line.long 0 "IC50R"
hexfld.long 0 " IC50 "
tree.end

base ad:0xa0411ccc
tree "IC51R"
group 0--3
line.long 0 "IC51R"
hexfld.long 0 " IC51 "
tree.end

base ad:0xa0411cd0
tree "IC52R"
group 0--3
line.long 0 "IC52R"
hexfld.long 0 " IC52 "
tree.end

base ad:0xa0411cd4
tree "IC53R"
group 0--3
line.long 0 "IC53R"
hexfld.long 0 " IC53 "
tree.end

base ad:0xa0411cd8
tree "IC54R"
group 0--3
line.long 0 "IC54R"
hexfld.long 0 " IC54 "
tree.end

base ad:0xa0411cdc
tree "IC55R"
group 0--3
line.long 0 "IC55R"
hexfld.long 0 " IC55 "
tree.end

base ad:0xa0411ce0
tree "IC56R"
group 0--3
line.long 0 "IC56R"
hexfld.long 0 " IC56 "
tree.end

base ad:0xa0411ce4
tree "IC57R"
group 0--3
line.long 0 "IC57R"
hexfld.long 0 " IC57 "
tree.end

base ad:0xa0411ce8
tree "IC58R"
group 0--3
line.long 0 "IC58R"
hexfld.long 0 " IC58 "
tree.end

base ad:0xa0411cec
tree "IC59R"
group 0--3
line.long 0 "IC59R"
hexfld.long 0 " IC59 "
tree.end

base ad:0xa0411cf0
tree "IC60R"
group 0--3
line.long 0 "IC60R"
hexfld.long 0 " IC60 "
tree.end

base ad:0xa0411cf4
tree "IC61R"
group 0--3
line.long 0 "IC61R"
hexfld.long 0 " IC61 "
tree.end

base ad:0xa0411cf8
tree "IC62R"
group 0--3
line.long 0 "IC62R"
hexfld.long 0 " IC62 "
tree.end

base ad:0xa0411cfc
tree "IC63R"
group 0--3
line.long 0 "IC63R"
hexfld.long 0 " IC63 "
tree.end

base ad:0xa0411d00
tree "PPISR"
rgroup 0--3
line.long 0 "PPISR"
bitfld.long 0 12.--15. " PPISS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0411d04
tree "SPIS0R"
rgroup 0--3
line.long 0 "SPIS0R"
hexfld.long 0 " SPIS0 "
tree.end

base ad:0xa0411d08
tree "SPIS1R"
rgroup 0--3
line.long 0 "SPIS1R"
hexfld.long 0 " SPIS1 "
tree.end

base ad:0xa0411d0c
tree "SPIS2R"
rgroup 0--3
line.long 0 "SPIS2R"
hexfld.long 0 " SPIS2 "
tree.end

base ad:0xa0411d10
tree "SPIS3R"
rgroup 0--3
line.long 0 "SPIS3R"
hexfld.long 0 " SPIS3 "
tree.end

base ad:0xa0411d14
tree "SPIS4R"
rgroup 0--3
line.long 0 "SPIS4R"
hexfld.long 0 " SPIS4 "
tree.end

base ad:0xa0411d18
tree "SPIS5R"
rgroup 0--3
line.long 0 "SPIS5R"
hexfld.long 0 " SPIS5 "
tree.end

base ad:0xa0411d1c
tree "SPIS6R"
rgroup 0--3
line.long 0 "SPIS6R"
hexfld.long 0 " SPIS6 "
tree.end

base ad:0xa0411d20
tree "SPIS7R"
rgroup 0--3
line.long 0 "SPIS7R"
hexfld.long 0 " SPIS7 "
tree.end

base ad:0xa0411d24
tree "SPIS8R"
rgroup 0--3
line.long 0 "SPIS8R"
hexfld.long 0 " SPIS8 "
tree.end

base ad:0xa0411d28
tree "SPIS9R"
rgroup 0--3
line.long 0 "SPIS9R"
hexfld.long 0 " SPIS9 "
tree.end

base ad:0xa0411d2c
tree "SPIS10R"
rgroup 0--3
line.long 0 "SPIS10R"
hexfld.long 0 " SPIS10 "
tree.end

base ad:0xa0411d30
tree "SPIS11R"
rgroup 0--3
line.long 0 "SPIS11R"
hexfld.long 0 " SPIS11 "
tree.end

base ad:0xa0411d34
tree "SPIS12R"
rgroup 0--3
line.long 0 "SPIS12R"
hexfld.long 0 " SPIS12 "
tree.end

base ad:0xa0411d38
tree "SPIS13R"
rgroup 0--3
line.long 0 "SPIS13R"
hexfld.long 0 " SPIS13 "
tree.end

base ad:0xa0411d3c
tree "SPIS14R"
rgroup 0--3
line.long 0 "SPIS14R"
hexfld.long 0 " SPIS14 "
tree.end

base ad:0xa0411d40
tree "SPIS15R"
rgroup 0--3
line.long 0 "SPIS15R"
hexfld.long 0 " SPIS15 "
tree.end

base ad:0xa0411d44
tree "SPIS16R"
rgroup 0--3
line.long 0 "SPIS16R"
hexfld.long 0 " SPIS16 "
tree.end

base ad:0xa0411d48
tree "SPIS17R"
rgroup 0--3
line.long 0 "SPIS17R"
hexfld.long 0 " SPIS17 "
tree.end

base ad:0xa0411d4c
tree "SPIS18R"
rgroup 0--3
line.long 0 "SPIS18R"
hexfld.long 0 " SPIS18 "
tree.end

base ad:0xa0411d50
tree "SPIS19R"
rgroup 0--3
line.long 0 "SPIS19R"
hexfld.long 0 " SPIS19 "
tree.end

base ad:0xa0411d54
tree "SPIS20R"
rgroup 0--3
line.long 0 "SPIS20R"
hexfld.long 0 " SPIS20 "
tree.end

base ad:0xa0411d58
tree "SPIS21R"
rgroup 0--3
line.long 0 "SPIS21R"
hexfld.long 0 " SPIS21 "
tree.end

base ad:0xa0411d5c
tree "SPIS22R"
rgroup 0--3
line.long 0 "SPIS22R"
hexfld.long 0 " SPIS22 "
tree.end

base ad:0xa0411d60
tree "SPIS23R"
rgroup 0--3
line.long 0 "SPIS23R"
hexfld.long 0 " SPIS23 "
tree.end

base ad:0xa0411d64
tree "SPIS24R"
rgroup 0--3
line.long 0 "SPIS24R"
hexfld.long 0 " SPIS24 "
tree.end

base ad:0xa0411d68
tree "SPIS25R"
rgroup 0--3
line.long 0 "SPIS25R"
hexfld.long 0 " SPIS25 "
tree.end

base ad:0xa0411d6c
tree "SPIS26R"
rgroup 0--3
line.long 0 "SPIS26R"
hexfld.long 0 " SPIS26 "
tree.end

base ad:0xa0411d70
tree "SPIS27R"
rgroup 0--3
line.long 0 "SPIS27R"
hexfld.long 0 " SPIS27 "
tree.end

base ad:0xa0411d74
tree "SPIS28R"
rgroup 0--3
line.long 0 "SPIS28R"
hexfld.long 0 " SPIS28 "
tree.end

base ad:0xa0411d78
tree "SPIS29R"
rgroup 0--3
line.long 0 "SPIS29R"
hexfld.long 0 " SPIS29 "
tree.end

base ad:0xa0411d7c
tree "SPIS30R"
rgroup 0--3
line.long 0 "SPIS30R"
hexfld.long 0 " SPIS30 "
tree.end

base ad:0xa0411f00
tree "STIR"
wgroup 0--3
line.long 0 "STIR"
bitfld.long 0 0.--3. " STIINTID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 15. " STISATT "  "0 ,1 "
hexfld.byte 2 " STICPUTL "
bitfld.long 0 24.--25. " STITLF "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0411fe0
tree "PPLI0R"
rgroup 0--3
line.long 0 "PPLI0R"
bitfld.long 0 0.--11. " PPLI0PN "  " "
bitfld.long 0 12.--18. " PPLI0JEP106 "  " "
bitfld.long 0 19. " PPLI0JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI0REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI0MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI0REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0411fe4
tree "PPLI1R"
rgroup 0--3
line.long 0 "PPLI1R"
bitfld.long 0 0.--11. " PPLI1PN "  " "
bitfld.long 0 12.--18. " PPLI1JEP106 "  " "
bitfld.long 0 19. " PPLI1JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI1REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI1MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI1REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0411fe8
tree "PPLI2R"
rgroup 0--3
line.long 0 "PPLI2R"
bitfld.long 0 0.--11. " PPLI2PN "  " "
bitfld.long 0 12.--18. " PPLI2JEP106 "  " "
bitfld.long 0 19. " PPLI2JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI2REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI2MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI2REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0411fec
tree "PPLI3R"
rgroup 0--3
line.long 0 "PPLI3R"
bitfld.long 0 0.--11. " PPLI3PN "  " "
bitfld.long 0 12.--18. " PPLI3JEP106 "  " "
bitfld.long 0 19. " PPLI3JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI3REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI3MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI3REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0411ff0
tree "PCI0R"
rgroup 0--3
line.long 0 "PCI0R"
hexfld.byte 0 " PCI0CID0 "
hexfld.byte 1 " PCI0CID1 "
hexfld.byte 2 " PCI0CID2 "
hexfld.byte 3 " PCI0CID3 "
tree.end

base ad:0xa0411ff4
tree "PCI1R"
rgroup 0--3
line.long 0 "PCI1R"
hexfld.byte 0 " PCI1CID0 "
hexfld.byte 1 " PCI1CID1 "
hexfld.byte 2 " PCI1CID2 "
hexfld.byte 3 " PCI1CID3 "
tree.end

base ad:0xa0411ff8
tree "PCI2R"
rgroup 0--3
line.long 0 "PCI2R"
hexfld.byte 0 " PCI2CID0 "
hexfld.byte 1 " PCI2CID1 "
hexfld.byte 2 " PCI2CID2 "
hexfld.byte 3 " PCI2CID3 "
tree.end

base ad:0xa0411ffc
tree "PCI3R"
rgroup 0--3
line.long 0 "PCI3R"
hexfld.byte 0 " PCI3CID0 "
hexfld.byte 1 " PCI3CID1 "
hexfld.byte 2 " PCI3CID2 "
hexfld.byte 3 " PCI3CID3 "
tree.end

tree.end

;==============================================================
tree "GPIO0"
;==============================================================
base ad:0xa002e000
tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
tree.end

base ad:0xa002e004
tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
tree.end

base ad:0xa002e008
tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
tree.end

base ad:0xa002e00c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
tree.end

base ad:0xa002e010
tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
tree.end

base ad:0xa002e014
tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
tree.end

base ad:0xa002e018
tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
tree.end

base ad:0xa002e01c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
tree.end

base ad:0xa002e020
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
tree.end

base ad:0xa002e024
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
tree.end

base ad:0xa002e028
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " GPLOWEMI "
tree.end

base ad:0xa002e040
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
tree.end

base ad:0xa002e044
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
tree.end

base ad:0xa002e048
tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
tree.end

base ad:0xa002e04c
tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
tree.end

base ad:0xa002e050
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
tree.end

base ad:0xa002e054
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
tree.end

base ad:0xa002e058
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
tree.end

tree.end

;==============================================================
tree "GPIO1"
;==============================================================
base ad:0xa002e080
tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
tree.end

base ad:0xa002e084
tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
tree.end

base ad:0xa002e088
tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
tree.end

base ad:0xa002e08c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
tree.end

base ad:0xa002e090
tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
tree.end

base ad:0xa002e094
tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
tree.end

base ad:0xa002e098
tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
tree.end

base ad:0xa002e09c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
tree.end

base ad:0xa002e0a0
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
tree.end

base ad:0xa002e0a4
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
tree.end

base ad:0xa002e0a8
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " GPLOWEMI "
tree.end

base ad:0xa002e0c0
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
tree.end

base ad:0xa002e0c4
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
tree.end

base ad:0xa002e0c8
tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
tree.end

base ad:0xa002e0cc
tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
tree.end

base ad:0xa002e0d0
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
tree.end

base ad:0xa002e0d4
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
tree.end

base ad:0xa002e0d8
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
tree.end

tree.end

;==============================================================
tree "GPIO2"
;==============================================================
base ad:0xa001e000
tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
tree.end

base ad:0xa001e004
tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
tree.end

base ad:0xa001e008
tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
tree.end

base ad:0xa001e00c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
tree.end

base ad:0xa001e010
tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
tree.end

base ad:0xa001e014
tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
tree.end

base ad:0xa001e018
tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
tree.end

base ad:0xa001e01c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
tree.end

base ad:0xa001e020
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
tree.end

base ad:0xa001e024
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
tree.end

base ad:0xa001e028
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " GPLOWEMI "
tree.end

base ad:0xa001e040
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
tree.end

base ad:0xa001e044
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
tree.end

base ad:0xa001e048
tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
tree.end

base ad:0xa001e04c
tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
tree.end

base ad:0xa001e050
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
tree.end

base ad:0xa001e054
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
tree.end

base ad:0xa001e058
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
tree.end

tree.end

;==============================================================
tree "GPIO3"
;==============================================================
base ad:0x8015a000
tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
tree.end

base ad:0x8015a004
tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
tree.end

base ad:0x8015a008
tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
tree.end

base ad:0x8015a00c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
tree.end

base ad:0x8015a010
tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
tree.end

base ad:0x8015a014
tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
tree.end

base ad:0x8015a018
tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
tree.end

base ad:0x8015a01c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
tree.end

base ad:0x8015a020
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
tree.end

base ad:0x8015a024
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
tree.end

base ad:0x8015a028
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " GPLOWEMI "
tree.end

base ad:0x8015a040
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
tree.end

base ad:0x8015a044
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
tree.end

base ad:0x8015a048
tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
tree.end

base ad:0x8015a04c
tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
tree.end

base ad:0x8015a050
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
tree.end

base ad:0x8015a054
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
tree.end

base ad:0x8015a058
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
tree.end

tree.end

;==============================================================
tree "GPIO4"
;==============================================================
base ad:0x8014e000
tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
tree.end

base ad:0x8014e004
tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
tree.end

base ad:0x8014e008
tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
tree.end

base ad:0x8014e00c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
tree.end

base ad:0x8014e010
tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
tree.end

base ad:0x8014e014
tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
tree.end

base ad:0x8014e018
tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
tree.end

base ad:0x8014e01c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
tree.end

base ad:0x8014e020
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
tree.end

base ad:0x8014e024
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
tree.end

base ad:0x8014e028
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " GPLOWEMI "
tree.end

base ad:0x8014e040
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
tree.end

base ad:0x8014e044
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
tree.end

base ad:0x8014e048
tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
tree.end

base ad:0x8014e04c
tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
tree.end

base ad:0x8014e050
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
tree.end

base ad:0x8014e054
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
tree.end

base ad:0x8014e058
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
tree.end

tree.end

;==============================================================
tree "GPIO5"
;==============================================================
base ad:0x8011e000
tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
tree.end

base ad:0x8011e004
tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
tree.end

base ad:0x8011e008
tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
tree.end

base ad:0x8011e00c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
tree.end

base ad:0x8011e010
tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
tree.end

base ad:0x8011e014
tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
tree.end

base ad:0x8011e018
tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
tree.end

base ad:0x8011e01c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
tree.end

base ad:0x8011e020
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
tree.end

base ad:0x8011e024
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
tree.end

base ad:0x8011e028
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " GPLOWEMI "
tree.end

base ad:0x8011e040
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
tree.end

base ad:0x8011e044
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
tree.end

base ad:0x8011e048
tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
tree.end

base ad:0x8011e04c
tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
tree.end

base ad:0x8011e050
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
tree.end

base ad:0x8011e054
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
tree.end

base ad:0x8011e058
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
tree.end

tree.end

;==============================================================
tree "GPIO6"
;==============================================================
base ad:0x8011e080
tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
tree.end

base ad:0x8011e084
tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
tree.end

base ad:0x8011e088
tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
tree.end

base ad:0x8011e08c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
tree.end

base ad:0x8011e090
tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
tree.end

base ad:0x8011e094
tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
tree.end

base ad:0x8011e098
tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
tree.end

base ad:0x8011e09c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
tree.end

base ad:0x8011e0a0
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
tree.end

base ad:0x8011e0a4
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
tree.end

base ad:0x8011e0a8
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " GPLOWEMI "
tree.end

base ad:0x8011e0c0
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
tree.end

base ad:0x8011e0c4
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
tree.end

base ad:0x8011e0c8
tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
tree.end

base ad:0x8011e0cc
tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
tree.end

base ad:0x8011e0d0
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
tree.end

base ad:0x8011e0d4
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
tree.end

base ad:0x8011e0d8
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
tree.end

tree.end

;==============================================================
tree "GPIO7"
;==============================================================
base ad:0x8011e100
tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
tree.end

base ad:0x8011e104
tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
tree.end

base ad:0x8011e108
tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
tree.end

base ad:0x8011e10c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
tree.end

base ad:0x8011e110
tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
tree.end

base ad:0x8011e114
tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
tree.end

base ad:0x8011e118
tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
tree.end

base ad:0x8011e11c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
tree.end

base ad:0x8011e120
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
tree.end

base ad:0x8011e124
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
tree.end

base ad:0x8011e128
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " GPLOWEMI "
tree.end

base ad:0x8011e140
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
tree.end

base ad:0x8011e144
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
tree.end

base ad:0x8011e148
tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
tree.end

base ad:0x8011e14c
tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
tree.end

base ad:0x8011e150
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
tree.end

base ad:0x8011e154
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
tree.end

base ad:0x8011e158
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
tree.end

tree.end

;==============================================================
tree "HASH (2 instances)"
;==============================================================
base ad:0x80121000
;********************************************
tree "HASH-0"
;********************************************
base ad:0x80121000
tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " INIT "  "0 ,1 "
bitfld.long 0 3. " DMAE "  "0 ,1 "
bitfld.long 0 4.--5. " DATAFORM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " MODE "  "0 ,1 "
bitfld.long 0 7. " ALGO "  "0 ,1 "
bitfld.long 0 8.--11. " NBW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " DINF "  "0 ,1 "
bitfld.long 0 16. " LKEY "  "0 ,1 "
bitfld.long 0 20. " EMPTYMSG "  "0 ,1 "
bitfld.long 0 31. " SWITCHON "  "0 ,1 "
tree.end

base ad:0x80121004
tree "0DIN"
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
tree.end

base ad:0x80121008
tree "0STR"
group 0--3
line.long 0 "STR"
bitfld.long 0 0.--4. " NBLW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " DCAL "  "0 ,1 "
tree.end

base ad:0x8012100c
tree "0H0"
group 0--3
line.long 0 "H0"
hexfld.long 0 " H0 "
tree.end

base ad:0x80121010
tree "0H1"
group 0--3
line.long 0 "H1"
hexfld.long 0 " H1 "
tree.end

base ad:0x80121014
tree "0H2"
group 0--3
line.long 0 "H2"
hexfld.long 0 " H2 "
tree.end

base ad:0x80121018
tree "0H3"
group 0--3
line.long 0 "H3"
hexfld.long 0 " H3 "
tree.end

base ad:0x8012101c
tree "0H4"
group 0--3
line.long 0 "H4"
hexfld.long 0 " H4 "
tree.end

base ad:0x80121020
tree "0H5"
group 0--3
line.long 0 "H5"
hexfld.long 0 " H5 "
tree.end

base ad:0x80121024
tree "0H6"
group 0--3
line.long 0 "H6"
hexfld.long 0 " H6 "
tree.end

base ad:0x80121028
tree "0H7"
group 0--3
line.long 0 "H7"
hexfld.long 0 " H7 "
tree.end

base ad:0x80121080
tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0x80121084
tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR "  "0 ,1 "
bitfld.long 0 1. " DMATC "  "0 ,1 "
bitfld.long 0 2. " DECPROT "  "0 ,1 "
tree.end

base ad:0x80121088
tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMABREQ "  "0 ,1 "
tree.end

base ad:0x801210f8
tree "0CSFULL"
group 0--3
line.long 0 "CSFULL"
bitfld.long 0 0. " FULL "  "0 ,1 "
bitfld.long 0 1. " FINISH "  "0 ,1 "
tree.end

base ad:0x801210fc
tree "0CSDATAIN"
group 0--3
line.long 0 "CSDATAIN"
hexfld.long 0 " DATA_INPUT "
tree.end

base ad:0x80121100
tree "0CSR0"
group 0--3
line.long 0 "CSR0"
bitfld.long 0 0. " ALGO "  "0 ,1 "
bitfld.long 0 1. " LAST "  "0 ,1 "
bitfld.long 0 2.--8. " STEP_CNT "  " "
bitfld.long 0 9.--10. " STBIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 11.--12. " PHASE "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " LKEY "  "0 ,1 "
bitfld.long 0 14.--17. " STBINOUTER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 18.--21. " WORD_CNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 22.--23. " PADDERSTBIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " CPHASE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80121104
tree "0CSR1"
group 0--3
line.long 0 "CSR1"
hexfld.long 0 " W1 "
tree.end

base ad:0x80121108
tree "0CSR2"
group 0--3
line.long 0 "CSR2"
hexfld.long 0 " W2 "
tree.end

base ad:0x8012110c
tree "0CSR3"
group 0--3
line.long 0 "CSR3"
hexfld.long 0 " W3 "
tree.end

base ad:0x80121110
tree "0CSR4"
group 0--3
line.long 0 "CSR4"
hexfld.long 0 " W4 "
tree.end

base ad:0x80121114
tree "0CSR5"
group 0--3
line.long 0 "CSR5"
hexfld.long 0 " W5 "
tree.end

base ad:0x80121118
tree "0CSR6"
group 0--3
line.long 0 "CSR6"
hexfld.long 0 " W6 "
tree.end

base ad:0x8012111c
tree "0CSR7"
group 0--3
line.long 0 "CSR7"
hexfld.long 0 " W7 "
tree.end

base ad:0x80121120
tree "0CSR8"
group 0--3
line.long 0 "CSR8"
hexfld.long 0 " W8 "
tree.end

base ad:0x80121124
tree "0CSR9"
group 0--3
line.long 0 "CSR9"
hexfld.long 0 " W9 "
tree.end

base ad:0x80121128
tree "0CSR10"
group 0--3
line.long 0 "CSR10"
hexfld.long 0 " W10 "
tree.end

base ad:0x8012112c
tree "0CSR11"
group 0--3
line.long 0 "CSR11"
hexfld.long 0 " W11 "
tree.end

base ad:0x80121130
tree "0CSR12"
group 0--3
line.long 0 "CSR12"
hexfld.long 0 " W12 "
tree.end

base ad:0x80121134
tree "0CSR13"
group 0--3
line.long 0 "CSR13"
hexfld.long 0 " W13 "
tree.end

base ad:0x80121138
tree "0CSR14"
group 0--3
line.long 0 "CSR14"
hexfld.long 0 " W14 "
tree.end

base ad:0x8012113c
tree "0CSR15"
group 0--3
line.long 0 "CSR15"
hexfld.long 0 " W15 "
tree.end

base ad:0x80121140
tree "0CSR16"
group 0--3
line.long 0 "CSR16"
hexfld.long 0 " W16 "
tree.end

base ad:0x80121144
tree "0CSR17"
group 0--3
line.long 0 "CSR17"
hexfld.long 0 " W17 "
tree.end

base ad:0x80121148
tree "0CSR18"
group 0--3
line.long 0 "CSR18"
hexfld.long 0 " W18 "
tree.end

base ad:0x8012114c
tree "0CSR19"
group 0--3
line.long 0 "CSR19"
hexfld.long 0 " W19 "
tree.end

base ad:0x80121150
tree "0CSR20"
group 0--3
line.long 0 "CSR20"
hexfld.long 0 " W20 "
tree.end

base ad:0x80121154
tree "0CSR21"
group 0--3
line.long 0 "CSR21"
hexfld.long 0 " W21 "
tree.end

base ad:0x80121158
tree "0CSR22"
group 0--3
line.long 0 "CSR22"
hexfld.long 0 " W22 "
tree.end

base ad:0x8012115c
tree "0CSR23"
group 0--3
line.long 0 "CSR23"
hexfld.long 0 " W23 "
tree.end

base ad:0x80121160
tree "0CSR24"
group 0--3
line.long 0 "CSR24"
hexfld.long 0 " W24 "
tree.end

base ad:0x80121164
tree "0CSR25"
group 0--3
line.long 0 "CSR25"
hexfld.long 0 " W25 "
tree.end

base ad:0x80121168
tree "0CSR26"
group 0--3
line.long 0 "CSR26"
hexfld.long 0 " W26 "
tree.end

base ad:0x8012116c
tree "0CSR27"
group 0--3
line.long 0 "CSR27"
hexfld.long 0 " W27 "
tree.end

base ad:0x80121170
tree "0CSR28"
group 0--3
line.long 0 "CSR28"
hexfld.long 0 " W28 "
tree.end

base ad:0x80121174
tree "0CSR29"
group 0--3
line.long 0 "CSR29"
hexfld.long 0 " W29 "
tree.end

base ad:0x80121178
tree "0CSR30"
group 0--3
line.long 0 "CSR30"
hexfld.long 0 " W30 "
tree.end

base ad:0x8012117c
tree "0CSR31"
group 0--3
line.long 0 "CSR31"
hexfld.long 0 " W31 "
tree.end

base ad:0x80121180
tree "0CSR32"
group 0--3
line.long 0 "CSR32"
hexfld.long 0 " W32 "
tree.end

base ad:0x80121184
tree "0CSR33"
group 0--3
line.long 0 "CSR33"
hexfld.long 0 " W33 "
tree.end

base ad:0x80121188
tree "0CSR34"
group 0--3
line.long 0 "CSR34"
hexfld.long 0 " W34 "
tree.end

base ad:0x8012118c
tree "0CSR35"
group 0--3
line.long 0 "CSR35"
hexfld.long 0 " W35 "
tree.end

base ad:0x80121190
tree "0CSR36"
group 0--3
line.long 0 "CSR36"
hexfld.long 0 " W36 "
tree.end

base ad:0x80121194
tree "0CSR37"
group 0--3
line.long 0 "CSR37"
hexfld.long 0 " W37 "
tree.end

base ad:0x80121198
tree "0CSR38"
group 0--3
line.long 0 "CSR38"
hexfld.long 0 " W38 "
tree.end

base ad:0x8012119c
tree "0CSR39"
group 0--3
line.long 0 "CSR39"
hexfld.long 0 " W39 "
tree.end

base ad:0x801211a0
tree "0CSR40"
group 0--3
line.long 0 "CSR40"
hexfld.long 0 " W40 "
tree.end

base ad:0x801211a4
tree "0CSR41"
group 0--3
line.long 0 "CSR41"
hexfld.long 0 " W41 "
tree.end

base ad:0x801211a8
tree "0CSR42"
group 0--3
line.long 0 "CSR42"
hexfld.long 0 " W42 "
tree.end

base ad:0x801211ac
tree "0CSR43"
group 0--3
line.long 0 "CSR43"
hexfld.long 0 " W43 "
tree.end

base ad:0x801211b0
tree "0CSR44"
group 0--3
line.long 0 "CSR44"
hexfld.long 0 " W44 "
tree.end

base ad:0x801211b4
tree "0CSR45"
group 0--3
line.long 0 "CSR45"
hexfld.long 0 " W45 "
tree.end

base ad:0x801211b8
tree "0CSR46"
group 0--3
line.long 0 "CSR46"
hexfld.long 0 " W46 "
tree.end

base ad:0x801211bc
tree "0CSR47"
group 0--3
line.long 0 "CSR47"
hexfld.long 0 " W47 "
tree.end

base ad:0x801211c0
tree "0CSR48"
group 0--3
line.long 0 "CSR48"
hexfld.long 0 " W48 "
tree.end

base ad:0x801211c4
tree "0CSR49"
group 0--3
line.long 0 "CSR49"
hexfld.long 0 " W49 "
tree.end

base ad:0x801211c8
tree "0CSR50"
group 0--3
line.long 0 "CSR50"
hexfld.long 0 " W50 "
tree.end

base ad:0x801211cc
tree "0CSR51"
group 0--3
line.long 0 "CSR51"
hexfld.long 0 " W51 "
tree.end

base ad:0x80121fe0
tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x80121fe4
tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80121fe8
tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80121fec
tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80121ff0
tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
tree.end

base ad:0x80121ff4
tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
tree.end

base ad:0x80121ff8
tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
tree.end

base ad:0x80121ffc
tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
tree.end

tree.end

base ad:0x80122000
;********************************************
tree "HASH-1"
;********************************************
base ad:0x80122000
tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " INIT "  "0 ,1 "
bitfld.long 0 3. " DMAE "  "0 ,1 "
bitfld.long 0 4.--5. " DATAFORM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " MODE "  "0 ,1 "
bitfld.long 0 7. " ALGO "  "0 ,1 "
bitfld.long 0 8.--11. " NBW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " DINF "  "0 ,1 "
bitfld.long 0 16. " LKEY "  "0 ,1 "
bitfld.long 0 20. " EMPTYMSG "  "0 ,1 "
bitfld.long 0 31. " SWITCHON "  "0 ,1 "
tree.end

base ad:0x80122004
tree "1DIN"
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
tree.end

base ad:0x80122008
tree "1STR"
group 0--3
line.long 0 "STR"
bitfld.long 0 0.--4. " NBLW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " DCAL "  "0 ,1 "
tree.end

base ad:0x8012200c
tree "1H0"
group 0--3
line.long 0 "H0"
hexfld.long 0 " H0 "
tree.end

base ad:0x80122010
tree "1H1"
group 0--3
line.long 0 "H1"
hexfld.long 0 " H1 "
tree.end

base ad:0x80122014
tree "1H2"
group 0--3
line.long 0 "H2"
hexfld.long 0 " H2 "
tree.end

base ad:0x80122018
tree "1H3"
group 0--3
line.long 0 "H3"
hexfld.long 0 " H3 "
tree.end

base ad:0x8012201c
tree "1H4"
group 0--3
line.long 0 "H4"
hexfld.long 0 " H4 "
tree.end

base ad:0x80122020
tree "1H5"
group 0--3
line.long 0 "H5"
hexfld.long 0 " H5 "
tree.end

base ad:0x80122024
tree "1H6"
group 0--3
line.long 0 "H6"
hexfld.long 0 " H6 "
tree.end

base ad:0x80122028
tree "1H7"
group 0--3
line.long 0 "H7"
hexfld.long 0 " H7 "
tree.end

base ad:0x80122080
tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0x80122084
tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR "  "0 ,1 "
bitfld.long 0 1. " DMATC "  "0 ,1 "
bitfld.long 0 2. " DECPROT "  "0 ,1 "
tree.end

base ad:0x80122088
tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMABREQ "  "0 ,1 "
tree.end

base ad:0x801220f8
tree "1CSFULL"
group 0--3
line.long 0 "CSFULL"
bitfld.long 0 0. " FULL "  "0 ,1 "
bitfld.long 0 1. " FINISH "  "0 ,1 "
tree.end

base ad:0x801220fc
tree "1CSDATAIN"
group 0--3
line.long 0 "CSDATAIN"
hexfld.long 0 " DATA_INPUT "
tree.end

base ad:0x80122100
tree "1CSR0"
group 0--3
line.long 0 "CSR0"
bitfld.long 0 0. " ALGO "  "0 ,1 "
bitfld.long 0 1. " LAST "  "0 ,1 "
bitfld.long 0 2.--8. " STEP_CNT "  " "
bitfld.long 0 9.--10. " STBIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 11.--12. " PHASE "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " LKEY "  "0 ,1 "
bitfld.long 0 14.--17. " STBINOUTER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 18.--21. " WORD_CNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 22.--23. " PADDERSTBIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " CPHASE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80122104
tree "1CSR1"
group 0--3
line.long 0 "CSR1"
hexfld.long 0 " W1 "
tree.end

base ad:0x80122108
tree "1CSR2"
group 0--3
line.long 0 "CSR2"
hexfld.long 0 " W2 "
tree.end

base ad:0x8012210c
tree "1CSR3"
group 0--3
line.long 0 "CSR3"
hexfld.long 0 " W3 "
tree.end

base ad:0x80122110
tree "1CSR4"
group 0--3
line.long 0 "CSR4"
hexfld.long 0 " W4 "
tree.end

base ad:0x80122114
tree "1CSR5"
group 0--3
line.long 0 "CSR5"
hexfld.long 0 " W5 "
tree.end

base ad:0x80122118
tree "1CSR6"
group 0--3
line.long 0 "CSR6"
hexfld.long 0 " W6 "
tree.end

base ad:0x8012211c
tree "1CSR7"
group 0--3
line.long 0 "CSR7"
hexfld.long 0 " W7 "
tree.end

base ad:0x80122120
tree "1CSR8"
group 0--3
line.long 0 "CSR8"
hexfld.long 0 " W8 "
tree.end

base ad:0x80122124
tree "1CSR9"
group 0--3
line.long 0 "CSR9"
hexfld.long 0 " W9 "
tree.end

base ad:0x80122128
tree "1CSR10"
group 0--3
line.long 0 "CSR10"
hexfld.long 0 " W10 "
tree.end

base ad:0x8012212c
tree "1CSR11"
group 0--3
line.long 0 "CSR11"
hexfld.long 0 " W11 "
tree.end

base ad:0x80122130
tree "1CSR12"
group 0--3
line.long 0 "CSR12"
hexfld.long 0 " W12 "
tree.end

base ad:0x80122134
tree "1CSR13"
group 0--3
line.long 0 "CSR13"
hexfld.long 0 " W13 "
tree.end

base ad:0x80122138
tree "1CSR14"
group 0--3
line.long 0 "CSR14"
hexfld.long 0 " W14 "
tree.end

base ad:0x8012213c
tree "1CSR15"
group 0--3
line.long 0 "CSR15"
hexfld.long 0 " W15 "
tree.end

base ad:0x80122140
tree "1CSR16"
group 0--3
line.long 0 "CSR16"
hexfld.long 0 " W16 "
tree.end

base ad:0x80122144
tree "1CSR17"
group 0--3
line.long 0 "CSR17"
hexfld.long 0 " W17 "
tree.end

base ad:0x80122148
tree "1CSR18"
group 0--3
line.long 0 "CSR18"
hexfld.long 0 " W18 "
tree.end

base ad:0x8012214c
tree "1CSR19"
group 0--3
line.long 0 "CSR19"
hexfld.long 0 " W19 "
tree.end

base ad:0x80122150
tree "1CSR20"
group 0--3
line.long 0 "CSR20"
hexfld.long 0 " W20 "
tree.end

base ad:0x80122154
tree "1CSR21"
group 0--3
line.long 0 "CSR21"
hexfld.long 0 " W21 "
tree.end

base ad:0x80122158
tree "1CSR22"
group 0--3
line.long 0 "CSR22"
hexfld.long 0 " W22 "
tree.end

base ad:0x8012215c
tree "1CSR23"
group 0--3
line.long 0 "CSR23"
hexfld.long 0 " W23 "
tree.end

base ad:0x80122160
tree "1CSR24"
group 0--3
line.long 0 "CSR24"
hexfld.long 0 " W24 "
tree.end

base ad:0x80122164
tree "1CSR25"
group 0--3
line.long 0 "CSR25"
hexfld.long 0 " W25 "
tree.end

base ad:0x80122168
tree "1CSR26"
group 0--3
line.long 0 "CSR26"
hexfld.long 0 " W26 "
tree.end

base ad:0x8012216c
tree "1CSR27"
group 0--3
line.long 0 "CSR27"
hexfld.long 0 " W27 "
tree.end

base ad:0x80122170
tree "1CSR28"
group 0--3
line.long 0 "CSR28"
hexfld.long 0 " W28 "
tree.end

base ad:0x80122174
tree "1CSR29"
group 0--3
line.long 0 "CSR29"
hexfld.long 0 " W29 "
tree.end

base ad:0x80122178
tree "1CSR30"
group 0--3
line.long 0 "CSR30"
hexfld.long 0 " W30 "
tree.end

base ad:0x8012217c
tree "1CSR31"
group 0--3
line.long 0 "CSR31"
hexfld.long 0 " W31 "
tree.end

base ad:0x80122180
tree "1CSR32"
group 0--3
line.long 0 "CSR32"
hexfld.long 0 " W32 "
tree.end

base ad:0x80122184
tree "1CSR33"
group 0--3
line.long 0 "CSR33"
hexfld.long 0 " W33 "
tree.end

base ad:0x80122188
tree "1CSR34"
group 0--3
line.long 0 "CSR34"
hexfld.long 0 " W34 "
tree.end

base ad:0x8012218c
tree "1CSR35"
group 0--3
line.long 0 "CSR35"
hexfld.long 0 " W35 "
tree.end

base ad:0x80122190
tree "1CSR36"
group 0--3
line.long 0 "CSR36"
hexfld.long 0 " W36 "
tree.end

base ad:0x80122194
tree "1CSR37"
group 0--3
line.long 0 "CSR37"
hexfld.long 0 " W37 "
tree.end

base ad:0x80122198
tree "1CSR38"
group 0--3
line.long 0 "CSR38"
hexfld.long 0 " W38 "
tree.end

base ad:0x8012219c
tree "1CSR39"
group 0--3
line.long 0 "CSR39"
hexfld.long 0 " W39 "
tree.end

base ad:0x801221a0
tree "1CSR40"
group 0--3
line.long 0 "CSR40"
hexfld.long 0 " W40 "
tree.end

base ad:0x801221a4
tree "1CSR41"
group 0--3
line.long 0 "CSR41"
hexfld.long 0 " W41 "
tree.end

base ad:0x801221a8
tree "1CSR42"
group 0--3
line.long 0 "CSR42"
hexfld.long 0 " W42 "
tree.end

base ad:0x801221ac
tree "1CSR43"
group 0--3
line.long 0 "CSR43"
hexfld.long 0 " W43 "
tree.end

base ad:0x801221b0
tree "1CSR44"
group 0--3
line.long 0 "CSR44"
hexfld.long 0 " W44 "
tree.end

base ad:0x801221b4
tree "1CSR45"
group 0--3
line.long 0 "CSR45"
hexfld.long 0 " W45 "
tree.end

base ad:0x801221b8
tree "1CSR46"
group 0--3
line.long 0 "CSR46"
hexfld.long 0 " W46 "
tree.end

base ad:0x801221bc
tree "1CSR47"
group 0--3
line.long 0 "CSR47"
hexfld.long 0 " W47 "
tree.end

base ad:0x801221c0
tree "1CSR48"
group 0--3
line.long 0 "CSR48"
hexfld.long 0 " W48 "
tree.end

base ad:0x801221c4
tree "1CSR49"
group 0--3
line.long 0 "CSR49"
hexfld.long 0 " W49 "
tree.end

base ad:0x801221c8
tree "1CSR50"
group 0--3
line.long 0 "CSR50"
hexfld.long 0 " W50 "
tree.end

base ad:0x801221cc
tree "1CSR51"
group 0--3
line.long 0 "CSR51"
hexfld.long 0 " W51 "
tree.end

base ad:0x80122fe0
tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x80122fe4
tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80122fe8
tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80122fec
tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80122ff0
tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
tree.end

base ad:0x80122ff4
tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
tree.end

base ad:0x80122ff8
tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
tree.end

base ad:0x80122ffc
tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
tree.end

tree.end

tree.end

;==============================================================
tree "HSEM"
;==============================================================
base ad:0xa0000000
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PROT2 "  "0 ,1 "
tree.end

base ad:0xa0000004
tree "R0"
group 0--3
line.long 0 "R0"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000008
tree "R1"
group 0--3
line.long 0 "R1"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa000000c
tree "R2"
group 0--3
line.long 0 "R2"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000010
tree "R3"
group 0--3
line.long 0 "R3"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000014
tree "R4"
group 0--3
line.long 0 "R4"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000018
tree "R5"
group 0--3
line.long 0 "R5"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa000001c
tree "R6"
group 0--3
line.long 0 "R6"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000020
tree "R7"
group 0--3
line.long 0 "R7"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000024
tree "R8"
group 0--3
line.long 0 "R8"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000028
tree "R9"
group 0--3
line.long 0 "R9"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa000002c
tree "R10"
group 0--3
line.long 0 "R10"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000030
tree "R11"
group 0--3
line.long 0 "R11"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0000034
tree "R12"
group 0--3
line.long 0 "R12"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000038
tree "R13"
group 0--3
line.long 0 "R13"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa000003c
tree "R14"
group 0--3
line.long 0 "R14"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000040
tree "R15"
group 0--3
line.long 0 "R15"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000044
tree "R16"
group 0--3
line.long 0 "R16"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000048
tree "R17"
group 0--3
line.long 0 "R17"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa000004c
tree "R18"
group 0--3
line.long 0 "R18"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000050
tree "R19"
group 0--3
line.long 0 "R19"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000054
tree "R20"
group 0--3
line.long 0 "R20"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000058
tree "R21"
group 0--3
line.long 0 "R21"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa000005c
tree "R22"
group 0--3
line.long 0 "R22"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000060
tree "R23"
group 0--3
line.long 0 "R23"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000064
tree "R24"
group 0--3
line.long 0 "R24"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000068
tree "R25"
group 0--3
line.long 0 "R25"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa000006c
tree "R26"
group 0--3
line.long 0 "R26"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000070
tree "R27"
group 0--3
line.long 0 "R27"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000074
tree "R28"
group 0--3
line.long 0 "R28"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000078
tree "R29"
group 0--3
line.long 0 "R29"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa000007c
tree "R30"
group 0--3
line.long 0 "R30"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000080
tree "R31"
group 0--3
line.long 0 "R31"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24. " LOCK "  "0 ,1 "
tree.end

base ad:0xa0000090
tree "ICRALL"
wgroup 0--3
line.long 0 "ICRALL"
bitfld.long 0 0. " HSEMICALL0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICALL1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICALL2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICALL3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICALL4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICALL5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICALL6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICALL7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICALL8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICALL9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICALL10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICALL11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICALL12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICALL13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICALL14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICALL15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICALL16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICALL17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICALL18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICALL19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICALL20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICALL21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICALL22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICALL23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICALL24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICALL25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICALL26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICALL27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICALL28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICALL29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICALL30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICALL31 "  "0 ,1 "
tree.end

base ad:0xa00000a0
tree "IMSCA"
group 0--3
line.long 0 "IMSCA"
bitfld.long 0 0. " HSEMIMA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMA31 "  "0 ,1 "
tree.end

base ad:0xa00000a4
tree "RISA"
rgroup 0--3
line.long 0 "RISA"
bitfld.long 0 0. " HSEMRISA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISA31 "  "0 ,1 "
tree.end

base ad:0xa00000a8
tree "MISA"
rgroup 0--3
line.long 0 "MISA"
bitfld.long 0 0. " HSEMMISA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISA31 "  "0 ,1 "
tree.end

base ad:0xa00000ac
tree "ICRA"
wgroup 0--3
line.long 0 "ICRA"
bitfld.long 0 0. " HSEMICA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICA31 "  "0 ,1 "
tree.end

base ad:0xa00000b0
tree "IMSCB"
group 0--3
line.long 0 "IMSCB"
bitfld.long 0 0. " HSEMIMB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMB31 "  "0 ,1 "
tree.end

base ad:0xa00000b4
tree "RISB"
rgroup 0--3
line.long 0 "RISB"
bitfld.long 0 0. " HSEMRISB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISB31 "  "0 ,1 "
tree.end

base ad:0xa00000b8
tree "MISB"
rgroup 0--3
line.long 0 "MISB"
bitfld.long 0 0. " HSEMMISB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISB31 "  "0 ,1 "
tree.end

base ad:0xa00000bc
tree "ICRB"
wgroup 0--3
line.long 0 "ICRB"
bitfld.long 0 0. " HSEMICB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICB31 "  "0 ,1 "
tree.end

base ad:0xa00000c0
tree "IMSCC"
group 0--3
line.long 0 "IMSCC"
bitfld.long 0 0. " HSEMIMC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMC31 "  "0 ,1 "
tree.end

base ad:0xa00000c4
tree "RISC"
rgroup 0--3
line.long 0 "RISC"
bitfld.long 0 0. " HSEMRISC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISC31 "  "0 ,1 "
tree.end

base ad:0xa00000c8
tree "MISC"
rgroup 0--3
line.long 0 "MISC"
bitfld.long 0 0. " HSEMMISC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISC31 "  "0 ,1 "
tree.end

base ad:0xa00000cc
tree "ICRC"
wgroup 0--3
line.long 0 "ICRC"
bitfld.long 0 0. " HSEMICC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICC31 "  "0 ,1 "
tree.end

base ad:0xa00000d0
tree "IMSCD"
group 0--3
line.long 0 "IMSCD"
bitfld.long 0 0. " HSEMIMD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMD31 "  "0 ,1 "
tree.end

base ad:0xa00000d4
tree "RISD"
rgroup 0--3
line.long 0 "RISD"
bitfld.long 0 0. " HSEMRISD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISD31 "  "0 ,1 "
tree.end

base ad:0xa00000d8
tree "MISD"
rgroup 0--3
line.long 0 "MISD"
bitfld.long 0 0. " HSEMMISD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISD31 "  "0 ,1 "
tree.end

base ad:0xa00000dc
tree "ICRD"
wgroup 0--3
line.long 0 "ICRD"
bitfld.long 0 0. " HSEMICD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMID20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICD31 "  "0 ,1 "
tree.end

base ad:0xa00000e0
tree "IMSCE"
group 0--3
line.long 0 "IMSCE"
bitfld.long 0 0. " HSEMIME0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIME1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIME2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIME3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIME4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIME5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIME6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIME7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIME8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIME9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIME10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIME11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIME12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIME13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIME14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIME15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIME16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIME17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIME18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIME19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIME20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIME21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIME22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIME23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIME24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIME25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIME26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIME27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIME28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIME29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIME30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIME31 "  "0 ,1 "
tree.end

base ad:0xa00000e4
tree "RISE"
rgroup 0--3
line.long 0 "RISE"
bitfld.long 0 0. " HSEMRISE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISE31 "  "0 ,1 "
tree.end

base ad:0xa00000e8
tree "MISE"
rgroup 0--3
line.long 0 "MISE"
bitfld.long 0 0. " HSEMMISE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISE31 "  "0 ,1 "
tree.end

base ad:0xa00000ec
tree "ICRE"
wgroup 0--3
line.long 0 "ICRE"
bitfld.long 0 0. " HSEMICE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICE31 "  "0 ,1 "
tree.end

base ad:0xa0000100
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0xa0000108
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " HSEMINTRA "  "0 ,1 "
bitfld.long 0 1. " HSEMINTRB "  "0 ,1 "
bitfld.long 0 2. " HSEMINTRC "  "0 ,1 "
bitfld.long 0 3. " HSEMINTRD "  "0 ,1 "
bitfld.long 0 4. " HSEMINTRE "  "0 ,1 "
tree.end

base ad:0xa0000fe0
tree "HSEMPeriphID0"
rgroup 0--3
line.long 0 "HSEMPeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0xa0000fe4
tree "HSEMPeriphID1"
rgroup 0--3
line.long 0 "HSEMPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0000fe8
tree "HSEMPeriphID2"
rgroup 0--3
line.long 0 "HSEMPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0000fec
tree "HSEMPeriphID3"
rgroup 0--3
line.long 0 "HSEMPeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0xa0000ff0
tree "HSEMPCellID0"
rgroup 0--3
line.long 0 "HSEMPCellID0"
hexfld.byte 0 " HSEMPCellID0 "
tree.end

base ad:0xa0000ff4
tree "HSEMPCellID1"
rgroup 0--3
line.long 0 "HSEMPCellID1"
hexfld.byte 0 " HSEMPCellID1 "
tree.end

base ad:0xa0000ff8
tree "HSEMPCellID2"
rgroup 0--3
line.long 0 "HSEMPCellID2"
hexfld.byte 0 " HSEMPCellID2 "
tree.end

base ad:0xa0000ffc
tree "HSEMPCellID3"
rgroup 0--3
line.long 0 "HSEMPCellID3"
hexfld.byte 0 " HSEMPCellID3 "
tree.end

tree.end

;==============================================================
tree "HSI2C (3 instances)"
;==============================================================
base ad:0xa0024000
;********************************************
tree "HSI2C-1"
;********************************************
base ad:0xa0024000
tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " FS "  "0 ,1 "
tree.end

base ad:0xa0024004
tree "1SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " SLSU "
tree.end

base ad:0xa0024008
tree "1HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa002400c
tree "1MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
tree.end

base ad:0xa0024010
tree "1TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
tree.end

base ad:0xa0024014
tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
tree.end

base ad:0xa0024018
tree "1RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
tree.end

base ad:0xa002401c
tree "1TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0024020
tree "1RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0024024
tree "1DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
tree.end

base ad:0xa0024028
tree "1BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 2 " BRCNT1 "
tree.end

base ad:0xa002402c
tree "1IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
tree.end

base ad:0xa0024030
tree "1RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
tree.end

base ad:0xa0024034
tree "1MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
tree.end

base ad:0xa0024038
tree "1ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
tree.end

base ad:0xa002403c
tree "1I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
tree.end

base ad:0xa0024040
tree "1I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
tree.end

base ad:0xa0024044
tree "1I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
tree.end

base ad:0xa0024048
tree "1I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
tree.end

base ad:0xa002404c
tree "1I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
tree.end

base ad:0xa0024050
tree "1I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base ad:0xa0024054
tree "1I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base ad:0xa0024058
tree "1I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base ad:0xa002405c
tree "1I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base ad:0xa0024fe0
tree "1PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0xa0024fe4
tree "1PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0024fe8
tree "1PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0024fec
tree "1PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0xa0024ff0
tree "1PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
tree.end

base ad:0xa0024ff4
tree "1PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
tree.end

base ad:0xa0024ff8
tree "1PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
tree.end

base ad:0xa0024ffc
tree "1PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
tree.end

tree.end

base ad:0x8010a000
;********************************************
tree "HSI2C-2"
;********************************************
base ad:0x8010a000
tree "2CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " FS "  "0 ,1 "
tree.end

base ad:0x8010a004
tree "2SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " SLSU "
tree.end

base ad:0x8010a008
tree "2HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8010a00c
tree "2MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
tree.end

base ad:0x8010a010
tree "2TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
tree.end

base ad:0x8010a014
tree "2SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
tree.end

base ad:0x8010a018
tree "2RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
tree.end

base ad:0x8010a01c
tree "2TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8010a020
tree "2RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8010a024
tree "2DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
tree.end

base ad:0x8010a028
tree "2BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 2 " BRCNT1 "
tree.end

base ad:0x8010a02c
tree "2IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
tree.end

base ad:0x8010a030
tree "2RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
tree.end

base ad:0x8010a034
tree "2MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
tree.end

base ad:0x8010a038
tree "2ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
tree.end

base ad:0x8010a03c
tree "2I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
tree.end

base ad:0x8010a040
tree "2I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
tree.end

base ad:0x8010a044
tree "2I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
tree.end

base ad:0x8010a048
tree "2I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
tree.end

base ad:0x8010a04c
tree "2I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
tree.end

base ad:0x8010a050
tree "2I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base ad:0x8010a054
tree "2I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base ad:0x8010a058
tree "2I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base ad:0x8010a05c
tree "2I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base ad:0x8010afe0
tree "2PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0x8010afe4
tree "2PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8010afe8
tree "2PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8010afec
tree "2PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x8010aff0
tree "2PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
tree.end

base ad:0x8010aff4
tree "2PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
tree.end

base ad:0x8010aff8
tree "2PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
tree.end

base ad:0x8010affc
tree "2PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
tree.end

tree.end

base ad:0x8010b000
;********************************************
tree "HSI2C-3"
;********************************************
base ad:0x8010b000
tree "3CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " FS "  "0 ,1 "
tree.end

base ad:0x8010b004
tree "3SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " SLSU "
tree.end

base ad:0x8010b008
tree "3HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8010b00c
tree "3MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
tree.end

base ad:0x8010b010
tree "3TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
tree.end

base ad:0x8010b014
tree "3SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
tree.end

base ad:0x8010b018
tree "3RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
tree.end

base ad:0x8010b01c
tree "3TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8010b020
tree "3RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8010b024
tree "3DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
tree.end

base ad:0x8010b028
tree "3BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 2 " BRCNT1 "
tree.end

base ad:0x8010b02c
tree "3IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
tree.end

base ad:0x8010b030
tree "3RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
tree.end

base ad:0x8010b034
tree "3MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
tree.end

base ad:0x8010b038
tree "3ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
tree.end

base ad:0x8010b03c
tree "3I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
tree.end

base ad:0x8010b040
tree "3I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
tree.end

base ad:0x8010b044
tree "3I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
tree.end

base ad:0x8010b048
tree "3I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
tree.end

base ad:0x8010b04c
tree "3I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
tree.end

base ad:0x8010b050
tree "3I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base ad:0x8010b054
tree "3I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base ad:0x8010b058
tree "3I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base ad:0x8010b05c
tree "3I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base ad:0x8010bfe0
tree "3PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0x8010bfe4
tree "3PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8010bfe8
tree "3PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8010bfec
tree "3PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x8010bff0
tree "3PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
tree.end

base ad:0x8010bff4
tree "3PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
tree.end

base ad:0x8010bff8
tree "3PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
tree.end

base ad:0x8010bffc
tree "3PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
tree.end

tree.end

tree.end

;==============================================================
tree "HSI2CMODEM"
;==============================================================
base ad:0xb7e02000
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xb7e02004
tree "SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " SLSU "
tree.end

base ad:0xb7e02008
tree "HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xb7e0200c
tree "MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
tree.end

base ad:0xb7e02010
tree "TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
tree.end

base ad:0xb7e02014
tree "SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
tree.end

base ad:0xb7e02018
tree "RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
tree.end

base ad:0xb7e0201c
tree "TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xb7e02020
tree "RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xb7e02024
tree "DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
tree.end

base ad:0xb7e02028
tree "BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 2 " BRCNT1 "
tree.end

base ad:0xb7e0202c
tree "IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
tree.end

base ad:0xb7e02030
tree "RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
tree.end

base ad:0xb7e02034
tree "MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
tree.end

base ad:0xb7e02038
tree "ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
tree.end

base ad:0xb7e0203c
tree "I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
tree.end

base ad:0xb7e02040
tree "I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
tree.end

base ad:0xb7e02044
tree "I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
tree.end

base ad:0xb7e02fe0
tree "PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0xb7e02fe4
tree "PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xb7e02fe8
tree "PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xb7e02fec
tree "PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0xb7e02ff0
tree "PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
tree.end

base ad:0xb7e02ff4
tree "PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
tree.end

base ad:0xb7e02ff8
tree "PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
tree.end

base ad:0xb7e02ffc
tree "PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
tree.end

tree.end

;==============================================================
tree "HVA"
;==============================================================
base ad:0x80200000
tree "HVA_NT3_REG_INIT_PRIORITY0"
group 0--3
line.long 0 "HVA_NT3_REG_INIT_PRIORITY0"
bitfld.long 0 0.--4. " PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_RULE "  "0 ,1 "
tree.end

base ad:0x80200004
tree "HVA_NT3_REG_INIT_PRIORITY1"
group 0--3
line.long 0 "HVA_NT3_REG_INIT_PRIORITY1"
bitfld.long 0 0.--4. " PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_RULE "  "0 ,1 "
tree.end

base ad:0x80200008
tree "HVA_NT3_REG_INIT_PRIORITY2"
group 0--3
line.long 0 "HVA_NT3_REG_INIT_PRIORITY2"
bitfld.long 0 0.--4. " PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_RULE "  "0 ,1 "
tree.end

base ad:0x80200024
tree "HVA_NT3_REG_INIT_LIMIT0"
group 0--3
line.long 0 "HVA_NT3_REG_INIT_LIMIT0"
bitfld.long 0 0.--3. " NEW_PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FRAME_SIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x80200028
tree "HVA_NT3_REG_INIT_LIMIT1"
group 0--3
line.long 0 "HVA_NT3_REG_INIT_LIMIT1"
bitfld.long 0 0.--3. " NEW_PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FRAME_SIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8020002c
tree "HVA_NT3_REG_INIT_LIMIT2"
group 0--3
line.long 0 "HVA_NT3_REG_INIT_LIMIT2"
bitfld.long 0 0.--3. " NEW_PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FRAME_SIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x80200030
tree "HVA_NT3_REG_TARG_PRIORITY"
group 0--3
line.long 0 "HVA_NT3_REG_TARG_PRIORITY"
bitfld.long 0 0.--3. " PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80200100
tree "HVA_HIF_REG_RST"
group 0--3
line.long 0 "HVA_HIF_REG_RST"
bitfld.long 0 0. " RST_0 "  "0 ,1 "
bitfld.long 0 1. " RST_1 "  "0 ,1 "
tree.end

base ad:0x80200104
tree "HVA_HIF_REG_RST_ACK"
rgroup 0--3
line.long 0 "HVA_HIF_REG_RST_ACK"
bitfld.long 0 0. " ACK "  "0 ,1 "
tree.end

base ad:0x80200108
tree "HVA_HIF_REG_MIF_CFG"
group 0--3
line.long 0 "HVA_HIF_REG_MIF_CFG"
bitfld.long 0 0.--2. " OPC_SIZE_LMI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " CHK_SIZE_LMI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--8. " MSG_SIZE_LMI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9.--12. " PAGE_SIZE_LMI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--18. " OPC_SIZE_EMI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--21. " CHK_SIZE_EMI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 22.--24. " MSG_SIZE_EMI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 25.--28. " PAGE_SIZE_EMI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8020010c
tree "HVA_HIF_REG_HEC_MIF_CFG"
group 0--3
line.long 0 "HVA_HIF_REG_HEC_MIF_CFG"
bitfld.long 0 0.--2. " OPC_SIZE_HED "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " CHK_SIZE_HED "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--8. " MSG_SIZE_HED "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9.--18. " BWL_WRITE "  " "
bitfld.long 0 19.--28. " BWL_READ "  " "
tree.end

base ad:0x80200110
tree "HVA_HIF_REG_CFL"
rgroup 0--3
line.long 0 "HVA_HIF_REG_CFL"
bitfld.long 0 0.--3. " LEVEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80200114
tree "HVA_HIF_FIFO_CMD"
wgroup 0--3
line.long 0 "HVA_HIF_FIFO_CMD"
hexfld.long 0 " CMD "
tree.end

base ad:0x80200118
tree "HVA_HIF_FIFO_STS"
group 0--3
line.long 0 "HVA_HIF_FIFO_STS"
hexfld.long 0 " STATUS "
tree.end

base ad:0x8020011c
tree "HVA_HIF_REG_SFL"
rgroup 0--3
line.long 0 "HVA_HIF_REG_SFL"
bitfld.long 0 0.--3. " LEVEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80200120
tree "HVA_HIF_REG_IT_ACK"
wgroup 0--3
line.long 0 "HVA_HIF_REG_IT_ACK"
bitfld.long 0 0. " ACK "  "0 ,1 "
tree.end

base ad:0x80200124
tree "HVA_HIF_REG_ERR_IT_ACK"
wgroup 0--3
line.long 0 "HVA_HIF_REG_ERR_IT_ACK"
bitfld.long 0 0. " ACK "  "0 ,1 "
tree.end

base ad:0x80200128
tree "HVA_HIF_REG_LMI_ERR"
rgroup 0--3
line.long 0 "HVA_HIF_REG_LMI_ERR"
bitfld.long 0 0.--1. " OPCODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--6. " SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8020012c
tree "HVA_HIF_REG_EMI_ERR"
rgroup 0--3
line.long 0 "HVA_HIF_REG_EMI_ERR"
bitfld.long 0 0.--1. " OPCODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--6. " SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x80200130
tree "HVA_HIF_REG_HEC_MIF_ERR"
rgroup 0--3
line.long 0 "HVA_HIF_REG_HEC_MIF_ERR"
bitfld.long 0 0. " READ_ERROR "  "0 ,1 "
bitfld.long 0 1. " WRITE_ERROR "  "0 ,1 "
tree.end

base ad:0x80200134
tree "HVA_HIF_REG_HEC_STS"
group 0--3
line.long 0 "HVA_HIF_REG_HEC_STS"
bitfld.long 0 0. " HEC_ACT "  "0 ,1 "
hexfld.byte 1 " HEC_CID "
hexfld.word 2 " HEC_TID "
tree.end

base ad:0x80200138
tree "HVA_HIF_REG_HVC_STS"
group 0--3
line.long 0 "HVA_HIF_REG_HVC_STS"
bitfld.long 0 0. " HVC_ACT "  "0 ,1 "
hexfld.byte 1 " HVC_CID "
hexfld.word 2 " HVC_TID "
tree.end

base ad:0x8020013c
tree "HVA_HIF_REG_HJE_STS"
group 0--3
line.long 0 "HVA_HIF_REG_HJE_STS"
bitfld.long 0 0. " HJE_ACT "  "0 ,1 "
hexfld.byte 1 " HJE_CID "
hexfld.word 2 " HJE_TID "
tree.end

base ad:0x80200140
tree "HVA_HIF_REG_CNT"
group 0--3
line.long 0 "HVA_HIF_REG_CNT"
hexfld.long 0 " COUNTER "
tree.end

base ad:0x80200144
tree "HVA_HIF_REG_HEC_CHKSYN_DIS"
group 0--3
line.long 0 "HVA_HIF_REG_HEC_CHKSYN_DIS"
bitfld.long 0 0.--16. " CHKSYN_DIS "  " "
tree.end

base ad:0x80200148
tree "HVA_HIF_REG_CLK_GATING"
group 0--3
line.long 0 "HVA_HIF_REG_CLK_GATING"
bitfld.long 0 0. " HVC_CLK_EN "  "0 ,1 "
bitfld.long 0 1. " HEC_CLK_EN "  "0 ,1 "
bitfld.long 0 2. " HJE_CLK_EN "  "0 ,1 "
tree.end

base ad:0x8020014c
tree "HVA_HIF_REG_VERSION"
rgroup 0--3
line.long 0 "HVA_HIF_REG_VERSION"
hexfld.long 0 " VERSION "
tree.end

tree.end

;==============================================================
tree "ICN"
;==============================================================
base ad:0xa0040000
tree "NODE_HIBW1_ESRAM_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0040004
tree "NODE_HIBW1_ESRAM_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0040018
tree "NODE_HIBW1_ESRAM_IN_0_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa004001c
tree "NODE_HIBW1_ESRAM_IN_0_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040020
tree "NODE_HIBW1_ESRAM_IN_0_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040024
tree "NODE_HIBW1_ESRAM_IN_1_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040028
tree "NODE_HIBW1_ESRAM_IN_1_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa004002c
tree "NODE_HIBW1_ESRAM_IN_1_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040400
tree "NODE_HIBW1_DDR_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0040404
tree "NODE_HIBW1_DDR_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0040408
tree "NODE_HIBW1_DDR_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0040424
tree "NODE_HIBW1_DDR_IN_0_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040428
tree "NODE_HIBW1_DDR_IN_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa004042c
tree "NODE_HIBW1_DDR_IN_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040430
tree "NODE_HIBW1_DDR_OUT_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040800
tree "NODE_HIBW2_ESRAM_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0040804
tree "NODE_HIBW2_ESRAM_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0040818
tree "NODE_HIBW2_ESRAM_IN_0_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa004081c
tree "NODE_HIBW2_ESRAM_IN_0_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040820
tree "NODE_HIBW2_ESRAM_IN_0_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040824
tree "NODE_HIBW2_ESRAM_IN_1_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040828
tree "NODE_HIBW2_ESRAM_IN_1_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa004082c
tree "NODE_HIBW2_ESRAM_IN_1_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040c00
tree "NODE_HIBW2_DDR_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0040c04
tree "NODE_HIBW2_DDR_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0040c08
tree "NODE_HIBW2_DDR_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0040c0c
tree "NODE_HIBW2_DDR_IN_3_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_3_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0040c30
tree "NODE_HIBW2_DDR_IN_0_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040c34
tree "NODE_HIBW2_DDR_IN_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040c38
tree "NODE_HIBW2_DDR_IN_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040c3c
tree "NODE_HIBW2_DDR_IN_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0040c40
tree "NODE_HIBW2_DDR_OUT_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0041000
tree "NODE_ESRAM0_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0041004
tree "NODE_ESRAM0_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0041008
tree "NODE_ESRAM0_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0041024
tree "NODE_ESRAM0_IN_0_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0041028
tree "NODE_ESRAM0_IN_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa004102c
tree "NODE_ESRAM0_IN_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0041030
tree "NODE_ESRAM0_OUT_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM0_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0041400
tree "NODE_ESRAM1_2_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0041404
tree "NODE_ESRAM1_2_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0041408
tree "NODE_ESRAM1_2_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0041424
tree "NODE_ESRAM1_2_IN_0_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0041428
tree "NODE_ESRAM1_2_IN_1_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa004142c
tree "NODE_ESRAM1_2_IN_2_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_2_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0041430
tree "NODE_ESRAM1_2_OUT_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0041800
tree "NODE_ESRAM3_4_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0041804
tree "NODE_ESRAM3_4_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0041808
tree "NODE_ESRAM3_4_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
tree.end

base ad:0xa0041824
tree "NODE_ESRAM3_4_IN_0_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0041828
tree "NODE_ESRAM3_4_IN_1_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa004182c
tree "NODE_ESRAM3_4_IN_2_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_2_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE1 "  " "
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0041830
tree "NODE_ESRAM3_4_OUT_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

tree.end

;==============================================================
tree "ICN_PMU"
;==============================================================
base ad:0x8015be00
tree "PMU_DFV0"
group 0--3
line.long 0 "PMU_DFV0"
bitfld.long 0 0. " DFV0 "  "0 ,1 "
tree.end

base ad:0x8015be08
tree "STOP_TRAFFIC"
rgroup 0--3
line.long 0 "STOP_TRAFFIC"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015be10
tree "STOP_TRAFFIC_CLR"
wgroup 0--3
line.long 0 "STOP_TRAFFIC_CLR"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015be18
tree "STOP_TRAFFIC_SET"
wgroup 0--3
line.long 0 "STOP_TRAFFIC_SET"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015be20
tree "CHANNEL_CLOSED_STA"
rgroup 0--3
line.long 0 "CHANNEL_CLOSED_STA"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015be28
tree "CHANNEL_CLOSED_ITS"
rgroup 0--3
line.long 0 "CHANNEL_CLOSED_ITS"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015be30
tree "CHANNEL_CLOSED_ITS_CLR"
wgroup 0--3
line.long 0 "CHANNEL_CLOSED_ITS_CLR"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015be38
tree "CHANNEL_CLOSED_ITS_SET"
wgroup 0--3
line.long 0 "CHANNEL_CLOSED_ITS_SET"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015be40
tree "CHANNEL_CLOSED_ITM"
rgroup 0--3
line.long 0 "CHANNEL_CLOSED_ITM"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015be48
tree "CHANNEL_CLOSED_ITM_CLR"
wgroup 0--3
line.long 0 "CHANNEL_CLOSED_ITM_CLR"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015be50
tree "CHANNEL_CLOSED_ITM_SET"
wgroup 0--3
line.long 0 "CHANNEL_CLOSED_ITM_SET"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015be58
tree "AUTO_PD_PROC"
rgroup 0--3
line.long 0 "AUTO_PD_PROC"
tree.end

base ad:0x8015be60
tree "AUTO_PD_PROC_CLR"
rgroup 0--3
line.long 0 "AUTO_PD_PROC_CLR"
tree.end

base ad:0x8015be68
tree "AUTO_PD_PROC_SET"
rgroup 0--3
line.long 0 "AUTO_PD_PROC_SET"
tree.end

base ad:0x8015be70
tree "GATE"
rgroup 0--3
line.long 0 "GATE"
tree.end

base ad:0x8015be80
tree "GATE_SET"
rgroup 0--3
line.long 0 "GATE_SET"
tree.end

base ad:0x8015be88
tree "TARGET_READY_STA"
rgroup 0--3
line.long 0 "TARGET_READY_STA"
tree.end

base ad:0x8015be90
tree "TARGET_READY_ITS"
rgroup 0--3
line.long 0 "TARGET_READY_ITS"
tree.end

base ad:0x8015be98
tree "TARGET_READY_ITS_CLR"
rgroup 0--3
line.long 0 "TARGET_READY_ITS_CLR"
tree.end

base ad:0x8015bea0
tree "TARGET_READY_ITS_SET"
rgroup 0--3
line.long 0 "TARGET_READY_ITS_SET"
tree.end

base ad:0x8015bea8
tree "TARGET_READY_ITM"
rgroup 0--3
line.long 0 "TARGET_READY_ITM"
tree.end

base ad:0x8015beb0
tree "TARGET_READY_ITM_CLR"
rgroup 0--3
line.long 0 "TARGET_READY_ITM_CLR"
tree.end

base ad:0x8015beb8
tree "TARGET_READY_ITM_SET"
rgroup 0--3
line.long 0 "TARGET_READY_ITM_SET"
tree.end

base ad:0x8015bec0
tree "AUTO_WU_PROC"
rgroup 0--3
line.long 0 "AUTO_WU_PROC"
tree.end

base ad:0x8015bec8
tree "AUTO_WU_PROC_CLR"
rgroup 0--3
line.long 0 "AUTO_WU_PROC_CLR"
tree.end

base ad:0x8015bed0
tree "AUTO_WU_PROC_SET"
rgroup 0--3
line.long 0 "AUTO_WU_PROC_SET"
tree.end

base ad:0x8015bed8
tree "INTERRUPT_MODE"
group 0--3
line.long 0 "INTERRUPT_MODE"
bitfld.long 0 0. " MODE "  "0 ,1 "
tree.end

base ad:0x8015bee0
tree "EXTERNAL_INTERRUPT_STA"
rgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_STA"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015bee8
tree "EXTERNAL_INTERRUPT_ITS"
rgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_ITS"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015bef0
tree "EXTERNAL_INTERRUPT_ITS_CLR"
wgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_ITS_CLR"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015bef8
tree "EXTERNAL_INTERRUPT_ITS_SET"
wgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_ITS_SET"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015bf00
tree "EXTERNAL_INTERRUPT_ITM"
rgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_ITM"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015bf08
tree "EXTERNAL_INTERRUPT_ITM_CLR"
wgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_ITM_CLR"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015bf10
tree "EXTERNAL_INTERRUPT_ITM_SET"
wgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_ITM_SET"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

base ad:0x8015bf18
tree "USER_CTRL_ERROR_MODE"
group 0--3
line.long 0 "USER_CTRL_ERROR_MODE"
bitfld.long 0 0. " DDR_HIBW1 "  "0 ,1 "
bitfld.long 0 1. " DDR_HIBW2 "  "0 ,1 "
bitfld.long 0 2. " SGA_S "  "0 ,1 "
bitfld.long 0 3. " SIA_S "  "0 ,1 "
bitfld.long 0 4. " DISP_S "  "0 ,1 "
bitfld.long 0 5. " SVA_S "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "IRDA"
;==============================================================
base ad:0x8010d000
tree "ID"
rgroup 0--3
line.long 0 "ID"
bitfld.long 0 0.--3. " Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--9. " H "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--17. " PRODUCTID "  " "
bitfld.long 0 18.--31. " PROVIDERID "  " "
tree.end

base ad:0x8010d004
tree "SIP"
group 0--3
line.long 0 "SIP"
bitfld.long 0 0. " SIPENMODE "  "0 ,1 "
bitfld.long 0 1. " SIPEN "  "0 ,1 "
bitfld.long 0 2. " SIPENAUTO "  "0 ,1 "
bitfld.long 0 3. " SIPENMAN "  "0 ,1 "
bitfld.long 0 4.--28. " COUNT_SIP_AUTO "  " "
tree.end

base ad:0x8010d008
tree "SIP_PULSE"
group 0--3
line.long 0 "SIP_PULSE"
bitfld.long 0 0.--6. " SIPON "  " "
bitfld.long 0 7.--15. " SIPOFF "  " "
tree.end

base ad:0x8010d00c
tree "RATV_SIP"
group 0--3
line.long 0 "RATV_SIP"
bitfld.long 0 0.--17. " RATV_SIP "  " "
tree.end

base ad:0x8010d010
tree "CON"
group 0--3
line.long 0 "CON"
bitfld.long 0 0. " RUN "  "0 ,1 "
tree.end

base ad:0x8010d014
tree "CONF"
group 0--3
line.long 0 "CONF"
bitfld.long 0 0.--12. " RATV "  " "
bitfld.long 0 16.--18. " BS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19. " POLRX "  "0 ,1 "
bitfld.long 0 20. " POLTX "  "0 ,1 "
bitfld.long 0 21. " MULEN "  "0 ,1 "
bitfld.long 0 22. " NO_FII_BOF "  "0 ,1 "
tree.end

base ad:0x8010d018
tree "PARA"
group 0--3
line.long 0 "PARA"
bitfld.long 0 0.--1. " MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--7. " ABF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--27. " MNRB "  " "
tree.end

base ad:0x8010d01c
tree "DV"
group 0--3
line.long 0 "DV"
hexfld.byte 0 " N "
hexfld.byte 1 " INC "
bitfld.long 0 16.--26. " DEC "  " "
tree.end

base ad:0x8010d020
tree "STAT"
rgroup 0--3
line.long 0 "STAT"
bitfld.long 0 0. " RXS "  "0 ,1 "
bitfld.long 0 1. " TXS "  "0 ,1 "
bitfld.long 0 2. " FIFOFULL "  "0 ,1 "
bitfld.long 0 3. " FIFOEMPTY "  "0 ,1 "
tree.end

base ad:0x8010d024
tree "TFS"
wgroup 0--3
line.long 0 "TFS"
bitfld.long 0 0.--11. " TFS "  " "
tree.end

base ad:0x8010d028
tree "RFS"
rgroup 0--3
line.long 0 "RFS"
bitfld.long 0 0.--11. " RFS "  " "
bitfld.long 0 16.--27. " SHADOWRFS "  " "
tree.end

base ad:0x8010d02c
tree "TXB"
wgroup 0--3
line.long 0 "TXB"
hexfld.long 0 " TXD "
tree.end

base ad:0x8010d030
tree "RXB"
rgroup 0--3
line.long 0 "RXB"
hexfld.long 0 " RXD "
tree.end

base ad:0x8010d0e8
tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " LSREQ "  "0 ,1 "
bitfld.long 0 1. " SREQ "  "0 ,1 "
bitfld.long 0 2. " LBREQ "  "0 ,1 "
bitfld.long 0 3. " BREQ "  "0 ,1 "
bitfld.long 0 4. " FT "  "0 ,1 "
bitfld.long 0 5. " SD "  "0 ,1 "
bitfld.long 0 6. " FI "  "0 ,1 "
bitfld.long 0 7. " FD "  "0 ,1 "
bitfld.long 0 8. " LB "  "0 ,1 "
tree.end

base ad:0x8010d0ec
tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " LSREQ "  "0 ,1 "
bitfld.long 0 1. " SREQ "  "0 ,1 "
bitfld.long 0 2. " LBREQ "  "0 ,1 "
bitfld.long 0 3. " BREQ "  "0 ,1 "
bitfld.long 0 4. " FT "  "0 ,1 "
bitfld.long 0 5. " SD "  "0 ,1 "
bitfld.long 0 6. " FI "  "0 ,1 "
bitfld.long 0 7. " FD "  "0 ,1 "
bitfld.long 0 8. " LB "  "0 ,1 "
tree.end

base ad:0x8010d0f0
tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " LSREQ "  "0 ,1 "
bitfld.long 0 1. " SREQ "  "0 ,1 "
bitfld.long 0 2. " LBREQ "  "0 ,1 "
bitfld.long 0 3. " BREQ "  "0 ,1 "
bitfld.long 0 4. " FT "  "0 ,1 "
bitfld.long 0 5. " SD "  "0 ,1 "
bitfld.long 0 6. " FI "  "0 ,1 "
bitfld.long 0 7. " FD "  "0 ,1 "
bitfld.long 0 8. " LB "  "0 ,1 "
tree.end

base ad:0x8010d0f4
tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " LSREQ "  "0 ,1 "
bitfld.long 0 1. " SREQ "  "0 ,1 "
bitfld.long 0 2. " LBREQ "  "0 ,1 "
bitfld.long 0 3. " BREQ "  "0 ,1 "
bitfld.long 0 4. " FT "  "0 ,1 "
bitfld.long 0 5. " SD "  "0 ,1 "
bitfld.long 0 6. " FI "  "0 ,1 "
bitfld.long 0 7. " FD "  "0 ,1 "
bitfld.long 0 8. " LB "  "0 ,1 "
tree.end

base ad:0x8010d0f8
tree "ISR"
wgroup 0--3
line.long 0 "ISR"
bitfld.long 0 0. " LSREQ "  "0 ,1 "
bitfld.long 0 1. " SREQ "  "0 ,1 "
bitfld.long 0 2. " LBREQ "  "0 ,1 "
bitfld.long 0 3. " BREQ "  "0 ,1 "
bitfld.long 0 4. " FT "  "0 ,1 "
bitfld.long 0 5. " SD "  "0 ,1 "
bitfld.long 0 6. " FI "  "0 ,1 "
bitfld.long 0 7. " FD "  "0 ,1 "
bitfld.long 0 8. " LB "  "0 ,1 "
tree.end

base ad:0x8010d0fc
tree "DMA"
group 0--3
line.long 0 "DMA"
bitfld.long 0 0. " LSREQEN "  "0 ,1 "
bitfld.long 0 1. " SREQEN "  "0 ,1 "
bitfld.long 0 2. " LBREQEN "  "0 ,1 "
bitfld.long 0 3. " BREQEN "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "IRRC"
;==============================================================
base ad:0x80110000
tree "VERSION"
rgroup 0--3
line.long 0 "VERSION"
hexfld.byte 0 " VERSION "
tree.end

base ad:0x80110004
tree "MODE"
group 0--3
line.long 0 "MODE"
bitfld.long 0 0. " CLKRQMODE "  "0 ,1 "
bitfld.long 0 1. " CLKRQ "  "0 ,1 "
bitfld.long 0 2. " CLKRQSTAT "  "0 ,1 "
bitfld.long 0 3. " IFCLKRQ "  "0 ,1 "
bitfld.long 0 4. " IFCLKRQSTAT "  "0 ,1 "
bitfld.long 0 5. " EN "  "0 ,1 "
tree.end

base ad:0x80110008
tree "DMA"
group 0--3
line.long 0 "DMA"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 1.--5. " REQLVL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x8011000c
tree "FIFO_STAT"
group 0--3
line.long 0 "FIFO_STAT"
bitfld.long 0 0.--4. " FIFOLEVEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " FIFOFLUSH "  "0 ,1 "
tree.end

base ad:0x80110010
tree "MOD_INST"
wgroup 0--3
line.long 0 "MOD_INST"
bitfld.long 0 0.--17. " INSTPERIOD "  " "
bitfld.long 0 29. " OUTPUTSELECT "  "0 ,1 "
bitfld.long 0 30. " OUTPUTSTATE "  "0 ,1 "
bitfld.long 0 31. " INSTVALID "  "0 ,1 "
tree.end

base ad:0x80110014
tree "CCLK_HT"
group 0--3
line.long 0 "CCLK_HT"
bitfld.long 0 0.--9. " CCLKHIGHTIME "  " "
tree.end

base ad:0x80110018
tree "CCLK_LT"
group 0--3
line.long 0 "CCLK_LT"
bitfld.long 0 0.--9. " CCLKLOWTIME "  " "
tree.end

base ad:0x8011001c
tree "BCLK_DIV"
group 0--3
line.long 0 "BCLK_DIV"
hexfld.word 0 " BITDIVIDE "
tree.end

base ad:0x80110020
tree "OUTPUT_INVERT"
group 0--3
line.long 0 "OUTPUT_INVERT"
bitfld.long 0 0. " OUTPUTINVERT "  "0 ,1 "
tree.end

base ad:0x80110024
tree "W_STAT"
rgroup 0--3
line.long 0 "W_STAT"
bitfld.long 0 0. " CCLKHTW "  "0 ,1 "
bitfld.long 0 1. " CCLKITW "  "0 ,1 "
bitfld.long 0 2. " BCLKDIVW "  "0 ,1 "
bitfld.long 0 3. " OUTPUTINVERTW "  "0 ,1 "
bitfld.long 0 4. " SWTSTW "  "0 ,1 "
tree.end

base ad:0x80110028
tree "IRQ_STAT"
rgroup 0--3
line.long 0 "IRQ_STAT"
bitfld.long 0 0. " SFRAMEEND "  "0 ,1 "
bitfld.long 0 1. " SFIFOFULL "  "0 ,1 "
bitfld.long 0 2. " SUNDERFLOW "  "0 ,1 "
bitfld.long 0 3. " SFIFOEMPTY "  "0 ,1 "
bitfld.long 0 4. " SFIFOHLFEMPTY "  "0 ,1 "
tree.end

base ad:0x8011002c
tree "IRQ_RAW_STAT"
rgroup 0--3
line.long 0 "IRQ_RAW_STAT"
bitfld.long 0 0. " RFRAMEEND "  "0 ,1 "
bitfld.long 0 1. " RFIFOFULL "  "0 ,1 "
bitfld.long 0 2. " RUNDERFLOW "  "0 ,1 "
bitfld.long 0 3. " RFIFOEMPTY "  "0 ,1 "
bitfld.long 0 4. " RFIFOHLFEMPTY "  "0 ,1 "
tree.end

base ad:0x80110030
tree "IRQ_EN_STAT"
rgroup 0--3
line.long 0 "IRQ_EN_STAT"
bitfld.long 0 0. " ESFRAMEEND "  "0 ,1 "
bitfld.long 0 1. " ESFIFOFULL "  "0 ,1 "
bitfld.long 0 2. " ESUNDERFLOW "  "0 ,1 "
bitfld.long 0 3. " ESFIFOEMPTY "  "0 ,1 "
bitfld.long 0 4. " ESFIFOHLFEMPTY "  "0 ,1 "
tree.end

base ad:0x80110034
tree "IRQ_EN"
wgroup 0--3
line.long 0 "IRQ_EN"
bitfld.long 0 0. " ONFRAMEND "  "0 ,1 "
bitfld.long 0 1. " ONFIFOFULL "  "0 ,1 "
bitfld.long 0 2. " ONUNDERFLOW "  "0 ,1 "
bitfld.long 0 3. " ONFIFOEMPTY "  "0 ,1 "
bitfld.long 0 4. " ONFIFOHLFEMPTY "  "0 ,1 "
tree.end

base ad:0x80110038
tree "IRQ_DISEN"
wgroup 0--3
line.long 0 "IRQ_DISEN"
bitfld.long 0 0. " OFFFRAMEEND "  "0 ,1 "
bitfld.long 0 1. " OFFFIFOFULL "  "0 ,1 "
bitfld.long 0 2. " OFFUNDERFLOW "  "0 ,1 "
bitfld.long 0 3. " OFFFIFOEMPTY "  "0 ,1 "
bitfld.long 0 4. " OFFFIFOHLFEMPTY "  "0 ,1 "
tree.end

base ad:0x8011003c
tree "IRQ_CL"
wgroup 0--3
line.long 0 "IRQ_CL"
bitfld.long 0 0. " CFRAMEEND "  "0 ,1 "
bitfld.long 0 1. " CFIFOFULL "  "0 ,1 "
bitfld.long 0 2. " CFIFOUNDERFLOW "  "0 ,1 "
bitfld.long 0 3. " CFIFOEMPTY "  "0 ,1 "
bitfld.long 0 4. " CFIFOHLFEMPTY "  "0 ,1 "
tree.end

base ad:0x80110040
tree "IRQ_FORCE"
wgroup 0--3
line.long 0 "IRQ_FORCE"
bitfld.long 0 0. " FFRAMEEND "  "0 ,1 "
bitfld.long 0 1. " FFIFOFULL "  "0 ,1 "
bitfld.long 0 2. " FFIFOUNDERFLOW "  "0 ,1 "
bitfld.long 0 3. " FFIFOEMPTY "  "0 ,1 "
bitfld.long 0 4. " FFIFOHLFEMPTY "  "0 ,1 "
tree.end

base ad:0x80110044
tree "SW_TST"
group 0--3
line.long 0 "SW_TST"
bitfld.long 0 0. " TSTMODE "  "0 ,1 "
bitfld.long 0 1. " TSTDATAOUT "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "KBD"
;==============================================================
base ad:0x80140000
tree "CTRL"
group 0--3
line.long 0 "CTRL"
bitfld.long 0 0.--3. " SI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--6. " DH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " SE "  "0 ,1 "
bitfld.long 0 8. " WAC "  "0 ,1 "
bitfld.long 0 9. " WAIC "  "0 ,1 "
bitfld.long 0 10. " WAIE "  "0 ,1 "
bitfld.long 0 11. " WAR "  "0 ,1 "
tree.end

base ad:0x80140004
tree "INT_CLEAR"
group 0--3
line.long 0 "INT_CLEAR"
bitfld.long 0 0. " IC "  "0 ,1 "
tree.end

base ad:0x80140008
tree "INT_ENABLE"
group 0--3
line.long 0 "INT_ENABLE"
bitfld.long 0 0. " IE "  "0 ,1 "
tree.end

base ad:0x8014000c
tree "INT_STATUS"
rgroup 0--3
line.long 0 "INT_STATUS"
bitfld.long 0 0. " IS "  "0 ,1 "
tree.end

base ad:0x80140010
tree "COLUMN"
rgroup 0--3
line.long 0 "COLUMN"
hexfld.byte 0 " COL "
tree.end

base ad:0x80140014
tree "ROW"
group 0--3
line.long 0 "ROW"
hexfld.byte 0 " ROW "
tree.end

base ad:0x80140018
tree "ARRAY1_0"
rgroup 0--3
line.long 0 "ARRAY1_0"
hexfld.byte 0 " COLSTATROW0 "
hexfld.byte 2 " COLSTATROW1 "
tree.end

base ad:0x8014001c
tree "ARRAY3_2"
rgroup 0--3
line.long 0 "ARRAY3_2"
hexfld.byte 0 " COLSTATROW2 "
hexfld.byte 2 " COLSTATROW3 "
tree.end

base ad:0x80140020
tree "ARRAY5_4"
rgroup 0--3
line.long 0 "ARRAY5_4"
hexfld.byte 0 " COLSTATROW4 "
hexfld.byte 2 " COLSTATROW5 "
tree.end

base ad:0x80140024
tree "ARRAY7_6"
rgroup 0--3
line.long 0 "ARRAY7_6"
hexfld.byte 0 " COLSTATROW6 "
hexfld.byte 2 " COLSTATROW7 "
tree.end

base ad:0x80140028
tree "ARRAY8"
rgroup 0--3
line.long 0 "ARRAY8"
hexfld.byte 0 " COLSTATROW8 "
tree.end

tree.end

;==============================================================
tree "MCDE"
;==============================================================
base ad:0xa0400000
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " DSI0_EN "  "0 ,1 "
bitfld.long 0 1. " DSI1_EN "  "0 ,1 "
bitfld.long 0 7. " DBI_EN "  "0 ,1 "
bitfld.long 0 9. " TV_EN "  "0 ,1 "
bitfld.long 0 15. " IFIFOCTRLEN "  "0 ,1 "
bitfld.long 0 30. " AUTOCLKG_EN "  "0 ,1 "
bitfld.long 0 31. " MCDEEN "  "0 ,1 "
tree.end

base ad:0xa0400004
tree "CONF0"
group 0--3
line.long 0 "CONF0"
bitfld.long 0 12.--14. " IFIFOCTRLWTRMRKLVL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0400100
tree "AIS"
rgroup 0--3
line.long 0 "AIS"
bitfld.long 0 0. " MCDEPPI "  "0 ,1 "
bitfld.long 0 1. " MCDEOVLI "  "0 ,1 "
bitfld.long 0 2. " MCDECHNLI "  "0 ,1 "
bitfld.long 0 3. " MCDEERRI "  "0 ,1 "
bitfld.long 0 4. " DSI0AI "  "0 ,1 "
bitfld.long 0 5. " DSI1AI "  "0 ,1 "
tree.end

base ad:0xa0400104
tree "IMSCPP"
group 0--3
line.long 0 "IMSCPP"
bitfld.long 0 0. " VCMPAIM "  "0 ,1 "
bitfld.long 0 1. " VCMPBIM "  "0 ,1 "
bitfld.long 0 2. " VSCC0IM "  "0 ,1 "
bitfld.long 0 3. " VSCC1IM "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDIM "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0400108
tree "IMSCOVL"
group 0--3
line.long 0 "IMSCOVL"
hexfld.word 0 " OVLRDIM "
hexfld.word 2 " OVLFDIM "
tree.end

base ad:0xa040010c
tree "IMSCCHNL"
group 0--3
line.long 0 "IMSCCHNL"
hexfld.word 0 " CHNLRDIM "
hexfld.word 2 " CHNLAIM "
tree.end

base ad:0xa0400110
tree "IMSCERR"
group 0--3
line.long 0 "IMSCERR"
bitfld.long 0 0. " FUAIM "  "0 ,1 "
bitfld.long 0 1. " FUBIM "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDIM "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFEIM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " ROTBFEIM "  "0 ,1 ,2 ,3 "
hexfld.word 2 " OVLFERRIM "
tree.end

base ad:0xa0400114
tree "RISPP"
group 0--3
line.long 0 "RISPP"
bitfld.long 0 0. " VCMPARIS "  "0 ,1 "
bitfld.long 0 1. " VCMPBRIS "  "0 ,1 "
bitfld.long 0 2. " VSCC0RIS "  "0 ,1 "
bitfld.long 0 3. " VSCC1RIS "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDRIS "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0400118
tree "RISOVL"
group 0--3
line.long 0 "RISOVL"
hexfld.word 0 " OVLRDRIS "
hexfld.word 2 " OVLFDRIS "
tree.end

base ad:0xa040011c
tree "RISCHNL"
group 0--3
line.long 0 "RISCHNL"
hexfld.word 0 " CHNLRDRIS "
hexfld.word 2 " CHNLARIS "
tree.end

base ad:0xa0400120
tree "RISERR"
group 0--3
line.long 0 "RISERR"
bitfld.long 0 0. " FUARIS "  "0 ,1 "
bitfld.long 0 1. " FUBRIS "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDRIS "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFERIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " ROTBFERIS "  "0 ,1 ,2 ,3 "
hexfld.word 2 " OVLFERRIS "
tree.end

base ad:0xa0400124
tree "MISPP"
rgroup 0--3
line.long 0 "MISPP"
bitfld.long 0 0. " VCMPAMIS "  "0 ,1 "
bitfld.long 0 1. " VCMPBMIS "  "0 ,1 "
bitfld.long 0 2. " VSCC0MIS "  "0 ,1 "
bitfld.long 0 3. " VSCC1MIS "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDMIS "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0400128
tree "MISOVL"
rgroup 0--3
line.long 0 "MISOVL"
hexfld.word 0 " OVLRDMIS "
hexfld.word 2 " OVLFDMIS "
tree.end

base ad:0xa040012c
tree "MISCHNL"
rgroup 0--3
line.long 0 "MISCHNL"
hexfld.word 0 " CHNLRDMIS "
hexfld.word 2 " CHNLAMIS "
tree.end

base ad:0xa0400130
tree "MISERR"
rgroup 0--3
line.long 0 "MISERR"
bitfld.long 0 0. " FUAMIS "  "0 ,1 "
bitfld.long 0 1. " FUBMIS "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDMIS "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFEMIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " ROTBFEMIS "  "0 ,1 ,2 ,3 "
hexfld.word 2 " OVLFERMIS "
tree.end

base ad:0xa0400134
tree "SISPP"
group 0--3
line.long 0 "SISPP"
bitfld.long 0 0. " VCMPASIS "  "0 ,1 "
bitfld.long 0 1. " VCMPBSIS "  "0 ,1 "
bitfld.long 0 2. " VSCC0SIS "  "0 ,1 "
bitfld.long 0 3. " VSCC1SIS "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDSIS "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0400138
tree "SISOVL"
group 0--3
line.long 0 "SISOVL"
hexfld.word 0 " OVLRDSIS "
hexfld.word 2 " OVLFDSIS "
tree.end

base ad:0xa040013c
tree "SISCHNL"
group 0--3
line.long 0 "SISCHNL"
hexfld.word 0 " CHNLRDSIS "
hexfld.word 2 " CHNLASIS "
tree.end

base ad:0xa0400140
tree "SISERR"
group 0--3
line.long 0 "SISERR"
bitfld.long 0 0. " FUASIS "  "0 ,1 "
bitfld.long 0 1. " FUBSIS "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDSIS "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFESIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " ROTBFESIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " FUC0SIS "  "0 ,1 "
bitfld.long 0 8. " FUC1SIS "  "0 ,1 "
hexfld.word 2 " OVLFERSIS "
tree.end

base ad:0xa04001fc
tree "PID"
rgroup 0--3
line.long 0 "PID"
hexfld.byte 0 " METALFIX_VERSION "
hexfld.byte 1 " DEVELOPMENT_VERSION "
hexfld.byte 2 " MINOR_VERSION "
hexfld.byte 3 " MAJOR_VERSION "
tree.end

base ad:0xa0400200
tree "EXTSRC0A0"
group 0--3
line.long 0 "EXTSRC0A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
tree.end

base ad:0xa0400204
tree "EXTSRC0A1"
group 0--3
line.long 0 "EXTSRC0A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
tree.end

base ad:0xa040020c
tree "EXTSRC0CONF"
group 0--3
line.long 0 "EXTSRC0CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
tree.end

base ad:0xa0400210
tree "EXTSRC0CR"
group 0--3
line.long 0 "EXTSRC0CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
tree.end

base ad:0xa0400220
tree "EXTSRC1A0"
group 0--3
line.long 0 "EXTSRC1A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
tree.end

base ad:0xa0400224
tree "EXTSRC1A1"
group 0--3
line.long 0 "EXTSRC1A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
tree.end

base ad:0xa040022c
tree "EXTSRC1CONF"
group 0--3
line.long 0 "EXTSRC1CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
tree.end

base ad:0xa0400230
tree "EXTSRC1CR"
group 0--3
line.long 0 "EXTSRC1CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
tree.end

base ad:0xa0400240
tree "EXTSRC2A0"
group 0--3
line.long 0 "EXTSRC2A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
tree.end

base ad:0xa0400244
tree "EXTSRC2A1"
group 0--3
line.long 0 "EXTSRC2A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
tree.end

base ad:0xa040024c
tree "EXTSRC2CONF"
group 0--3
line.long 0 "EXTSRC2CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
tree.end

base ad:0xa0400250
tree "EXTSRC2CR"
group 0--3
line.long 0 "EXTSRC2CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
tree.end

base ad:0xa0400400
tree "OVL0CR"
group 0--3
line.long 0 "OVL0CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0400404
tree "OVL0CONF"
group 0--3
line.long 0 "OVL0CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base ad:0xa0400408
tree "OVL0CONF2"
group 0--3
line.long 0 "OVL0CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
tree.end

base ad:0xa040040c
tree "OVL0LJINC"
group 0--3
line.long 0 "OVL0LJINC"
hexfld.long 0 " LJINC "
tree.end

base ad:0xa0400410
tree "OVL0CROP"
group 0--3
line.long 0 "OVL0CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
tree.end

base ad:0xa0400414
tree "OVL0COMP"
group 0--3
line.long 0 "OVL0COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0400420
tree "OVL1CR"
group 0--3
line.long 0 "OVL1CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0400424
tree "OVL1CONF"
group 0--3
line.long 0 "OVL1CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base ad:0xa0400428
tree "OVL1CONF2"
group 0--3
line.long 0 "OVL1CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
tree.end

base ad:0xa040042c
tree "OVL1LJINC"
group 0--3
line.long 0 "OVL1LJINC"
hexfld.long 0 " LJINC "
tree.end

base ad:0xa0400430
tree "OVL1CROP"
group 0--3
line.long 0 "OVL1CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
tree.end

base ad:0xa0400434
tree "OVL1COMP"
group 0--3
line.long 0 "OVL1COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0400440
tree "OVL2CR"
group 0--3
line.long 0 "OVL2CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0400444
tree "OVL2CONF"
group 0--3
line.long 0 "OVL2CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base ad:0xa0400448
tree "OVL2CONF2"
group 0--3
line.long 0 "OVL2CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
tree.end

base ad:0xa040044c
tree "OVL2LJINC"
group 0--3
line.long 0 "OVL2LJINC"
hexfld.long 0 " LJINC "
tree.end

base ad:0xa0400450
tree "OVL2CROP"
group 0--3
line.long 0 "OVL2CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
tree.end

base ad:0xa0400454
tree "OVL2COMP"
group 0--3
line.long 0 "OVL2COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0400600
tree "CHNL0CONF"
group 0--3
line.long 0 "CHNL0CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base ad:0xa0400604
tree "CHNL0STAT"
group 0--3
line.long 0 "CHNL0STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
tree.end

base ad:0xa0400608
tree "CHNL0SYNCHMOD"
group 0--3
line.long 0 "CHNL0SYNCHMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa040060c
tree "CHNL0SYNCHSW"
group 0--3
line.long 0 "CHNL0SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
tree.end

base ad:0xa0400610
tree "CHNL0BCKGNDCOL"
group 0--3
line.long 0 "CHNL0BCKGNDCOL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
tree.end

base ad:0xa0400614
tree "CHNL0PRIO"
group 0--3
line.long 0 "CHNL0PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0400620
tree "CHNL1CONF"
group 0--3
line.long 0 "CHNL1CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base ad:0xa0400624
tree "CHNL1STAT"
group 0--3
line.long 0 "CHNL1STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
tree.end

base ad:0xa0400628
tree "CHNL1SYNCHMOD"
group 0--3
line.long 0 "CHNL1SYNCHMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa040062c
tree "CHNL1SYNCHSW"
rgroup 0--3
line.long 0 "CHNL1SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
tree.end

base ad:0xa0400630
tree "CHNL1BCKGNDCOL"
group 0--3
line.long 0 "CHNL1BCKGNDCOL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
tree.end

base ad:0xa0400634
tree "CHNL1PRIO"
group 0--3
line.long 0 "CHNL1PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0400800
tree "CRA0"
group 0--3
line.long 0 "CRA0"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 1. " RESERVED "  "0 ,1 "
bitfld.long 0 2. " BLENDEN "  "0 ,1 "
bitfld.long 0 3. " AFLICKEN "  "0 ,1 "
bitfld.long 0 4. " PALEN "  "0 ,1 "
bitfld.long 0 5. " DITHEN "  "0 ,1 "
bitfld.long 0 6. " GAMEN "  "0 ,1 "
bitfld.long 0 7.--9. " KEYCTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " BLENDCTRL "  "0 ,1 "
bitfld.long 0 11.--12. " FLICKMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " FLICKFORMAT "  "0 ,1 "
bitfld.long 0 14. " PALMODE "  "0 ,1 "
bitfld.long 0 15. " OLEDEN "  "0 ,1 "
hexfld.byte 2 " ALPHABLEND "
bitfld.long 0 24. " ROTEN "  "0 ,1 "
tree.end

base ad:0xa0400804
tree "CRA1"
group 0--3
line.long 0 "CRA1"
bitfld.long 0 30. " CLKTYPE "  "0 ,1 "
tree.end

base ad:0xa0400808
tree "COLKEYA"
group 0--3
line.long 0 "COLKEYA"
hexfld.byte 0 " KEYB "
hexfld.byte 1 " KEYG "
hexfld.byte 2 " KEYR "
hexfld.byte 3 " KEYA "
tree.end

base ad:0xa040080c
tree "FCOLKEYA"
group 0--3
line.long 0 "FCOLKEYA"
hexfld.byte 0 " FKEYB "
hexfld.byte 1 " FKEYG "
hexfld.byte 2 " FKEYR "
hexfld.byte 3 " FKEYA "
tree.end

base ad:0xa0400810
tree "RGBCONV1A"
group 0--3
line.long 0 "RGBCONV1A"
bitfld.long 0 0.--10. " YR_GREEN "  " "
bitfld.long 0 16.--26. " YR_RED "  " "
tree.end

base ad:0xa0400814
tree "RGBCONV2A"
group 0--3
line.long 0 "RGBCONV2A"
bitfld.long 0 0.--10. " CR_RED "  " "
bitfld.long 0 16.--26. " YR_BLUE "  " "
tree.end

base ad:0xa0400818
tree "RGBCONV3A"
group 0--3
line.long 0 "RGBCONV3A"
bitfld.long 0 0.--10. " CR_BLUE "  " "
bitfld.long 0 16.--26. " CR_GREEN "  " "
tree.end

base ad:0xa040081c
tree "RGBCONV4A"
group 0--3
line.long 0 "RGBCONV4A"
bitfld.long 0 0.--10. " CB_GREEN "  " "
bitfld.long 0 16.--26. " CB_RED "  " "
tree.end

base ad:0xa0400820
tree "RGBCONV5A"
group 0--3
line.long 0 "RGBCONV5A"
bitfld.long 0 0.--10. " OFF_RED "  " "
bitfld.long 0 16.--26. " CB_BLUE "  " "
tree.end

base ad:0xa0400824
tree "RGBCONV6A"
group 0--3
line.long 0 "RGBCONV6A"
bitfld.long 0 0.--10. " OFF_BLUE "  " "
bitfld.long 0 16.--26. " OFF_GREEN "  " "
tree.end

base ad:0xa0400828
tree "FFCOEFA0"
group 0--3
line.long 0 "FFCOEFA0"
hexfld.byte 0 " COEFF0_N1 "
hexfld.byte 1 " COEFF0_N2 "
hexfld.byte 2 " COEFF0_N3 "
bitfld.long 0 24.--27. " T0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa040082c
tree "FFCOEFA1"
group 0--3
line.long 0 "FFCOEFA1"
hexfld.byte 0 " COEFF1_N1 "
hexfld.byte 1 " COEFF1_N2 "
hexfld.byte 2 " COEFF1_N3 "
bitfld.long 0 24.--27. " T1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0400830
tree "FFCOEFA2"
group 0--3
line.long 0 "FFCOEFA2"
hexfld.byte 0 " COEFF2_N1 "
hexfld.byte 1 " COEFF2_N2 "
hexfld.byte 2 " COEFF2_N3 "
bitfld.long 0 24.--27. " T2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0400834
tree "WDATAA"
wgroup 0--3
line.long 0 "WDATAA"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
tree.end

base ad:0xa0400838
tree "TVCR"
group 0--3
line.long 0 "TVCR"
bitfld.long 0 1. " INTEREN "  "0 ,1 "
bitfld.long 0 2. " IFIELD "  "0 ,1 "
bitfld.long 0 3.--5. " TVMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--7. " SDTVMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8. " AVRGEN "  "0 ,1 "
bitfld.long 0 9. " CKINV "  "0 ,1 "
tree.end

base ad:0xa040083c
tree "TVBL1"
group 0--3
line.long 0 "TVBL1"
bitfld.long 0 0.--10. " BEL1 "  " "
bitfld.long 0 16.--26. " BSL1 "  " "
tree.end

base ad:0xa0400840
tree "TVISL"
group 0--3
line.long 0 "TVISL"
bitfld.long 0 0.--10. " FSL1 "  " "
bitfld.long 0 16.--26. " FSL2 "  " "
tree.end

base ad:0xa0400844
tree "TVDVO"
group 0--3
line.long 0 "TVDVO"
bitfld.long 0 0.--10. " DVO1 "  " "
bitfld.long 0 16.--26. " DVO2 "  " "
tree.end

base ad:0xa040084c
tree "TVTIM1"
group 0--3
line.long 0 "TVTIM1"
bitfld.long 0 0.--10. " DHO "  " "
tree.end

base ad:0xa0400850
tree "TVLBALW"
group 0--3
line.long 0 "TVLBALW"
bitfld.long 0 0.--10. " LBW "  " "
bitfld.long 0 16.--26. " ALW "  " "
tree.end

base ad:0xa0400854
tree "TVBL2"
group 0--3
line.long 0 "TVBL2"
bitfld.long 0 0.--10. " BEL2 "  " "
bitfld.long 0 16.--26. " BSL2 "  " "
tree.end

base ad:0xa0400858
tree "TVBLU"
group 0--3
line.long 0 "TVBLU"
hexfld.byte 0 " TVBLU "
hexfld.byte 1 " TVBCB "
hexfld.byte 2 " TVBCR "
tree.end

base ad:0xa0400864
tree "DITCTRLA"
group 0--3
line.long 0 "DITCTRLA"
bitfld.long 0 0. " TEMP "  "0 ,1 "
bitfld.long 0 1. " COMP "  "0 ,1 "
bitfld.long 0 2.--3. " MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MASK "  "0 ,1 "
bitfld.long 0 5.--9. " FOFFX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--14. " FOFFY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0400868
tree "DITOFFA"
group 0--3
line.long 0 "DITOFFA"
bitfld.long 0 0.--4. " XG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " YG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " XB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--28. " YB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa040086c
tree "PAL0A"
group 0--3
line.long 0 "PAL0A"
bitfld.long 0 0.--11. " BLUE "  " "
bitfld.long 0 16.--27. " GREEN "  " "
tree.end

base ad:0xa0400870
tree "PAL1A"
group 0--3
line.long 0 "PAL1A"
bitfld.long 0 0.--11. " RED "  " "
tree.end

base ad:0xa0400874
tree "ROTADD0A"
group 0--3
line.long 0 "ROTADD0A"
bitfld.long 0 3.--31. " ROTADD0 "  " "
tree.end

base ad:0xa0400878
tree "ROTADD1A"
group 0--3
line.long 0 "ROTADD1A"
bitfld.long 0 3.--31. " ROTADD1 "  " "
tree.end

base ad:0xa040087c
tree "ROTACONF"
group 0--3
line.long 0 "ROTACONF"
bitfld.long 0 0.--2. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " ROTDIR "  "0 ,1 "
bitfld.long 0 4.--5. " WR_MAXOUT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " RD_MAXOUT "  "0 ,1 ,2 ,3 "
hexfld.byte 1 " STRIP_WIDTH "
hexfld.byte 2 " WR_ROPC "
hexfld.byte 3 " RD_ROPC "
tree.end

base ad:0xa0400880
tree "SYNCHCONFA"
group 0--3
line.long 0 "SYNCHCONFA"
bitfld.long 0 0.--1. " HWREQVEVENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--15. " HWREQVCNT "  " "
bitfld.long 0 16.--17. " SWINTVEVENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--31. " SWINTVCNT "  " "
tree.end

base ad:0xa0400884
tree "CTRLA"
group 0--3
line.long 0 "CTRLA"
bitfld.long 0 0.--8. " FIFOWTRMRK "  " "
tree.end

base ad:0xa0400888
tree "GAM0A"
group 0--3
line.long 0 "GAM0A"
bitfld.long 0 0.--23. " BLUE "  " "
tree.end

base ad:0xa040088c
tree "GAM1A"
group 0--3
line.long 0 "GAM1A"
bitfld.long 0 0.--23. " GREEN "  " "
tree.end

base ad:0xa0400890
tree "GAM2A"
group 0--3
line.long 0 "GAM2A"
bitfld.long 0 0.--23. " RED "  " "
tree.end

base ad:0xa0400894
tree "OLEDCONV1A"
group 0--3
line.long 0 "OLEDCONV1A"
bitfld.long 0 0.--13. " ALPHA_RED "  " "
bitfld.long 0 16.--29. " ALPHA_GREEN "  " "
tree.end

base ad:0xa0400898
tree "OLEDCONV2A"
group 0--3
line.long 0 "OLEDCONV2A"
bitfld.long 0 0.--13. " ALPHA_BLUE "  " "
bitfld.long 0 16.--29. " BETA_RED "  " "
tree.end

base ad:0xa040089c
tree "OLEDCONV3A"
group 0--3
line.long 0 "OLEDCONV3A"
bitfld.long 0 0.--13. " BETA_GREEN "  " "
bitfld.long 0 16.--29. " BETA_BLUE "  " "
tree.end

base ad:0xa04008a0
tree "OLEDCONV4A"
group 0--3
line.long 0 "OLEDCONV4A"
bitfld.long 0 0.--13. " GAMMA_RED "  " "
bitfld.long 0 16.--29. " GAMMA_GREEN "  " "
tree.end

base ad:0xa04008a4
tree "OLEDCONV5A"
group 0--3
line.long 0 "OLEDCONV5A"
bitfld.long 0 0.--13. " GAMMA_BLUE "  " "
bitfld.long 0 16.--29. " OFF_RED "  " "
tree.end

base ad:0xa04008a8
tree "OLEDCONV6A"
group 0--3
line.long 0 "OLEDCONV6A"
bitfld.long 0 0.--13. " OFF_GREEN "  " "
bitfld.long 0 16.--29. " OFF_BLUE "  " "
tree.end

base ad:0xa0400a00
tree "CRB0"
group 0--3
line.long 0 "CRB0"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 1. " POWEREN "  "0 ,1 "
bitfld.long 0 2. " BLENDEN "  "0 ,1 "
bitfld.long 0 3. " AFLICKEN "  "0 ,1 "
bitfld.long 0 4. " PALEN "  "0 ,1 "
bitfld.long 0 5. " DITHEN "  "0 ,1 "
bitfld.long 0 6. " GAMEN "  "0 ,1 "
bitfld.long 0 7.--9. " KEYCTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " BLENDCTRL "  "0 ,1 "
bitfld.long 0 11.--12. " FLICKMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " FLICKFORMAT "  "0 ,1 "
bitfld.long 0 14. " PALMODE "  "0 ,1 "
bitfld.long 0 15. " OLEDEN "  "0 ,1 "
hexfld.byte 2 " ALPHABLEND "
bitfld.long 0 24. " ROTEN "  "0 ,1 "
tree.end

base ad:0xa0400a04
tree "CRB1"
group 0--3
line.long 0 "CRB1"
bitfld.long 0 30. " CLKTYPE "  "0 ,1 "
tree.end

base ad:0xa0400a08
tree "COLKEYB"
group 0--3
line.long 0 "COLKEYB"
hexfld.byte 0 " KEYB "
hexfld.byte 1 " KEYG "
hexfld.byte 2 " KEYR "
hexfld.byte 3 " KEYA "
tree.end

base ad:0xa0400a0c
tree "FCOLKEYB"
group 0--3
line.long 0 "FCOLKEYB"
hexfld.byte 0 " FKEYB "
hexfld.byte 1 " FKEYG "
hexfld.byte 2 " FKEYR "
hexfld.byte 3 " FKEYA "
tree.end

base ad:0xa0400a10
tree "RGBCONV1B"
group 0--3
line.long 0 "RGBCONV1B"
bitfld.long 0 0.--10. " YR_GREEN "  " "
bitfld.long 0 16.--26. " YR_RED "  " "
tree.end

base ad:0xa0400a14
tree "RGBCONV2B"
group 0--3
line.long 0 "RGBCONV2B"
bitfld.long 0 0.--10. " CR_RED "  " "
bitfld.long 0 16.--26. " YR_BLUE "  " "
tree.end

base ad:0xa0400a18
tree "RGBCONV3B"
group 0--3
line.long 0 "RGBCONV3B"
bitfld.long 0 0.--10. " CR_BLUE "  " "
bitfld.long 0 16.--26. " CR_GREEN "  " "
tree.end

base ad:0xa0400a1c
tree "RGBCONV4B"
group 0--3
line.long 0 "RGBCONV4B"
bitfld.long 0 0.--10. " CB_GREEN "  " "
bitfld.long 0 16.--26. " CB_RED "  " "
tree.end

base ad:0xa0400a20
tree "RGBCONV5B"
group 0--3
line.long 0 "RGBCONV5B"
bitfld.long 0 0.--10. " OFF_RED "  " "
bitfld.long 0 16.--26. " CB_BLUE "  " "
tree.end

base ad:0xa0400a24
tree "RGBCONV6B"
group 0--3
line.long 0 "RGBCONV6B"
bitfld.long 0 0.--10. " OFF_BLUE "  " "
bitfld.long 0 16.--26. " OFF_GREEN "  " "
tree.end

base ad:0xa0400a34
tree "WDATAB"
wgroup 0--3
line.long 0 "WDATAB"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
tree.end

base ad:0xa0400a64
tree "DITCTRLB"
group 0--3
line.long 0 "DITCTRLB"
bitfld.long 0 0. " TEMP "  "0 ,1 "
bitfld.long 0 1. " COMP "  "0 ,1 "
bitfld.long 0 2.--3. " MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MASK "  "0 ,1 "
bitfld.long 0 5.--9. " FOFFX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--14. " FOFFY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0400a68
tree "DITOFFB"
group 0--3
line.long 0 "DITOFFB"
bitfld.long 0 0.--4. " XG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " YG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " XB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--28. " YB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0400a6c
tree "PAL0B"
group 0--3
line.long 0 "PAL0B"
bitfld.long 0 0.--11. " BLUE "  " "
bitfld.long 0 16.--27. " GREEN "  " "
tree.end

base ad:0xa0400a70
tree "PAL1B"
group 0--3
line.long 0 "PAL1B"
bitfld.long 0 0.--11. " RED "  " "
tree.end

base ad:0xa0400a74
tree "ROTADD0B"
group 0--3
line.long 0 "ROTADD0B"
bitfld.long 0 3.--31. " ROTADD0 "  " "
tree.end

base ad:0xa0400a78
tree "ROTADD1B"
group 0--3
line.long 0 "ROTADD1B"
bitfld.long 0 3.--31. " ROTADD1 "  " "
tree.end

base ad:0xa0400a7c
tree "ROTBCONF"
group 0--3
line.long 0 "ROTBCONF"
bitfld.long 0 0.--2. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " ROTDIR "  "0 ,1 "
bitfld.long 0 4.--5. " WR_MAXOUT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " RD_MAXOUT "  "0 ,1 ,2 ,3 "
hexfld.byte 1 " STRIP_WIDTH "
hexfld.byte 2 " WR_ROPC "
hexfld.byte 3 " RD_ROPC "
tree.end

base ad:0xa0400a80
tree "SYNCHCONFB"
group 0--3
line.long 0 "SYNCHCONFB"
bitfld.long 0 0.--1. " HWREQVEVENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--15. " HWREQVCNT "  " "
bitfld.long 0 16.--17. " SWINTVEVENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--31. " SWINTVCNT "  " "
tree.end

base ad:0xa0400a84
tree "CTRLB"
group 0--3
line.long 0 "CTRLB"
bitfld.long 0 0.--8. " FIFOWTRMRK "  " "
tree.end

base ad:0xa0400a88
tree "GAM0B"
group 0--3
line.long 0 "GAM0B"
bitfld.long 0 0.--23. " BLUE "  " "
tree.end

base ad:0xa0400a8c
tree "GAM1B"
group 0--3
line.long 0 "GAM1B"
bitfld.long 0 0.--23. " GREEN "  " "
tree.end

base ad:0xa0400a90
tree "GAM2B"
group 0--3
line.long 0 "GAM2B"
bitfld.long 0 0.--23. " RED "  " "
tree.end

base ad:0xa0400a94
tree "OLEDCONV1B"
group 0--3
line.long 0 "OLEDCONV1B"
bitfld.long 0 0.--13. " ALPHA_RED "  " "
bitfld.long 0 16.--29. " ALPHA_GREEN "  " "
tree.end

base ad:0xa0400a98
tree "OLEDCONV2B"
group 0--3
line.long 0 "OLEDCONV2B"
bitfld.long 0 0.--13. " ALPHA_BLUE "  " "
bitfld.long 0 16.--29. " BETA_RED "  " "
tree.end

base ad:0xa0400a9c
tree "OLEDCONV3B"
group 0--3
line.long 0 "OLEDCONV3B"
bitfld.long 0 0.--13. " BETA_GREEN "  " "
bitfld.long 0 16.--29. " BETA_BLUE "  " "
tree.end

base ad:0xa0400aa0
tree "OLEDCONV4B"
group 0--3
line.long 0 "OLEDCONV4B"
bitfld.long 0 0.--13. " GAMMA_RED "  " "
bitfld.long 0 16.--29. " GAMMA_GREEN "  " "
tree.end

base ad:0xa0400aa4
tree "OLEDCONV5B"
group 0--3
line.long 0 "OLEDCONV5B"
bitfld.long 0 0.--13. " GAMMA_BLUE "  " "
bitfld.long 0 16.--29. " OFF_RED "  " "
tree.end

base ad:0xa0400aa8
tree "OLEDCONV6B"
group 0--3
line.long 0 "OLEDCONV6B"
bitfld.long 0 0.--13. " OFF_GREEN "  " "
bitfld.long 0 16.--29. " OFF_BLUE "  " "
tree.end

base ad:0xa0400c00
tree "CRC"
group 0--3
line.long 0 "CRC"
bitfld.long 0 5. " SYCEN0 "  "0 ,1 "
bitfld.long 0 9. " INBAND1 "  "0 ,1 "
bitfld.long 0 14. " CS1EN "  "0 ,1 "
bitfld.long 0 16. " RESEN "  "0 ,1 "
bitfld.long 0 17. " CS1POL "  "0 ,1 "
bitfld.long 0 19. " CD1POL "  "0 ,1 "
bitfld.long 0 21. " WR1POL "  "0 ,1 "
bitfld.long 0 23. " RD1POL "  "0 ,1 "
bitfld.long 0 25. " RES1POL "  "0 ,1 "
tree.end

base ad:0xa0400c04
tree "PBCCRC"
group 0--3
line.long 0 "PBCCRC"
bitfld.long 0 0.--2. " BSCM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " BSDM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " PDM "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PDCTRL "  "0 ,1 "
bitfld.long 0 13.--15. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0400c0c
tree "PBCBMRC0"
group 0--3
line.long 0 "PBCBMRC0"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base ad:0xa0400c10
tree "PBCBMRC1"
group 0--3
line.long 0 "PBCBMRC1"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base ad:0xa0400c14
tree "PBCBMRC2"
group 0--3
line.long 0 "PBCBMRC2"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base ad:0xa0400c18
tree "PBCBMRC3"
group 0--3
line.long 0 "PBCBMRC3"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base ad:0xa0400c1c
tree "PBCBMRC4"
group 0--3
line.long 0 "PBCBMRC4"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base ad:0xa0400c34
tree "PBCBCRC0"
group 0--3
line.long 0 "PBCBCRC0"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
tree.end

base ad:0xa0400c38
tree "PBCBCRC1"
group 0--3
line.long 0 "PBCBCRC1"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
tree.end

base ad:0xa0400c5c
tree "VSCRC0"
group 0--3
line.long 0 "VSCRC0"
bitfld.long 0 0.--11. " VSPMIN "  " "
bitfld.long 0 12.--23. " VSPMAX "  " "
bitfld.long 0 24.--26. " VSPDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 27. " VSPOL "  "0 ,1 "
bitfld.long 0 28. " VSSEL "  "0 ,1 "
bitfld.long 0 29.--31. " VSDBL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0400c60
tree "VSCRC1"
group 0--3
line.long 0 "VSCRC1"
bitfld.long 0 0.--11. " VSPMIN "  " "
bitfld.long 0 12.--23. " VSPMAX "  " "
bitfld.long 0 24.--26. " VSPDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 27. " VSPOL "  "0 ,1 "
bitfld.long 0 28. " VSSEL "  "0 ,1 "
bitfld.long 0 29.--31. " VSDBL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0400c64
tree "SCTRC"
group 0--3
line.long 0 "SCTRC"
hexfld.byte 0 " SYNCDELC0 "
hexfld.byte 1 " SYNCDELC1 "
bitfld.long 0 16.--27. " TRDELC "  " "
tree.end

base ad:0xa0400c6c
tree "BCNR"
group 0--3
line.long 0 "BCNR"
hexfld.byte 0 " BCN "
tree.end

base ad:0xa0400c74
tree "CSCDTR"
group 0--3
line.long 0 "CSCDTR"
hexfld.byte 0 " CSACT "
hexfld.byte 1 " CSDEACT "
hexfld.byte 2 " CDACT "
hexfld.byte 3 " CDDEACT "
tree.end

base ad:0xa0400c7c
tree "RDWRTR"
group 0--3
line.long 0 "RDWRTR"
hexfld.byte 0 " RWACT "
hexfld.byte 1 " RWDEACT "
bitfld.long 0 16. " MOTINT "  "0 ,1 "
tree.end

base ad:0xa0400c84
tree "DOTR"
group 0--3
line.long 0 "DOTR"
hexfld.byte 0 " DOACT "
hexfld.byte 1 " DODEACT "
tree.end

base ad:0xa0400c9c
tree "RDATADC"
rgroup 0--3
line.long 0 "RDATADC"
hexfld.word 0 " DATAREADFROMDISPLAYMODULE "
bitfld.long 0 16. " STARTREAD "  "0 ,1 "
tree.end

base ad:0xa0400ca4
tree "STATC"
rgroup 0--3
line.long 0 "STATC"
bitfld.long 0 0. " STATBUSY0 "  "0 ,1 "
bitfld.long 0 1. " FIFOEMPTY0 "  "0 ,1 "
bitfld.long 0 2. " FIFOFULL0 "  "0 ,1 "
tree.end

base ad:0xa0400e00
tree "DSI0CONF0"
group 0--3
line.long 0 "DSI0CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0400e04
tree "DSI0FRAME"
group 0--3
line.long 0 "DSI0FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
tree.end

base ad:0xa0400e08
tree "DSI0PKT"
group 0--3
line.long 0 "DSI0PKT"
hexfld.word 0 " PACKET "
tree.end

base ad:0xa0400e0c
tree "DSI0SYNC"
group 0--3
line.long 0 "DSI0SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
tree.end

base ad:0xa0400e10
tree "DSI0CMDW"
group 0--3
line.long 0 "DSI0CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 2 " CMDW_START "
tree.end

base ad:0xa0400e14
tree "DSI0DELAY0"
group 0--3
line.long 0 "DSI0DELAY0"
hexfld.word 0 " INTPKTDEL "
tree.end

base ad:0xa0400e18
tree "DSI0DELAY1"
group 0--3
line.long 0 "DSI0DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
tree.end

base ad:0xa0400e20
tree "DSI1CONF0"
group 0--3
line.long 0 "DSI1CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0400e24
tree "DSI1FRAME"
group 0--3
line.long 0 "DSI1FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
tree.end

base ad:0xa0400e28
tree "DSI1PKT"
group 0--3
line.long 0 "DSI1PKT"
hexfld.word 0 " PACKET "
tree.end

base ad:0xa0400e2c
tree "DSI1SYNC"
group 0--3
line.long 0 "DSI1SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
tree.end

base ad:0xa0400e30
tree "DSI1CMDW"
group 0--3
line.long 0 "DSI1CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 2 " CMDW_START "
tree.end

base ad:0xa0400e34
tree "DSI1DELAY0"
group 0--3
line.long 0 "DSI1DELAY0"
hexfld.word 0 " INTPKTDEL "
tree.end

base ad:0xa0400e38
tree "DSI1DELAY1"
group 0--3
line.long 0 "DSI1DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
tree.end

tree.end

;==============================================================
tree "MCSBAG"
;==============================================================
base ad:0xa0030000
tree "BA_ENABLE"
group 0--3
line.long 0 "BA_ENABLE"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
tree.end

base ad:0xa0030004
tree "BA_MODE"
group 0--3
line.long 0 "BA_MODE"
bitfld.long 0 0.--2. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0030008
tree "BA_MSG_PORT_PACE"
group 0--3
line.long 0 "BA_MSG_PORT_PACE"
hexfld.word 0 " DIVIDER "
tree.end

base ad:0xa003000c
tree "BA_STATUS"
rgroup 0--3
line.long 0 "BA_STATUS"
bitfld.long 0 0.--1. " FF_FLAGS "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0030020
tree "WPSAT_ENABLE"
group 0--3
line.long 0 "WPSAT_ENABLE"
bitfld.long 0 0.--3. " WPSen "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0030024
tree "WPSAT_PROG_MODE"
group 0--3
line.long 0 "WPSAT_PROG_MODE"
bitfld.long 0 0.--3. " WPSprog "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0030028
tree "WPSAT_PROG_STATUS"
rgroup 0--3
line.long 0 "WPSAT_PROG_STATUS"
bitfld.long 0 0.--3. " WPSprogstatus "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa003002c
tree "WPSAT_PROG_CLEAR"
group 0--3
line.long 0 "WPSAT_PROG_CLEAR"
bitfld.long 0 0. " CLEAR "  "0 ,1 "
tree.end

base ad:0xa0030040
tree "TMSAT_ENABLE"
group 0--3
line.long 0 "TMSAT_ENABLE"
hexfld.byte 0 " TMSen "
tree.end

base ad:0xa0030044
tree "TMSAT_PROG_MODE"
group 0--3
line.long 0 "TMSAT_PROG_MODE"
hexfld.byte 0 " TMSprog "
tree.end

base ad:0xa0030048
tree "TMSAT_PROG_STATUS"
rgroup 0--3
line.long 0 "TMSAT_PROG_STATUS"
hexfld.byte 0 " TMSprogstatus "
tree.end

base ad:0xa003004c
tree "TMSAT_PROG_CLEAR"
group 0--3
line.long 0 "TMSAT_PROG_CLEAR"
bitfld.long 0 0. " CLEAR "  "0 ,1 "
tree.end

base ad:0xa0030050
tree "TMSAT_READ_STATUS"
rgroup 0--3
line.long 0 "TMSAT_READ_STATUS"
hexfld.byte 0 " TMSreadstatus "
tree.end

base ad:0xa0030060
tree "WPSAT_ITS"
rgroup 0--3
line.long 0 "WPSAT_ITS"
bitfld.long 0 0.--3. " WPSAT_ITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0030064
tree "WPSAT_ITS_CLR"
group 0--3
line.long 0 "WPSAT_ITS_CLR"
bitfld.long 0 0.--3. " WPSAT_ITS_CLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0030068
tree "WPSAT_ITS_SET"
wgroup 0--3
line.long 0 "WPSAT_ITS_SET"
bitfld.long 0 0.--3. " WPSAT_ITS_SET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa003006c
tree "WPSAT_ITM"
rgroup 0--3
line.long 0 "WPSAT_ITM"
bitfld.long 0 0.--3. " WPSAT_ITM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0030070
tree "WPSAT_ITM_CLR"
group 0--3
line.long 0 "WPSAT_ITM_CLR"
bitfld.long 0 0.--3. " WPSAT_ITM_CLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0030074
tree "WPSAT_ITM_SET"
wgroup 0--3
line.long 0 "WPSAT_ITM_SET"
bitfld.long 0 0.--3. " WPSAT_ITM_SET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0030078
tree "PI_ITS"
rgroup 0--3
line.long 0 "PI_ITS"
hexfld.word 0 " PI_ITS "
tree.end

base ad:0xa003007c
tree "PI_ITS_CLR"
group 0--3
line.long 0 "PI_ITS_CLR"
hexfld.word 0 " PI_ITS_CLR "
tree.end

base ad:0xa0030080
tree "PI_ITS_SET"
wgroup 0--3
line.long 0 "PI_ITS_SET"
hexfld.word 0 " PI_ITS_SET "
tree.end

base ad:0xa0030084
tree "PI_ITM"
rgroup 0--3
line.long 0 "PI_ITM"
hexfld.word 0 " PI_ITM "
tree.end

base ad:0xa0030088
tree "PI_ITM_CLR"
group 0--3
line.long 0 "PI_ITM_CLR"
hexfld.word 0 " PI_ITM_CLR "
tree.end

base ad:0xa003008c
tree "PI_ITM_SET"
wgroup 0--3
line.long 0 "PI_ITM_SET"
hexfld.word 0 " PI_ITM_SET "
tree.end

base ad:0xa0030090
tree "TMSAT_ITS"
rgroup 0--3
line.long 0 "TMSAT_ITS"
hexfld.byte 0 " TMSAT_ITS "
tree.end

base ad:0xa0030094
tree "TMSAT_ITS_CLR"
group 0--3
line.long 0 "TMSAT_ITS_CLR"
hexfld.byte 0 " TMSAT_ITS_CLR "
tree.end

base ad:0xa0030098
tree "TMSAT_ITS_SET"
wgroup 0--3
line.long 0 "TMSAT_ITS_SET"
hexfld.byte 0 " TMSAT_ITS_SET "
tree.end

base ad:0xa003009c
tree "TMSAT_ITM"
rgroup 0--3
line.long 0 "TMSAT_ITM"
hexfld.byte 0 " TMSAT_ITM "
tree.end

base ad:0xa00300a0
tree "TMSAT_ITM_CLR"
group 0--3
line.long 0 "TMSAT_ITM_CLR"
hexfld.byte 0 " TMSAT_ITM_CLR "
tree.end

base ad:0xa00300a4
tree "TMSAT_ITM_SET"
wgroup 0--3
line.long 0 "TMSAT_ITM_SET"
hexfld.byte 0 " TMSAT_ITM_SET "
tree.end

base ad:0xa00300a8
tree "PI_ERROR"
rgroup 0--3
line.long 0 "PI_ERROR"
hexfld.word 0 " PI_ERROR "
tree.end

base ad:0xa00300ac
tree "PI_ERROR_CLR"
group 0--3
line.long 0 "PI_ERROR_CLR"
hexfld.word 0 " PI_ERROR_CLR "
tree.end

base ad:0xa00300b0
tree "TMSAT0_T7_ERROR"
rgroup 0--3
line.long 0 "TMSAT0_T7_ERROR"
hexfld.long 0 " TMSAT0_T7_ERROR "
tree.end

base ad:0xa00300b4
tree "TMSAT8_T15_ERROR"
rgroup 0--3
line.long 0 "TMSAT8_T15_ERROR"
hexfld.long 0 " TMSAT8_T15_ERROR "
tree.end

base ad:0xa00300b8
tree "TM_LOST_ERROR"
rgroup 0--3
line.long 0 "TM_LOST_ERROR"
bitfld.long 0 0. " TM_ERROR "  "0 ,1 "
tree.end

base ad:0xa00300bc
tree "TM_ERROR_CLR"
group 0--3
line.long 0 "TM_ERROR_CLR"
bitfld.long 0 0. " TM_ERROR_CLR "  "0 ,1 "
tree.end

base ad:0xa00300c0
tree "SBAG_DVF0"
group 0--3
line.long 0 "SBAG_DVF0"
bitfld.long 0 0. " SBAG_DVF0 "  "0 ,1 "
tree.end

base ad:0xa00300c4
tree "TIME_ABSOLUTE_LSB"
group 0--3
line.long 0 "TIME_ABSOLUTE_LSB"
hexfld.long 0 " TIME_ABSOLUTE_LSB "
tree.end

base ad:0xa00300c8
tree "TIME_ABSOLUTE_MSB"
rgroup 0--3
line.long 0 "TIME_ABSOLUTE_MSB"
hexfld.long 0 " TIME_ABSOLUTE_MSB "
tree.end

base ad:0xa0030200
tree "WPSAT0_REG1"
group 0--3
line.long 0 "WPSAT0_REG1"
hexfld.long 0 " REG1 "
tree.end

base ad:0xa0030204
tree "WPSAT0_REG2"
group 0--3
line.long 0 "WPSAT0_REG2"
hexfld.long 0 " REG2 "
tree.end

base ad:0xa0030208
tree "WPSAT0_REG3"
group 0--3
line.long 0 "WPSAT0_REG3"
hexfld.long 0 " REG3 "
tree.end

base ad:0xa003020c
tree "WPSAT0_REG4"
group 0--3
line.long 0 "WPSAT0_REG4"
hexfld.long 0 " REG4 "
tree.end

base ad:0xa0030210
tree "WPSAT0_REQ_NOT_RSP"
rgroup 0--3
line.long 0 "WPSAT0_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
tree.end

base ad:0xa0030214
tree "WPSAT1_REG1"
group 0--3
line.long 0 "WPSAT1_REG1"
hexfld.long 0 " REG1 "
tree.end

base ad:0xa0030218
tree "WPSAT1_REG2"
group 0--3
line.long 0 "WPSAT1_REG2"
hexfld.long 0 " REG2 "
tree.end

base ad:0xa003021c
tree "WPSAT1_REG3"
group 0--3
line.long 0 "WPSAT1_REG3"
hexfld.long 0 " REG3 "
tree.end

base ad:0xa0030220
tree "WPSAT1_REG4"
group 0--3
line.long 0 "WPSAT1_REG4"
hexfld.long 0 " REG4 "
tree.end

base ad:0xa0030224
tree "WPSAT1_REQ_NOT_RSP"
rgroup 0--3
line.long 0 "WPSAT1_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
tree.end

base ad:0xa0030228
tree "WPSAT2_REG1"
group 0--3
line.long 0 "WPSAT2_REG1"
hexfld.long 0 " REG1 "
tree.end

base ad:0xa003022c
tree "WPSAT2_REG2"
group 0--3
line.long 0 "WPSAT2_REG2"
hexfld.long 0 " REG2 "
tree.end

base ad:0xa0030230
tree "WPSAT2_REG3"
group 0--3
line.long 0 "WPSAT2_REG3"
hexfld.long 0 " REG3 "
tree.end

base ad:0xa0030234
tree "WPSAT2_REG4"
group 0--3
line.long 0 "WPSAT2_REG4"
hexfld.long 0 " REG4 "
tree.end

base ad:0xa0030238
tree "WPSAT2_REQ_NOT_RSP"
rgroup 0--3
line.long 0 "WPSAT2_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
tree.end

base ad:0xa003023c
tree "WPSAT3_REG1"
group 0--3
line.long 0 "WPSAT3_REG1"
hexfld.long 0 " REG1 "
tree.end

base ad:0xa0030240
tree "WPSAT3_REG2"
group 0--3
line.long 0 "WPSAT3_REG2"
hexfld.long 0 " REG2 "
tree.end

base ad:0xa0030244
tree "WPSAT3_REG3"
group 0--3
line.long 0 "WPSAT3_REG3"
hexfld.long 0 " REG3 "
tree.end

base ad:0xa0030248
tree "WPSAT3_REG4"
group 0--3
line.long 0 "WPSAT3_REG4"
hexfld.long 0 " REG4 "
tree.end

base ad:0xa003024c
tree "WPSAT3_REQ_NOT_RSP"
rgroup 0--3
line.long 0 "WPSAT3_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
tree.end

base ad:0xa0030400
tree "MSG_REF_PACE"
group 0--3
line.long 0 "MSG_REF_PACE"
hexfld.long 0 " PACE "
tree.end

base ad:0xa0030404
tree "MSG_FPF_DATA"
group 0--3
line.long 0 "MSG_FPF_DATA"
hexfld.long 0 " DATA "
tree.end

base ad:0xa0030408
tree "MSG_FPF_TRACE_CTRL"
group 0--3
line.long 0 "MSG_FPF_TRACE_CTRL"
bitfld.long 0 0. " DATA "  "0 ,1 "
bitfld.long 0 24. " TIME "  "0 ,1 "
bitfld.long 0 31. " EN "  "0 ,1 "
tree.end

base ad:0xa003040c
tree "MSG_PI_TRACE_CTRL"
group 0--3
line.long 0 "MSG_PI_TRACE_CTRL"
hexfld.word 0 " INCDATA "
bitfld.long 0 24. " TIME "  "0 ,1 "
bitfld.long 0 31. " EN "  "0 ,1 "
tree.end

base ad:0xa0030410
tree "MSG_REF_TRACE_CONTROL"
group 0--3
line.long 0 "MSG_REF_TRACE_CONTROL"
bitfld.long 0 31. " EN "  "0 ,1 "
tree.end

base ad:0xa0030414
tree "MSG_ERR_TRACE_CONTROL"
group 0--3
line.long 0 "MSG_ERR_TRACE_CONTROL"
bitfld.long 0 0. " FL0 "  "0 ,1 "
bitfld.long 0 8. " FL1 "  "0 ,1 "
bitfld.long 0 9. " FL2 "  "0 ,1 "
bitfld.long 0 16. " FL3 "  "0 ,1 "
bitfld.long 0 31. " EN "  "0 ,1 "
tree.end

base ad:0xa0030418
tree "MSG_WP_ENABLE"
group 0--3
line.long 0 "MSG_WP_ENABLE"
bitfld.long 0 0.--3. " MSGWPEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa003041c
tree "MSG_WP_TRACE_CTRL"
group 0--3
line.long 0 "MSG_WP_TRACE_CTRL"
bitfld.long 0 0. " C1 "  "0 ,1 "
bitfld.long 0 1. " C2 "  "0 ,1 "
bitfld.long 0 8. " DATA "  "0 ,1 "
bitfld.long 0 24. " TIME "  "0 ,1 "
tree.end

base ad:0xa0030420
tree "MSG_TM_ENABLE"
group 0--3
line.long 0 "MSG_TM_ENABLE"
hexfld.byte 0 " MSGTMEN "
tree.end

base ad:0xa0030424
tree "MSG_TM_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG_TM_TRACE_CTRL_L"
bitfld.long 0 0. " ERR_M3_M2_M1 "  "0 ,1 "
tree.end

base ad:0xa0030428
tree "MSG_TM_TRACE_CTRL_M"
group 0--3
line.long 0 "MSG_TM_TRACE_CTRL_M"
bitfld.long 0 0. " ERR_M3_M2_M1 "  "0 ,1 "
tree.end

base ad:0xa0030600
tree "TMSAT0_REG1"
group 0--3
line.long 0 "TMSAT0_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030604
tree "TMSAT0_REG2"
group 0--3
line.long 0 "TMSAT0_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030608
tree "TMSAT0_REG3"
group 0--3
line.long 0 "TMSAT0_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa003060c
tree "TMSAT1_REG1"
group 0--3
line.long 0 "TMSAT1_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030610
tree "TMSAT1_REG2"
group 0--3
line.long 0 "TMSAT1_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030614
tree "TMSAT1_REG3"
group 0--3
line.long 0 "TMSAT1_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030618
tree "TMSAT2_REG1"
group 0--3
line.long 0 "TMSAT2_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa003061c
tree "TMSAT2_REG2"
group 0--3
line.long 0 "TMSAT2_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030620
tree "TMSAT2_REG3"
group 0--3
line.long 0 "TMSAT2_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030624
tree "TMSAT3_REG1"
group 0--3
line.long 0 "TMSAT3_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030628
tree "TMSAT3_REG2"
group 0--3
line.long 0 "TMSAT3_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa003062c
tree "TMSAT3_REG3"
group 0--3
line.long 0 "TMSAT3_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030630
tree "TMSAT4_REG1"
group 0--3
line.long 0 "TMSAT4_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030634
tree "TMSAT4_REG2"
group 0--3
line.long 0 "TMSAT4_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030638
tree "TMSAT4_REG3"
group 0--3
line.long 0 "TMSAT4_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa003063c
tree "TMSAT5_REG1"
group 0--3
line.long 0 "TMSAT5_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030640
tree "TMSAT5_REG2"
group 0--3
line.long 0 "TMSAT5_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030644
tree "TMSAT5_REG3"
group 0--3
line.long 0 "TMSAT5_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030648
tree "TMSAT6_REG1"
group 0--3
line.long 0 "TMSAT6_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa003064c
tree "TMSAT6_REG2"
group 0--3
line.long 0 "TMSAT6_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030650
tree "TMSAT6_REG3"
group 0--3
line.long 0 "TMSAT6_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030654
tree "TMSAT7_REG1"
group 0--3
line.long 0 "TMSAT7_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030658
tree "TMSAT7_REG2"
group 0--3
line.long 0 "TMSAT7_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa003065c
tree "TMSAT7_REG3"
group 0--3
line.long 0 "TMSAT7_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030660
tree "TMSAT8_REG1"
group 0--3
line.long 0 "TMSAT8_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030664
tree "TMSAT8_REG2"
group 0--3
line.long 0 "TMSAT8_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030668
tree "TMSAT8_REG3"
group 0--3
line.long 0 "TMSAT8_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa003066c
tree "TMSAT9_REG1"
group 0--3
line.long 0 "TMSAT9_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030670
tree "TMSAT9_REG2"
group 0--3
line.long 0 "TMSAT9_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030674
tree "TMSAT9_REG3"
group 0--3
line.long 0 "TMSAT9_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030678
tree "TMSAT10_REG1"
group 0--3
line.long 0 "TMSAT10_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa003067c
tree "TMSAT10_REG2"
group 0--3
line.long 0 "TMSAT10_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030680
tree "TMSAT10_REG3"
group 0--3
line.long 0 "TMSAT10_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030684
tree "TMSAT11_REG1"
group 0--3
line.long 0 "TMSAT11_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030688
tree "TMSAT11_REG2"
group 0--3
line.long 0 "TMSAT11_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa003068c
tree "TMSAT11_REG3"
group 0--3
line.long 0 "TMSAT11_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030690
tree "TMSAT12_REG1"
group 0--3
line.long 0 "TMSAT12_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030694
tree "TMSAT12_REG2"
group 0--3
line.long 0 "TMSAT12_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030698
tree "TMSAT12_REG3"
group 0--3
line.long 0 "TMSAT12_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa003069c
tree "TMSAT13_REG1"
group 0--3
line.long 0 "TMSAT13_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa00306a0
tree "TMSAT13_REG2"
group 0--3
line.long 0 "TMSAT13_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa00306a4
tree "TMSAT13_REG3"
group 0--3
line.long 0 "TMSAT13_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base ad:0xa0030800
tree "PI_TRIGGER_RAISE"
group 0--3
line.long 0 "PI_TRIGGER_RAISE"
hexfld.word 0 " RISING "
tree.end

base ad:0xa0030804
tree "PI_TRIGGER_FALLING"
group 0--3
line.long 0 "PI_TRIGGER_FALLING"
hexfld.word 0 " FALLING "
tree.end

tree.end

;==============================================================
tree "MMCI (5 instances)"
;==============================================================
base ad:0xa0021000
;********************************************
tree "MMCI-0"
;********************************************
base ad:0xa0021000
tree "0Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
tree.end

base ad:0xa0021004
tree "0Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
tree.end

base ad:0xa0021008
tree "0Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
tree.end

base ad:0xa002100c
tree "0Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
tree.end

base ad:0xa0021010
tree "0RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0021014
tree "0Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
tree.end

base ad:0xa0021018
tree "0Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
tree.end

base ad:0xa002101c
tree "0Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
tree.end

base ad:0xa0021020
tree "0Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
tree.end

base ad:0xa0021024
tree "0Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
tree.end

base ad:0xa0021028
tree "0DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
tree.end

base ad:0xa002102c
tree "0DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 4.--7. " BlockSize "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
tree.end

base ad:0xa0021030
tree "0DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
tree.end

base ad:0xa0021034
tree "0Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
tree.end

base ad:0xa0021038
tree "0Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
tree.end

base ad:0xa002103c
tree "0Mask0"
group 0--3
line.long 0 "Mask0"
tree.end

base ad:0xa0021040
tree "0Mask1"
group 0--3
line.long 0 "Mask1"
tree.end

base ad:0xa0021044
tree "0CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0021048
tree "0FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
tree.end

base ad:0xa0021080
tree "0Fifo"
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
tree.end

base ad:0xa00210c0
tree "0DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
tree.end

base ad:0xa00210c4
tree "0TRSCA"
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
tree.end

base ad:0xa0021fe0
tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0xa0021fe4
tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0021fe8
tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0021fec
tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0xa0021ff0
tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
tree.end

base ad:0xa0021ff4
tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
tree.end

base ad:0xa0021ff8
tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
tree.end

base ad:0xa0021ffc
tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
tree.end

tree.end

base ad:0xa0022000
;********************************************
tree "MMCI-2"
;********************************************
base ad:0xa0022000
tree "2Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
tree.end

base ad:0xa0022004
tree "2Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
tree.end

base ad:0xa0022008
tree "2Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
tree.end

base ad:0xa002200c
tree "2Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
tree.end

base ad:0xa0022010
tree "2RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0022014
tree "2Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
tree.end

base ad:0xa0022018
tree "2Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
tree.end

base ad:0xa002201c
tree "2Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
tree.end

base ad:0xa0022020
tree "2Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
tree.end

base ad:0xa0022024
tree "2Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
tree.end

base ad:0xa0022028
tree "2DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
tree.end

base ad:0xa002202c
tree "2DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 4.--7. " BlockSize "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
tree.end

base ad:0xa0022030
tree "2DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
tree.end

base ad:0xa0022034
tree "2Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
tree.end

base ad:0xa0022038
tree "2Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
tree.end

base ad:0xa002203c
tree "2Mask0"
group 0--3
line.long 0 "Mask0"
tree.end

base ad:0xa0022040
tree "2Mask1"
group 0--3
line.long 0 "Mask1"
tree.end

base ad:0xa0022044
tree "2CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0022048
tree "2FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
tree.end

base ad:0xa0022080
tree "2Fifo"
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
tree.end

base ad:0xa00220c0
tree "2DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
tree.end

base ad:0xa00220c4
tree "2TRSCA"
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
tree.end

base ad:0xa0022fe0
tree "2PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0xa0022fe4
tree "2PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0022fe8
tree "2PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0022fec
tree "2PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0xa0022ff0
tree "2PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
tree.end

base ad:0xa0022ff4
tree "2PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
tree.end

base ad:0xa0022ff8
tree "2PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
tree.end

base ad:0xa0022ffc
tree "2PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
tree.end

tree.end

base ad:0x80107000
;********************************************
tree "MMCI-1"
;********************************************
base ad:0x80107000
tree "1Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
tree.end

base ad:0x80107004
tree "1Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
tree.end

base ad:0x80107008
tree "1Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
tree.end

base ad:0x8010700c
tree "1Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
tree.end

base ad:0x80107010
tree "1RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x80107014
tree "1Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
tree.end

base ad:0x80107018
tree "1Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
tree.end

base ad:0x8010701c
tree "1Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
tree.end

base ad:0x80107020
tree "1Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
tree.end

base ad:0x80107024
tree "1Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
tree.end

base ad:0x80107028
tree "1DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
tree.end

base ad:0x8010702c
tree "1DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 4.--7. " BlockSize "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
tree.end

base ad:0x80107030
tree "1DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
tree.end

base ad:0x80107034
tree "1Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
tree.end

base ad:0x80107038
tree "1Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
tree.end

base ad:0x8010703c
tree "1Mask0"
group 0--3
line.long 0 "Mask0"
tree.end

base ad:0x80107040
tree "1Mask1"
group 0--3
line.long 0 "Mask1"
tree.end

base ad:0x80107044
tree "1CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80107048
tree "1FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
tree.end

base ad:0x80107080
tree "1Fifo"
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
tree.end

base ad:0x801070c0
tree "1DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
tree.end

base ad:0x801070c4
tree "1TRSCA"
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
tree.end

base ad:0x80107fe0
tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0x80107fe4
tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80107fe8
tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80107fec
tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80107ff0
tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
tree.end

base ad:0x80107ff4
tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
tree.end

base ad:0x80107ff8
tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
tree.end

base ad:0x80107ffc
tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
tree.end

tree.end

base ad:0x80108000
;********************************************
tree "MMCI-3"
;********************************************
base ad:0x80108000
tree "3Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
tree.end

base ad:0x80108004
tree "3Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
tree.end

base ad:0x80108008
tree "3Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
tree.end

base ad:0x8010800c
tree "3Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
tree.end

base ad:0x80108010
tree "3RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x80108014
tree "3Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
tree.end

base ad:0x80108018
tree "3Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
tree.end

base ad:0x8010801c
tree "3Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
tree.end

base ad:0x80108020
tree "3Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
tree.end

base ad:0x80108024
tree "3Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
tree.end

base ad:0x80108028
tree "3DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
tree.end

base ad:0x8010802c
tree "3DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 4.--7. " BlockSize "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
tree.end

base ad:0x80108030
tree "3DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
tree.end

base ad:0x80108034
tree "3Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
tree.end

base ad:0x80108038
tree "3Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
tree.end

base ad:0x8010803c
tree "3Mask0"
group 0--3
line.long 0 "Mask0"
tree.end

base ad:0x80108040
tree "3Mask1"
group 0--3
line.long 0 "Mask1"
tree.end

base ad:0x80108044
tree "3CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80108048
tree "3FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
tree.end

base ad:0x80108080
tree "3Fifo"
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
tree.end

base ad:0x801080c0
tree "3DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
tree.end

base ad:0x801080c4
tree "3TRSCA"
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
tree.end

base ad:0x80108fe0
tree "3PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0x80108fe4
tree "3PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80108fe8
tree "3PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80108fec
tree "3PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80108ff0
tree "3PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
tree.end

base ad:0x80108ff4
tree "3PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
tree.end

base ad:0x80108ff8
tree "3PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
tree.end

base ad:0x80108ffc
tree "3PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
tree.end

tree.end

base ad:0x80109000
;********************************************
tree "MMCI-4"
;********************************************
base ad:0x80109000
tree "4Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
tree.end

base ad:0x80109004
tree "4Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
tree.end

base ad:0x80109008
tree "4Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
tree.end

base ad:0x8010900c
tree "4Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
tree.end

base ad:0x80109010
tree "4RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x80109014
tree "4Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
tree.end

base ad:0x80109018
tree "4Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
tree.end

base ad:0x8010901c
tree "4Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
tree.end

base ad:0x80109020
tree "4Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
tree.end

base ad:0x80109024
tree "4Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
tree.end

base ad:0x80109028
tree "4DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
tree.end

base ad:0x8010902c
tree "4DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 4.--7. " BlockSize "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
tree.end

base ad:0x80109030
tree "4DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
tree.end

base ad:0x80109034
tree "4Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
tree.end

base ad:0x80109038
tree "4Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
tree.end

base ad:0x8010903c
tree "4Mask0"
group 0--3
line.long 0 "Mask0"
tree.end

base ad:0x80109040
tree "4Mask1"
group 0--3
line.long 0 "Mask1"
tree.end

base ad:0x80109044
tree "4CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80109048
tree "4FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
tree.end

base ad:0x80109080
tree "4Fifo"
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
tree.end

base ad:0x801090c0
tree "4DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
tree.end

base ad:0x801090c4
tree "4TRSCA"
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
tree.end

base ad:0x80109fe0
tree "4PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0x80109fe4
tree "4PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80109fe8
tree "4PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80109fec
tree "4PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80109ff0
tree "4PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
tree.end

base ad:0x80109ff4
tree "4PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
tree.end

base ad:0x80109ff8
tree "4PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
tree.end

base ad:0x80109ffc
tree "4PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
tree.end

tree.end

tree.end

;==============================================================
tree "MSP (3 instances)"
;==============================================================
base ad:0xa0025000
;********************************************
tree "MSP-0"
;********************************************
base ad:0xa0025000
tree "0DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
tree.end

base ad:0xa0025004
tree "0GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
tree.end

base ad:0xa0025008
tree "0TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa002500c
tree "0RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0025010
tree "0SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
tree.end

base ad:0xa0025014
tree "0FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
tree.end

base ad:0xa0025018
tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
tree.end

base ad:0xa002501c
tree "0WMRK"
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
tree.end

base ad:0xa0025020
tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
tree.end

base ad:0xa0025024
tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
tree.end

base ad:0xa0025028
tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
tree.end

base ad:0xa002502c
tree "0ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
tree.end

base ad:0xa0025030
tree "0MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0025034
tree "0RCV"
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
tree.end

base ad:0xa0025038
tree "0RCM"
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
tree.end

base ad:0xa0025040
tree "0TCE0"
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
tree.end

base ad:0xa0025044
tree "0TCE1"
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
tree.end

base ad:0xa0025048
tree "0TCE2"
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
tree.end

base ad:0xa002504c
tree "0TCE3"
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
tree.end

base ad:0xa0025060
tree "0RCE0"
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
tree.end

base ad:0xa0025064
tree "0RCE1"
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
tree.end

base ad:0xa0025068
tree "0RCE2"
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
tree.end

base ad:0xa002506c
tree "0RCE3"
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
tree.end

base ad:0xa0025070
tree "0IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0025080
tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
tree.end

base ad:0xa0025084
tree "0ITIP"
group 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
tree.end

base ad:0xa0025088
tree "0ITOP"
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
tree.end

base ad:0xa002508c
tree "0TSTDR"
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
tree.end

base ad:0xa0025fe0
tree "0PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
tree.end

base ad:0xa0025fe4
tree "0PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
tree.end

base ad:0xa0025fe8
tree "0PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
tree.end

base ad:0xa0025fec
tree "0PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
tree.end

base ad:0xa0025ff0
tree "0PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
tree.end

base ad:0xa0025ff4
tree "0PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
tree.end

base ad:0xa0025ff8
tree "0PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
tree.end

base ad:0xa0025ffc
tree "0PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
tree.end

tree.end

base ad:0x8010c000
;********************************************
tree "MSP-2"
;********************************************
base ad:0x8010c000
tree "2DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010c004
tree "2GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
tree.end

base ad:0x8010c008
tree "2TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8010c00c
tree "2RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8010c010
tree "2SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
tree.end

base ad:0x8010c014
tree "2FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
tree.end

base ad:0x8010c018
tree "2DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
tree.end

base ad:0x8010c01c
tree "2WMRK"
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
tree.end

base ad:0x8010c020
tree "2IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
tree.end

base ad:0x8010c024
tree "2RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
tree.end

base ad:0x8010c028
tree "2MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
tree.end

base ad:0x8010c02c
tree "2ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
tree.end

base ad:0x8010c030
tree "2MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8010c034
tree "2RCV"
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
tree.end

base ad:0x8010c038
tree "2RCM"
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
tree.end

base ad:0x8010c040
tree "2TCE0"
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
tree.end

base ad:0x8010c044
tree "2TCE1"
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
tree.end

base ad:0x8010c048
tree "2TCE2"
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
tree.end

base ad:0x8010c04c
tree "2TCE3"
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
tree.end

base ad:0x8010c060
tree "2RCE0"
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
tree.end

base ad:0x8010c064
tree "2RCE1"
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
tree.end

base ad:0x8010c068
tree "2RCE2"
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
tree.end

base ad:0x8010c06c
tree "2RCE3"
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
tree.end

base ad:0x8010c070
tree "2IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8010c080
tree "2ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
tree.end

base ad:0x8010c084
tree "2ITIP"
group 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010c088
tree "2ITOP"
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010c08c
tree "2TSTDR"
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010cfe0
tree "2PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010cfe4
tree "2PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010cfe8
tree "2PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010cfec
tree "2PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010cff0
tree "2PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010cff4
tree "2PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010cff8
tree "2PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010cffc
tree "2PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
tree.end

tree.end

base ad:0x80159000
;********************************************
tree "MSP-1"
;********************************************
base ad:0x80159000
tree "1DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
tree.end

base ad:0x80159004
tree "1GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
tree.end

base ad:0x80159008
tree "1TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8015900c
tree "1RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80159010
tree "1SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
tree.end

base ad:0x80159014
tree "1FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
tree.end

base ad:0x80159018
tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
tree.end

base ad:0x8015901c
tree "1WMRK"
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
tree.end

base ad:0x80159020
tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
tree.end

base ad:0x80159024
tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
tree.end

base ad:0x80159028
tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
tree.end

base ad:0x8015902c
tree "1ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
tree.end

base ad:0x80159030
tree "1MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80159034
tree "1RCV"
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
tree.end

base ad:0x80159038
tree "1RCM"
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
tree.end

base ad:0x80159040
tree "1TCE0"
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
tree.end

base ad:0x80159044
tree "1TCE1"
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
tree.end

base ad:0x80159048
tree "1TCE2"
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
tree.end

base ad:0x8015904c
tree "1TCE3"
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
tree.end

base ad:0x80159060
tree "1RCE0"
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
tree.end

base ad:0x80159064
tree "1RCE1"
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
tree.end

base ad:0x80159068
tree "1RCE2"
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
tree.end

base ad:0x8015906c
tree "1RCE3"
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
tree.end

base ad:0x80159070
tree "1IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80159080
tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
tree.end

base ad:0x80159084
tree "1ITIP"
group 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
tree.end

base ad:0x80159088
tree "1ITOP"
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
tree.end

base ad:0x8015908c
tree "1TSTDR"
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
tree.end

base ad:0x80159fe0
tree "1PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
tree.end

base ad:0x80159fe4
tree "1PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
tree.end

base ad:0x80159fe8
tree "1PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
tree.end

base ad:0x80159fec
tree "1PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
tree.end

base ad:0x80159ff0
tree "1PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
tree.end

base ad:0x80159ff4
tree "1PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
tree.end

base ad:0x80159ff8
tree "1PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
tree.end

base ad:0x80159ffc
tree "1PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
tree.end

tree.end

tree.end

;==============================================================
tree "MSSTPIU"
;==============================================================
base ad:0x801a0000
tree "PORTSIZE"
rgroup 0--3
line.long 0 "PORTSIZE"
bitfld.long 0 0. " PORTSIZE "  "0 ,1 "
tree.end

base ad:0x801a0004
tree "CURRPORTSIZE"
group 0--3
line.long 0 "CURRPORTSIZE"
hexfld.long 0 " CURRPORTSIZE "
tree.end

base ad:0x801a0100
tree "SUPPTRIGMODES"
rgroup 0--3
line.long 0 "SUPPTRIGMODES"
bitfld.long 0 0. " MULT2 "  "0 ,1 "
bitfld.long 0 1. " MULT4 "  "0 ,1 "
bitfld.long 0 2. " MULT16 "  "0 ,1 "
bitfld.long 0 3. " MULT256 "  "0 ,1 "
bitfld.long 0 4. " MULT64K "  "0 ,1 "
bitfld.long 0 8. " TCOUNT8 "  "0 ,1 "
bitfld.long 0 16. " TRIGGERED "  "0 ,1 "
bitfld.long 0 17. " TRGRUN "  "0 ,1 "
tree.end

base ad:0x801a0104
tree "TRIGCOUNT"
group 0--3
line.long 0 "TRIGCOUNT"
hexfld.byte 0 " TRIGCOUNT "
tree.end

base ad:0x801a0108
tree "TRIGMULT"
group 0--3
line.long 0 "TRIGMULT"
bitfld.long 0 0. " MULT2 "  "0 ,1 "
bitfld.long 0 1. " MULT4 "  "0 ,1 "
bitfld.long 0 2. " MULT16 "  "0 ,1 "
bitfld.long 0 3. " MULT256 "  "0 ,1 "
bitfld.long 0 4. " MULT64K "  "0 ,1 "
tree.end

base ad:0x801a0200
tree "SUPPTESTPAT"
rgroup 0--3
line.long 0 "SUPPTESTPAT"
bitfld.long 0 0. " PATW1 "  "0 ,1 "
bitfld.long 0 1. " PATW0 "  "0 ,1 "
bitfld.long 0 2. " PATA5 "  "0 ,1 "
bitfld.long 0 3. " PATF0 "  "0 ,1 "
bitfld.long 0 16. " PTIMEEN "  "0 ,1 "
bitfld.long 0 17. " PCONTEN "  "0 ,1 "
tree.end

base ad:0x801a0204
tree "CURRTESTPAT"
group 0--3
line.long 0 "CURRTESTPAT"
bitfld.long 0 0. " PATW1 "  "0 ,1 "
bitfld.long 0 1. " PATW0 "  "0 ,1 "
bitfld.long 0 2. " PATA5 "  "0 ,1 "
bitfld.long 0 3. " PATF0 "  "0 ,1 "
bitfld.long 0 16. " PTIMEEN "  "0 ,1 "
bitfld.long 0 17. " PCONTEN "  "0 ,1 "
tree.end

base ad:0x801a0208
tree "TESTPATTREPCNT"
group 0--3
line.long 0 "TESTPATTREPCNT"
hexfld.byte 0 " PATTCOUNT "
tree.end

base ad:0x801a0300
tree "FORMATSTAT"
rgroup 0--3
line.long 0 "FORMATSTAT"
bitfld.long 0 0. " FIP "  "0 ,1 "
bitfld.long 0 1. " FTS "  "0 ,1 "
bitfld.long 0 2. " TCP "  "0 ,1 "
tree.end

base ad:0x801a0304
tree "FORMATCTRL"
group 0--3
line.long 0 "FORMATCTRL"
bitfld.long 0 0. " ENFTC "  "0 ,1 "
bitfld.long 0 1. " ENFCONT "  "0 ,1 "
bitfld.long 0 4. " FONFLIN "  "0 ,1 "
bitfld.long 0 5. " FONTRIG "  "0 ,1 "
bitfld.long 0 6. " FONMAN "  "0 ,1 "
bitfld.long 0 8. " TRIGIN "  "0 ,1 "
bitfld.long 0 9. " TRIGEVT "  "0 ,1 "
bitfld.long 0 10. " TRIGFL "  "0 ,1 "
bitfld.long 0 12. " STOPFI "  "0 ,1 "
bitfld.long 0 13. " STOPTRIG "  "0 ,1 "
tree.end

base ad:0x801a0308
tree "FORMATSYNC"
group 0--3
line.long 0 "FORMATSYNC"
bitfld.long 0 0.--11. " CYCCOUNT "  " "
tree.end

base ad:0x801a0400
tree "EXTCTLIN"
group 0--3
line.long 0 "EXTCTLIN"
bitfld.long 0 0. " EXTCTLIN "  "0 ,1 "
tree.end

base ad:0x801a0404
tree "EXTCTLOUT"
group 0--3
line.long 0 "EXTCTLOUT"
bitfld.long 0 0. " EXTCTLOUT "  "0 ,1 "
tree.end

base ad:0x801a0ee4
tree "ITTRFLINACK"
wgroup 0--3
line.long 0 "ITTRFLINACK"
bitfld.long 0 0. " ITTRFLINACK "  "0 ,1 "
tree.end

base ad:0x801a0ee8
tree "ITTRFLIN"
group 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0. " ITTRFLIN "  "0 ,1 "
tree.end

base ad:0x801a0eec
tree "ITATBDATA0"
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ITATBDATA0 "  "0 ,1 "
tree.end

base ad:0x801a0ef0
tree "ITATBCTR2"
wgroup 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ITATBCTR2 "  "0 ,1 "
tree.end

base ad:0x801a0ef4
tree "ITATBCTR1"
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0. " ITATBCTR1 "  "0 ,1 "
tree.end

base ad:0x801a0ef8
tree "ITATBCTR0"
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ITATBCTR0 "  "0 ,1 "
tree.end

base ad:0x801a0f00
tree "IMCR"
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " IMCR "  "0 ,1 "
tree.end

base ad:0x801a0fa0
tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801a0fa4
tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801a0fb0
tree "LAR"
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
tree.end

base ad:0x801a0fb4
tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x801a0fb8
tree "ASR"
rgroup 0--3
line.long 0 "ASR"
hexfld.byte 0 " ASR "
tree.end

base ad:0x801a0fc8
tree "DevID"
rgroup 0--3
line.long 0 "DevID"
bitfld.long 0 0. " DevID "  "0 ,1 "
tree.end

base ad:0x801a0fcc
tree "Dev"
rgroup 0--3
line.long 0 "Dev"
hexfld.byte 0 " Dev "
tree.end

base ad:0x801a0fd0
tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
tree.end

base ad:0x801a0fd4
tree "PERIPHERAL_ID5"
group 0--3
line.long 0 "PERIPHERAL_ID5"
hexfld.byte 0 " PERIPHERAL_ID5 "
tree.end

base ad:0x801a0fd8
tree "PERIPHERAL_ID6"
group 0--3
line.long 0 "PERIPHERAL_ID6"
hexfld.byte 0 " PERIPHERAL_ID6 "
tree.end

base ad:0x801a0fdc
tree "PERIPHERAL_ID7"
group 0--3
line.long 0 "PERIPHERAL_ID7"
hexfld.byte 0 " PERIPHERAL_ID7 "
tree.end

base ad:0x801a0fe0
tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
tree.end

base ad:0x801a0fe4
tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
tree.end

base ad:0x801a0fe8
tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
tree.end

base ad:0x801a0fec
tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
tree.end

base ad:0x801a0ff0
tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
hexfld.byte 0 " COMPONENT_ID0 "
tree.end

base ad:0x801a0ff4
tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
tree.end

base ad:0x801a0ff8
tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
tree.end

base ad:0x801a0ffc
tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
tree.end

tree.end

;==============================================================
tree "PKA"
;==============================================================
base ad:0x80124000
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PKAGO "  "0 ,1 "
bitfld.long 0 1. " PKASTOP "  "0 ,1 "
bitfld.long 0 2. " PKARESTORE "  "0 ,1 "
bitfld.long 0 3. " PKACLEAR "  "0 ,1 "
bitfld.long 0 4. " PKARESTART "  "0 ,1 "
tree.end

base ad:0x80124004
tree "CFG"
group 0--3
line.long 0 "CFG"
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGOMODE "  "0 ,1 "
bitfld.long 0 3.--4. " ALGOCALC "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " SECLVL "  "0 ,1 ,2 ,3 "
bitfld.long 0 7.--8. " DATASWAP "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80124008
tree "SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " BUSY "  "0 ,1 "
bitfld.long 0 1. " STATUSSTOP "  "0 ,1 "
bitfld.long 0 2. " STATUSRESTORE "  "0 ,1 "
tree.end

base ad:0x8012400c
tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " PKAIM "  "0 ,1 "
tree.end

base ad:0x80124010
tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " PKARIS "  "0 ,1 "
tree.end

base ad:0x80124014
tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " PKAMIS "  "0 ,1 "
tree.end

base ad:0x80124018
tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " PKAIC "  "0 ,1 "
tree.end

base ad:0x80124800
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0x80124804
tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
tree.end

base ad:0x80124808
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " PKAINTR "  "0 ,1 "
tree.end

base ad:0x80124fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x80124fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80124fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80124fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80124ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PKAPCellID0 "
tree.end

base ad:0x80124ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PKAPCellID1 "
tree.end

base ad:0x80124ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PKAPCellID2 "
tree.end

base ad:0x80124ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PKA0PCellID3 "
tree.end

tree.end

;==============================================================
tree "PMU"
;==============================================================
base ad:0x801c9000
tree "CTRL"
group 0--3
line.long 0 "CTRL"
bitfld.long 0 2. " IOFORCE "  "0 ,1 "
bitfld.long 0 3. " SDMCHLD "  "0 ,1 "
bitfld.long 0 4. " DEEPDIS "  "0 ,1 "
bitfld.long 0 5. " HPIWKEN "  "0 ,1 "
bitfld.long 0 6. " HPIBYPEN "  "0 ,1 "
bitfld.long 0 7. " HPIEV "  "0 ,1 "
bitfld.long 0 8. " HPICTEN "  "0 ,1 "
bitfld.long 0 9. " HPIMOD "  "0 ,1 "
bitfld.long 0 10. " HPIEND "  "0 ,1 "
bitfld.long 0 11. " HPIPSRAM "  "0 ,1 "
bitfld.long 0 15. " GPIORSTCFG "  "0 ,1 "
bitfld.long 0 16.--17. " SXAGPIO "  "0 ,1 ,2 ,3 "
bitfld.long 0 21. " DDR2V5 "  "0 ,1 "
bitfld.long 0 22. " DIFCLCDHiZ "  "0 ,1 "
bitfld.long 0 23.--24. " SDMCSTR "  "0 ,1 ,2 ,3 "
bitfld.long 0 25. " SDMCPDEN "  "0 ,1 "
bitfld.long 0 26. " SDMCZOUTPRG "  "0 ,1 "
bitfld.long 0 27. " HTIMEN "  "0 ,1 "
bitfld.long 0 28. " EXTBRKEN "  "0 ,1 "
bitfld.long 0 30. " DSPDBG "  "0 ,1 "
tree.end

base ad:0x801c9004
tree "STA"
group 0--3
line.long 0 "STA"
bitfld.long 0 0. " RTCWKSTA "  "0 ,1 "
bitfld.long 0 1. " HPIWKSTA "  "0 ,1 "
bitfld.long 0 2. " GP0WKSTA "  "0 ,1 "
bitfld.long 0 3. " GP1WKSTA "  "0 ,1 "
bitfld.long 0 4. " GP2WKSTA "  "0 ,1 "
bitfld.long 0 5. " GP3WKSTA "  "0 ,1 "
bitfld.long 0 6. " GP4WKSTA "  "0 ,1 "
bitfld.long 0 7. " GP5WKSTA "  "0 ,1 "
bitfld.long 0 8. " GP6WKSTA "  "0 ,1 "
bitfld.long 0 9. " SWDGWKSTA "  "0 ,1 "
bitfld.long 0 15. " SCRLOCK "  "0 ,1 "
bitfld.long 0 16. " COMPOK "  "0 ,1 "
bitfld.long 0 17. " DRAMCOMPOK "  "0 ,1 "
bitfld.long 0 18.--24. " DRAMNASRC "  " "
bitfld.long 0 25.--31. " NASRC "  " "
tree.end

base ad:0x801c9008
tree "CTRL2"
group 0--3
line.long 0 "CTRL2"
hexfld.byte 0 " WKUP_TEMPO_CORE "
hexfld.byte 1 " WKUP_TEMPO_CPU "
bitfld.long 0 16. " IOLVLA "  "0 ,1 "
bitfld.long 0 17. " IOLVLB "  "0 ,1 "
bitfld.long 0 18. " IOLVLC "  "0 ,1 "
bitfld.long 0 28. " DRAMCOMPTYP "  "0 ,1 "
bitfld.long 0 29. " DRAMCOMPFRZ "  "0 ,1 "
bitfld.long 0 30. " COMPTYP "  "0 ,1 "
bitfld.long 0 31. " COMPFRZ "  "0 ,1 "
tree.end

base ad:0x801c900c
tree "CTRL3"
group 0--3
line.long 0 "CTRL3"
bitfld.long 0 0. " MSPBYP01AEN "  "0 ,1 "
bitfld.long 0 1. " MSPBYP01CK10 "  "0 ,1 "
bitfld.long 0 2. " MSPBYP01CK01 "  "0 ,1 "
bitfld.long 0 3. " MSPBYP01FS10 "  "0 ,1 "
bitfld.long 0 4. " MSPBYP01FS01 "  "0 ,1 "
bitfld.long 0 8. " MSPBYP03AEN "  "0 ,1 "
bitfld.long 0 9. " MSPBYP03CK30 "  "0 ,1 "
bitfld.long 0 10. " MSPBYP03CK03 "  "0 ,1 "
bitfld.long 0 11. " MSPBYP03FS30 "  "0 ,1 "
bitfld.long 0 12. " MSPBYP03FS03 "  "0 ,1 "
bitfld.long 0 16. " MSP0WR "  "0 ,1 "
bitfld.long 0 17. " MMCI1WR "  "0 ,1 "
bitfld.long 0 18. " MMC2WR "  "0 ,1 "
bitfld.long 0 24. " SAAMSP "  "0 ,1 "
bitfld.long 0 25. " SVAMSP "  "0 ,1 "
bitfld.long 0 26. " SIAMSP "  "0 ,1 "
bitfld.long 0 27. " MSP1CLR "  "0 ,1 "
bitfld.long 0 28. " MSP3CLR "  "0 ,1 "
tree.end

base ad:0x801c9010
tree "SPR0"
group 0--3
line.long 0 "SPR0"
hexfld.long 0 " SPR0 "
tree.end

base ad:0x801c9014
tree "SPR1"
group 0--3
line.long 0 "SPR1"
hexfld.long 0 " SPR1 "
tree.end

base ad:0x801c9018
tree "SPR2"
group 0--3
line.long 0 "SPR2"
hexfld.long 0 " SPR2 "
tree.end

base ad:0x801c901c
tree "SPR3"
group 0--3
line.long 0 "SPR3"
hexfld.long 0 " SPR3 "
tree.end

base ad:0x801c9020
tree "CTRL4"
group 0--3
line.long 0 "CTRL4"
bitfld.long 0 0.--3. " SBAGD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " SBAGT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " MSPBYP13FS13 "  "0 ,1 "
bitfld.long 0 9. " MSPBYP13FS31 "  "0 ,1 "
bitfld.long 0 10. " MSPBYP13CK13 "  "0 ,1 "
bitfld.long 0 11. " MSPBYP13CK31 "  "0 ,1 "
bitfld.long 0 12. " MSPBYP13AEN "  "0 ,1 "
bitfld.long 0 13.--15. " SPARE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--17. " SAADMACH0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " SAADMACH1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " SAADMACH2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " SAADMACH3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801c9028
tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 1. " HWI2C_ABTRIS "  "0 ,1 "
tree.end

base ad:0x801c902c
tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 1. " HWI2CABTIC "  "0 ,1 "
tree.end

base ad:0x801c9030
tree "SWCR"
group 0--3
line.long 0 "SWCR"
bitfld.long 0 0. " SAAEN "  "0 ,1 "
bitfld.long 0 1. " SIAEN "  "0 ,1 "
bitfld.long 0 2. " SVAEN "  "0 ,1 "
bitfld.long 0 3. " SGAEN "  "0 ,1 "
tree.end

base ad:0x801c9034
tree "SWSR"
rgroup 0--3
line.long 0 "SWSR"
bitfld.long 0 0. " SAAST "  "0 ,1 "
bitfld.long 0 1. " SIAST "  "0 ,1 "
bitfld.long 0 2. " SVAST "  "0 ,1 "
bitfld.long 0 3. " SGAST "  "0 ,1 "
bitfld.long 0 4. " COREST "  "0 ,1 "
tree.end

base ad:0x801c9038
tree "CTRL5"
group 0--3
line.long 0 "CTRL5"
bitfld.long 0 0.--1. " SVADMACH0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " SVADMACH1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " SVADMACH2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " SVADMACH3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--17. " SIADMACH0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " SIADMACH1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " SIADMACH2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " SIADMACH3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801c903c
tree "CTRL6"
group 0--3
line.long 0 "CTRL6"
bitfld.long 0 0.--3. " KPSKA0MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " KPSKA1MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " KPSKA2MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " KPSKB0MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " KPSB1MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " KPSKB2MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " KPO8MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 27.--29. " KPO9MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " KBDORETM "  "0 ,1 "
tree.end

base ad:0x801c9040
tree "CTRL7"
group 0--3
line.long 0 "CTRL7"
bitfld.long 0 0.--2. " VPIPPWM8MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--7. " G12_ATTR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801c9060
tree "ATTR0"
group 0--3
line.long 0 "ATTR0"
bitfld.long 0 0.--3. " SAA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " HPI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " SVADSP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " SIADSP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " DMAM1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " SVADMA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DISP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " SGA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801c9064
tree "ATTR1"
group 0--3
line.long 0 "ATTR1"
bitfld.long 0 0.--3. " B2R2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " DMAM2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " ARMM1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " ARMM0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " SIADMA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801c9100
tree "SLVDDCPUVAL"
group 0--3
line.long 0 "SLVDDCPUVAL"
bitfld.long 0 0.--5. " SLVDDCPUVAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " SLEN "  "0 ,1 "
tree.end

base ad:0x801c9104
tree "HWI2C"
group 0--3
line.long 0 "HWI2C"
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 12. " HWGCEN "  "0 ,1 "
bitfld.long 0 14. " STOPEN "  "0 ,1 "
hexfld.byte 2 " REG_ADD "
tree.end

base ad:0x801c9108
tree "HWI2CSR"
rgroup 0--3
line.long 0 "HWI2CSR"
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801c910c
tree "PWRDCNT"
group 0--3
line.long 0 "PWRDCNT"
hexfld.word 0 " INTVAL "
tree.end

base ad:0x801c9f00
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0x801c9f04
tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " nWARMRESET "  "0 ,1 "
bitfld.long 0 1. " SOFTRESREQ "  "0 ,1 "
bitfld.long 0 2. " WDRES "  "0 ,1 "
bitfld.long 0 4. " RTCWKUP "  "0 ,1 "
tree.end

base ad:0x801c9f08
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " PWR_EN "  "0 ,1 "
bitfld.long 0 2. " WAKEUP "  "0 ,1 "
bitfld.long 0 4. " IOFORCE "  "0 ,1 "
bitfld.long 0 5. " SDRAM_HLD "  "0 ,1 "
bitfld.long 0 6. " SOFTRESSTAT "  "0 ,1 "
bitfld.long 0 7. " WATRESSTAT "  "0 ,1 "
bitfld.long 0 8. " EXTRESSTAT "  "0 ,1 "
bitfld.long 0 9. " PORESSTAT "  "0 ,1 "
bitfld.long 0 10. " SLEEPRESSTAT "  "0 ,1 "
bitfld.long 0 18. " FSMCPUP "  "0 ,1 "
bitfld.long 0 19. " SDMCPDEN "  "0 ,1 "
bitfld.long 0 20. " SDMCSTR0 "  "0 ,1 "
bitfld.long 0 21. " SDMCSTR1 "  "0 ,1 "
tree.end

base ad:0x801c9fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0x801c9fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
hexfld.byte 0 " Partnumber1 "
tree.end

base ad:0x801c9fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
hexfld.byte 0 " Partnumber2 "
tree.end

base ad:0x801c9fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Partnumber3 "
tree.end

base ad:0x801c9ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
tree.end

base ad:0x801c9ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
tree.end

base ad:0x801c9ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
tree.end

base ad:0x801c9ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
tree.end

tree.end

;==============================================================
tree "PRCMU"
;==============================================================
base ad:0x80157000
tree "PRCM_ARMCLKFIX_MGT"
group 0--3
line.long 0 "PRCM_ARMCLKFIX_MGT"
bitfld.long 0 0.--4. " ARMCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " ARMCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 9. " ARMCLK26 "  "0 ,1 "
bitfld.long 0 10. " ARMCLK26SRC "  "0 ,1 "
bitfld.long 0 11. " ARMCLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157004
tree "PRCM_ACLK_MGT"
group 0--3
line.long 0 "PRCM_ACLK_MGT"
bitfld.long 0 0.--4. " ACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " ACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " ACLKEN "  "0 ,1 "
bitfld.long 0 9. " ACLK26 "  "0 ,1 "
bitfld.long 0 10. " ACLK26SRC "  "0 ,1 "
bitfld.long 0 11. " ACLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157008
tree "PRCM_SVACLK_MGT"
group 0--3
line.long 0 "PRCM_SVACLK_MGT"
bitfld.long 0 0.--4. " SVACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SVACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SVACLKEN "  "0 ,1 "
bitfld.long 0 9. " SVACLK26 "  "0 ,1 "
bitfld.long 0 10. " SVACLK26SRC "  "0 ,1 "
bitfld.long 0 13. " SVACLK26DIV "  "0 ,1 "
tree.end

base ad:0x8015700c
tree "PRCM_SIACLK_MGT"
group 0--3
line.long 0 "PRCM_SIACLK_MGT"
bitfld.long 0 0.--4. " SIACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SIACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SIACLKEN "  "0 ,1 "
bitfld.long 0 9. " SIACLK26 "  "0 ,1 "
bitfld.long 0 10. " SIACLK26SRC "  "0 ,1 "
bitfld.long 0 13. " SIACLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157014
tree "PRCM_SGACLK_MGT"
group 0--3
line.long 0 "PRCM_SGACLK_MGT"
bitfld.long 0 0.--4. " SGACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SGACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SGACLKEN "  "0 ,1 "
bitfld.long 0 9. " SGACLK26 "  "0 ,1 "
bitfld.long 0 10. " SGACLK26SRC "  "0 ,1 "
bitfld.long 0 11. " SGACLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157018
tree "PRCM_UARTCLK_MGT"
group 0--3
line.long 0 "PRCM_UARTCLK_MGT"
bitfld.long 0 0.--4. " UARTCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " UARTCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 9. " UARTCLK26 "  "0 ,1 "
bitfld.long 0 10. " UARTCLK26SRC "  "0 ,1 "
bitfld.long 0 11. " UARTCLK26DIV "  "0 ,1 "
tree.end

base ad:0x8015701c
tree "PRCM_MSP02CLK_MGT"
group 0--3
line.long 0 "PRCM_MSP02CLK_MGT"
bitfld.long 0 0.--4. " MSP02CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " MSP02CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 9. " MSP02CLK26 "  "0 ,1 "
bitfld.long 0 10. " MSP02CLK26SRC "  "0 ,1 "
bitfld.long 0 11. " MSP02CLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157020
tree "PRCM_I2CCLK_MGT"
group 0--3
line.long 0 "PRCM_I2CCLK_MGT"
bitfld.long 0 0.--4. " I2CCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " I2CCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " I2CCLK26 "  "0 ,1 "
bitfld.long 0 10. " I2CCLK26SRC "  "0 ,1 "
bitfld.long 0 11. " I2CCLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157024
tree "PRCM_SDMMCCLK_MGT"
group 0--3
line.long 0 "PRCM_SDMMCCLK_MGT"
bitfld.long 0 0.--4. " SDMMCCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SDMMCCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLK26 "  "0 ,1 "
bitfld.long 0 10. " SDMMCCLK26SRC "  "0 ,1 "
bitfld.long 0 11. " SDMMCCLK26DIV "  "0 ,1 "
tree.end

base ad:0x8015702c
tree "PRCM_PER1CLK_MGT"
group 0--3
line.long 0 "PRCM_PER1CLK_MGT"
bitfld.long 0 0.--4. " PER1CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER1CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER1CLK26 "  "0 ,1 "
bitfld.long 0 10. " PER1CLK26SRC "  "0 ,1 "
bitfld.long 0 11. " PER1CLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157030
tree "PRCM_PER2CLK_MGT"
group 0--3
line.long 0 "PRCM_PER2CLK_MGT"
bitfld.long 0 0.--4. " PER2CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER2CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER2CLK26 "  "0 ,1 "
bitfld.long 0 10. " PER2CLK26SRC "  "0 ,1 "
bitfld.long 0 11. " PER2CLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157034
tree "PRCM_PER3CLK_MGT"
group 0--3
line.long 0 "PRCM_PER3CLK_MGT"
bitfld.long 0 0.--4. " PER3CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER3CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER3CLK26 "  "0 ,1 "
bitfld.long 0 10. " PER3CLK26SRC "  "0 ,1 "
bitfld.long 0 11. " PER3CLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157038
tree "PRCM_PER5CLK_MGT"
group 0--3
line.long 0 "PRCM_PER5CLK_MGT"
bitfld.long 0 0.--4. " PER5CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER5CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER5CLK26 "  "0 ,1 "
bitfld.long 0 10. " PER5CLK26SRC "  "0 ,1 "
bitfld.long 0 11. " PER5CLK26DIV "  "0 ,1 "
tree.end

base ad:0x8015703c
tree "PRCM_PER6CLK_MGT"
group 0--3
line.long 0 "PRCM_PER6CLK_MGT"
bitfld.long 0 0.--4. " PER6CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER6CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER6CLK26 "  "0 ,1 "
bitfld.long 0 10. " PER6CLK26SRC "  "0 ,1 "
bitfld.long 0 11. " PER6CLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157040
tree "PRCM_IRDACLK_MGT"
group 0--3
line.long 0 "PRCM_IRDACLK_MGT"
bitfld.long 0 0.--4. " IRDACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " IRDACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " IRDACLKEN "  "0 ,1 "
bitfld.long 0 9. " IRDACLK26 "  "0 ,1 "
bitfld.long 0 10. " IRDACLK26SRC "  "0 ,1 "
bitfld.long 0 11. " IRDACLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157044
tree "PRCM_PWMCLK_MGT"
group 0--3
line.long 0 "PRCM_PWMCLK_MGT"
bitfld.long 0 0.--4. " PWMCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PWMCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PWMCLKEN "  "0 ,1 "
bitfld.long 0 9. " PWMCLK26 "  "0 ,1 "
bitfld.long 0 10. " PWMCLK26SRC "  "0 ,1 "
bitfld.long 0 11. " PWMCLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157048
tree "PRCM_SPARE1CLK_MGT"
group 0--3
line.long 0 "PRCM_SPARE1CLK_MGT"
bitfld.long 0 0.--4. " SPARE1CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SPARE1CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE1CLK26 "  "0 ,1 "
bitfld.long 0 10. " SPARE1CLK26SRC "  "0 ,1 "
bitfld.long 0 11. " SPARE1CLK26DIV "  "0 ,1 "
tree.end

base ad:0x8015704c
tree "PRCM_IRRCCLK_MGT"
group 0--3
line.long 0 "PRCM_IRRCCLK_MGT"
bitfld.long 0 0.--4. " IRRCCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " IRRCCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " IRRCCLKEN "  "0 ,1 "
bitfld.long 0 9. " IRRCCLK26 "  "0 ,1 "
bitfld.long 0 10. " IRRCCLK26SRC "  "0 ,1 "
bitfld.long 0 11. " IRRCCLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157058
tree "PRCM_HDMICLK_MGT"
group 0--3
line.long 0 "PRCM_HDMICLK_MGT"
bitfld.long 0 0.--4. " HDMICLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " HDMICLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 9. " HDMICLK26 "  "0 ,1 "
bitfld.long 0 10. " HDMICLK26SRC "  "0 ,1 "
bitfld.long 0 11. " HDMICLK26DIV "  "0 ,1 "
tree.end

base ad:0x8015705c
tree "PRCM_APEATCLK_MGT"
group 0--3
line.long 0 "PRCM_APEATCLK_MGT"
bitfld.long 0 0.--4. " APEATCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " APEATCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 9. " APEATCLK26 "  "0 ,1 "
bitfld.long 0 10. " APEATCLK26SRC "  "0 ,1 "
bitfld.long 0 11. " APEATCLK26DIV "  "0 ,1 "
bitfld.long 0 12. " APEATCLK_DIV4_EN "  "0 ,1 "
tree.end

base ad:0x80157060
tree "PRCM_APETRACECLK_MGT"
group 0--3
line.long 0 "PRCM_APETRACECLK_MGT"
bitfld.long 0 0.--4. " APETRACECLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " APETRACECLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 9. " APETRACECLK26 "  "0 ,1 "
bitfld.long 0 10. " APETRACECLK26SRC "  "0 ,1 "
bitfld.long 0 11. " APETRACECLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157064
tree "PRCM_MCDECLK_MGT"
group 0--3
line.long 0 "PRCM_MCDECLK_MGT"
bitfld.long 0 0.--4. " MCDECLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " MCDECLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 9. " MCDECLK26 "  "0 ,1 "
bitfld.long 0 10. " MCDECLK26SRC "  "0 ,1 "
bitfld.long 0 11. " MCDECLK26DIV "  "0 ,1 "
tree.end

base ad:0x8015706c
tree "PRCM_DSIALTCLK_MGT"
group 0--3
line.long 0 "PRCM_DSIALTCLK_MGT"
bitfld.long 0 0.--4. " DSIALTCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " DSIALTCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 9. " DSIALTCLK26 "  "0 ,1 "
bitfld.long 0 10. " DSIALTCLK26SRC "  "0 ,1 "
bitfld.long 0 11. " DSIALTCLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157070
tree "PRCM_SPARE2CLK_MGT"
group 0--3
line.long 0 "PRCM_SPARE2CLK_MGT"
bitfld.long 0 0.--4. " SPARE2CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SPARE2CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SPARE2CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE2CLK26 "  "0 ,1 "
bitfld.long 0 10. " SPARE2CLK26SRC "  "0 ,1 "
bitfld.long 0 11. " SPARE2CLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157074
tree "PRCM_DMACLK_MGT"
group 0--3
line.long 0 "PRCM_DMACLK_MGT"
bitfld.long 0 0.--4. " DMACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " DMACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " DMACLKEN "  "0 ,1 "
bitfld.long 0 9. " DMACLK26 "  "0 ,1 "
bitfld.long 0 10. " DMACLK26SRC "  "0 ,1 "
bitfld.long 0 11. " DMACLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157078
tree "PRCM_B2R2CLK_MGT"
group 0--3
line.long 0 "PRCM_B2R2CLK_MGT"
bitfld.long 0 0.--4. " B2R2CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " B2R2CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 9. " B2R2CLK26 "  "0 ,1 "
bitfld.long 0 10. " B2R2CLK26SRC "  "0 ,1 "
bitfld.long 0 11. " B2R2CLK26DIV "  "0 ,1 "
tree.end

base ad:0x8015707c
tree "PRCM_TVCLK_MGT"
group 0--3
line.long 0 "PRCM_TVCLK_MGT"
bitfld.long 0 0.--4. " TVCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " TVCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " TVCLKEN "  "0 ,1 "
bitfld.long 0 9. " TVCLK26 "  "0 ,1 "
bitfld.long 0 10. " TVCLK26SRC "  "0 ,1 "
bitfld.long 0 11. " TVCLK26DIV "  "0 ,1 "
tree.end

base ad:0x80157080
tree "PRCM_PLLSOC0_FREQ"
group 0--3
line.long 0 "PRCM_PLLSOC0_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
bitfld.long 0 25. " DIV2EN "  "0 ,1 "
tree.end

base ad:0x80157084
tree "PRCM_PLLSOC1_FREQ"
group 0--3
line.long 0 "PRCM_PLLSOC1_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
tree.end

base ad:0x80157088
tree "PRCM_PLLARM_FREQ"
group 0--3
line.long 0 "PRCM_PLLARM_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
tree.end

base ad:0x8015708c
tree "PRCM_PLLDDR_FREQ"
group 0--3
line.long 0 "PRCM_PLLDDR_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
bitfld.long 0 25. " DIV2EN "  "0 ,1 "
tree.end

base ad:0x80157090
tree "PRCM_PLLSOC0_ENABLE"
group 0--3
line.long 0 "PRCM_PLLSOC0_ENABLE"
bitfld.long 0 0. " PRCM_PLLSOC0_ENABLE "  "0 ,1 "
tree.end

base ad:0x80157094
tree "PRCM_PLLSOC1_ENABLE"
group 0--3
line.long 0 "PRCM_PLLSOC1_ENABLE"
bitfld.long 0 0. " PRCM_PLLSOC1_ENABLE "  "0 ,1 "
tree.end

base ad:0x80157098
tree "PRCM_PLLARM_ENABLE"
group 0--3
line.long 0 "PRCM_PLLARM_ENABLE"
bitfld.long 0 0. " PRCM_PLLARM_ENABLE "  "0 ,1 "
bitfld.long 0 8. " PRCM_PLLARM_COUNTON "  "0 ,1 "
tree.end

base ad:0x8015709c
tree "PRCM_PLLDDR_ENABLE"
group 0--3
line.long 0 "PRCM_PLLDDR_ENABLE"
bitfld.long 0 0. " PRCM_PLLDDR_ENABLE "  "0 ,1 "
tree.end

base ad:0x801570a0
tree "PRCM_PLLSOC0_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLSOC0_LOCKP"
bitfld.long 0 0. " PRCM_PLLSOC0_LOCK10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLSOC0_LOCK3 "  "0 ,1 "
tree.end

base ad:0x801570a4
tree "PRCM_PLLSOC1_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLSOC1_LOCKP"
bitfld.long 0 0. " PRCM_PLLSOC1_LOCK10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLSOC1_LOCK3 "  "0 ,1 "
tree.end

base ad:0x801570a8
tree "PRCM_PLLARM_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLARM_LOCKP"
bitfld.long 0 0. " PRCM_PLLARM_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLARM_LOCKP3 "  "0 ,1 "
tree.end

base ad:0x801570ac
tree "PRCM_PLLDDR_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLDDR_LOCKP"
bitfld.long 0 0. " PRCM_PLLDDR_LOCKP "  "0 ,1 "
tree.end

base ad:0x801570b0
tree "PRCM_XP70CLK_MGT"
group 0--3
line.long 0 "PRCM_XP70CLK_MGT"
bitfld.long 0 1. " PCLKDBG_EN "  "0 ,1 "
bitfld.long 0 2. " PCLKP4GPIO_EN "  "0 ,1 "
bitfld.long 0 3. " P4PRCM_CLK_L2_SW "  "0 ,1 "
bitfld.long 0 4. " CLK26M2CLKGEN_SW "  "0 ,1 "
bitfld.long 0 5.--7. " CLK26M_DDRPLL_SW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--14. " FREERUNNINGOSC_DIV "  " "
bitfld.long 0 15.--19. " P4SUBCLK_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 20. " PCLKMSP1_EN "  "0 ,1 "
bitfld.long 0 21. " PCLKCD_EN "  "0 ,1 "
bitfld.long 0 22. " EVT_FORCESFREERUNNING_CLK "  "0 ,1 "
bitfld.long 0 23.--25. " CLK26M_SOC1PLL_SW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 26. " CLK26MDSI_SW "  "0 ,1 "
bitfld.long 0 27. " MSP1CLK_EN "  "0 ,1 "
bitfld.long 0 28. " CLK26M2CLKGEN_EN "  "0 ,1 "
bitfld.long 0 29. " CLK26M2DSI_EN "  "0 ,1 "
bitfld.long 0 30. " PMBCLK_EN "  "0 ,1 "
bitfld.long 0 31. " TEMP_SENS_EN "  "0 ,1 "
tree.end

base ad:0x801570b4
tree "PRCM_TIMER_0_REF"
group 0--3
line.long 0 "PRCM_TIMER_0_REF"
hexfld.long 0 " PRCM_TIMER_0_REF "
tree.end

base ad:0x801570b8
tree "PRCM_TIMER_0_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_0_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_0_DOWNCOUNT "
tree.end

base ad:0x801570bc
tree "PRCM_TIMER_0_MODE"
group 0--3
line.long 0 "PRCM_TIMER_0_MODE"
bitfld.long 0 0. " PRCM_TIMER_0_MODE "  "0 ,1 "
tree.end

base ad:0x801570c0
tree "PRCM_TIMER_1_REF"
group 0--3
line.long 0 "PRCM_TIMER_1_REF"
hexfld.long 0 " PRCM_TIMER_1_REF "
tree.end

base ad:0x801570c4
tree "PRCM_TIMER_1_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_1_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_1_DOWNCOUNT "
tree.end

base ad:0x801570c8
tree "PRCM_TIMER_1_MODE"
group 0--3
line.long 0 "PRCM_TIMER_1_MODE"
bitfld.long 0 0. " PRCM_TIMER_1_MODE "  "0 ,1 "
tree.end

base ad:0x801570cc
tree "PRCM_TIMER_2_REF"
group 0--3
line.long 0 "PRCM_TIMER_2_REF"
hexfld.long 0 " PRCM_TIMER_2_REF "
tree.end

base ad:0x801570d0
tree "PRCM_TIMER_2_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_2_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_2_DOWNCOUNT "
tree.end

base ad:0x801570d4
tree "PRCM_TIMER_2_MODE"
group 0--3
line.long 0 "PRCM_TIMER_2_MODE"
bitfld.long 0 0. " PRCM_TIMER_2_MODE "  "0 ,1 "
tree.end

base ad:0x801570e8
tree "PRCM_MODECLK"
group 0--3
line.long 0 "PRCM_MODECLK"
bitfld.long 0 0.--2. " PRCM_MODECLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801570f0
tree "PRCM_ARM_IT_SET"
group 0--3
line.long 0 "PRCM_ARM_IT_SET"
bitfld.long 0 0. " PRCM_ARM_IT_SET "  "0 ,1 "
tree.end

base ad:0x801570f4
tree "PRCM_ARM_IT_CLR"
group 0--3
line.long 0 "PRCM_ARM_IT_CLR"
bitfld.long 0 0. " PRCM_ARM_IT_CLR "  "0 ,1 "
tree.end

base ad:0x801570f8
tree "PRCM_4500_CLK_REQ"
group 0--3
line.long 0 "PRCM_4500_CLK_REQ"
bitfld.long 0 0. " SYSCLKREQ "  "0 ,1 "
bitfld.long 0 16. " PRCM_MODSYSCLKREQ_EN "  "0 ,1 "
tree.end

base ad:0x801570fc
tree "PRCM_MBOX_CPU_VAL"
rgroup 0--3
line.long 0 "PRCM_MBOX_CPU_VAL"
bitfld.long 0 0. " XP70_IT_EVENT_10 "  "0 ,1 "
bitfld.long 0 1. " XP70_IT_EVENT_11 "  "0 ,1 "
bitfld.long 0 2. " XP70_IT_EVENT_12 "  "0 ,1 "
bitfld.long 0 3. " XP70_IT_EVENT_13 "  "0 ,1 "
bitfld.long 0 4. " XP70_IT_EVENT_16 "  "0 ,1 "
bitfld.long 0 5. " XP70_IT_EVENT_17 "  "0 ,1 "
bitfld.long 0 6. " XP70_IT_EVENT_18 "  "0 ,1 "
bitfld.long 0 7. " XP70_IT_EVENT_19 "  "0 ,1 "
tree.end

base ad:0x80157100
tree "PRCM_MBOX_CPU_SET"
wgroup 0--3
line.long 0 "PRCM_MBOX_CPU_SET"
bitfld.long 0 0. " XP70_IT_EVENT_10 "  "0 ,1 "
bitfld.long 0 1. " XP70_IT_EVENT_11 "  "0 ,1 "
bitfld.long 0 2. " XP70_IT_EVENT_12 "  "0 ,1 "
bitfld.long 0 3. " XP70_IT_EVENT_13 "  "0 ,1 "
bitfld.long 0 4. " XP70_IT_EVENT_16 "  "0 ,1 "
bitfld.long 0 5. " XP70_IT_EVENT_17 "  "0 ,1 "
bitfld.long 0 6. " XP70_IT_EVENT_18 "  "0 ,1 "
bitfld.long 0 7. " XP70_IT_EVENT_19 "  "0 ,1 "
tree.end

base ad:0x80157104
tree "PRCM_MBOX_CPU_CLR"
wgroup 0--3
line.long 0 "PRCM_MBOX_CPU_CLR"
bitfld.long 0 0. " XP70_IT_EVENT_10 "  "0 ,1 "
bitfld.long 0 1. " XP70_IT_EVENT_11 "  "0 ,1 "
bitfld.long 0 2. " XP70_IT_EVENT_12 "  "0 ,1 "
bitfld.long 0 3. " XP70_IT_EVENT_13 "  "0 ,1 "
bitfld.long 0 4. " XP70_IT_EVENT_16 "  "0 ,1 "
bitfld.long 0 5. " XP70_IT_EVENT_17 "  "0 ,1 "
bitfld.long 0 6. " XP70_IT_EVENT_18 "  "0 ,1 "
bitfld.long 0 7. " XP70_IT_EVENT_19 "  "0 ,1 "
tree.end

base ad:0x8015710c
tree "PRCM_PLL32K_ENABLE"
group 0--3
line.long 0 "PRCM_PLL32K_ENABLE"
bitfld.long 0 0. " PRCM_PLL32K_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLL32K_BIDIR_OEN "  "0 ,1 "
bitfld.long 0 2. " PRCM_PLL32K_GATE_EN "  "0 ,1 "
tree.end

base ad:0x80157110
tree "PRCM_PLL32K_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLL32K_LOCKP"
bitfld.long 0 0. " PRCM_PLL32K_LOCKP "  "0 ,1 "
tree.end

base ad:0x80157114
tree "PRCM_ARM_CHGCLKREQ"
group 0--3
line.long 0 "PRCM_ARM_CHGCLKREQ"
bitfld.long 0 0. " PRCM_ARM_CHGCLKREQ "  "0 ,1 "
bitfld.long 0 16. " PRCM_ARM_DIVSEL "  "0 ,1 "
tree.end

base ad:0x80157118
tree "PRCM_ARM_PLLDIVPS"
group 0--3
line.long 0 "PRCM_ARM_PLLDIVPS"
bitfld.long 0 0.--5. " ARM_BRM_RATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8.--9. " ARM_BRM_IDLEDIV "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " ARM_BRM_IDLEEN "  "0 ,1 "
bitfld.long 0 16.--17. " ARM_PLL_OBSDIV "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " ARM_PLL_OBSEN "  "0 ,1 "
tree.end

base ad:0x8015711c
tree "PRCM_ARMITMSK31TO0"
group 0--3
line.long 0 "PRCM_ARMITMSK31TO0"
hexfld.long 0 " PRCM_ARMITMSK31TO0 "
tree.end

base ad:0x80157120
tree "PRCM_ARMITMSK63TO32"
group 0--3
line.long 0 "PRCM_ARMITMSK63TO32"
hexfld.long 0 " PRCM_ARMITMSK63TO32 "
tree.end

base ad:0x80157124
tree "PRCM_ARMITMSK95TO64"
group 0--3
line.long 0 "PRCM_ARMITMSK95TO64"
hexfld.long 0 " PRCM_ARMITMSK95TO64 "
tree.end

base ad:0x80157128
tree "PRCM_ARMITMSK127TO96"
group 0--3
line.long 0 "PRCM_ARMITMSK127TO96"
hexfld.long 0 " PRCM_ARMITMSK127TO96 "
tree.end

base ad:0x80157130
tree "PRCM_ARMSTANDBY_STATUS"
group 0--3
line.long 0 "PRCM_ARMSTANDBY_STATUS"
bitfld.long 0 0. " PL320_IDLE "  "0 ,1 "
bitfld.long 0 1. " STANDBYWFE_0 "  "0 ,1 "
bitfld.long 0 2. " STANDBYWFE_1 "  "0 ,1 "
bitfld.long 0 3. " STANDBYWFI_0 "  "0 ,1 "
bitfld.long 0 4. " STANDBYWFI_1 "  "0 ,1 "
bitfld.long 0 5. " STANDBYWFI_WFE "  "0 ,1 "
bitfld.long 0 6. " EVENT_O "  "0 ,1 "
tree.end

base ad:0x80157134
tree "PRCM_CGATING_BYPASS"
group 0--3
line.long 0 "PRCM_CGATING_BYPASS"
bitfld.long 0 0. " PRCMCKGEN_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 1. " APECKGEN_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 2. " DSS_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 3. " DMA_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 4. " ICN0_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 5. " ICN1_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 6. " ICN2_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 7. " ICN3_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 8. " SPARE0_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 9. " SPARE1_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 10. " SPARE2_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 11. " SPARE3_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 12. " SPARE4_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 13. " SPARE5_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 14. " SPARE6_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 15. " SPARE7_CGATING_BYPASS "  "0 ,1 "
tree.end

base ad:0x80157138
tree "PRCM_GPIOCR"
group 0--3
line.long 0 "PRCM_GPIOCR"
bitfld.long 0 0.--3. " DBG_PRCMUC_CMD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " DBG_PRCMUD_CMD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " DBG_PRCMUE_CMD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " DBG_PRCMUF_CMD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 19. " DBG_UART0_F_CMD "  "0 ,1 "
bitfld.long 0 20. " DBG_TRIG_CMD "  "0 ,1 "
bitfld.long 0 21. " DBG_UART0_CMD "  "0 ,1 "
bitfld.long 0 22. " DBG_SBAG_A_CMD "  "0 ,1 "
bitfld.long 0 23. " DBG_BUSMON_CMD "  "0 ,1 "
bitfld.long 0 24. " DBG_USBSIMSE0_CMD "  "0 ,1 "
bitfld.long 0 25. " DBG_USBSIMDAT_CMD "  "0 ,1 "
bitfld.long 0 26. " DBG_USBSIMPDC_CMD "  "0 ,1 "
bitfld.long 0 27. " DBG_USBSIMOE_CMD "  "0 ,1 "
tree.end

base ad:0x8015713c
tree "PRCM_LEMI"
group 0--3
line.long 0 "PRCM_LEMI"
bitfld.long 0 0. " CLKOUT2 "  "0 ,1 "
bitfld.long 0 1. " RESOUTX "  "0 ,1 "
tree.end

base ad:0x80157140
tree "PRCM_COMPCR"
group 0--3
line.long 0 "PRCM_COMPCR"
bitfld.long 0 0. " C1V2COMPTYP "  "0 ,1 "
bitfld.long 0 1. " C1V2COMPFRZ "  "0 ,1 "
bitfld.long 0 2. " C1V2COMPN "  "0 ,1 "
bitfld.long 0 3. " C1V8COMPTQ "  "0 ,1 "
bitfld.long 0 4. " C1V8COMPFRZ "  "0 ,1 "
bitfld.long 0 5. " C1V8COMPN "  "0 ,1 "
bitfld.long 0 6. " C1V8COMPACCURATE "  "0 ,1 "
bitfld.long 0 7. " C1V8COMPFASTFRZ "  "0 ,1 "
bitfld.long 0 16.--22. " C1V8NASRCR "  " "
bitfld.long 0 23.--29. " C1V8PASRCR "  " "
tree.end

base ad:0x80157144
tree "PRCM_COMPSTA"
group 0--3
line.long 0 "PRCM_COMPSTA"
bitfld.long 0 0. " C1V2COMPOK "  "0 ,1 "
bitfld.long 0 2.--8. " C1V2NASRC "  " "
bitfld.long 0 9.--15. " C1V2PASRC "  " "
bitfld.long 0 16. " C1V8COMPOK "  "0 ,1 "
bitfld.long 0 18.--24. " C1V8NASRC "  " "
bitfld.long 0 25.--31. " C1V8PASRC "  " "
tree.end

base ad:0x80157148
tree "PRCM_ITSTATUS0"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS0"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " CD_IRQ_N "  "0 ,1 "
bitfld.long 0 4. " SRPTIMER_IT "  "0 ,1 "
bitfld.long 0 5. " APE_RQ "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " IRQ_N "  "0 ,1 "
tree.end

base ad:0x8015714c
tree "PRCM_ITCLR0"
wgroup 0--3
line.long 0 "PRCM_ITCLR0"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " CD_IRQ_N "  "0 ,1 "
bitfld.long 0 4. " SRPTIMER_IT "  "0 ,1 "
bitfld.long 0 5. " APE_RQ "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " IRQ_N "  "0 ,1 "
tree.end

base ad:0x80157150
tree "PRCM_ITSTATUS1"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS1"
bitfld.long 0 0. " MSP1INTR "  "0 ,1 "
tree.end

base ad:0x80157154
tree "PRCM_ITCLR1"
wgroup 0--3
line.long 0 "PRCM_ITCLR1"
bitfld.long 0 0. " MSP1INTR "  "0 ,1 "
tree.end

base ad:0x80157158
tree "PRCM_ITSTATUS2"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS2"
bitfld.long 0 0. " DDR_RQ "  "0 ,1 "
bitfld.long 0 1. " DDR_LATENCY "  "0 ,1 "
bitfld.long 0 2. " MODEM_ACK "  "0 ,1 "
bitfld.long 0 3. " MOD_MEM_ACK "  "0 ,1 "
tree.end

base ad:0x8015715c
tree "PRCM_ITCLR2"
wgroup 0--3
line.long 0 "PRCM_ITCLR2"
bitfld.long 0 0. " DDR_RQ "  "0 ,1 "
bitfld.long 0 1. " DDR_LATENCY "  "0 ,1 "
bitfld.long 0 2. " MODEM_ACK "  "0 ,1 "
bitfld.long 0 3. " MOD_MEM_ACK "  "0 ,1 "
tree.end

base ad:0x80157160
tree "PRCM_ITSTATUS3"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS3"
bitfld.long 0 1. " POWER_RQ "  "0 ,1 "
bitfld.long 0 2. " M_CLK_RQ "  "0 ,1 "
tree.end

base ad:0x80157164
tree "PRCM_ITCLR3"
wgroup 0--3
line.long 0 "PRCM_ITCLR3"
bitfld.long 0 1. " POWER_RQ "  "0 ,1 "
bitfld.long 0 2. " M_CLK_RQ "  "0 ,1 "
tree.end

base ad:0x80157168
tree "PRCM_ITSTATUS4"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS4"
bitfld.long 0 0. " SWRESET "  "0 ,1 "
bitfld.long 0 1. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 2. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 3. " MOD_WDOG_BARK_N "  "0 ,1 "
bitfld.long 0 4. " SPARE_2 "  "0 ,1 "
bitfld.long 0 5. " SPARE_3 "  "0 ,1 "
tree.end

base ad:0x8015716c
tree "PRCM_ITCLR4"
wgroup 0--3
line.long 0 "PRCM_ITCLR4"
bitfld.long 0 0. " SWRESET "  "0 ,1 "
bitfld.long 0 1. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 2. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 3. " MOD_WDOG_BARK_N "  "0 ,1 "
bitfld.long 0 4. " SPARE_2 "  "0 ,1 "
bitfld.long 0 5. " SPARE_3 "  "0 ,1 "
tree.end

base ad:0x80157170
tree "PRCM_LINE_VALUE"
rgroup 0--3
line.long 0 "PRCM_LINE_VALUE"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " CD_IRQ_N "  "0 ,1 "
bitfld.long 0 4. " SRPTIMER_IT "  "0 ,1 "
bitfld.long 0 5. " APE_RQ "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " IRQ_N "  "0 ,1 "
bitfld.long 0 8. " MSP1INTR "  "0 ,1 "
bitfld.long 0 9. " DDR_RQ "  "0 ,1 "
bitfld.long 0 10. " DDR_LATENCY "  "0 ,1 "
bitfld.long 0 11. " MODEM_ACK "  "0 ,1 "
bitfld.long 0 12. " MOD_MEM_ACK "  "0 ,1 "
bitfld.long 0 13. " SPARE_1 "  "0 ,1 "
bitfld.long 0 14. " POWER_RQ "  "0 ,1 "
bitfld.long 0 15. " M_CLK_RQ "  "0 ,1 "
bitfld.long 0 16. " SPARE_2 "  "0 ,1 "
bitfld.long 0 17. " SWRESET "  "0 ,1 "
bitfld.long 0 18. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 19. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 20. " MOD_WDOG_BARK_N "  "0 ,1 "
bitfld.long 0 23.--30. " GPIO_EVENTS "  " "
bitfld.long 0 31. " SPARE_5 "  "0 ,1 "
tree.end

base ad:0x80157174
tree "PRCM_HOLD_EVT"
group 0--3
line.long 0 "PRCM_HOLD_EVT"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " CD_IRQ_N "  "0 ,1 "
bitfld.long 0 4. " SRPTIMER_IT "  "0 ,1 "
bitfld.long 0 5. " APE_RQ "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " IRQ_N "  "0 ,1 "
bitfld.long 0 8. " MSP1INTR "  "0 ,1 "
bitfld.long 0 9. " DDR_RQ "  "0 ,1 "
bitfld.long 0 10. " DDR_LATENCY "  "0 ,1 "
bitfld.long 0 11. " MODEM_ACK "  "0 ,1 "
bitfld.long 0 12. " MOD_MEM_ACK "  "0 ,1 "
bitfld.long 0 13. " SPARE_1 "  "0 ,1 "
bitfld.long 0 14. " POWER_RQ "  "0 ,1 "
bitfld.long 0 15. " M_CLK_RQ "  "0 ,1 "
bitfld.long 0 16. " SPARE_2 "  "0 ,1 "
bitfld.long 0 17. " SWRESET "  "0 ,1 "
bitfld.long 0 18. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 19. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 20. " MOD_WDOG_BARK_N "  "0 ,1 "
bitfld.long 0 23.--30. " GPIO_EVENTS "  " "
bitfld.long 0 31. " SPARE_5 "  "0 ,1 "
tree.end

base ad:0x80157178
tree "PRCM_EDGE_SENS_L"
group 0--3
line.long 0 "PRCM_EDGE_SENS_L"
bitfld.long 0 0.--1. " RTCWKUP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " RTT0WKUP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " RTT1WKUP "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " CD_IRQ_N "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " SRPTIMER_IT "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " APE_RQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " USB_WKUP "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " IRQ_N "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " MSP1INTR "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " DDR_RQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " DDR_LATENCY "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " MODEM_ACK "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " MOD_MEM_ACK "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " SPARE_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " POWER_RQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " M_CLK_RQ "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8015717c
tree "PRCM_EDGE_SENS_H"
group 0--3
line.long 0 "PRCM_EDGE_SENS_H"
bitfld.long 0 0.--1. " SPARE_2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " SWRESET "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " A9_WDRSTREQ_INT_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " A9_WDRSTREQ_INT_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " MOD_WDOG_BARK_N "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " GPIO_EVENTS_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " GPIO_EVENTS_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " GPIO_EVENTS_2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " GPIO_EVENTS_3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " GPIO_EVENTS_4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " GPIO_EVENTS_5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " GPIO_EVENTS_6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " GPIO_EVENTS_7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " SPARE_5 "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80157188
tree "PRCM_CLKODIV"
group 0--3
line.long 0 "PRCM_CLKODIV"
bitfld.long 0 0.--2. " CLKOUT0_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " CLKOUT1_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80157190
tree "PRCM_DEBUG_CTRL_VAL"
rgroup 0--3
line.long 0 "PRCM_DEBUG_CTRL_VAL"
bitfld.long 0 0. " DBG_MODEM_ACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
tree.end

base ad:0x80157194
tree "PRCM_DEBUG_NOPWRDOWN_VAL"
rgroup 0--3
line.long 0 "PRCM_DEBUG_NOPWRDOWN_VAL"
bitfld.long 0 0. " ARM_DEBUG_NOPOWER_DOWN_REQ "  "0 ,1 "
tree.end

base ad:0x80157198
tree "PRCM_DEBUG_CTRL_ACK"
group 0--3
line.long 0 "PRCM_DEBUG_CTRL_ACK"
bitfld.long 0 2. " MOD_PWRUPREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_CSYSPWRUPACK "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_CDBGRSTACK "  "0 ,1 "
bitfld.long 0 8. " CSYSPWRUP_SWT "  "0 ,1 "
tree.end

base ad:0x8015719c
tree "PRCM_A9PL_FORCE_CLKEN"
group 0--3
line.long 0 "PRCM_A9PL_FORCE_CLKEN"
bitfld.long 0 0. " PRCM_A9PL_FORCE_CLKEN "  "0 ,1 "
bitfld.long 0 1. " PRCM_A9AXI_FORCE_CLKEN "  "0 ,1 "
tree.end

base ad:0x801571a0
tree "PRCM_TPIU_FLUSHIN_REQ"
group 0--3
line.long 0 "PRCM_TPIU_FLUSHIN_REQ"
bitfld.long 0 0. " PRCM_TPIU_FLUSHIN_REQ "  "0 ,1 "
tree.end

base ad:0x801571a4
tree "PRCM_TPIU_FLUSHIN_ACK"
rgroup 0--3
line.long 0 "PRCM_TPIU_FLUSHIN_ACK"
bitfld.long 0 0. " PRCM_TPIU_FLUSHIN_ACK "  "0 ,1 "
tree.end

base ad:0x801571a8
tree "PRCM_STP_FLUSHIN_REQ"
group 0--3
line.long 0 "PRCM_STP_FLUSHIN_REQ"
bitfld.long 0 0. " PRCM_STP_FLUSHIN_REQ "  "0 ,1 "
tree.end

base ad:0x801571ac
tree "PRCM_STP_FLUSHIN_ACK"
rgroup 0--3
line.long 0 "PRCM_STP_FLUSHIN_ACK"
bitfld.long 0 0. " PRCM_STP_FLUSHIN_ACK "  "0 ,1 "
tree.end

base ad:0x801571b0
tree "PRCM_HWI2C_DIV"
group 0--3
line.long 0 "PRCM_HWI2C_DIV"
bitfld.long 0 0.--1. " PRCM_HWI2C_DIV "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x801571b4
tree "PRCM_HWI2C_GO"
group 0--3
line.long 0 "PRCM_HWI2C_GO"
bitfld.long 0 0. " PRCM_HWI2C_GO "  "0 ,1 "
tree.end

base ad:0x801571b8
tree "PRCM_HWI2C_CMD"
group 0--3
line.long 0 "PRCM_HWI2C_CMD"
bitfld.long 0 0. " RWB "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--9. " TSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " HWGCEN "  "0 ,1 "
bitfld.long 0 11. " STOPEN "  "0 ,1 "
hexfld.byte 2 " REG_ADD "
hexfld.byte 3 " REG_DATA "
tree.end

base ad:0x801571bc
tree "PRCM_HWI2C_DATA123"
group 0--3
line.long 0 "PRCM_HWI2C_DATA123"
hexfld.byte 0 " DATA1 "
hexfld.byte 1 " DATA2 "
hexfld.byte 2 " DATA3 "
tree.end

base ad:0x801571c0
tree "PRCM_HWI2C_SR"
rgroup 0--3
line.long 0 "PRCM_HWI2C_SR"
bitfld.long 0 0.--1. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801571c8
tree "PRCM_TCR"
group 0--3
line.long 0 "PRCM_TCR"
bitfld.long 0 0. " TENSEL0 "  "0 ,1 "
bitfld.long 0 1. " TENSEL1 "  "0 ,1 "
bitfld.long 0 2. " TENSEL2 "  "0 ,1 "
bitfld.long 0 3. " TENSEL3 "  "0 ,1 "
bitfld.long 0 4. " TENSEL4 "  "0 ,1 "
bitfld.long 0 5. " TENSEL5 "  "0 ,1 "
bitfld.long 0 6. " TENSEL6 "  "0 ,1 "
bitfld.long 0 7. " TENSEL7 "  "0 ,1 "
bitfld.long 0 16. " STOP_TIMERS "  "0 ,1 "
bitfld.long 0 17. " DOZE_MODE "  "0 ,1 "
tree.end

base ad:0x801571cc
tree "PRCM_CLKOCR"
group 0--3
line.long 0 "PRCM_CLKOCR"
bitfld.long 0 0.--3. " CLKOUT0_SEL0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--13. " CLKOUT0_SEL "  " "
bitfld.long 0 16.--19. " CLKOUT1_SEL0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--29. " CLKOUT1_SEL "  " "
tree.end

base ad:0x801571d0
tree "PRCM_ITSTATUS_DBG"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS_DBG"
bitfld.long 0 0. " DBG_MODEM_ACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " CLKOUTREQ_GPIO_ALTA "  "0 ,1 "
tree.end

base ad:0x801571d4
tree "PRCM_ITCLR_DBG"
wgroup 0--3
line.long 0 "PRCM_ITCLR_DBG"
bitfld.long 0 0. " DBG_MODEM_ACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " CLKOUTREQ_GPIO_ALTA "  "0 ,1 "
tree.end

base ad:0x801571d8
tree "PRCM_LINE_VALUE_DBG"
rgroup 0--3
line.long 0 "PRCM_LINE_VALUE_DBG"
bitfld.long 0 0. " DBG_MODEM_ACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " CLKOUTREQ_GPIO_ALTA "  "0 ,1 "
tree.end

base ad:0x801571dc
tree "PRCM_DBG_HOLD"
group 0--3
line.long 0 "PRCM_DBG_HOLD"
bitfld.long 0 0. " DBG_MODEM_ACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " CLKOUTREQ_GPIO_ALTA "  "0 ,1 "
tree.end

base ad:0x801571e0
tree "PRCM_EDGE_SENS_DBG"
group 0--3
line.long 0 "PRCM_EDGE_SENS_DBG"
bitfld.long 0 0.--1. " DBG_MODEM_ACK "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " DAP_APE_CDBGRSTREQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " CLKOUTREQ_GPIO_ALTA "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x801571e4
tree "PRCM_APE_RESETN_SET"
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "
bitfld.long 0 1. " SGA_M_INITN "  "0 ,1 "
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " DSS_M_INITN "  "0 ,1 "
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " ACCESS_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 11. " SIA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 12. " ACCESS_SS_M_INITN "  "0 ,1 "
bitfld.long 0 13. " ACCESS_SS_MRET_INITN "  "0 ,1 "
bitfld.long 0 14. " DSIPLL_RESETN "  "0 ,1 "
bitfld.long 0 17. " DDR_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 18. " DDR_MOD_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 19. " DDR_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 20. " DDR_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 21. " SPARE_1 "  "0 ,1 "
bitfld.long 0 22. " SIA_PIPE_M_RAD_RESETN "  "0 ,1 "
bitfld.long 0 24. " ESRAM1_INITN "  "0 ,1 "
bitfld.long 0 25. " ESRAM2_INITN "  "0 ,1 "
bitfld.long 0 29. " APE_MEM_INITN "  "0 ,1 "
bitfld.long 0 30. " APE_PWRON_RESETN "  "0 ,1 "
bitfld.long 0 31. " APE_RESETN "  "0 ,1 "
tree.end

base ad:0x801571e8
tree "PRCM_APE_RESETN_CLR"
group 0--3
line.long 0 "PRCM_APE_RESETN_CLR"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "
bitfld.long 0 1. " SGA_M_INITN "  "0 ,1 "
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " DSS_M_INITN "  "0 ,1 "
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " ACCESS_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 11. " SIA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 12. " ACCESS_SS_M_INITN "  "0 ,1 "
bitfld.long 0 13. " ACCESS_SS_MRET_INITN "  "0 ,1 "
bitfld.long 0 14. " DSIPLL_RESETN "  "0 ,1 "
bitfld.long 0 17. " DDR_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 18. " DDR_MOD_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 19. " DDR_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 20. " DDR_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 21. " SPARE_1 "  "0 ,1 "
bitfld.long 0 22. " SIA_PIPE_M_RAD_RESETN "  "0 ,1 "
bitfld.long 0 24. " ESRAM1_INITN "  "0 ,1 "
bitfld.long 0 25. " ESRAM2_INITN "  "0 ,1 "
bitfld.long 0 29. " APE_MEM_INITN "  "0 ,1 "
bitfld.long 0 30. " APE_PWRON_RESETN "  "0 ,1 "
bitfld.long 0 31. " APE_RESETN "  "0 ,1 "
tree.end

base ad:0x801571ec
tree "PRCM_APE_RESETN_VAL"
group 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "
bitfld.long 0 1. " SGA_M_INITN "  "0 ,1 "
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " DSS_M_INITN "  "0 ,1 "
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " ACCESS_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 11. " SIA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 12. " ACCESS_SS_M_INITN "  "0 ,1 "
bitfld.long 0 13. " ACCESS_SS_MRET_INITN "  "0 ,1 "
bitfld.long 0 14. " DSIPLL_RESETN "  "0 ,1 "
bitfld.long 0 17. " DDR_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 18. " DDR_MOD_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 19. " DDR_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 20. " DDR_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 21. " SPARE_1 "  "0 ,1 "
bitfld.long 0 22. " SIA_PIPE_M_RAD_RESETN "  "0 ,1 "
bitfld.long 0 24. " ESRAM1_INITN "  "0 ,1 "
bitfld.long 0 25. " ESRAM2_INITN "  "0 ,1 "
bitfld.long 0 29. " APE_MEM_INITN "  "0 ,1 "
bitfld.long 0 30. " APE_PWRON_RESETN "  "0 ,1 "
bitfld.long 0 31. " APE_RESETN "  "0 ,1 "
tree.end

base ad:0x801571fc
tree "PRCM_MOD_RESETN_SET"
group 0--3
line.long 0 "PRCM_MOD_RESETN_SET"
bitfld.long 0 0. " NRESET "  "0 ,1 "
bitfld.long 0 1. " NCORERESET "  "0 ,1 "
bitfld.long 0 2. " NDBGRESET "  "0 ,1 "
tree.end

base ad:0x80157200
tree "PRCM_MOD_RESETN_CLR"
group 0--3
line.long 0 "PRCM_MOD_RESETN_CLR"
bitfld.long 0 0. " NRESET "  "0 ,1 "
bitfld.long 0 1. " NCORERESET "  "0 ,1 "
bitfld.long 0 2. " NDBGRESET "  "0 ,1 "
tree.end

base ad:0x80157204
tree "PRCM_MOD_RESETN_VAL"
group 0--3
line.long 0 "PRCM_MOD_RESETN_VAL"
bitfld.long 0 0. " NRESET "  "0 ,1 "
bitfld.long 0 1. " NCORERESET "  "0 ,1 "
bitfld.long 0 2. " NDBGRESET "  "0 ,1 "
tree.end

base ad:0x80157208
tree "PRCM_GPIO_RESETN_SET"
group 0--3
line.long 0 "PRCM_GPIO_RESETN_SET"
bitfld.long 0 0. " GPIO_RESETN_GRP0 "  "0 ,1 "
bitfld.long 0 1. " GPIO_RESETN_GRP0_MX "  "0 ,1 "
bitfld.long 0 2. " GPIO_RESETN_GRP1 "  "0 ,1 "
bitfld.long 0 3. " GPIO_RESETN_GRP1_MX "  "0 ,1 "
bitfld.long 0 4. " GPIO_RESETN_GRP2 "  "0 ,1 "
bitfld.long 0 5. " GPIO_RESETN_GRP2_MX "  "0 ,1 "
bitfld.long 0 6. " GPIO_RESETN_GRP3 "  "0 ,1 "
bitfld.long 0 7. " GPIO_RESETN_GRP3_MX "  "0 ,1 "
bitfld.long 0 8. " GPIO_RESETN_GRP4 "  "0 ,1 "
bitfld.long 0 9. " GPIO_RESETN_GRP4_MX "  "0 ,1 "
bitfld.long 0 10. " GPIO_RESETN_GRP5 "  "0 ,1 "
bitfld.long 0 11. " GPIO_RESETN_GRP5_MX "  "0 ,1 "
bitfld.long 0 12. " GPIO_RESETN_GRP6 "  "0 ,1 "
bitfld.long 0 13. " GPIO_RESETN_GRP6_MX "  "0 ,1 "
bitfld.long 0 14. " GPIO_RESETN_GRP7 "  "0 ,1 "
bitfld.long 0 15. " GPIO_RESETN_GRP7_MX "  "0 ,1 "
tree.end

base ad:0x8015720c
tree "PRCM_GPIO_RESETN_CLR"
group 0--3
line.long 0 "PRCM_GPIO_RESETN_CLR"
bitfld.long 0 0. " GPIO_RESETN_GRP0 "  "0 ,1 "
bitfld.long 0 1. " GPIO_RESETN_GRP0_MX "  "0 ,1 "
bitfld.long 0 2. " GPIO_RESETN_GRP1 "  "0 ,1 "
bitfld.long 0 3. " GPIO_RESETN_GRP1_MX "  "0 ,1 "
bitfld.long 0 4. " GPIO_RESETN_GRP2 "  "0 ,1 "
bitfld.long 0 5. " GPIO_RESETN_GRP2_MX "  "0 ,1 "
bitfld.long 0 6. " GPIO_RESETN_GRP3 "  "0 ,1 "
bitfld.long 0 7. " GPIO_RESETN_GRP3_MX "  "0 ,1 "
bitfld.long 0 8. " GPIO_RESETN_GRP4 "  "0 ,1 "
bitfld.long 0 9. " GPIO_RESETN_GRP4_MX "  "0 ,1 "
bitfld.long 0 10. " GPIO_RESETN_GRP5 "  "0 ,1 "
bitfld.long 0 11. " GPIO_RESETN_GRP5_MX "  "0 ,1 "
bitfld.long 0 12. " GPIO_RESETN_GRP6 "  "0 ,1 "
bitfld.long 0 13. " GPIO_RESETN_GRP6_MX "  "0 ,1 "
bitfld.long 0 14. " GPIO_RESETN_GRP7 "  "0 ,1 "
bitfld.long 0 15. " GPIO_RESETN_GRP7_MX "  "0 ,1 "
tree.end

base ad:0x80157210
tree "PRCM_GPIO_RESETN_VAL"
group 0--3
line.long 0 "PRCM_GPIO_RESETN_VAL"
bitfld.long 0 0. " GPIO_RESETN_GRP0 "  "0 ,1 "
bitfld.long 0 1. " GPIO_RESETN_GRP0_MX "  "0 ,1 "
bitfld.long 0 2. " GPIO_RESETN_GRP1 "  "0 ,1 "
bitfld.long 0 3. " GPIO_RESETN_GRP1_MX "  "0 ,1 "
bitfld.long 0 4. " GPIO_RESETN_GRP2 "  "0 ,1 "
bitfld.long 0 5. " GPIO_RESETN_GRP2_MX "  "0 ,1 "
bitfld.long 0 6. " GPIO_RESETN_GRP3 "  "0 ,1 "
bitfld.long 0 7. " GPIO_RESETN_GRP3_MX "  "0 ,1 "
bitfld.long 0 8. " GPIO_RESETN_GRP4 "  "0 ,1 "
bitfld.long 0 9. " GPIO_RESETN_GRP4_MX "  "0 ,1 "
bitfld.long 0 10. " GPIO_RESETN_GRP5 "  "0 ,1 "
bitfld.long 0 11. " GPIO_RESETN_GRP5_MX "  "0 ,1 "
bitfld.long 0 12. " GPIO_RESETN_GRP6 "  "0 ,1 "
bitfld.long 0 13. " GPIO_RESETN_GRP6_MX "  "0 ,1 "
bitfld.long 0 14. " GPIO_RESETN_GRP7 "  "0 ,1 "
bitfld.long 0 15. " GPIO_RESETN_GRP7_MX "  "0 ,1 "
tree.end

base ad:0x80157214
tree "PRCM_RESOUTN_SET"
group 0--3
line.long 0 "PRCM_RESOUTN_SET"
bitfld.long 0 0. " RESOUT0_N "  "0 ,1 "
bitfld.long 0 1. " RESOUT1_N "  "0 ,1 "
bitfld.long 0 2. " RESOUT2_N "  "0 ,1 "
tree.end

base ad:0x80157218
tree "PRCM_RESOUTN_CLR"
group 0--3
line.long 0 "PRCM_RESOUTN_CLR"
bitfld.long 0 0. " RESOUT0_N "  "0 ,1 "
bitfld.long 0 1. " RESOUT1_N "  "0 ,1 "
bitfld.long 0 2. " RESOUT2_N "  "0 ,1 "
tree.end

base ad:0x8015721c
tree "PRCM_RESOUTN_VAL"
rgroup 0--3
line.long 0 "PRCM_RESOUTN_VAL"
bitfld.long 0 0. " RESOUT0_N "  "0 ,1 "
bitfld.long 0 1. " RESOUT1_N "  "0 ,1 "
bitfld.long 0 2. " RESOUT2_N "  "0 ,1 "
tree.end

base ad:0x80157228
tree "PRCM_APE_SOFTRST"
wgroup 0--3
line.long 0 "PRCM_APE_SOFTRST"
bitfld.long 0 0. " PRCM_APE_SOFTRST "  "0 ,1 "
tree.end

base ad:0x80157238
tree "PRCM_SWD_RST_TEMPO"
group 0--3
line.long 0 "PRCM_SWD_RST_TEMPO"
bitfld.long 0 0.--9. " PRCM_SWD_RST_TEMPO "  " "
tree.end

base ad:0x8015723c
tree "PRCM_RST_4500_TEMPO"
group 0--3
line.long 0 "PRCM_RST_4500_TEMPO"
bitfld.long 0 0.--9. " PRCM_RST_4500_TEMPO "  " "
tree.end

base ad:0x80157240
tree "PRCM_APE2MOD_IT_SET"
group 0--3
line.long 0 "PRCM_APE2MOD_IT_SET"
bitfld.long 0 0. " APE2MOD_WDSWRST_N "  "0 ,1 "
bitfld.long 0 1. " SPARE0 "  "0 ,1 "
bitfld.long 0 2. " SPARE1 "  "0 ,1 "
tree.end

base ad:0x80157244
tree "PRCM_APE2MOD_IT_CLR"
group 0--3
line.long 0 "PRCM_APE2MOD_IT_CLR"
bitfld.long 0 0. " APE2MOD_WDSWRST_N "  "0 ,1 "
bitfld.long 0 1. " SPARE0 "  "0 ,1 "
bitfld.long 0 2. " SPARE1 "  "0 ,1 "
tree.end

base ad:0x80157248
tree "PRCM_APE2MOD_IT_VAL"
rgroup 0--3
line.long 0 "PRCM_APE2MOD_IT_VAL"
bitfld.long 0 0. " APE2MOD_WDSWRST_N "  "0 ,1 "
bitfld.long 0 1. " SPARE0 "  "0 ,1 "
bitfld.long 0 2. " SPARE1 "  "0 ,1 "
tree.end

base ad:0x80157250
tree "PRCM_STM_DATA"
wgroup 0--3
line.long 0 "PRCM_STM_DATA"
hexfld.byte 0 " PRCM_STM_DATA "
tree.end

base ad:0x80157254
tree "PRCM_POWER_STATE_SET"
group 0--3
line.long 0 "PRCM_POWER_STATE_SET"
bitfld.long 0 0.--1. " VAPE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " VARM_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " DDR_CONTROLLER "  "0 ,1 "
bitfld.long 0 5.--6. " ACCESS_SS_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SIA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 10. " SVA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 11. " DSS_STATE "  "0 ,1 "
bitfld.long 0 12. " SGA_STATE "  "0 ,1 "
bitfld.long 0 13.--14. " VMODEM_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " CSI_DSI "  "0 ,1 "
bitfld.long 0 16.--17. " ESRAM0_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " ESRAM1_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " ESRAM2_STATE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80157258
tree "PRCM_POWER_STATE_CLR"
group 0--3
line.long 0 "PRCM_POWER_STATE_CLR"
bitfld.long 0 0.--1. " VAPE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " VARM_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " DDR_CONTROLLER "  "0 ,1 "
bitfld.long 0 5.--6. " ACCESS_SS_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SIA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 10. " SVA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 11. " DSS_STATE "  "0 ,1 "
bitfld.long 0 12. " SGA_STATE "  "0 ,1 "
bitfld.long 0 15. " CSI_DSI "  "0 ,1 "
bitfld.long 0 16.--17. " ESRAM0_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " ESRAM1_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " ESRAM2_STATE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8015725c
tree "PRCM_POWER_STATE_VAL"
group 0--3
line.long 0 "PRCM_POWER_STATE_VAL"
bitfld.long 0 0.--1. " VAPE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " VARM_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " DDR_CONTROLLER "  "0 ,1 "
bitfld.long 0 5.--6. " ACCESS_SS_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SIA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 10. " SVA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 11. " DSS_STATE "  "0 ,1 "
bitfld.long 0 12. " SGA_STATE "  "0 ,1 "
bitfld.long 0 15. " CSI_DSI "  "0 ,1 "
bitfld.long 0 16.--17. " ESRAM0_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " ESRAM1_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " ESRAM2_STATE "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80157260
tree "PRCM_ARMITVALUE31TO0"
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE31TO0"
hexfld.long 0 " PRCM_ARMITVALUE31TO0 "
tree.end

base ad:0x80157264
tree "PRCM_ARMITVALUE63TO32"
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE63TO32"
hexfld.long 0 " PRCM_ARMITVALUE63TO32 "
tree.end

base ad:0x80157268
tree "PRCM_ARMITVALUE95TO64"
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE95TO64"
hexfld.long 0 " PRCM_ARMITVALUE95TO64 "
tree.end

base ad:0x8015726c
tree "PRCM_ARMITVALUE127TO96"
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE127TO96"
hexfld.long 0 " PRCM_ARMITVALUE127TO96 "
tree.end

base ad:0x80157270
tree "PRCM_REDUN_LOAD"
group 0--3
line.long 0 "PRCM_REDUN_LOAD"
bitfld.long 0 0. " PRCM_REDUN_GO_ARM "  "0 ,1 "
bitfld.long 0 1. " PRCM_REDUN_GO_SIA "  "0 ,1 "
tree.end

base ad:0x80157274
tree "PRCM_REDUN_STATUS"
group 0--3
line.long 0 "PRCM_REDUN_STATUS"
bitfld.long 0 0. " PRCM_REDUN_OK_ARM "  "0 ,1 "
bitfld.long 0 1. " PRCM_REDUN_OK_SIA "  "0 ,1 "
bitfld.long 0 2. " PRCM_REDUN_OK_ESRAM "  "0 ,1 "
tree.end

base ad:0x80157284
tree "PRCM_RNGCLK_MGT"
group 0--3
line.long 0 "PRCM_RNGCLK_MGT"
bitfld.long 0 0.--4. " RNGCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " RNGCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 9. " RNGCLK26 "  "0 ,1 "
bitfld.long 0 10. " RNGCLK26SRC "  "0 ,1 "
bitfld.long 0 11. " RNGCLK26DIV "  "0 ,1 "
tree.end

base ad:0x801572a0
tree "PRCM_DAP_RESETN_SET"
group 0--3
line.long 0 "PRCM_DAP_RESETN_SET"
bitfld.long 0 0. " DAP_RESETN "  "0 ,1 "
bitfld.long 0 16. " SOC_NRESETDBG "  "0 ,1 "
tree.end

base ad:0x801572a4
tree "PRCM_DAP_RESETN_CLR"
group 0--3
line.long 0 "PRCM_DAP_RESETN_CLR"
bitfld.long 0 0. " DAP_RESETN "  "0 ,1 "
bitfld.long 0 16. " SOC_NRESETDBG "  "0 ,1 "
tree.end

base ad:0x801572a8
tree "PRCM_DAP_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_DAP_RESETN_VAL"
bitfld.long 0 0. " DAP_RESETN "  "0 ,1 "
bitfld.long 0 16. " SOC_NRESETDBG "  "0 ,1 "
tree.end

base ad:0x80157300
tree "PRCM_SRAM_DEDCSTOV"
group 0--3
line.long 0 "PRCM_SRAM_DEDCSTOV"
bitfld.long 0 0.--5. " DC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " DE "  "0 ,1 "
bitfld.long 0 7. " STOV "  "0 ,1 "
tree.end

base ad:0x80157304
tree "PRCM_SRAM_LS_SLEEP"
group 0--3
line.long 0 "PRCM_SRAM_LS_SLEEP"
bitfld.long 0 0. " SGA_SLEEP "  "0 ,1 "
bitfld.long 0 1. " SGA_LS "  "0 ,1 "
bitfld.long 0 2. " SVA_PIPE_SLEEP "  "0 ,1 "
bitfld.long 0 3. " SVA_PIPE_LS "  "0 ,1 "
bitfld.long 0 6. " SIA_PIPE_SLEEP "  "0 ,1 "
bitfld.long 0 7. " SIA_PIPE_LS "  "0 ,1 "
bitfld.long 0 8. " ACCESS_SS_SLEEP "  "0 ,1 "
bitfld.long 0 9. " ACCESS_SS_LS "  "0 ,1 "
bitfld.long 0 10. " DSS_SLEEP "  "0 ,1 "
bitfld.long 0 14. " APE_SLEEP "  "0 ,1 "
bitfld.long 0 18. " ESRAM1_SLEEP "  "0 ,1 "
bitfld.long 0 20. " ESRAM2_SLEEP "  "0 ,1 "
bitfld.long 0 28. " BOOTROM_PDN "  "0 ,1 "
tree.end

base ad:0x80157308
tree "PRCM_SRAM_A9"
group 0--3
line.long 0 "PRCM_SRAM_A9"
bitfld.long 0 0.--5. " A9_DC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " A9_DE "  "0 ,1 "
bitfld.long 0 7. " A9_STOV "  "0 ,1 "
bitfld.long 0 8. " A9_SLEEP "  "0 ,1 "
bitfld.long 0 9. " A9_LS "  "0 ,1 "
tree.end

base ad:0x8015730c
tree "PRCM_ARM_LS_CLAMP"
group 0--3
line.long 0 "PRCM_ARM_LS_CLAMP"
bitfld.long 0 0. " INCLAMP_I "  "0 ,1 "
bitfld.long 0 1. " OUTCLAMP_I "  "0 ,1 "
bitfld.long 0 2. " PLL_INLATCH_I "  "0 ,1 "
tree.end

base ad:0x80157310
tree "PRCM_IOCR"
group 0--3
line.long 0 "PRCM_IOCR"
bitfld.long 0 0. " IOFORCE "  "0 ,1 "
bitfld.long 0 1. " TDO_PULLUP_ENABLE "  "0 ,1 "
tree.end

base ad:0x80157314
tree "PRCM_MODEM_SYSCLKOK"
group 0--3
line.long 0 "PRCM_MODEM_SYSCLKOK"
bitfld.long 0 0.--1. " PRCM_MODEM_SYSCLKOK "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80157318
tree "PRCM_SYSCLKOK_DELAY"
group 0--3
line.long 0 "PRCM_SYSCLKOK_DELAY"
hexfld.byte 0 " PRCM_SYSCLKOK_DELAY "
tree.end

base ad:0x8015731c
tree "PRCM_SYSCLKSTATUS"
rgroup 0--3
line.long 0 "PRCM_SYSCLKSTATUS"
bitfld.long 0 1. " SYSCLKLOCKED "  "0 ,1 "
tree.end

base ad:0x80157320
tree "PRCM_SYSCLKOK_TIMER_START"
wgroup 0--3
line.long 0 "PRCM_SYSCLKOK_TIMER_START"
bitfld.long 0 0. " PRCM_SYSCLKOK_TIMER_START "  "0 ,1 "
tree.end

base ad:0x80157324
tree "PRCM_DSI_SW_RESET"
group 0--3
line.long 0 "PRCM_DSI_SW_RESET"
bitfld.long 0 0. " DSI0_SW_RESETN "  "0 ,1 "
bitfld.long 0 1. " DSI1_SW_RESETN "  "0 ,1 "
tree.end

base ad:0x80157328
tree "PRCM_A9_MASK_REQ"
group 0--3
line.long 0 "PRCM_A9_MASK_REQ"
bitfld.long 0 0. " PRCM_A9_MASK_REQ "  "0 ,1 "
tree.end

base ad:0x8015732c
tree "PRCM_A9_MASK_ACK"
rgroup 0--3
line.long 0 "PRCM_A9_MASK_ACK"
bitfld.long 0 0. " PRCM_A9_MASK_ACK "  "0 ,1 "
tree.end

base ad:0x80157334
tree "PRCM_HOSTACCESS_REQ"
group 0--3
line.long 0 "PRCM_HOSTACCESS_REQ"
bitfld.long 0 0. " HOSTACCESS_REQ "  "0 ,1 "
bitfld.long 0 1.--2. " HOSTACCESS_ID "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80157338
tree "PRCM_TIMER_3_REF"
group 0--3
line.long 0 "PRCM_TIMER_3_REF"
hexfld.long 0 " PRCM_TIMER_3_REF "
tree.end

base ad:0x8015733c
tree "PRCM_TIMER_3_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_3_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_3_DOWNCOUNT "
tree.end

base ad:0x80157340
tree "PRCM_TIMER_3_MODE"
group 0--3
line.long 0 "PRCM_TIMER_3_MODE"
bitfld.long 0 0. " PRCM_TIMER_3_MODE "  "0 ,1 "
tree.end

base ad:0x80157344
tree "PRCM_PMB_SENS_CTRL"
group 0--3
line.long 0 "PRCM_PMB_SENS_CTRL"
bitfld.long 0 0.--3. " SEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--7. " DIV_SPEED "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " DIV_LEAK "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " SENS_RUN "  "0 ,1 "
bitfld.long 0 11.--12. " SMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " AUX_SEL "  "0 ,1 "
bitfld.long 0 14. " ALL_SENS "  "0 ,1 "
bitfld.long 0 15. " PD_SENS "  "0 ,1 "
tree.end

base ad:0x80157348
tree "PRCM_PMB_REF_COUNTER"
group 0--3
line.long 0 "PRCM_PMB_REF_COUNTER"
hexfld.word 0 " REF_COUNTER "
tree.end

base ad:0x8015734c
tree "PRCM_PMB_SENSOR_STATUS"
group 0--3
line.long 0 "PRCM_PMB_SENSOR_STATUS"
hexfld.word 0 " SENSOR_STATUS "
tree.end

base ad:0x80157400
tree "PRCM_SEM"
group 0--3
line.long 0 "PRCM_SEM"
bitfld.long 0 0. " PRCM_SEM "  "0 ,1 "
tree.end

base ad:0x80157404
tree "PRCM_APE_EPOD_CFG"
group 0--3
line.long 0 "PRCM_APE_EPOD_CFG"
bitfld.long 0 0.--1. " VDDI_WAKEUP_CUR_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " VDDI_WAKEUP_CUR_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " VDDI_BIAS_VOLT_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--9. " VDDI_BIAS_VOLT_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--11. " VDDI_BIAS_CUR_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " BIAS_BOOST_VDDI_ESRAM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " VDDI_BIAS_CUR_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16. " BIAS_BOOST_VDDI_MMDSP "  "0 ,1 "
tree.end

base ad:0x80157408
tree "PRCM_DDR_EPOD_CFG"
group 0--3
line.long 0 "PRCM_DDR_EPOD_CFG"
bitfld.long 0 0.--1. " GNDI_WAKEUP_CUR "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " VDDI_WAKEUP_CUR "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " GNDI_BIAS_VOLT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--8. " VDDI_BIAS_VOLT_CTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9.--11. " VDDI_BIAS_VOLT_PHY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--13. " BIAS_CUR_CTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " BIAS_BOOST_GNDI_CTRL "  "0 ,1 "
bitfld.long 0 15.--17. " BIAS_BOOST_VDDI_CTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80157410
tree "PRCM_EPOD_C_SET"
group 0--3
line.long 0 "PRCM_EPOD_C_SET"
bitfld.long 0 0. " ESRAM1_2_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM1_2_RET "  "0 ,1 "
bitfld.long 0 8. " SGA_L_ON "  "0 ,1 "
bitfld.long 0 9. " SGA_M_ON "  "0 ,1 "
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 11. " SVA_M_ON "  "0 ,1 "
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 16. " SIA_M_ON "  "0 ,1 "
bitfld.long 0 17. " ACCESS_SS_L_ON "  "0 ,1 "
bitfld.long 0 18. " ACCESS_SS_M_ON "  "0 ,1 "
bitfld.long 0 19. " ACCESS_SS_M_RET "  "0 ,1 "
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "
bitfld.long 0 21. " DSS_M_ON "  "0 ,1 "
bitfld.long 0 22. " APERAMS_ON "  "0 ,1 "
tree.end

base ad:0x80157414
tree "PRCM_EPOD_C_CLR"
group 0--3
line.long 0 "PRCM_EPOD_C_CLR"
bitfld.long 0 0. " ESRAM1_2_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM1_2_RET "  "0 ,1 "
bitfld.long 0 8. " SGA_L_ON "  "0 ,1 "
bitfld.long 0 9. " SGA_M_ON "  "0 ,1 "
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 11. " SVA_M_ON "  "0 ,1 "
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 16. " SIA_M_ON "  "0 ,1 "
bitfld.long 0 17. " ACCESS_SS_L_ON "  "0 ,1 "
bitfld.long 0 18. " ACCESS_SS_M_ON "  "0 ,1 "
bitfld.long 0 19. " ACCESS_SS_M_RET "  "0 ,1 "
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "
bitfld.long 0 21. " DSS_M_ON "  "0 ,1 "
bitfld.long 0 22. " APERAMS_ON "  "0 ,1 "
tree.end

base ad:0x80157418
tree "PRCM_EPOD_C_VAL"
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 0. " ESRAM1_2_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM1_2_RET "  "0 ,1 "
bitfld.long 0 8. " SGA_L_ON "  "0 ,1 "
bitfld.long 0 9. " SGA_M_ON "  "0 ,1 "
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 11. " SVA_M_ON "  "0 ,1 "
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 16. " SIA_M_ON "  "0 ,1 "
bitfld.long 0 17. " ACCESS_SS_L_ON "  "0 ,1 "
bitfld.long 0 18. " ACCESS_SS_M_ON "  "0 ,1 "
bitfld.long 0 19. " ACCESS_SS_M_RET "  "0 ,1 "
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "
bitfld.long 0 21. " DSS_M_ON "  "0 ,1 "
bitfld.long 0 22. " APERAMS_ON "  "0 ,1 "
tree.end

base ad:0x8015741c
tree "PRCM_EPOD_VOK"
group 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 0. " ESRAM1_2_VOK "  "0 ,1 "
bitfld.long 0 8. " SGA_L_VOK "  "0 ,1 "
bitfld.long 0 9. " SGA_M_VOK "  "0 ,1 "
bitfld.long 0 10. " SVA_L_VOK "  "0 ,1 "
bitfld.long 0 11. " SVA_M_VOK "  "0 ,1 "
bitfld.long 0 15. " SIA_L_VOK "  "0 ,1 "
bitfld.long 0 16. " SIA_M_VOK "  "0 ,1 "
bitfld.long 0 17. " ACCESS_SS_L_VOK "  "0 ,1 "
bitfld.long 0 18. " ACCESS_SS_M_VOK "  "0 ,1 "
bitfld.long 0 19. " ACCESS_SS_MRET_VOK "  "0 ,1 "
bitfld.long 0 20. " DSS_L_VOK "  "0 ,1 "
bitfld.long 0 21. " DSS_M_VOK "  "0 ,1 "
bitfld.long 0 22. " APERAMS_M_VOK "  "0 ,1 "
tree.end

base ad:0x80157420
tree "PRCM_MMIP_LS_CLAMP_SET"
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_SET"
bitfld.long 0 2. " ESRAM2_CLAMP "  "0 ,1 "
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "
bitfld.long 0 11. " DSIPLL_CLAMP "  "0 ,1 "
bitfld.long 0 16. " SGA_CLAMPI "  "0 ,1 "
bitfld.long 0 17. " SVA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 19. " SIA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 21. " DSS_CLAMPI "  "0 ,1 "
bitfld.long 0 22. " DSIPLL_CLAMPI "  "0 ,1 "
tree.end

base ad:0x80157424
tree "PRCM_MMIP_LS_CLAMP_CLR"
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 2. " ESRAM2_CLAMP "  "0 ,1 "
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "
bitfld.long 0 11. " DSIPLL_CLAMP "  "0 ,1 "
bitfld.long 0 16. " SGA_CLAMPI "  "0 ,1 "
bitfld.long 0 17. " SVA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 19. " SIA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 21. " DSS_CLAMPI "  "0 ,1 "
bitfld.long 0 22. " DSIPLL_CLAMPI "  "0 ,1 "
tree.end

base ad:0x80157428
tree "PRCM_MMIP_LS_CLAMP_VAL"
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 2. " ESRAM2_CLAMP "  "0 ,1 "
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "
bitfld.long 0 11. " DSIPLL_CLAMP "  "0 ,1 "
bitfld.long 0 16. " SGA_CLAMPI "  "0 ,1 "
bitfld.long 0 17. " SVA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 19. " SIA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 21. " DSS_CLAMPI "  "0 ,1 "
bitfld.long 0 22. " DSIPLL_CLAMPI "  "0 ,1 "
tree.end

base ad:0x8015742c
tree "PRCM_VSAFE_LS_CLAMP_SET"
group 0--3
line.long 0 "PRCM_VSAFE_LS_CLAMP_SET"
bitfld.long 0 0. " VAPE_VSAFE_FIFOCLAMP "  "0 ,1 "
bitfld.long 0 2. " VAPE_VSAFE_CLAMP_0 "  "0 ,1 "
bitfld.long 0 4. " VAPE_VSAFE_CLAMP_1 "  "0 ,1 "
bitfld.long 0 6. " VAPE_VSAFE_CLAMP_2 "  "0 ,1 "
bitfld.long 0 7. " VPLL_VSAFE_CLAMP "  "0 ,1 "
bitfld.long 0 8. " VANA_VSAFE_CLAMP "  "0 ,1 "
bitfld.long 0 16. " PMB_CLAMP_VARM "  "0 ,1 "
bitfld.long 0 17. " PMB_CLAMP_VAPE "  "0 ,1 "
tree.end

base ad:0x80157430
tree "PRCM_VSAFE_LS_CLAMP_CLR"
group 0--3
line.long 0 "PRCM_VSAFE_LS_CLAMP_CLR"
bitfld.long 0 0. " VAPE_VSAFE_FIFOCLAMP "  "0 ,1 "
bitfld.long 0 2. " VAPE_VSAFE_CLAMP_0 "  "0 ,1 "
bitfld.long 0 4. " VAPE_VSAFE_CLAMP_1 "  "0 ,1 "
bitfld.long 0 6. " VAPE_VSAFE_CLAMP_2 "  "0 ,1 "
bitfld.long 0 7. " VPLL_VSAFE_CLAMP "  "0 ,1 "
bitfld.long 0 8. " VANA_VSAFE_CLAMP "  "0 ,1 "
bitfld.long 0 16. " PMB_CLAMP_VARM "  "0 ,1 "
bitfld.long 0 17. " PMB_CLAMP_VAPE "  "0 ,1 "
tree.end

base ad:0x80157434
tree "PRCM_VSAFE_LS_CLAMP_VAL"
group 0--3
line.long 0 "PRCM_VSAFE_LS_CLAMP_VAL"
bitfld.long 0 0. " VAPE_VSAFE_FIFOCLAMP "  "0 ,1 "
bitfld.long 0 2. " VAPE_VSAFE_CLAMP_0 "  "0 ,1 "
bitfld.long 0 4. " VAPE_VSAFE_CLAMP_1 "  "0 ,1 "
bitfld.long 0 6. " VAPE_VSAFE_CLAMP_2 "  "0 ,1 "
bitfld.long 0 7. " VPLL_VSAFE_CLAMP "  "0 ,1 "
bitfld.long 0 8. " VANA_VSAFE_CLAMP "  "0 ,1 "
bitfld.long 0 16. " PMB_CLAMP_VARM "  "0 ,1 "
bitfld.long 0 17. " PMB_CLAMP_VAPE "  "0 ,1 "
tree.end

base ad:0x80157438
tree "PRCM_DDRSUBSYS_APE_MINBW"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_APE_MINBW"
bitfld.long 0 0.--1. " APE_MIN_BW "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8015743c
tree "PRCM_DDRSUBSYS_STATUS"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_STATUS"
bitfld.long 0 0.--4. " MAIN_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " EFFECTIVE_MIN_BW "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--13. " CORE_DOMAIN_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14.--16. " PHY_DOMAIN_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17.--19. " PLL_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--31. " SPARE "  " "
tree.end

base ad:0x80157440
tree "PRCM_DDRSUBSYS_CONTROL"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_CONTROL"
bitfld.long 0 0. " CORE_BIAS_DISABLE "  "0 ,1 "
bitfld.long 0 1. " CORE_OFF_DISABLE "  "0 ,1 "
bitfld.long 0 2. " PHY_OFF_DISABLE "  "0 ,1 "
bitfld.long 0 3.--4. " SPARE_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " FREQDIV_BY4_DISABLE "  "0 ,1 "
bitfld.long 0 8. " FORCE_PHY_IO_ISOLATION "  "0 ,1 "
bitfld.long 0 9. " VREF_IO_SET_WITH_EXTERNAL_VREF "  "0 ,1 "
bitfld.long 0 10. " MIN_BW_REMAP "  "0 ,1 "
bitfld.long 0 11.--23. " SPARE_2 "  " "
tree.end

base ad:0x80157444
tree "PRCM_DDRSUBSYS_HIGH_LEAK_COND"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_HIGH_LEAK_COND"
tree.end

base ad:0x80157448
tree "PRCM_DDRSUBSYS_CONFIG"
rgroup 0--3
line.long 0 "PRCM_DDRSUBSYS_CONFIG"
bitfld.long 0 0.--1. " DDRCONFIG_REQ "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x8015744c
tree "PRCM_DDRSUBSYS_CONFIG_ACK"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_CONFIG_ACK"
bitfld.long 0 0.--1. " DDRCONFIG_ACK "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80157450
tree "PRCM_TIMER_4_REF"
group 0--3
line.long 0 "PRCM_TIMER_4_REF"
hexfld.long 0 " PRCM_TIMER_4_REF "
tree.end

base ad:0x80157454
tree "PRCM_TIMER_4_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_4_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_4_DOWNCOUNT "
tree.end

base ad:0x80157458
tree "PRCM_TIMER_4_MODE"
group 0--3
line.long 0 "PRCM_TIMER_4_MODE"
bitfld.long 0 0. " PRCM_TIMER_4_MODE "  "0 ,1 "
tree.end

base ad:0x8015745c
tree "PRCM_TIMER_5_REF"
group 0--3
line.long 0 "PRCM_TIMER_5_REF"
hexfld.long 0 " PRCM_TIMER_5_REF "
tree.end

base ad:0x80157460
tree "PRCM_TIMER_5_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_5_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_5_DOWNCOUNT "
tree.end

base ad:0x80157464
tree "PRCM_TIMER_5_MODE"
group 0--3
line.long 0 "PRCM_TIMER_5_MODE"
bitfld.long 0 0. " PRCM_TIMER_5_MODE "  "0 ,1 "
tree.end

base ad:0x8015746c
tree "PRCM_SEM_A9_IT_CLR"
group 0--3
line.long 0 "PRCM_SEM_A9_IT_CLR"
bitfld.long 0 0. " PRCM_SEM_A9_IT_CLR "  "0 ,1 "
tree.end

base ad:0x80157470
tree "PRCM_APE_MEM_REQ"
group 0--3
line.long 0 "PRCM_APE_MEM_REQ"
bitfld.long 0 0. " APE_MEM_REQ "  "0 ,1 "
tree.end

base ad:0x80157474
tree "PRCM_DBG_FORCES_APE_MEM_REQ"
group 0--3
line.long 0 "PRCM_DBG_FORCES_APE_MEM_REQ"
bitfld.long 0 0. " DBG_FORCES_APE_MEM_REQ "  "0 ,1 "
tree.end

base ad:0x80157478
tree "PRCM_APE_MEM_WFX_EN"
group 0--3
line.long 0 "PRCM_APE_MEM_WFX_EN"
bitfld.long 0 0. " PL310_IDLE_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WFI_0_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WFI_1_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WFE_0_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WFE_1_ENABLE "  "0 ,1 "
tree.end

base ad:0x8015747c
tree "PRCM_APE_MEM_LATENCY"
group 0--3
line.long 0 "PRCM_APE_MEM_LATENCY"
bitfld.long 0 0. " APE_MEM_LATENCY "  "0 ,1 "
tree.end

base ad:0x80157480
tree "PRCM_APE_MEM_ACK"
rgroup 0--3
line.long 0 "PRCM_APE_MEM_ACK"
bitfld.long 0 0. " APE_MEM_ACK "  "0 ,1 "
tree.end

base ad:0x80157484
tree "PRCM_ITSTATUS5"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS5"
hexfld.byte 0 " GPIO_EVENTS "
tree.end

base ad:0x80157488
tree "PRCM_ITCLR5"
wgroup 0--3
line.long 0 "PRCM_ITCLR5"
hexfld.byte 0 " GPIO_EVENTS "
tree.end

base ad:0x8015748c
tree "PRCM_ARM_IT1_CLR"
group 0--3
line.long 0 "PRCM_ARM_IT1_CLR"
hexfld.byte 0 " PRCM_ARM_IT1_CLR "
tree.end

base ad:0x80157490
tree "PRCM_ARM_IT1_SET"
group 0--3
line.long 0 "PRCM_ARM_IT1_SET"
hexfld.byte 0 " PRCM_ARM_IT1_SET "
tree.end

base ad:0x80157494
tree "PRCM_ARM_IT1_VAL"
group 0--3
line.long 0 "PRCM_ARM_IT1_VAL"
hexfld.byte 0 " PRCM_ARM_IT1_VAL "
tree.end

base ad:0x80157498
tree "PRCM_MOD_PWR_OK"
group 0--3
line.long 0 "PRCM_MOD_PWR_OK"
bitfld.long 0 0. " PRCM_MOD_PWR_OK "  "0 ,1 "
tree.end

base ad:0x8015749c
tree "PRCM_MOD_APE_ACK"
group 0--3
line.long 0 "PRCM_MOD_APE_ACK"
bitfld.long 0 0. " PRCM_MOD_APE_ACK "  "0 ,1 "
tree.end

base ad:0x801574ac
tree "PRCM_DBG_PWRCTL"
group 0--3
line.long 0 "PRCM_DBG_PWRCTL"
bitfld.long 0 0. " A9PWRUPEN "  "0 ,1 "
bitfld.long 0 1. " MODPWRUPEN "  "0 ,1 "
bitfld.long 0 2. " MODNOPWRDN "  "0 ,1 "
bitfld.long 0 3. " MODDBGCLKEN "  "0 ,1 "
bitfld.long 0 4. " A9DBGCLKEN "  "0 ,1 "
bitfld.long 0 5.--9. " SPARE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x801574b0
tree "PRCM_HWOBS_H"
group 0--3
line.long 0 "PRCM_HWOBS_H"
bitfld.long 0 0.--1. " HW_OBS_SEL_16 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " HW_OBS_SEL_17 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " HW_OBS_EN "  "0 ,1 "
tree.end

base ad:0x801574b4
tree "PRCM_HWOBS_L"
group 0--3
line.long 0 "PRCM_HWOBS_L"
bitfld.long 0 0.--1. " HW_OBS_SEL_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " HW_OBS_SEL_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " HW_OBS_SEL_2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " HW_OBS_SEL_3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " HW_OBS_SEL_4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " HW_OBS_SEL_5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " HW_OBS_SEL_6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " HW_OBS_SEL_7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " HW_OBS_SEL_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " HW_OBS_SEL_9 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " HW_OBS_SEL_10 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " HW_OBS_SEL_11 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " HW_OBS_SEL_12 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " HW_OBS_SEL_13 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " HW_OBS_SEL_14 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " HW_OBS_SEL_15 "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80157500
tree "PRCM_PLLDSI_FREQ"
group 0--3
line.long 0 "PRCM_PLLDSI_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
tree.end

base ad:0x80157504
tree "PRCM_PLLDSI_ENABLE"
group 0--3
line.long 0 "PRCM_PLLDSI_ENABLE"
bitfld.long 0 0. " PRCM_PLLDSI_ENABLE "  "0 ,1 "
tree.end

base ad:0x80157508
tree "PRCM_PLLDSI_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLDSI_LOCKP"
bitfld.long 0 0. " PRCM_PLLDSI_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLDSI_LOCKP3 "  "0 ,1 "
tree.end

base ad:0x8015750c
tree "PRCM_RNG_ENABLE"
group 0--3
line.long 0 "PRCM_RNG_ENABLE"
bitfld.long 0 0. " PRCM_RNG_ENABLE "  "0 ,1 "
tree.end

base ad:0x80157510
tree "PRCM_YYCLKEN0_MGT_SET"
group 0--3
line.long 0 "PRCM_YYCLKEN0_MGT_SET"
bitfld.long 0 0. " ARMCLKFIXEN "  "0 ,1 "
bitfld.long 0 1. " ACLKEN "  "0 ,1 "
bitfld.long 0 2. " SVACLKEN "  "0 ,1 "
bitfld.long 0 3. " SIACLKEN "  "0 ,1 "
bitfld.long 0 4. " SGACLKEN "  "0 ,1 "
bitfld.long 0 5. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 6. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 11. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 12. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 13. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 14. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 15. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 16. " IRDACLKEN "  "0 ,1 "
bitfld.long 0 17. " PWMCLKEN "  "0 ,1 "
bitfld.long 0 18. " IRRCCLKEN "  "0 ,1 "
bitfld.long 0 21. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 22. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 23. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 24. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 26. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 27. " DMACLKEN "  "0 ,1 "
bitfld.long 0 28. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 29. " TVCLKEN "  "0 ,1 "
tree.end

base ad:0x80157514
tree "PRCM_YYCLKEN1_MGT_SET"
group 0--3
line.long 0 "PRCM_YYCLKEN1_MGT_SET"
bitfld.long 0 0. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 8. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE2CLKEN "  "0 ,1 "
tree.end

base ad:0x80157518
tree "PRCM_YYCLKEN0_MGT_CLR"
group 0--3
line.long 0 "PRCM_YYCLKEN0_MGT_CLR"
bitfld.long 0 0. " ARMCLKFIXEN "  "0 ,1 "
bitfld.long 0 1. " ACLKEN "  "0 ,1 "
bitfld.long 0 2. " SVACLKEN "  "0 ,1 "
bitfld.long 0 3. " SIACLKEN "  "0 ,1 "
bitfld.long 0 4. " SGACLKEN "  "0 ,1 "
bitfld.long 0 5. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 6. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 11. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 12. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 13. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 14. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 15. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 16. " IRDACLKEN "  "0 ,1 "
bitfld.long 0 17. " PWMCLKEN "  "0 ,1 "
bitfld.long 0 18. " IRRCCLKEN "  "0 ,1 "
bitfld.long 0 21. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 22. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 23. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 24. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 26. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 27. " DMACLKEN "  "0 ,1 "
bitfld.long 0 28. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 29. " TVCLKEN "  "0 ,1 "
tree.end

base ad:0x8015751c
tree "PRCM_YYCLKEN1_MGT_CLR"
group 0--3
line.long 0 "PRCM_YYCLKEN1_MGT_CLR"
bitfld.long 0 0. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 8. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE2CLKEN "  "0 ,1 "
tree.end

base ad:0x80157520
tree "PRCM_YYCLKEN0_MGT_VAL"
rgroup 0--3
line.long 0 "PRCM_YYCLKEN0_MGT_VAL"
bitfld.long 0 0. " ARMCLKFIXEN "  "0 ,1 "
bitfld.long 0 1. " ACLKEN "  "0 ,1 "
bitfld.long 0 2. " SVACLKEN "  "0 ,1 "
bitfld.long 0 3. " SIACLKEN "  "0 ,1 "
bitfld.long 0 4. " SGACLKEN "  "0 ,1 "
bitfld.long 0 5. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 6. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 11. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 12. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 13. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 14. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 15. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 16. " IRDACLKEN "  "0 ,1 "
bitfld.long 0 17. " PWMCLKEN "  "0 ,1 "
bitfld.long 0 18. " IRRCCLKEN "  "0 ,1 "
bitfld.long 0 21. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 22. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 23. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 24. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 26. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 27. " DMACLKEN "  "0 ,1 "
bitfld.long 0 28. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 29. " TVCLKEN "  "0 ,1 "
tree.end

base ad:0x80157524
tree "PRCM_YYCLKEN1_MGT_VAL"
rgroup 0--3
line.long 0 "PRCM_YYCLKEN1_MGT_VAL"
bitfld.long 0 0. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 8. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE2CLKEN "  "0 ,1 "
tree.end

base ad:0x80157528
tree "PRCM_XP70CLK_MGT2"
group 0--3
line.long 0 "PRCM_XP70CLK_MGT2"
bitfld.long 0 0.--2. " PLL_SOC0_MX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " XP70_CLK_L2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--8. " XP70_CLK_L1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " FREERUNNINGOSC_COMP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8015752c
tree "PRCM_DSITVCLK_DIV"
group 0--3
line.long 0 "PRCM_DSITVCLK_DIV"
hexfld.byte 0 " DSI0_ESC_CLK_DIV "
hexfld.byte 1 " DSI1_ESC_CLK_DIV "
bitfld.long 0 24. " DSI0_ESC_CLK_EN "  "0 ,1 "
bitfld.long 0 25. " DSI1_ESC_CLK_EN "  "0 ,1 "
tree.end

base ad:0x80157530
tree "PRCM_DSI_PLLOUT_SEL"
group 0--3
line.long 0 "PRCM_DSI_PLLOUT_SEL"
bitfld.long 0 0.--2. " DSI0_PLLOUT_DIVSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " DSI1_PLLOUT_DIVSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80157534
tree "PRCM_DSI_GLITCHFREE_EN"
group 0--3
line.long 0 "PRCM_DSI_GLITCHFREE_EN"
bitfld.long 0 0. " DSI0_BYPASS_BYTE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 1. " DSI0_BYPASS_MCDE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 8. " DSI1_BYPASS_BYTE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 9. " DSI1_BYPASS_MCDE_CLK_SYNC "  "0 ,1 "
tree.end

base ad:0x80157538
tree "PRCM_CLKACTIV"
group 0--3
line.long 0 "PRCM_CLKACTIV"
bitfld.long 0 0. " RTCCLK_RUNNING "  "0 ,1 "
bitfld.long 0 1. " REFCLK_RUNNING "  "0 ,1 "
bitfld.long 0 2. " PLLSOC0_RUNNING "  "0 ,1 "
bitfld.long 0 3. " PLLSOC1_RUNNING "  "0 ,1 "
bitfld.long 0 4. " PLLDDR_RUNNING "  "0 ,1 "
bitfld.long 0 6. " ULPPLL_RUNNING "  "0 ,1 "
bitfld.long 0 9. " ARMCLK_RUNNING "  "0 ,1 "
bitfld.long 0 10. " TVCLK_RUNNING "  "0 ,1 "
bitfld.long 0 11. " IRDACLK_RUNNING "  "0 ,1 "
bitfld.long 0 12. " SYSCLK_0_RUNNING "  "0 ,1 "
bitfld.long 0 17. " PLLSOC1_EN "  "0 ,1 "
bitfld.long 0 18. " PLLDDR_DIV12_EN "  "0 ,1 "
bitfld.long 0 19. " PLLDDR_DIV2_EN "  "0 ,1 "
bitfld.long 0 20. " PLLSOC0_DIV12_EN "  "0 ,1 "
bitfld.long 0 21. " PLLSOC0_DIV2_EN "  "0 ,1 "
tree.end

base ad:0x80157544
tree "PRCM_SXA_FORCE_CLKEN"
group 0--3
line.long 0 "PRCM_SXA_FORCE_CLKEN"
bitfld.long 0 0. " SIA "  "0 ,1 "
bitfld.long 0 1. " SVA "  "0 ,1 "
tree.end

base ad:0x80157570
tree "PRCM_UICC_NANDTREE"
group 0--3
line.long 0 "PRCM_UICC_NANDTREE"
tree.end

base ad:0x80157574
tree "PRCM_GPIOCR2"
group 0--3
line.long 0 "PRCM_GPIOCR2"
tree.end

base ad:0x80157578
tree "PRCM_MDM_ACWAKE"
group 0--3
line.long 0 "PRCM_MDM_ACWAKE"
tree.end

base ad:0x80157580
tree "PRCM_PWRCTRL_SET"
group 0--3
line.long 0 "PRCM_PWRCTRL_SET"
bitfld.long 0 0. " PWRCTRL0 "  "0 ,1 "
bitfld.long 0 1. " PWRCTRL1 "  "0 ,1 "
bitfld.long 0 2. " PWRCTRL2 "  "0 ,1 "
tree.end

base ad:0x80157584
tree "PRCM_PWRCTRL_CLR"
group 0--3
line.long 0 "PRCM_PWRCTRL_CLR"
bitfld.long 0 0. " PWRCTRL0 "  "0 ,1 "
bitfld.long 0 1. " PWRCTRL1 "  "0 ,1 "
bitfld.long 0 2. " PWRCTRL2 "  "0 ,1 "
tree.end

base ad:0x80157588
tree "PRCM_PWRCTRL_VAL"
rgroup 0--3
line.long 0 "PRCM_PWRCTRL_VAL"
bitfld.long 0 0. " PWRCTRL0 "  "0 ,1 "
bitfld.long 0 1. " PWRCTRL1 "  "0 ,1 "
bitfld.long 0 2. " PWRCTRL2 "  "0 ,1 "
tree.end

base ad:0x8015758c
tree "PRCM_CLKOCR2"
group 0--3
line.long 0 "PRCM_CLKOCR2"
bitfld.long 0 0.--2. " CLKOCR2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80157590
tree "PRCM_ITSTATUS6"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS6"
hexfld.byte 0 " ACC_STRB_N "
tree.end

base ad:0x80157594
tree "PRCM_ITCLR6"
wgroup 0--3
line.long 0 "PRCM_ITCLR6"
hexfld.byte 0 " ACC_STRB_N "
tree.end

base ad:0x80157598
tree "PRCM_ACC_LINE_VALUE"
rgroup 0--3
line.long 0 "PRCM_ACC_LINE_VALUE"
bitfld.long 0 0. " ACC_STRB_N_0 "  "0 ,1 "
bitfld.long 0 1. " ACC_STRB_N_1 "  "0 ,1 "
bitfld.long 0 2. " ACC_STRB_N_2 "  "0 ,1 "
bitfld.long 0 3. " ACC_STRB_N_3 "  "0 ,1 "
bitfld.long 0 4. " ACC_STRB_N_4 "  "0 ,1 "
bitfld.long 0 5. " ACC_STRB_N_5 "  "0 ,1 "
bitfld.long 0 6. " ACC_STRB_N_6 "  "0 ,1 "
bitfld.long 0 7. " ACC_STRB_N_7 "  "0 ,1 "
bitfld.long 0 8.--31. " SPARE "  " "
tree.end

base ad:0x8015759c
tree "PRCM_EDGE_SENS_ACC"
group 0--3
line.long 0 "PRCM_EDGE_SENS_ACC"
bitfld.long 0 0.--1. " ACC_STRB_N_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " ACC_STRB_N_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " ACC_STRB_N_2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " ACC_STRB_N_3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " ACC_STRB_N_4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " ACC_STRB_N_5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " ACC_STRB_N_6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " ACC_STRB_N_7 "  "0 ,1 ,2 ,3 "
hexfld.word 2 " SPARE "
tree.end

base ad:0x801575a0
tree "PRCM_HOLD_EVT_ACC"
group 0--3
line.long 0 "PRCM_HOLD_EVT_ACC"
bitfld.long 0 0. " ACC_STRB_N "  "0 ,1 "
tree.end

base ad:0x801575a4
tree "PRCM_MOD_MEM_REQ"
group 0--3
line.long 0 "PRCM_MOD_MEM_REQ"
bitfld.long 0 0. " MOD_MEM_REQ_EN "  "0 ,1 "
bitfld.long 0 1. " MOD_MEM_REQ_FORCE "  "0 ,1 "
tree.end

base ad:0x801575a8
tree "PRCM_MOD_MEM_ACK"
group 0--3
line.long 0 "PRCM_MOD_MEM_ACK"
bitfld.long 0 0. " MOD_MEM_ACK_EN "  "0 ,1 "
bitfld.long 0 1. " MOD_MEM_ACK_FORCE "  "0 ,1 "
tree.end

base ad:0x801575ac
tree "PRCM_ACC_STRB_ACK"
group 0--3
line.long 0 "PRCM_ACC_STRB_ACK"
hexfld.byte 0 " PRCM_ACC_STRB_ACK_N "
tree.end

base ad:0x801575b0
tree "PRCM_ARM_PLLDIVPS_REQ"
group 0--3
line.long 0 "PRCM_ARM_PLLDIVPS_REQ"
bitfld.long 0 0. " ARM_BRM_RATEVAL "  "0 ,1 "
bitfld.long 0 4. " ARM_PLL_OBSVAL "  "0 ,1 "
tree.end

base ad:0x801575b4
tree "PRCM_ARM_PLLDIVPS_ACK"
rgroup 0--3
line.long 0 "PRCM_ARM_PLLDIVPS_ACK"
bitfld.long 0 0. " ARM_BRM_RATEACK "  "0 ,1 "
bitfld.long 0 4. " ARM_PLL_OBSACK "  "0 ,1 "
tree.end

base ad:0x801575b8
tree "PRCM_SERVICEMODE"
rgroup 0--3
line.long 0 "PRCM_SERVICEMODE"
bitfld.long 0 0. " SERVICE_N "  "0 ,1 "
tree.end

base ad:0x801575bc
tree "PRCM_DDRSUBSYS_CONTROL2"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_CONTROL2"
bitfld.long 0 0. " PRCM_FORCE_PHY_IO_RESET "  "0 ,1 "
bitfld.long 0 1. " PRCM_FORCE_PHY_IO_ISO "  "0 ,1 "
tree.end

base ad:0x801575d0
tree "PRCM_SRPTIMER_VAL"
group 0--3
line.long 0 "PRCM_SRPTIMER_VAL"
hexfld.byte 0 " SRPTIMER_VAL "
tree.end

base ad:0x801575d8
tree "PRCM_HWI2C_A9_IT_CLR"
group 0--3
line.long 0 "PRCM_HWI2C_A9_IT_CLR"
bitfld.long 0 0. " PRCM_HWI2C_A9_IT_CLR "  "0 ,1 "
tree.end

base ad:0x80158000
tree "PRCM_SECNONSEWM"
group 0--3
line.long 0 "PRCM_SECNONSEWM"
hexfld.word 0 " PRCM_SECNONSECWM "
tree.end

base ad:0x80158004
tree "PRCM_ESRAM0_INITN"
group 0--3
line.long 0 "PRCM_ESRAM0_INITN"
bitfld.long 0 0. " PRCM_ESRAM0_INITN "  "0 ,1 "
tree.end

base ad:0x80158008
tree "PRCM_ARMITMSKSEC_31TO0"
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_31TO0"
hexfld.long 0 " PRCM_ARMITMSKSEC_31TO0 "
tree.end

base ad:0x8015800c
tree "PRCM_ARMITMSKSEC_63TO32"
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_63TO32"
hexfld.long 0 " PRCM_ARMITMSKSEC_63TO32 "
tree.end

base ad:0x80158010
tree "PRCM_ARMITMSKSEC_95TO64"
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_95TO64"
hexfld.long 0 " PRCM_ARMITMSKSEC_95TO64 "
tree.end

base ad:0x80158014
tree "PRCM_ARMITMSKSEC_127TO96"
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_127TO96"
hexfld.long 0 " PRCM_ARMITMSKSEC_127TO96 "
tree.end

base ad:0x80158018
tree "PRCM_ARMIT_MASKXP70_IT"
group 0--3
line.long 0 "PRCM_ARMIT_MASKXP70_IT"
bitfld.long 0 0. " PRCM_ARMIT_MASKXP70_IT "  "0 ,1 "
tree.end

base ad:0x8015801c
tree "PRCM_ESRAM0_EPOD_CFG"
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_CFG"
bitfld.long 0 0.--1. " VDDI_WAKEUP_CUR "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " VDDI_BIAS_VOLT_CTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " BIAS_CUR_CTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " BOOST "  "0 ,1 "
tree.end

base ad:0x80158020
tree "PRCM_ESRAM0_EPOD_C_VAL"
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_C_VAL"
bitfld.long 0 0. " ESRAM0_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_RET "  "0 ,1 "
tree.end

base ad:0x80158024
tree "PRCM_ESRAM0_EPOD_C_SET"
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_C_SET"
bitfld.long 0 0. " ESRAM0_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_RET "  "0 ,1 "
tree.end

base ad:0x80158028
tree "PRCM_ESRAM0_EPOD_C_CLR"
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_C_CLR"
bitfld.long 0 0. " ESRAM0_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_RET "  "0 ,1 "
tree.end

base ad:0x8015802c
tree "PRCM_ESRAM0_EPOD_VOK"
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_VOK"
bitfld.long 0 0. " ESRAM0_VOK "  "0 ,1 "
tree.end

base ad:0x80158030
tree "PRCM_ESRAM0_LS_SLEEP"
group 0--3
line.long 0 "PRCM_ESRAM0_LS_SLEEP"
bitfld.long 0 0. " ESRAM0_SLEEP "  "0 ,1 "
tree.end

base ad:0x80158034
tree "PRCM_SECURE_ONGOING"
group 0--3
line.long 0 "PRCM_SECURE_ONGOING"
bitfld.long 0 0. " SECURE_ONGOING "  "0 ,1 "
tree.end

base ad:0x80158038
tree "PRCM_I2C_SECURE"
group 0--3
line.long 0 "PRCM_I2C_SECURE"
bitfld.long 0 0. " I2C_SECURE "  "0 ,1 "
tree.end

base ad:0x8015803c
tree "PRCM_RESET_STATUS"
group 0--3
line.long 0 "PRCM_RESET_STATUS"
bitfld.long 0 0. " A9_CPU0_WATCHDOG_RESET "  "0 ,1 "
bitfld.long 0 1. " A9_CPU1_WATCHDOG_RESET "  "0 ,1 "
bitfld.long 0 2. " APE_SOFTWARE_RESET "  "0 ,1 "
bitfld.long 0 3. " APE_RESET "  "0 ,1 "
bitfld.long 0 4. " SECURE_WATCHDOG "  "0 ,1 "
bitfld.long 0 5. " POWER_ON_RESET "  "0 ,1 "
bitfld.long 0 6. " A9_RESTART "  "0 ,1 "
bitfld.long 0 7. " APE_RESTART "  "0 ,1 "
bitfld.long 0 8. " MODEM_SOFTWARE_RESET "  "0 ,1 "
tree.end

base ad:0x80158040
tree "PRCM_PERIPH4_RESETN_SET"
group 0--3
line.long 0 "PRCM_PERIPH4_RESETN_SET"
bitfld.long 0 0. " RTC_RESETN "  "0 ,1 "
bitfld.long 0 1. " RTT0_RESETN "  "0 ,1 "
bitfld.long 0 2. " RTT1_RESETN "  "0 ,1 "
bitfld.long 0 3. " BACKUP_RAM_RESETN "  "0 ,1 "
bitfld.long 0 4. " SEC_REG_RESETN "  "0 ,1 "
bitfld.long 0 5. " CLK_PLL_CONF_RESETN "  "0 ,1 "
bitfld.long 0 6. " MSP1_RESETN "  "0 ,1 "
bitfld.long 0 7. " CD_RESETN "  "0 ,1 "
bitfld.long 0 8. " PRESETN_MSP1 "  "0 ,1 "
tree.end

base ad:0x80158044
tree "PRCM_PERIPH4_RESETN_CLR"
group 0--3
line.long 0 "PRCM_PERIPH4_RESETN_CLR"
bitfld.long 0 0. " RTC_RESETN "  "0 ,1 "
bitfld.long 0 1. " RTT0_RESETN "  "0 ,1 "
bitfld.long 0 2. " RTT1_RESETN "  "0 ,1 "
bitfld.long 0 3. " BACKUP_RAM_RESETN "  "0 ,1 "
bitfld.long 0 4. " SEC_REG_RESETN "  "0 ,1 "
bitfld.long 0 5. " CLK_PLL_CONF_RESETN "  "0 ,1 "
bitfld.long 0 6. " MSP1_RESETN "  "0 ,1 "
bitfld.long 0 7. " CD_RESETN "  "0 ,1 "
bitfld.long 0 8. " PRESETN_MSP1 "  "0 ,1 "
tree.end

base ad:0x80158048
tree "PRCM_PERIPH4_RESETN_VAL"
group 0--3
line.long 0 "PRCM_PERIPH4_RESETN_VAL"
bitfld.long 0 0. " RTC_RESETN "  "0 ,1 "
bitfld.long 0 1. " RTT0_RESETN "  "0 ,1 "
bitfld.long 0 2. " RTT1_RESETN "  "0 ,1 "
bitfld.long 0 3. " BACKUP_RAM_RESETN "  "0 ,1 "
bitfld.long 0 4. " SEC_REG_RESETN "  "0 ,1 "
bitfld.long 0 5. " CLK_PLL_CONF_RESETN "  "0 ,1 "
bitfld.long 0 6. " MSP1_RESETN "  "0 ,1 "
bitfld.long 0 7. " CD_RESETN "  "0 ,1 "
bitfld.long 0 8. " PRESETN_MSP1 "  "0 ,1 "
tree.end

base ad:0x8015804c
tree "PRCM_SPAREOUT_SEC"
group 0--3
line.long 0 "PRCM_SPAREOUT_SEC"
hexfld.word 0 " SPAREOUT_SEC "
tree.end

base ad:0x801580d8
tree "PRCM_PIPELINEDCR"
group 0--3
line.long 0 "PRCM_PIPELINEDCR"
hexfld.long 0 " PRCM_PIPELINEDCR "
tree.end

base ad:0x801580dc
tree "PRCM_VOLATILEIOCR"
group 0--3
line.long 0 "PRCM_VOLATILEIOCR"
hexfld.long 0 " PRCM_VOLATILEIOCR "
tree.end

base ad:0x801580e0
tree "PRCM_XP70CFGCR"
group 0--3
line.long 0 "PRCM_XP70CFGCR"
bitfld.long 0 0. " XP70_P_FETCH_EN "  "0 ,1 "
bitfld.long 0 1. " XP70_WAKE_UP "  "0 ,1 "
bitfld.long 0 2. " XP70_EXCEPT_VB "  "0 ,1 "
bitfld.long 0 3. " XP70_IDLE_ACK "  "0 ,1 "
tree.end

base ad:0x801581f0
tree "PRCM_A9_RESETN_SET"
group 0--3
line.long 0 "PRCM_A9_RESETN_SET"
bitfld.long 0 0. " A9_NPORESET "  "0 ,1 "
bitfld.long 0 1. " A9_NRESET_SLICE "  "0 ,1 "
bitfld.long 0 2. " APE_NRESET "  "0 ,1 "
bitfld.long 0 3. " A9_NRESET_DBG "  "0 ,1 "
bitfld.long 0 4. " A9_NRESET_0 "  "0 ,1 "
bitfld.long 0 5. " A9_NRESET_1 "  "0 ,1 "
bitfld.long 0 6. " A9_WD_REQ_RESETN "  "0 ,1 "
bitfld.long 0 7. " A9_NRESET_SWPLL_FF "  "0 ,1 "
tree.end

base ad:0x801581f4
tree "PRCM_A9_RESETN_CLR"
group 0--3
line.long 0 "PRCM_A9_RESETN_CLR"
bitfld.long 0 0. " A9_NPORESET "  "0 ,1 "
bitfld.long 0 1. " A9_NRESET_SLICE "  "0 ,1 "
bitfld.long 0 2. " APE_NRESET "  "0 ,1 "
bitfld.long 0 3. " A9_NRESET_DBG "  "0 ,1 "
bitfld.long 0 4. " A9_NRESET_0 "  "0 ,1 "
bitfld.long 0 5. " A9_NRESET_1 "  "0 ,1 "
bitfld.long 0 6. " A9_WD_REQ_RESETN "  "0 ,1 "
bitfld.long 0 7. " A9_NRESET_SWPLL_FF "  "0 ,1 "
tree.end

base ad:0x801581f8
tree "PRCM_A9_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_A9_RESETN_VAL"
bitfld.long 0 0. " A9_NPORESET "  "0 ,1 "
bitfld.long 0 1. " A9_NRESET_SLICE "  "0 ,1 "
bitfld.long 0 2. " APE_NRESET "  "0 ,1 "
bitfld.long 0 3. " A9_NRESET_DBG "  "0 ,1 "
bitfld.long 0 4. " A9_NRESET_0 "  "0 ,1 "
bitfld.long 0 5. " A9_NRESET_1 "  "0 ,1 "
bitfld.long 0 6. " A9_WD_REQ_RESETN "  "0 ,1 "
bitfld.long 0 7. " A9_NRESET_SWPLL_FF "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "PWM"
;==============================================================
base ad:0x80141000
tree "CTRL_REG_1"
group 0--3
line.long 0 "CTRL_REG_1"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 1. " BM "  "0 ,1 "
bitfld.long 0 2.--15. " PRESCALAR "  " "
tree.end

base ad:0x80141004
tree "DUTY_REG_1"
group 0--3
line.long 0 "DUTY_REG_1"
hexfld.word 0 " DUTY "
tree.end

base ad:0x80141008
tree "PERIOD_REG_1"
group 0--3
line.long 0 "PERIOD_REG_1"
hexfld.word 0 " PERIOD "
tree.end

base ad:0x80141010
tree "BURST_REG_1"
group 0--3
line.long 0 "BURST_REG_1"
bitfld.long 0 0.--8. " NOIB "  " "
tree.end

base ad:0x80141014
tree "SEQUENCE_REG_1"
group 0--3
line.long 0 "SEQUENCE_REG_1"
bitfld.long 0 0.--24. " NOS "  " "
tree.end

base ad:0x80141018
tree "DELAY_REG_1"
group 0--3
line.long 0 "DELAY_REG_1"
bitfld.long 0 0.--24. " DELAY "  " "
tree.end

base ad:0x80141020
tree "CTRL_REG_2"
group 0--3
line.long 0 "CTRL_REG_2"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 1. " BM "  "0 ,1 "
bitfld.long 0 2.--15. " PRESCALAR "  " "
tree.end

base ad:0x80141024
tree "DUTY_REG_2"
group 0--3
line.long 0 "DUTY_REG_2"
hexfld.word 0 " DUTY "
tree.end

base ad:0x80141028
tree "PERIOD_REG_2"
group 0--3
line.long 0 "PERIOD_REG_2"
hexfld.word 0 " PERIOD "
tree.end

base ad:0x80141030
tree "BURST_REG_2"
group 0--3
line.long 0 "BURST_REG_2"
bitfld.long 0 0.--8. " NOIB "  " "
tree.end

base ad:0x80141034
tree "SEQUENCE_REG_2"
group 0--3
line.long 0 "SEQUENCE_REG_2"
bitfld.long 0 0.--24. " NOS "  " "
tree.end

base ad:0x80141038
tree "DELAY_REG_2"
group 0--3
line.long 0 "DELAY_REG_2"
bitfld.long 0 0.--24. " DELAY "  " "
tree.end

base ad:0x80141040
tree "CTRL_REG_3"
group 0--3
line.long 0 "CTRL_REG_3"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 1. " BM "  "0 ,1 "
bitfld.long 0 2.--15. " PRESCALAR "  " "
tree.end

base ad:0x80141044
tree "DUTY_REG_3"
group 0--3
line.long 0 "DUTY_REG_3"
hexfld.word 0 " DUTY "
tree.end

base ad:0x80141048
tree "PERIOD_REG_3"
group 0--3
line.long 0 "PERIOD_REG_3"
hexfld.word 0 " PERIOD "
tree.end

base ad:0x80141050
tree "BURST_REG_3"
group 0--3
line.long 0 "BURST_REG_3"
bitfld.long 0 0.--8. " NOIB "  " "
tree.end

base ad:0x80141054
tree "SEQUENCE_REG_3"
group 0--3
line.long 0 "SEQUENCE_REG_3"
bitfld.long 0 0.--24. " NOS "  " "
tree.end

base ad:0x80141058
tree "DELAY_REG_3"
group 0--3
line.long 0 "DELAY_REG_3"
bitfld.long 0 0.--24. " DELAY "  " "
tree.end

base ad:0x80141060
tree "CTRL_REG_4"
group 0--3
line.long 0 "CTRL_REG_4"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 1. " BM "  "0 ,1 "
bitfld.long 0 2.--15. " PRESCALAR "  " "
tree.end

base ad:0x80141064
tree "DUTY_REG_4"
group 0--3
line.long 0 "DUTY_REG_4"
hexfld.word 0 " DUTY "
tree.end

base ad:0x80141068
tree "PERIOD_REG_4"
group 0--3
line.long 0 "PERIOD_REG_4"
hexfld.word 0 " PERIOD "
tree.end

base ad:0x80141070
tree "BURST_REG_4"
group 0--3
line.long 0 "BURST_REG_4"
bitfld.long 0 0.--8. " NOIB "  " "
tree.end

base ad:0x80141074
tree "SEQUENCE_REG_4"
group 0--3
line.long 0 "SEQUENCE_REG_4"
bitfld.long 0 0.--24. " NOS "  " "
tree.end

base ad:0x80141078
tree "DELAY_REG_4"
group 0--3
line.long 0 "DELAY_REG_4"
bitfld.long 0 0.--24. " DELAY "  " "
tree.end

tree.end

;==============================================================
tree "RNG"
;==============================================================
base ad:0x80120000
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SEC "  "0 ,1 "
bitfld.long 0 1. " PRIV "  "0 ,1 "
bitfld.long 0 2. " RNGDIS "  "0 ,1 "
bitfld.long 0 3. " TSTCLK "  "0 ,1 "
bitfld.long 0 4. " RNGLCK "  "0 ,1 "
tree.end

base ad:0x80120004
tree "SR"
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RNGRDY "  "0 ,1 "
bitfld.long 0 1. " REVCLK "  "0 ,1 "
bitfld.long 0 2. " FAULT "  "0 ,1 "
bitfld.long 0 4. " RNGLCK "  "0 ,1 "
tree.end

base ad:0x80120008
tree "VAL"
group 0--3
line.long 0 "VAL"
bitfld.long 0 0. " 16 "  "0 ,1 "
tree.end

base ad:0x80120fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x80120fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80120fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80120fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80120ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
tree.end

base ad:0x80120ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
tree.end

base ad:0x80120ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
tree.end

base ad:0x80120ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
tree.end

tree.end

;==============================================================
tree "RTC"
;==============================================================
base ad:0x80154000
tree "DR"
rgroup 0--3
line.long 0 "DR"
bitfld.long 0 0.--5. " CWSEC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " WMIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--16. " CWHOUR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 17.--19. " CWDAYW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--24. " CWDAYM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--28. " CWMONTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80154004
tree "MR"
group 0--3
line.long 0 "MR"
bitfld.long 0 0.--5. " CWSECM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " WMINM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--16. " CWHOURM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 17.--19. " CWDAYWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--24. " CWDAYMM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--28. " CWMONTHM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80154008
tree "LR"
group 0--3
line.long 0 "LR"
bitfld.long 0 0.--5. " CWSECL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " WMINL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--16. " CWHOURL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 17.--19. " CWDAYWL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--24. " CWDAYML "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--28. " CWMONTHL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x8015400c
tree "TCR"
group 0--3
line.long 0 "TCR"
hexfld.word 0 " CKDIV "
bitfld.long 0 16.--25. " CKDEL "  " "
bitfld.long 0 26. " RTCEN "  "0 ,1 "
bitfld.long 0 27. " SEC "  "0 ,1 "
tree.end

base ad:0x80154010
tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTCIMSC "  "0 ,1 "
bitfld.long 0 1. " RTTIMSC "  "0 ,1 "
tree.end

base ad:0x80154014
tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTCRIS "  "0 ,1 "
bitfld.long 0 1. " RTTRIS "  "0 ,1 "
tree.end

base ad:0x80154018
tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTCMIS "  "0 ,1 "
bitfld.long 0 1. " RTTMIS "  "0 ,1 "
tree.end

base ad:0x8015401c
tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTCIC "  "0 ,1 "
bitfld.long 0 1. " RTTIC "  "0 ,1 "
tree.end

base ad:0x80154020
tree "RTT_DR"
group 0--3
line.long 0 "RTT_DR"
hexfld.long 0 " Data "
tree.end

base ad:0x80154024
tree "RTT_LR1"
group 0--3
line.long 0 "RTT_LR1"
hexfld.long 0 " Load "
tree.end

base ad:0x8015402c
tree "RTT_LR2"
group 0--3
line.long 0 "RTT_LR2"
hexfld.long 0 " Load "
tree.end

base ad:0x8015403c
tree "RTT_PR1"
group 0--3
line.long 0 "RTT_PR1"
hexfld.long 0 " Load "
tree.end

base ad:0x80154040
tree "RTT_PR2"
group 0--3
line.long 0 "RTT_PR2"
hexfld.long 0 " Load "
tree.end

base ad:0x80154044
tree "RTT_PR3"
group 0--3
line.long 0 "RTT_PR3"
hexfld.long 0 " Load "
tree.end

base ad:0x80154048
tree "RTT_PR4"
group 0--3
line.long 0 "RTT_PR4"
hexfld.long 0 " Load "
tree.end

base ad:0x8015404c
tree "IN"
rgroup 0--3
line.long 0 "IN"
hexfld.long 0 " TINTERRUPT "
tree.end

base ad:0x80154050
tree "WK"
group 0--3
line.long 0 "WK"
hexfld.long 0 " TINTERRUPT "
tree.end

base ad:0x80154054
tree "SMIN"
rgroup 0--3
line.long 0 "SMIN"
hexfld.long 0 " SINTERRUPT "
tree.end

base ad:0x80154028
tree "RTT_CR"
group 0--3
line.long 0 "RTT_CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
bitfld.long 0 2. " RTTSS "  "0 ,1 "
bitfld.long 0 3. " RTTSM "  "0 ,1 "
bitfld.long 0 4.--10. " RTTPS "  " "
bitfld.long 0 11. " RTTCLK "  "0 ,1 "
tree.end

base ad:0x80154030
tree "YR"
rgroup 0--3
line.long 0 "YR"
bitfld.long 0 0.--13. " CWYEAR "  " "
tree.end

base ad:0x80154034
tree "YMR"
group 0--3
line.long 0 "YMR"
bitfld.long 0 0.--13. " CWYEARM "  " "
tree.end

base ad:0x80154038
tree "YLR"
group 0--3
line.long 0 "YLR"
bitfld.long 0 0.--13. " CWYEARL "  " "
tree.end

base ad:0x80154080
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTCNT "  "0 ,1 "
tree.end

base ad:0x80154084
tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
tree.end

base ad:0x80154088
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTCINTR "  "0 ,1 "
bitfld.long 0 1. " RTCWKUP "  "0 ,1 "
bitfld.long 0 2. " PWLOUT "  "0 ,1 "
bitfld.long 0 3. " RTTINTR "  "0 ,1 "
bitfld.long 0 4. " RTTWKUP "  "0 ,1 "
tree.end

base ad:0x80154fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x80154fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80154fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80154fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80154ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " RTCPCellID0 "
tree.end

base ad:0x80154ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " RTCPCellID1 "
tree.end

base ad:0x80154ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " RTCPCellID2 "
tree.end

base ad:0x80154ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " RTCPCellID3 "
tree.end

tree.end

;==============================================================
tree "RTT0"
;==============================================================
base ad:0x80152000
tree "CTCR"
group 0--3
line.long 0 "CTCR"
hexfld.word 0 " CKDIV "
tree.end

base ad:0x80152004
tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTTIMSC "  "0 ,1 "
tree.end

base ad:0x80152008
tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTTRIS "  "0 ,1 "
tree.end

base ad:0x8015200c
tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTTMIS "  "0 ,1 "
tree.end

base ad:0x80152010
tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTTIC "  "0 ,1 "
tree.end

base ad:0x80152014
tree "DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " Data "
tree.end

base ad:0x80152018
tree "LR"
group 0--3
line.long 0 "LR"
hexfld.long 0 " Load "
tree.end

base ad:0x8015201c
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
tree.end

base ad:0x80152080
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0x80152084
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTTINTR "  "0 ,1 "
bitfld.long 0 1. " RTTWKUP "  "0 ,1 "
tree.end

base ad:0x80152fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x80152fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80152fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80152fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80152ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " RTCPCellID0 "
tree.end

base ad:0x80152ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " RTCPCellID1 "
tree.end

base ad:0x80152ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " RTCPCellID2 "
tree.end

base ad:0x80152ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " RTCPCellID3 "
tree.end

tree.end

;==============================================================
tree "RTT1"
;==============================================================
base ad:0x80153000
tree "CTCR"
group 0--3
line.long 0 "CTCR"
hexfld.word 0 " CKDIV "
tree.end

base ad:0x80153004
tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTTIMSC "  "0 ,1 "
tree.end

base ad:0x80153008
tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTTRIS "  "0 ,1 "
tree.end

base ad:0x8015300c
tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTTMIS "  "0 ,1 "
tree.end

base ad:0x80153010
tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTTIC "  "0 ,1 "
tree.end

base ad:0x80153014
tree "DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " Data "
tree.end

base ad:0x80153018
tree "LR"
group 0--3
line.long 0 "LR"
hexfld.long 0 " Load "
tree.end

base ad:0x8015301c
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
tree.end

base ad:0x80153080
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0x80153084
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTTINTR "  "0 ,1 "
bitfld.long 0 1. " RTTWKUP "  "0 ,1 "
tree.end

base ad:0x80153fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x80153fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80153fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80153fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80153ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " RTCPCellID0 "
tree.end

base ad:0x80153ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " RTCPCellID1 "
tree.end

base ad:0x80153ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " RTCPCellID2 "
tree.end

base ad:0x80153ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " RTCPCellID3 "
tree.end

tree.end

;==============================================================
tree "SCR"
;==============================================================
base ad:0x80155000
tree "FVR0"
rgroup 0--3
line.long 0 "FVR0"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155004
tree "FVR1"
rgroup 0--3
line.long 0 "FVR1"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155008
tree "FVR2"
rgroup 0--3
line.long 0 "FVR2"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x8015500c
tree "FVR3"
rgroup 0--3
line.long 0 "FVR3"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155010
tree "FVR4"
rgroup 0--3
line.long 0 "FVR4"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155014
tree "FVR5"
rgroup 0--3
line.long 0 "FVR5"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155018
tree "FVR6"
rgroup 0--3
line.long 0 "FVR6"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x8015501c
tree "FVR7"
rgroup 0--3
line.long 0 "FVR7"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155020
tree "FVR8"
rgroup 0--3
line.long 0 "FVR8"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155024
tree "FVR9"
rgroup 0--3
line.long 0 "FVR9"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155028
tree "FVR10"
rgroup 0--3
line.long 0 "FVR10"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x8015502c
tree "FVR11"
rgroup 0--3
line.long 0 "FVR11"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155030
tree "FVR12"
rgroup 0--3
line.long 0 "FVR12"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155034
tree "FVR13"
rgroup 0--3
line.long 0 "FVR13"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155038
tree "FVR14"
rgroup 0--3
line.long 0 "FVR14"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x8015503c
tree "FVR15"
rgroup 0--3
line.long 0 "FVR15"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155040
tree "FVR16"
rgroup 0--3
line.long 0 "FVR16"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155044
tree "FVR17"
rgroup 0--3
line.long 0 "FVR17"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155048
tree "FVR18"
rgroup 0--3
line.long 0 "FVR18"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x8015504c
tree "FVR19"
rgroup 0--3
line.long 0 "FVR19"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155050
tree "FVR20"
rgroup 0--3
line.long 0 "FVR20"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155054
tree "FVR21"
rgroup 0--3
line.long 0 "FVR21"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155058
tree "FVR22"
rgroup 0--3
line.long 0 "FVR22"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x8015505c
tree "FVR23"
rgroup 0--3
line.long 0 "FVR23"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155060
tree "FVR24"
rgroup 0--3
line.long 0 "FVR24"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155064
tree "FVR25"
rgroup 0--3
line.long 0 "FVR25"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155068
tree "FVR26"
rgroup 0--3
line.long 0 "FVR26"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x8015506c
tree "FVR27"
rgroup 0--3
line.long 0 "FVR27"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155070
tree "FVR28"
rgroup 0--3
line.long 0 "FVR28"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155074
tree "FVR29"
rgroup 0--3
line.long 0 "FVR29"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155078
tree "FVR30"
rgroup 0--3
line.long 0 "FVR30"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x8015507c
tree "FVR31"
rgroup 0--3
line.long 0 "FVR31"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155080
tree "FVR32"
rgroup 0--3
line.long 0 "FVR32"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155084
tree "FVR33"
rgroup 0--3
line.long 0 "FVR33"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155088
tree "FVR34"
rgroup 0--3
line.long 0 "FVR34"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x8015508c
tree "FVR35"
rgroup 0--3
line.long 0 "FVR35"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155090
tree "FVR36"
rgroup 0--3
line.long 0 "FVR36"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155094
tree "FVR37"
rgroup 0--3
line.long 0 "FVR37"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155098
tree "FVR38"
rgroup 0--3
line.long 0 "FVR38"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x8015509c
tree "FVR39"
rgroup 0--3
line.long 0 "FVR39"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550a0
tree "FVR40"
rgroup 0--3
line.long 0 "FVR40"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550a4
tree "FVR41"
rgroup 0--3
line.long 0 "FVR41"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550a8
tree "FVR42"
rgroup 0--3
line.long 0 "FVR42"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550ac
tree "FVR43"
rgroup 0--3
line.long 0 "FVR43"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550b0
tree "FVR44"
rgroup 0--3
line.long 0 "FVR44"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550b4
tree "FVR45"
rgroup 0--3
line.long 0 "FVR45"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550b8
tree "FVR46"
rgroup 0--3
line.long 0 "FVR46"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550bc
tree "FVR47"
rgroup 0--3
line.long 0 "FVR47"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550c0
tree "FVR48"
rgroup 0--3
line.long 0 "FVR48"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550c4
tree "FVR49"
rgroup 0--3
line.long 0 "FVR49"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550c8
tree "FVR50"
rgroup 0--3
line.long 0 "FVR50"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550cc
tree "FVR51"
rgroup 0--3
line.long 0 "FVR51"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550d0
tree "FVR52"
rgroup 0--3
line.long 0 "FVR52"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550d4
tree "FVR53"
rgroup 0--3
line.long 0 "FVR53"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550d8
tree "FVR54"
rgroup 0--3
line.long 0 "FVR54"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550dc
tree "FVR55"
rgroup 0--3
line.long 0 "FVR55"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550e0
tree "FVR56_ECCMODE0"
rgroup 0--3
line.long 0 "FVR56_ECCMODE0"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550e4
tree "FVR57_ECCMODE1"
rgroup 0--3
line.long 0 "FVR57_ECCMODE1"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550e8
tree "FVR58_ECCMODE2"
rgroup 0--3
line.long 0 "FVR58_ECCMODE2"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550ec
tree "FVR59_ECCMODE3"
rgroup 0--3
line.long 0 "FVR59_ECCMODE3"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550f0
tree "FVR60_RD_PLOCK0"
rgroup 0--3
line.long 0 "FVR60_RD_PLOCK0"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550f4
tree "FVR61_RD_PLOCK1"
rgroup 0--3
line.long 0 "FVR61_RD_PLOCK1"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550f8
tree "FVR62_RD_PLOCK2"
rgroup 0--3
line.long 0 "FVR62_RD_PLOCK2"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x801550fc
tree "FVR63_RD_PLOCK3"
rgroup 0--3
line.long 0 "FVR63_RD_PLOCK3"
hexfld.long 0 " FVR_VAL "
tree.end

base ad:0x80155100
tree "FVR_WR_PLOCK0"
rgroup 0--3
line.long 0 "FVR_WR_PLOCK0"
hexfld.long 0 " WRPLOCKVAL "
tree.end

base ad:0x80155104
tree "FVR_WR_PLOCK1"
rgroup 0--3
line.long 0 "FVR_WR_PLOCK1"
hexfld.long 0 " WRPLOCKVAL "
tree.end

base ad:0x80155108
tree "FVR_WR_PLOCK2"
rgroup 0--3
line.long 0 "FVR_WR_PLOCK2"
hexfld.long 0 " WRPLOCKVAL "
tree.end

base ad:0x8015510c
tree "FVR_WR_PLOCK3"
rgroup 0--3
line.long 0 "FVR_WR_PLOCK3"
hexfld.long 0 " WRPLOCKVAL "
tree.end

base ad:0x80155110
tree "OTP_RD_SLOCK_L"
group 0--3
line.long 0 "OTP_RD_SLOCK_L"
hexfld.long 0 " RDSLOCKVAL "
tree.end

base ad:0x80155114
tree "OTP_RD_SLOCK_H"
group 0--3
line.long 0 "OTP_RD_SLOCK_H"
hexfld.long 0 " RDSLOCKVAL "
tree.end

base ad:0x80155118
tree "OTP_WR_SLOCK_L"
group 0--3
line.long 0 "OTP_WR_SLOCK_L"
hexfld.long 0 " WRSLOCKVAL "
tree.end

base ad:0x8015511c
tree "OTP_WR_SLOCK_H"
group 0--3
line.long 0 "OTP_WR_SLOCK_H"
hexfld.long 0 " WRSLOCKVAL "
tree.end

base ad:0x80155120
tree "OTP_WR_SLOCK_X"
group 0--3
line.long 0 "OTP_WR_SLOCK_X"
bitfld.long 0 0. " WRSLOCK0 "  "0 ,1 "
bitfld.long 0 1. " WRSLOCK1 "  "0 ,1 "
bitfld.long 0 2. " WRSLOCK2 "  "0 ,1 "
bitfld.long 0 3. " WRSLOCK3 "  "0 ,1 "
bitfld.long 0 4. " WRSLOCK4 "  "0 ,1 "
bitfld.long 0 5. " WRSLOCK5 "  "0 ,1 "
tree.end

base ad:0x80155124
tree "SEC_SR"
rgroup 0--3
line.long 0 "SEC_SR"
bitfld.long 0 0. " ENGIBOOTREQ "  "0 ,1 "
bitfld.long 0 1. " FTVREQ "  "0 ,1 "
bitfld.long 0 2. " Spare0 "  "0 ,1 "
bitfld.long 0 3. " Spare1 "  "0 ,1 "
bitfld.long 0 23. " FCT_READ_DISABLE "  "0 ,1 "
bitfld.long 0 24. " COREDIS "  "0 ,1 "
bitfld.long 0 26. " MODEMDIS "  "0 ,1 "
bitfld.long 0 27. " FTVENABLE "  "0 ,1 "
bitfld.long 0 28. " SWDGCLK "  "0 ,1 "
bitfld.long 0 29. " FTVDIS "  "0 ,1 "
bitfld.long 0 30. " FCTDIS "  "0 ,1 "
bitfld.long 0 31. " OPENDEVn "  "0 ,1 "
tree.end

base ad:0x80155128
tree "SEC_CR"
group 0--3
line.long 0 "SEC_CR"
bitfld.long 0 0. " APEDBGEN0 "  "0 ,1 "
bitfld.long 0 1. " APENIDEN0 "  "0 ,1 "
bitfld.long 0 2. " APESPNIDEN0 "  "0 ,1 "
bitfld.long 0 3. " APESPIDEN0 "  "0 ,1 "
bitfld.long 0 4. " APEDBGEN1 "  "0 ,1 "
bitfld.long 0 5. " APENIDEN1 "  "0 ,1 "
bitfld.long 0 6. " APESPNIDEN1 "  "0 ,1 "
bitfld.long 0 7. " APESPIDEN1 "  "0 ,1 "
bitfld.long 0 9. " MODDBGEN "  "0 ,1 "
bitfld.long 0 10. " MODNIDEN "  "0 ,1 "
bitfld.long 0 14. " PRCMUDBGEN "  "0 ,1 "
bitfld.long 0 15. " TOPDBGEN "  "0 ,1 "
bitfld.long 0 16. " MCSBAGEN "  "0 ,1 "
bitfld.long 0 17. " APESTMSTRCEN "  "0 ,1 "
bitfld.long 0 18. " APESTMEN "  "0 ,1 "
bitfld.long 0 23. " FTVLOCK "  "0 ,1 "
bitfld.long 0 24. " COREDIS "  "0 ,1 "
bitfld.long 0 26. " MODEMDIS "  "0 ,1 "
bitfld.long 0 27. " SSKEYDIS "  "0 ,1 "
bitfld.long 0 28. " SWDGCLK "  "0 ,1 "
bitfld.long 0 29. " SPRSTEN0 "  "0 ,1 "
bitfld.long 0 30. " SPRSTEN1 "  "0 ,1 "
bitfld.long 0 31. " CRRSTEN "  "0 ,1 "
tree.end

base ad:0x8015512c
tree "OTP_WR_DATA"
group 0--3
line.long 0 "OTP_WR_DATA"
hexfld.long 0 " WRDATAVAL "
tree.end

base ad:0x80155130
tree "OTP_CONTROL"
group 0--3
line.long 0 "OTP_CONTROL"
hexfld.byte 0 " OTP_ADD "
bitfld.long 0 12. " OTP_WRITE "  "0 ,1 "
bitfld.long 0 13. " OTP_LOCK "  "0 ,1 "
bitfld.long 0 14. " OTP_ECCSWITCH "  "0 ,1 "
bitfld.long 0 15.--17. " OTP_PRGWIDTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 18. " OTP_DISTURBED "  "0 ,1 "
bitfld.long 0 19. " OTP_ERRORFLAG "  "0 ,1 "
bitfld.long 0 20. " OTP_PROGFAIL "  "0 ,1 "
bitfld.long 0 21. " OTP_BUSY "  "0 ,1 "
bitfld.long 0 22. " OTP_FORBIDDEN "  "0 ,1 "
tree.end

base ad:0x80155134
tree "FVR_DISTURBED_L"
rgroup 0--3
line.long 0 "FVR_DISTURBED_L"
hexfld.long 0 " DISTURBVAL "
tree.end

base ad:0x80155138
tree "FVR_DISTURBED_H"
rgroup 0--3
line.long 0 "FVR_DISTURBED_H"
hexfld.long 0 " DISTURBVAL "
tree.end

base ad:0x8015513c
tree "FVR_VALID_L"
rgroup 0--3
line.long 0 "FVR_VALID_L"
hexfld.long 0 " VALIDVAL "
tree.end

base ad:0x80155140
tree "FVR_VALID_H"
rgroup 0--3
line.long 0 "FVR_VALID_H"
hexfld.long 0 " VALIDVAL "
tree.end

base ad:0x80155144
tree "FVR_ERRORFLAG_L"
rgroup 0--3
line.long 0 "FVR_ERRORFLAG_L"
hexfld.long 0 " ERRORFVAL "
tree.end

base ad:0x80155148
tree "FVR_ERRORFLAG_H"
rgroup 0--3
line.long 0 "FVR_ERRORFLAG_H"
hexfld.long 0 " ERRORFVAL "
tree.end

base ad:0x80155150
tree "WDR"
rgroup 0--3
line.long 0 "WDR"
hexfld.long 0 " SWDTVAL "
tree.end

base ad:0x80155154
tree "WLR"
group 0--3
line.long 0 "WLR"
hexfld.long 0 " SWDTLOAD "
tree.end

base ad:0x80155158
tree "WCR"
group 0--3
line.long 0 "WCR"
bitfld.long 0 0. " SWDTDIS "  "0 ,1 "
bitfld.long 0 1. " SWDTLDIS "  "0 ,1 "
bitfld.long 0 2. " SWDTLOCK "  "0 ,1 "
tree.end

base ad:0x80155160
tree "SRAMPROT0"
group 0--3
line.long 0 "SRAMPROT0"
bitfld.long 0 0.--3. " SRAMPROT0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80155164
tree "SPR0"
group 0--3
line.long 0 "SPR0"
hexfld.long 0 " SSPR0 "
tree.end

base ad:0x80155168
tree "SPR1"
group 0--3
line.long 0 "SPR1"
hexfld.long 0 " SSPR1 "
tree.end

base ad:0x8015516c
tree "ROSZ"
group 0--3
line.long 0 "ROSZ"
bitfld.long 0 0.--9. " ROSZ0 "  " "
bitfld.long 0 12.--21. " ROSZ1 "  " "
tree.end

base ad:0x80155170
tree "DECPROT"
group 0--3
line.long 0 "DECPROT"
bitfld.long 0 0.--25. " DECPROT "  " "
tree.end

base ad:0x80155178
tree "DDRMODLOW"
group 0--3
line.long 0 "DDRMODLOW"
hexfld.long 0 " DDRMODLOW "
tree.end

base ad:0x8015517c
tree "DDRMODHIGH"
group 0--3
line.long 0 "DDRMODHIGH"
hexfld.long 0 " DDRMODHIGH "
tree.end

base ad:0x80155180
tree "DDRSHAREHIGH"
group 0--3
line.long 0 "DDRSHAREHIGH"
hexfld.long 0 " DDRSHAREHIGH "
tree.end

base ad:0x80155184
tree "DDRSECLOW"
group 0--3
line.long 0 "DDRSECLOW"
hexfld.long 0 " DDRSECLOW "
tree.end

base ad:0x80155188
tree "DDRSECHIGH"
group 0--3
line.long 0 "DDRSECHIGH"
hexfld.long 0 " DDRSECHIGH "
tree.end

base ad:0x8015518c
tree "DDRA9LOW"
group 0--3
line.long 0 "DDRA9LOW"
hexfld.long 0 " DDRA9LOW "
tree.end

base ad:0x80155190
tree "DDRA9HIGH"
group 0--3
line.long 0 "DDRA9HIGH"
hexfld.long 0 " DDRA9HIGH "
tree.end

base ad:0x80155194
tree "DDRMAXSPACE"
group 0--3
line.long 0 "DDRMAXSPACE"
hexfld.long 0 " DDRMAXSPACE "
tree.end

base ad:0x80155198
tree "CRCF"
group 0--3
line.long 0 "CRCF"
hexfld.byte 0 " CRC0 "
hexfld.byte 1 " CRC1 "
hexfld.byte 2 " CRC2 "
hexfld.byte 3 " CRC3 "
tree.end

base ad:0x801551a0
tree "SCRBCTRL"
group 0--3
line.long 0 "SCRBCTRL"
bitfld.long 0 0. " SCRBEN "  "0 ,1 "
bitfld.long 0 4. " DDR_HOLD "  "0 ,1 "
tree.end

base ad:0x801551a4
tree "SCRBKEY_L"
group 0--3
line.long 0 "SCRBKEY_L"
hexfld.long 0 " SCRAMBLE_KEY "
tree.end

base ad:0x801551a8
tree "SCRBKEY_H"
group 0--3
line.long 0 "SCRBKEY_H"
hexfld.long 0 " SCRAMBLE_KEY "
tree.end

tree.end

;==============================================================
tree "SCTL"
;==============================================================
base ad:0x80155000
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0.--3. " MODECR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " MODESTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " REMAPCLR "  "0 ,1 "
bitfld.long 0 9. " REMAPSTAT "  "0 ,1 "
bitfld.long 0 16. " RST4820SW "  "0 ,1 "
tree.end

base ad:0x80155004
tree "IMCR"
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " ITMDEN "  "0 ,1 "
bitfld.long 0 1.--4. " ITMDCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80155008
tree "IMSR"
group 0--3
line.long 0 "IMSR"
bitfld.long 0 0. " ITMDSTAT "  "0 ,1 "
tree.end

base ad:0x8015500c
tree "XTALCR"
group 0--3
line.long 0 "XTALCR"
hexfld.word 0 " MXTALTIME "
hexfld.byte 2 " RESET_TEMPO "
bitfld.long 0 24. " SYSCLKDIV0 "  "0 ,1 "
bitfld.long 0 25. " SYSCLKDIV1 "  "0 ,1 "
bitfld.long 0 26.--27. " PERULPDIV "  "0 ,1 ,2 ,3 "
bitfld.long 0 28. " LCDULPDIV "  "0 ,1 "
bitfld.long 0 31. " SCRAL "  "0 ,1 "
tree.end

base ad:0x80155010
tree "PLL1CR"
group 0--3
line.long 0 "PLL1CR"
bitfld.long 0 0. " PLL1OVER "  "0 ,1 "
bitfld.long 0 1. " PLL1EN "  "0 ,1 "
bitfld.long 0 2. " PLL1STAT "  "0 ,1 "
bitfld.long 0 8. " PLL1CT "  "0 ,1 "
bitfld.long 0 9. " PLL1LCKCNTEN "  "0 ,1 "
bitfld.long 0 15. " GPIORSTCFG "  "0 ,1 "
hexfld.word 2 " PLL1CKINVAL "
tree.end

base ad:0x80155014
tree "PLLFR"
group 0--3
line.long 0 "PLLFR"
bitfld.long 0 0.--2. " PLL1PA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--8. " AUDDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 9.--15. " PLL1D "  " "
bitfld.long 0 16.--18. " PLL2PA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " PHIBEN "  "0 ,1 "
bitfld.long 0 21. " MSP4CLK "  "0 ,1 "
bitfld.long 0 22. " MSP3CLK "  "0 ,1 "
bitfld.long 0 23. " MSP1CLK "  "0 ,1 "
bitfld.long 0 24.--30. " PLL2D "  " "
tree.end

base ad:0x80155018
tree "RSTSR"
group 0--3
line.long 0 "RSTSR"
bitfld.long 0 0. " PORRST "  "0 ,1 "
bitfld.long 0 1. " SECRST "  "0 ,1 "
bitfld.long 0 2. " WDTRST "  "0 ,1 "
bitfld.long 0 3. " SOFTRST "  "0 ,1 "
bitfld.long 0 4. " SLEEPRST "  "0 ,1 "
tree.end

base ad:0x8015501c
tree "XDBGEN"
group 0--3
line.long 0 "XDBGEN"
bitfld.long 0 0. " ICEEXBRKINE "  "0 ,1 "
bitfld.long 0 1. " ICEHABRKOE "  "0 ,1 "
bitfld.long 0 2. " ICEHVBRKOE "  "0 ,1 "
bitfld.long 0 3. " ICEHIBRKOE "  "0 ,1 "
bitfld.long 0 4. " ICESBAGINTOE "  "0 ,1 "
bitfld.long 0 5. " HAEXBRKINE "  "0 ,1 "
bitfld.long 0 6. " HAICEBRKOE "  "0 ,1 "
bitfld.long 0 7. " HAHVBRKOE "  "0 ,1 "
bitfld.long 0 8. " HAHIBRKOE "  "0 ,1 "
bitfld.long 0 9. " HASBAGINTOE "  "0 ,1 "
bitfld.long 0 10. " HVEXBRKINE "  "0 ,1 "
bitfld.long 0 11. " HVICEBRKOE "  "0 ,1 "
bitfld.long 0 12. " HVHABRKOE "  "0 ,1 "
bitfld.long 0 13. " HVHIBRKOE "  "0 ,1 "
bitfld.long 0 14. " HVSBAGINTOE "  "0 ,1 "
bitfld.long 0 15. " HIEXBRKINE "  "0 ,1 "
bitfld.long 0 16. " HIICEBRKOE "  "0 ,1 "
bitfld.long 0 17. " HIHABRKOE "  "0 ,1 "
bitfld.long 0 18. " HIHVBRKOE "  "0 ,1 "
bitfld.long 0 19. " HISBAGINTOE "  "0 ,1 "
tree.end

base ad:0x80155020
tree "XDBGAO"
group 0--3
line.long 0 "XDBGAO"
bitfld.long 0 0. " ICEEXBRKAO "  "0 ,1 "
bitfld.long 0 1. " ICEHABRKAO "  "0 ,1 "
bitfld.long 0 2. " ICEHVBRKAO "  "0 ,1 "
bitfld.long 0 3. " ICEHIBRKAO "  "0 ,1 "
bitfld.long 0 4. " ICESBAGINTAO "  "0 ,1 "
bitfld.long 0 5. " HAEXBRKAO "  "0 ,1 "
bitfld.long 0 6. " HAICEBRKAO "  "0 ,1 "
bitfld.long 0 7. " HAHVBRKAO "  "0 ,1 "
bitfld.long 0 8. " HAHIBRKAO "  "0 ,1 "
bitfld.long 0 9. " HASBAGINTAO "  "0 ,1 "
bitfld.long 0 10. " HVEXBRKAO "  "0 ,1 "
bitfld.long 0 11. " HVICEBRKAO "  "0 ,1 "
bitfld.long 0 12. " HVHABRKAO "  "0 ,1 "
bitfld.long 0 13. " HVHIBRKAO "  "0 ,1 "
bitfld.long 0 14. " HVSBAGINTAO "  "0 ,1 "
bitfld.long 0 15. " HIEXBRKAO "  "0 ,1 "
bitfld.long 0 16. " HIICEBRKAO "  "0 ,1 "
bitfld.long 0 17. " HIHABRKAO "  "0 ,1 "
bitfld.long 0 18. " HIHVBRKAO "  "0 ,1 "
bitfld.long 0 19. " HISBAGINTAO "  "0 ,1 "
tree.end

base ad:0x80155024
tree "PCKEN0"
group 0--3
line.long 0 "PCKEN0"
hexfld.long 0 " PCKEN0 "
tree.end

base ad:0x80155028
tree "PCKDIS0"
group 0--3
line.long 0 "PCKDIS0"
hexfld.long 0 " PERDIS "
tree.end

base ad:0x8015502c
tree "PCKENSR0"
rgroup 0--3
line.long 0 "PCKENSR0"
hexfld.long 0 " PCKENSR0 "
tree.end

base ad:0x80155030
tree "PCKSR0"
rgroup 0--3
line.long 0 "PCKSR0"
hexfld.long 0 " PCKSR0 "
tree.end

base ad:0x80155034
tree "PCKEN1"
group 0--3
line.long 0 "PCKEN1"
hexfld.long 0 " PCKEN1 "
tree.end

base ad:0x80155038
tree "PCKDIS1"
group 0--3
line.long 0 "PCKDIS1"
hexfld.long 0 " PERDIS1 "
tree.end

base ad:0x8015503c
tree "PCKENSR1"
rgroup 0--3
line.long 0 "PCKENSR1"
hexfld.long 0 " PCKENSR1 "
tree.end

base ad:0x80155040
tree "PCKSR1"
rgroup 0--3
line.long 0 "PCKSR1"
hexfld.long 0 " PCKSR1 "
tree.end

base ad:0x80155044
tree "CLKOCR"
group 0--3
line.long 0 "CLKOCR"
bitfld.long 0 0.--5. " CLKODIV0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--8. " CLKOSEL0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--21. " CLKODIV1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--24. " CLKOSEL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 28. " OSRV_GRP1ORGRP2 "  "0 ,1 "
tree.end

base ad:0x80155048
tree "PLL2CR"
group 0--3
line.long 0 "PLL2CR"
bitfld.long 0 0. " PLL2OVER "  "0 ,1 "
bitfld.long 0 1. " PLL2EN "  "0 ,1 "
bitfld.long 0 2. " PLL2STAT "  "0 ,1 "
bitfld.long 0 3.--27. " PLLTIME "  " "
bitfld.long 0 28. " AP1CLKDIVSEL "  "0 ,1 "
bitfld.long 0 29. " AP2CLKDIVSEL "  "0 ,1 "
bitfld.long 0 30. " AP3CLKDIVSEL "  "0 ,1 "
bitfld.long 0 31. " AP4CLKDIVSEL "  "0 ,1 "
tree.end

base ad:0x8015504c
tree "CLKCR"
group 0--3
line.long 0 "CLKCR"
bitfld.long 0 0.--4. " LCDDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--9. " PERDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--13. " HSITDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14.--17. " SYSDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 18.--23. " TVODIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 26.--29. " HSIRDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 30. " TVOSEL "  "0 ,1 "
bitfld.long 0 31. " SYSSEL "  "0 ,1 "
tree.end

base ad:0x80155050
tree "TCR"
group 0--3
line.long 0 "TCR"
bitfld.long 0 0. " TENSEL0 "  "0 ,1 "
bitfld.long 0 1. " TENSEL1 "  "0 ,1 "
bitfld.long 0 2. " TENSEL2 "  "0 ,1 "
bitfld.long 0 3. " TENSEL3 "  "0 ,1 "
bitfld.long 0 4. " TENSEL4 "  "0 ,1 "
bitfld.long 0 5. " TENSEL5 "  "0 ,1 "
bitfld.long 0 6. " TENSEL6 "  "0 ,1 "
bitfld.long 0 7. " TENSEL7 "  "0 ,1 "
bitfld.long 0 8. " TENSEL8 "  "0 ,1 "
bitfld.long 0 9. " TENSEL9 "  "0 ,1 "
bitfld.long 0 10. " TENSEL10 "  "0 ,1 "
bitfld.long 0 11. " TENSEL11 "  "0 ,1 "
bitfld.long 0 12. " TENSEL12 "  "0 ,1 "
bitfld.long 0 13. " TENSEL13 "  "0 ,1 "
bitfld.long 0 14. " TENSEL14 "  "0 ,1 "
bitfld.long 0 15. " TENSEL15 "  "0 ,1 "
tree.end

base ad:0x80155054
tree "PCKEN2"
group 0--3
line.long 0 "PCKEN2"
hexfld.long 0 " PCKEN2 "
tree.end

base ad:0x80155058
tree "PCKDIS2"
group 0--3
line.long 0 "PCKDIS2"
hexfld.long 0 " PCKDIS2 "
tree.end

base ad:0x8015505c
tree "PCKENSR2"
rgroup 0--3
line.long 0 "PCKENSR2"
hexfld.long 0 " PCKENSR2 "
tree.end

base ad:0x80155060
tree "PCKSR2"
rgroup 0--3
line.long 0 "PCKSR2"
hexfld.long 0 " PCKSR2 "
tree.end

base ad:0x80155064
tree "DBGCR"
group 0--3
line.long 0 "DBGCR"
bitfld.long 0 0. " nETMRU "  "0 ,1 "
bitfld.long 0 1. " ETMENE "  "0 ,1 "
bitfld.long 0 2. " ETBSWREN "  "0 ,1 "
bitfld.long 0 3. " SGADBGEN "  "0 ,1 "
bitfld.long 0 4. " SGADBGM "  "0 ,1 "
bitfld.long 0 5.--6. " SGADBGSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--13. " VLIM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14. " SYSCLKDIV24 "  "0 ,1 "
bitfld.long 0 15. " DSPCLKDIV12 "  "0 ,1 "
hexfld.word 2 " SGADBGGPIO "
tree.end

base ad:0x80155100
tree "TGTFV"
group 0--3
line.long 0 "TGTFV"
bitfld.long 0 0.--2. " P "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--14. " D "  " "
bitfld.long 0 16.--21. " V "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x80155104
tree "CRTFV"
rgroup 0--3
line.long 0 "CRTFV"
bitfld.long 0 0.--2. " P "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--14. " D "  " "
bitfld.long 0 16.--21. " V "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x80155108
tree "CLOCKCR1"
group 0--3
line.long 0 "CLOCKCR1"
bitfld.long 0 0.--4. " ARMCLKFIXPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " ARMCLKFIXPLLSW "  "0 ,1 "
bitfld.long 0 6. " ARMCLKFIX38M_ON "  "0 ,1 "
bitfld.long 0 7. " ARMCLKFIXEN "  "0 ,1 "
bitfld.long 0 8.--12. " ACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " ACLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " ACLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " ACLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " SVAMMDSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " SVAMMDSPCLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " SVAMMDSPCLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " SIAMMDSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " SIAMMDSPCLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " SIAMMDSPCLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " SIAMMDSPCLKEN "  "0 ,1 "
tree.end

base ad:0x8015510c
tree "CLOCKCR2"
group 0--3
line.long 0 "CLOCKCR2"
bitfld.long 0 0.--4. " SAAMMDSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " SAAMMDSPCLKPLLSW "  "0 ,1 "
bitfld.long 0 6. " SAAMMDSPCLK38M_ON "  "0 ,1 "
bitfld.long 0 7. " SAAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 8.--12. " SGACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " SGACLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " SGACLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " SGACLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " UARTCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " UARTCLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " UARTCLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " MSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " MSPCLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " MSPCLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " MSPCLKEN "  "0 ,1 "
tree.end

base ad:0x80155110
tree "CLOCKCR3"
group 0--3
line.long 0 "CLOCKCR3"
bitfld.long 0 0.--4. " I2CCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " I2CCLKPLLSW "  "0 ,1 "
bitfld.long 0 6. " I2CCLK38M_ON "  "0 ,1 "
bitfld.long 0 7. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 8.--12. " SDMMCCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " SDMMCCLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " SDMMCCLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " SLIMBUSCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " SLIMBUSCLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " SLIMBUSCLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " SLIMBUSCLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " PER1CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " PER1CLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " PER1CLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " PER1CLKEN "  "0 ,1 "
tree.end

base ad:0x80155114
tree "CLOCKCR4"
group 0--3
line.long 0 "CLOCKCR4"
bitfld.long 0 0.--4. " PER2CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " PER2CLKPLLSW "  "0 ,1 "
bitfld.long 0 6. " PER2CLK38M_ON "  "0 ,1 "
bitfld.long 0 7. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 8.--12. " PER3CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " PER3CLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " PER3CLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " PER5CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " PER5CLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " PER5CLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " PER6CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " PER6CLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " PER6CLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " PER6CLKEN "  "0 ,1 "
tree.end

base ad:0x80155118
tree "CLOCKCR5"
group 0--3
line.long 0 "CLOCKCR5"
bitfld.long 0 0.--4. " PER7CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " PER7CLKPLLSW "  "0 ,1 "
bitfld.long 0 6. " PER7CLK38M_ON "  "0 ,1 "
bitfld.long 0 7. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 8.--12. " LCDCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " LCDCLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " LCDCLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " DSICLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " DSICLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " DSICLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " DSICLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " BMLCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " BMLCLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " BMLCLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " BMLCLKEN "  "0 ,1 "
tree.end

base ad:0x8015511c
tree "CLOCKCR6"
group 0--3
line.long 0 "CLOCKCR6"
bitfld.long 0 0.--4. " HSITXCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " HSITXCLKPLLSW "  "0 ,1 "
bitfld.long 0 6. " HSITXCLK38M_ON "  "0 ,1 "
bitfld.long 0 7. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 8.--12. " HSIRXCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " HSIRXCLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " HSIRXCLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " HDMICLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " HDMICLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " HDMICLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " APEATCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " APEATCLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " APEATCLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " APEATCLKEN "  "0 ,1 "
tree.end

base ad:0x80155120
tree "CLOCKCR7"
group 0--3
line.long 0 "CLOCKCR7"
bitfld.long 0 0.--4. " GxDEBUGCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " GxDEBUGCLKPLLSW "  "0 ,1 "
bitfld.long 0 6. " GxDEBUGCLK38M_ON "  "0 ,1 "
bitfld.long 0 7. " GxDEBUGCLKEN "  "0 ,1 "
bitfld.long 0 8.--12. " SPARE1CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " SPARE1CLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " SPARE1CLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " SPARE2CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " SPARE2CLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " SPARE2CLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " SPARE2CLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " SPARE3CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " SPARE3CLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " SPARE3CLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " SPARE3CLKEN "  "0 ,1 "
tree.end

base ad:0x80155124
tree "PLLSOC0FR"
group 0--3
line.long 0 "PLLSOC0FR"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " SELDIV2 "  "0 ,1 "
tree.end

base ad:0x80155128
tree "PLLSOC1FR"
group 0--3
line.long 0 "PLLSOC1FR"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " SELDIV2 "  "0 ,1 "
tree.end

base ad:0x8015512c
tree "PLLARMFR"
group 0--3
line.long 0 "PLLARMFR"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " SELDIV2 "  "0 ,1 "
tree.end

base ad:0x80155130
tree "PLLDDRFR"
group 0--3
line.long 0 "PLLDDRFR"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " SELDIV2 "  "0 ,1 "
tree.end

base ad:0x80155134
tree "PLLDSIFR"
group 0--3
line.long 0 "PLLDSIFR"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " SELDIV2 "  "0 ,1 "
tree.end

base ad:0x80155138
tree "SRC_PLLSOC0SR"
rgroup 0--3
line.long 0 "SRC_PLLSOC0SR"
bitfld.long 0 0. " PLLSOC0_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PLLSOC0_LOCKP3 "  "0 ,1 "
tree.end

base ad:0x8015513c
tree "SRC_PLLSOC1SR"
rgroup 0--3
line.long 0 "SRC_PLLSOC1SR"
bitfld.long 0 0. " PLLSOC1_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PLLSOC1_LOCKP3 "  "0 ,1 "
tree.end

base ad:0x80155140
tree "SRC_PLLARMSR"
rgroup 0--3
line.long 0 "SRC_PLLARMSR"
bitfld.long 0 0. " PLLARM_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PLLARM_LOCKP3 "  "0 ,1 "
tree.end

base ad:0x80155144
tree "SRC_PLLDDRSR"
rgroup 0--3
line.long 0 "SRC_PLLDDRSR"
bitfld.long 0 0. " PLLDDR_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PLLDDR_LOCKP3 "  "0 ,1 "
tree.end

base ad:0x80155148
tree "SRC_PLLDSISR"
rgroup 0--3
line.long 0 "SRC_PLLDSISR"
bitfld.long 0 0. " PLLDSI_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PLLDSI_LOCKP3 "  "0 ,1 "
tree.end

base ad:0x80155f00
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0x80155f04
tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RemapStat "  "0 ,1 "
bitfld.long 0 1. " nIRQ "  "0 ,1 "
bitfld.long 0 2. " nFIQ "  "0 ,1 "
bitfld.long 0 3. " PLL1ON "  "0 ,1 "
bitfld.long 0 5. " SoftResStat "  "0 ,1 "
bitfld.long 0 7. " ExtResStat "  "0 ,1 "
bitfld.long 0 8. " PORESStat "  "0 ,1 "
bitfld.long 0 9. " PLLSW "  "0 ,1 "
bitfld.long 0 10. " PLLTimeEn "  "0 ,1 "
bitfld.long 0 12. " XtalTimeEn "  "0 ,1 "
bitfld.long 0 13. " MPMCnSMC "  "0 ,1 "
bitfld.long 0 15. " DOZECLK "  "0 ,1 "
bitfld.long 0 16. " REFCLK "  "0 ,1 "
bitfld.long 0 17. " WDEN "  "0 ,1 "
bitfld.long 0 18. " SLEEPRESSTAT "  "0 ,1 "
bitfld.long 0 19. " PLL2ON "  "0 ,1 "
tree.end

base ad:0x80155f08
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " SoftResReq "  "0 ,1 "
bitfld.long 0 1. " RemapClear "  "0 ,1 "
bitfld.long 0 2. " PLL1En "  "0 ,1 "
bitfld.long 0 4.--7. " SYSMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10. " PLLRQSW "  "0 ,1 "
bitfld.long 0 11. " SLEEPMODE "  "0 ,1 "
bitfld.long 0 17. " PLL2EN "  "0 ,1 "
bitfld.long 0 19. " SLOWDIV8CLKEN "  "0 ,1 "
bitfld.long 0 20.--21. " CLK1HZCLKEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 22. " EXTCLKEN "  "0 ,1 "
tree.end

base ad:0x80155fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0x80155fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80155fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80155fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80155ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SCPCellID0 "
tree.end

base ad:0x80155ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SCPCellID1 "
tree.end

base ad:0x80155ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SCPCellID2 "
tree.end

base ad:0x80155ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SCPCellID3 "
tree.end

tree.end

;==============================================================
tree "SCU"
;==============================================================
base ad:0xa0410000
tree "SCU_CR"
group 0--3
line.long 0 "SCU_CR"
bitfld.long 0 0. " SCUCREN "  "0 ,1 "
bitfld.long 0 1. " SCUCRAFEN "  "0 ,1 "
bitfld.long 0 2. " SCUCRRPE "  "0 ,1 "
tree.end

base ad:0xa0410004
tree "SCU_CONFR"
group 0--3
line.long 0 "SCU_CONFR"
bitfld.long 0 0.--1. " SCUCONFRCPUN "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " SCUCONFRCPUSMP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " SCUCONFRTRS "
tree.end

base ad:0xa0410008
tree "SCU_CPUPSR"
group 0--3
line.long 0 "SCU_CPUPSR"
bitfld.long 0 0.--1. " SCUCPUPSRCPU0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " SCUCPUPSRCPU1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " SCUCPUPSRCPU2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " SCUCPUPSRCPU3 "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa041000c
tree "SCU_IA"
wgroup 0--3
line.long 0 "SCU_IA"
bitfld.long 0 0.--3. " SCUIACPU0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " SCUIACPU1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " SCUIACPU2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " SCUIACPU3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0410040
tree "SCU_FSAR"
group 0--3
line.long 0 "SCU_FSAR"
bitfld.long 0 20.--31. " SCUFSARFSA "  " "
tree.end

base ad:0xa0410044
tree "SCU_FEAR"
group 0--3
line.long 0 "SCU_FEAR"
bitfld.long 0 20.--31. " SCUFEARFEA "  " "
tree.end

base ad:0xa0410050
tree "SCU_ACR"
group 0--3
line.long 0 "SCU_ACR"
bitfld.long 0 0. " SCUACRCPU0 "  "0 ,1 "
bitfld.long 0 1. " SCUACRCPU1 "  "0 ,1 "
bitfld.long 0 2. " SCUACRCPU2 "  "0 ,1 "
bitfld.long 0 3. " SCUACRCPU3 "  "0 ,1 "
tree.end

base ad:0xa0410054
tree "SCU_SACR"
group 0--3
line.long 0 "SCU_SACR"
bitfld.long 0 0. " SCUSACRCPU0 "  "0 ,1 "
bitfld.long 0 1. " SCUSACRCPU1 "  "0 ,1 "
bitfld.long 0 2. " SCUSACRCPU2 "  "0 ,1 "
bitfld.long 0 3. " SCUSACRCPU3 "  "0 ,1 "
bitfld.long 0 4. " SCUSACRTCPU0 "  "0 ,1 "
bitfld.long 0 5. " SCUSACRTCPU1 "  "0 ,1 "
bitfld.long 0 6. " SCUSACRTCPU2 "  "0 ,1 "
bitfld.long 0 7. " SCUSACRTCPU3 "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "SGA"
;==============================================================
base ad:0x801d0000
tree "GP2_VSCL_START_ADDR"
group 0--3
line.long 0 "GP2_VSCL_START_ADDR"
bitfld.long 0 3.--31. " VSCL_START "  " "
tree.end

base ad:0x801d0004
tree "GP2_VSCL_END_ADDR"
group 0--3
line.long 0 "GP2_VSCL_END_ADDR"
bitfld.long 0 3.--31. " VSCL_END "  " "
tree.end

base ad:0x801d0008
tree "GP2_PLBCL_START_ADDR"
group 0--3
line.long 0 "GP2_PLBCL_START_ADDR"
bitfld.long 0 3.--31. " PLBCL_START "  " "
tree.end

base ad:0x801d000c
tree "GP2_PLBCL_END_ADDR"
group 0--3
line.long 0 "GP2_PLBCL_END_ADDR"
bitfld.long 0 3.--31. " PLBCL_END "  " "
tree.end

base ad:0x801d0010
tree "GP2_PLB_ALLOC_START_ADDR"
group 0--3
line.long 0 "GP2_PLB_ALLOC_START_ADDR"
bitfld.long 0 7.--31. " PLB_ALLOC_START_ADDR "  " "
tree.end

base ad:0x801d0014
tree "GP2_PLB_ALLOC_END_ADDR"
group 0--3
line.long 0 "GP2_PLB_ALLOC_END_ADDR"
bitfld.long 0 7.--31. " PLB_ALLOC_END_ADDR "  " "
tree.end

base ad:0x801d0020
tree "GP2_CMD"
group 0--3
line.long 0 "GP2_CMD"
bitfld.long 0 0. " START_VS "  "0 ,1 "
bitfld.long 0 1. " START_PLB "  "0 ,1 "
bitfld.long 0 4. " UPDATE_PLB_ALLOC "  "0 ,1 "
bitfld.long 0 5. " RESET "  "0 ,1 "
bitfld.long 0 6. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 7. " FLUSH_CACHE "  "0 ,1 "
bitfld.long 0 8. " START_BUS "  "0 ,1 "
bitfld.long 0 9. " STOP_BUS "  "0 ,1 "
bitfld.long 0 10. " SOFT_RESET "  "0 ,1 "
bitfld.long 0 11. " CLK_OVERRIDE "  "0 ,1 "
tree.end

base ad:0x801d0024
tree "GP2_INT_RAWSTAT"
group 0--3
line.long 0 "GP2_INT_RAWSTAT"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
bitfld.long 0 12. " AXI_BUS_STOPPED "  "0 ,1 "
bitfld.long 0 13. " VS_INVALID_CMD "  "0 ,1 "
bitfld.long 0 14. " PLB_INVALID_CMD "  "0 ,1 "
bitfld.long 0 19. " RESET_COMPLETED "  "0 ,1 "
bitfld.long 0 20. " SEMAPHORE_UNDERFLOW "  "0 ,1 "
bitfld.long 0 21. " SEMAPHORE_OVERFLOW "  "0 ,1 "
bitfld.long 0 22. " PTR_OUT_OF_BOUNDS "  "0 ,1 "
tree.end

base ad:0x801d0028
tree "GP2_INT_CLEAR"
wgroup 0--3
line.long 0 "GP2_INT_CLEAR"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
bitfld.long 0 12. " AXI_BUS_STOPPED "  "0 ,1 "
bitfld.long 0 13. " VS_INVALID_CMD "  "0 ,1 "
bitfld.long 0 14. " PLB_INVALID_CMD "  "0 ,1 "
bitfld.long 0 19. " RESET_COMPLETED "  "0 ,1 "
bitfld.long 0 20. " SEMAPHORE_UNDERFLOW "  "0 ,1 "
bitfld.long 0 21. " SEMAPHORE_OVERFLOW "  "0 ,1 "
bitfld.long 0 22. " PTR_OUT_OF_BOUNDS "  "0 ,1 "
tree.end

base ad:0x801d002c
tree "GP2_INT_MASK"
group 0--3
line.long 0 "GP2_INT_MASK"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
bitfld.long 0 12. " AXI_BUS_STOPPED "  "0 ,1 "
bitfld.long 0 13. " VS_INVALID_CMD "  "0 ,1 "
bitfld.long 0 14. " PLB_INVALID_CMD "  "0 ,1 "
bitfld.long 0 19. " RESET_COMPLETED "  "0 ,1 "
bitfld.long 0 20. " SEMAPHORE_UNDERFLOW "  "0 ,1 "
bitfld.long 0 21. " SEMAPHORE_OVERFLOW "  "0 ,1 "
bitfld.long 0 22. " PTR_OUT_OF_BOUNDS "  "0 ,1 "
tree.end

base ad:0x801d0030
tree "GP2_INT_STAT"
rgroup 0--3
line.long 0 "GP2_INT_STAT"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
bitfld.long 0 12. " AXI_BUS_STOPPED "  "0 ,1 "
bitfld.long 0 13. " VS_INVALID_CMD "  "0 ,1 "
bitfld.long 0 14. " PLB_INVALID_CMD "  "0 ,1 "
bitfld.long 0 19. " RESET_COMPLETED "  "0 ,1 "
bitfld.long 0 20. " SEMAPHORE_UNDERFLOW "  "0 ,1 "
bitfld.long 0 21. " SEMAPHORE_OVERFLOW "  "0 ,1 "
bitfld.long 0 22. " PTR_OUT_OF_BOUNDS "  "0 ,1 "
tree.end

base ad:0x801d0034
tree "GP2_WRITE_BOUNDARY_LOW"
group 0--3
line.long 0 "GP2_WRITE_BOUNDARY_LOW"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_LOW "  " "
tree.end

base ad:0x801d0038
tree "GP2_WRITE_BOUNDARY_HIGH"
group 0--3
line.long 0 "GP2_WRITE_BOUNDARY_HIGH"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_HIGH "  " "
tree.end

base ad:0x801d003c
tree "GP2_PERF_CNT_0_ENABLE"
group 0--3
line.long 0 "GP2_PERF_CNT_0_ENABLE"
bitfld.long 0 0. " PERF_CNT_0_ENABLE "  "0 ,1 "
tree.end

base ad:0x801d0040
tree "GP2_PERF_CNT_1_ENABLE"
group 0--3
line.long 0 "GP2_PERF_CNT_1_ENABLE"
bitfld.long 0 0. " PERF_CNT_1_ENABLE "  "0 ,1 "
tree.end

base ad:0x801d0044
tree "GP2_PERF_CNT_0_SRC"
group 0--3
line.long 0 "GP2_PERF_CNT_0_SRC"
bitfld.long 0 0.--4. " PERF_CNT_0_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x801d0048
tree "GP2_PERF_CNT_1_SRC"
group 0--3
line.long 0 "GP2_PERF_CNT_1_SRC"
bitfld.long 0 0.--4. " PERF_CNT_1_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x801d004c
tree "GP2_PERF_CNT_0_VAL"
rgroup 0--3
line.long 0 "GP2_PERF_CNT_0_VAL"
hexfld.long 0 " PERF_CNT_0_VAL "
tree.end

base ad:0x801d0050
tree "GP2_PERF_CNT_1_VAL"
rgroup 0--3
line.long 0 "GP2_PERF_CNT_1_VAL"
hexfld.long 0 " PERF_CNT_1_VAL "
tree.end

base ad:0x801d0054
tree "GP2_PERF_CNT_0_LIMIT"
group 0--3
line.long 0 "GP2_PERF_CNT_0_LIMIT"
hexfld.long 0 " PERF_CNT_0_LIMIT "
tree.end

base ad:0x801d0058
tree "GP2_PERF_CNT_1_LIMIT"
group 0--3
line.long 0 "GP2_PERF_CNT_1_LIMIT"
hexfld.long 0 " PERF_CNT_1_LIMIT "
tree.end

base ad:0x801d0068
tree "GP2_STATUS"
rgroup 0--3
line.long 0 "GP2_STATUS"
bitfld.long 0 0. " IRQ "  "0 ,1 "
bitfld.long 0 1. " VS_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " BUS_STOPPED "  "0 ,1 "
bitfld.long 0 3. " PLB_ACTIVE "  "0 ,1 "
bitfld.long 0 5. " PLB_STALLED "  "0 ,1 "
bitfld.long 0 6. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 7. " HANG "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 9. " CLK_OVERRIDE "  "0 ,1 "
tree.end

base ad:0x801d006c
tree "GP2_VERSION"
rgroup 0--3
line.long 0 "GP2_VERSION"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 2 " PRODUCT_ID "
tree.end

base ad:0x801d0080
tree "GP2_VSCL_INITIAL_ADDR"
rgroup 0--3
line.long 0 "GP2_VSCL_INITIAL_ADDR"
bitfld.long 0 3.--31. " VSCL_INITIAL_ADDR "  " "
tree.end

base ad:0x801d0084
tree "GP2_PLBCL_INITIAL_ADDR"
rgroup 0--3
line.long 0 "GP2_PLBCL_INITIAL_ADDR"
bitfld.long 0 3.--31. " PLBCL_INITIAL_ADDR "  " "
tree.end

base ad:0x801d0088
tree "GP2_WRITE_BOUNDARY_ERROR_ADDR"
rgroup 0--3
line.long 0 "GP2_WRITE_BOUNDARY_ERROR_ADDR"
bitfld.long 0 0. " WRITE_BOUNDARY_ERROR_ADDR "  "0 ,1 "
tree.end

base ad:0x801d0094
tree "GP2_AXI_BUS_ERROR_STAT"
rgroup 0--3
line.long 0 "GP2_AXI_BUS_ERROR_STAT"
bitfld.long 0 0. " READ_ERROR "  "0 ,1 "
bitfld.long 0 1. " WRITE_ERROR "  "0 ,1 "
bitfld.long 0 2.--5. " READ_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--9. " WRITE_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801d00a0
tree "GP2_WATCHDOG_DISABLE"
group 0--3
line.long 0 "GP2_WATCHDOG_DISABLE"
bitfld.long 0 0. " WATCHDOG_DISABLE "  "0 ,1 "
tree.end

base ad:0x801d00a4
tree "GP2_WATCHDOG_TIMEOUT"
group 0--3
line.long 0 "GP2_WATCHDOG_TIMEOUT"
hexfld.long 0 " WATCHDOG_TIMEOUT "
tree.end

base ad:0x801d1000
tree "L2_VERSION"
rgroup 0--3
line.long 0 "L2_VERSION"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 2 " PRODUCT_ID "
tree.end

base ad:0x801d1004
tree "L2_SIZE"
rgroup 0--3
line.long 0 "L2_SIZE"
hexfld.byte 0 " LINE_SIZE "
hexfld.byte 1 " ASSOCIATIVITY "
hexfld.byte 2 " CACHE8SIZE "
hexfld.byte 3 " EXTERNAL_BUS_WIDTH "
tree.end

base ad:0x801d1008
tree "L2_STATUS"
rgroup 0--3
line.long 0 "L2_STATUS"
bitfld.long 0 0. " COMMAND_BUSY "  "0 ,1 "
bitfld.long 0 1. " DATA_BUSY "  "0 ,1 "
tree.end

base ad:0x801d1010
tree "L2_COMMAND"
group 0--3
line.long 0 "L2_COMMAND"
bitfld.long 0 0.--2. " COMMAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801d1014
tree "L2_CLEAR_PAGE"
group 0--3
line.long 0 "L2_CLEAR_PAGE"
hexfld.long 0 " CLEAR_PAGE "
tree.end

base ad:0x801d1018
tree "L2_MAX_READS"
group 0--3
line.long 0 "L2_MAX_READS"
bitfld.long 0 0.--4. " MAX_READS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x801d101c
tree "L2_ENABLE"
group 0--3
line.long 0 "L2_ENABLE"
bitfld.long 0 0. " PERMIT_CACHEABLE_ACCESSES "  "0 ,1 "
bitfld.long 0 1. " PERMIT_CACHE_READ_ALLOCATE "  "0 ,1 "
tree.end

base ad:0x801d1020
tree "L2_PERFCNT_SRC0"
group 0--3
line.long 0 "L2_PERFCNT_SRC0"
bitfld.long 0 0.--6. " PERFCNT_SRC0 "  " "
tree.end

base ad:0x801d1024
tree "L2_PERFCNT_VAL0"
group 0--3
line.long 0 "L2_PERFCNT_VAL0"
hexfld.long 0 " PERFCNT_VAL0 "
tree.end

base ad:0x801d1028
tree "L2_PERFCNT_SRC1"
group 0--3
line.long 0 "L2_PERFCNT_SRC1"
bitfld.long 0 0.--6. " PERFCNT_SRC1 "  " "
tree.end

base ad:0x801d102c
tree "L2_PERFCNT_VAL1"
group 0--3
line.long 0 "L2_PERFCNT_VAL1"
hexfld.long 0 " PERFCNT_VAL1 "
tree.end

base ad:0x801d3000
tree "GP_MMU_DTE_ADDR"
group 0--3
line.long 0 "GP_MMU_DTE_ADDR"
bitfld.long 0 0.--19. " DTE_ADDR "  " "
tree.end

base ad:0x801d3004
tree "GP_MMU_STATUS"
rgroup 0--3
line.long 0 "GP_MMU_STATUS"
bitfld.long 0 0. " PAGING_ENABLED "  "0 ,1 "
bitfld.long 0 1. " PAGE_FAULT_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " STALL_ACTIVE "  "0 ,1 "
bitfld.long 0 3. " IDLE "  "0 ,1 "
bitfld.long 0 4. " REPLAY_BUFFER_EMPTY "  "0 ,1 "
bitfld.long 0 5. " PAGE_FAULT_IS_WRITE "  "0 ,1 "
bitfld.long 0 6.--10. " PAGE_FAULT_BUS_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x801d3008
tree "GP_MMU_COMMAND"
group 0--3
line.long 0 "GP_MMU_COMMAND"
bitfld.long 0 0.--2. " COMMAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801d300c
tree "GP_MMU_PAGE_FAULT_ADDR"
rgroup 0--3
line.long 0 "GP_MMU_PAGE_FAULT_ADDR"
bitfld.long 0 0. " PAGE_FAULT_ADDR "  "0 ,1 "
tree.end

base ad:0x801d3010
tree "GP_MMU_ZAPE_ONE_LINE"
group 0--3
line.long 0 "GP_MMU_ZAPE_ONE_LINE"
bitfld.long 0 0. " ZAPE_ONE_LINE "  "0 ,1 "
tree.end

base ad:0x801d3014
tree "GP_MMU_INT_RAWSTAT"
group 0--3
line.long 0 "GP_MMU_INT_RAWSTAT"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
tree.end

base ad:0x801d3018
tree "GP_MMU_INT_CLEAR"
wgroup 0--3
line.long 0 "GP_MMU_INT_CLEAR"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
tree.end

base ad:0x801d301c
tree "GP_MMU_INT_MASK"
group 0--3
line.long 0 "GP_MMU_INT_MASK"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
tree.end

base ad:0x801d3020
tree "GP_MMU_INT_STATUS"
rgroup 0--3
line.long 0 "GP_MMU_INT_STATUS"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
tree.end

base ad:0x801d4000
tree "PP0_MMU_DTE_ADDR"
group 0--3
line.long 0 "PP0_MMU_DTE_ADDR"
bitfld.long 0 0.--19. " DTE_ADDR "  " "
tree.end

base ad:0x801d4004
tree "PP0_MMU_STATUS"
rgroup 0--3
line.long 0 "PP0_MMU_STATUS"
bitfld.long 0 0. " PAGING_ENABLED "  "0 ,1 "
bitfld.long 0 1. " PAGE_FAULT_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " STALL_ACTIVE "  "0 ,1 "
bitfld.long 0 3. " IDLE "  "0 ,1 "
bitfld.long 0 4. " REPLAY_BUFFER_EMPTY "  "0 ,1 "
bitfld.long 0 5. " PAGE_FAULT_IS_WRITE "  "0 ,1 "
bitfld.long 0 6.--10. " PAGE_FAULT_BUS_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x801d4008
tree "PP0_MMU_COMMAND"
group 0--3
line.long 0 "PP0_MMU_COMMAND"
bitfld.long 0 0.--2. " COMMAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801d400c
tree "PP0_MMU_PAGE_FAULT_ADDR"
rgroup 0--3
line.long 0 "PP0_MMU_PAGE_FAULT_ADDR"
bitfld.long 0 0. " PAGE_FAULT_ADDR "  "0 ,1 "
tree.end

base ad:0x801d4010
tree "PP0_MMU_ZAPE_ONE_LINE"
group 0--3
line.long 0 "PP0_MMU_ZAPE_ONE_LINE"
bitfld.long 0 0. " ZAPE_ONE_LINE "  "0 ,1 "
tree.end

base ad:0x801d4014
tree "PP0_MMU_INT_RAWSTAT"
group 0--3
line.long 0 "PP0_MMU_INT_RAWSTAT"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
tree.end

base ad:0x801d4018
tree "PP0_MMU_INT_CLEAR"
wgroup 0--3
line.long 0 "PP0_MMU_INT_CLEAR"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
tree.end

base ad:0x801d401c
tree "PP0_MMU_INT_MASK"
group 0--3
line.long 0 "PP0_MMU_INT_MASK"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
tree.end

base ad:0x801d4020
tree "PP0_MMU_INT_STATUS"
rgroup 0--3
line.long 0 "PP0_MMU_INT_STATUS"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
tree.end

base ad:0x801d8000
tree "REND_LIST_ADDR"
group 0--3
line.long 0 "REND_LIST_ADDR"
bitfld.long 0 3.--31. " REND_LIST_ADDR "  " "
tree.end

base ad:0x801d8004
tree "REND_RSW_BASE"
group 0--3
line.long 0 "REND_RSW_BASE"
bitfld.long 0 6.--31. " REND_RSW_BASE "  " "
tree.end

base ad:0x801d8008
tree "REND_VERTEX_BASE"
group 0--3
line.long 0 "REND_VERTEX_BASE"
bitfld.long 0 6.--31. " REND_VERTEX_BASE "  " "
tree.end

base ad:0x801d800c
tree "FEATURE_ENABLE"
group 0--3
line.long 0 "FEATURE_ENABLE"
bitfld.long 0 0. " FP_TILEBUF_ENABLE "  "0 ,1 "
bitfld.long 0 1. " EARLYZ_ENABLE "  "0 ,1 "
bitfld.long 0 3. " EARLYZ_DISABLE1 "  "0 ,1 "
bitfld.long 0 4. " EARLYZ_DISABLE2 "  "0 ,1 "
bitfld.long 0 5. " ORIGIN_LOWER_LEFT "  "0 ,1 "
bitfld.long 0 6. " SUMMATE_QUAD_COVER "  "0 ,1 "
tree.end

base ad:0x801d8010
tree "Z_CLEAR_VALUE"
group 0--3
line.long 0 "Z_CLEAR_VALUE"
bitfld.long 0 0.--23. " Z_CLEAR_VALUE "  " "
tree.end

base ad:0x801d8014
tree "STENCIL_CLEAR_VALUE"
group 0--3
line.long 0 "STENCIL_CLEAR_VALUE"
hexfld.byte 0 " STENCIL_CLEAR_VALUE "
tree.end

base ad:0x801d8018
tree "ARGB_CLEAR_VALUE_0"
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_0"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
tree.end

base ad:0x801d801c
tree "ARGB_CLEAR_VALUE_1"
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_1"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
tree.end

base ad:0x801d8020
tree "ARGB_CLEAR_VALUE_2"
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_2"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
tree.end

base ad:0x801d8024
tree "ARGB_CLEAR_VALUE_3"
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_3"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
tree.end

base ad:0x801d8028
tree "BOUNDING_BOX_LEFT_RIGHT"
group 0--3
line.long 0 "BOUNDING_BOX_LEFT_RIGHT"
bitfld.long 0 0.--13. " BOUNDING_BOX_RIGHT "  " "
bitfld.long 0 16.--19. " BOUNDING_BOX_LEFT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801d802c
tree "BOUNDING_BOX_BOTTOM"
group 0--3
line.long 0 "BOUNDING_BOX_BOTTOM"
bitfld.long 0 0.--13. " BOUNDING_BOX_BOTTOM "  " "
tree.end

base ad:0x801d8030
tree "FS_STACK_ADDR"
group 0--3
line.long 0 "FS_STACK_ADDR"
bitfld.long 0 3.--31. " FS_STACK_ADDR "  " "
tree.end

base ad:0x801d8034
tree "FS_STACK_SIZE_AND_INIT_VAL"
group 0--3
line.long 0 "FS_STACK_SIZE_AND_INIT_VAL"
hexfld.word 0 " FP_STACK_SIZE "
hexfld.word 2 " FS_STACK_INIT_VAL "
tree.end

base ad:0x801d8040
tree "ORIGIN_OFFSET_X"
group 0--3
line.long 0 "ORIGIN_OFFSET_X"
hexfld.word 0 " ORIGIN_OFFSET_X "
tree.end

base ad:0x801d8044
tree "ORIGIN_OFFSET_Y"
group 0--3
line.long 0 "ORIGIN_OFFSET_Y"
hexfld.word 0 " ORIGIN_OFFSET_Y "
tree.end

base ad:0x801d8048
tree "SUBPIXEL_SPECIFIER"
group 0--3
line.long 0 "SUBPIXEL_SPECIFIER"
hexfld.byte 0 " SUBPIXEL_SPECIFIER "
tree.end

base ad:0x801d804c
tree "TIEBREAK_MODE"
group 0--3
line.long 0 "TIEBREAK_MODE"
bitfld.long 0 0.--2. " TIEBREAK_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801d8050
tree "PLIST_CONFIG"
group 0--3
line.long 0 "PLIST_CONFIG"
bitfld.long 0 0.--5. " SCALE_X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--21. " SCALE_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 28.--29. " LIST_FORMAT "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x801d8054
tree "SCALING_CONFIG"
group 0--3
line.long 0 "SCALING_CONFIG"
bitfld.long 0 0. " POINT_AND_LINE_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 1. " DITHERING_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 2. " FRAGCOORD_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " DERIVATIVE_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 8. " FLIP_POINT_SPRITES "  "0 ,1 "
bitfld.long 0 9. " FLIP_DITHERING_MATRIX "  "0 ,1 "
bitfld.long 0 10. " FLIP_FRAGCOORD "  "0 ,1 "
bitfld.long 0 11. " FLIP_DERIVATIVE_Y "  "0 ,1 "
bitfld.long 0 16.--18. " SCALE_X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " SCALE_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801d8058
tree "TILEBUFFER_BITS"
group 0--3
line.long 0 "TILEBUFFER_BITS"
bitfld.long 0 0.--3. " TILEBUFFER_R_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " TILEBUFFER_G_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TILEBUFFER_B_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " TILEBUFFER_A_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801d8100
tree "WB0_SOURCE_SELECT"
group 0--3
line.long 0 "WB0_SOURCE_SELECT"
bitfld.long 0 0.--1. " WB0_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x801d8104
tree "WB0_TARGET_ADDR"
group 0--3
line.long 0 "WB0_TARGET_ADDR"
bitfld.long 0 3.--31. " WB0_TARGET_ADDR "  " "
tree.end

base ad:0x801d8108
tree "WB0_TARGET_PIXEL_FORMAT"
group 0--3
line.long 0 "WB0_TARGET_PIXEL_FORMAT"
bitfld.long 0 0.--3. " WB0_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801d810c
tree "WB0_TARGET_AA_FORMAT"
group 0--3
line.long 0 "WB0_TARGET_AA_FORMAT"
bitfld.long 0 0.--2. " WB0_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB0_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB0_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801d8110
tree "WB0_TARGET_LAYOUT"
group 0--3
line.long 0 "WB0_TARGET_LAYOUT"
bitfld.long 0 0.--1. " WB0_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x801d8114
tree "WB0_TARGET_SCANLINE_LENGTH"
group 0--3
line.long 0 "WB0_TARGET_SCANLINE_LENGTH"
hexfld.word 0 " WB0_TARGET_SCANLINE_LENGTH "
tree.end

base ad:0x801d8118
tree "WB0_TARGET_FLAGS"
group 0--3
line.long 0 "WB0_TARGET_FLAGS"
bitfld.long 0 0. " WB0_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB0_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB0_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB0_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB0_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB0_BIG_ENDIAN "  "0 ,1 "
tree.end

base ad:0x801d811c
tree "WB0_MRT_ENABLE"
group 0--3
line.long 0 "WB0_MRT_ENABLE"
bitfld.long 0 0.--3. " WB0_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801d8120
tree "WB0_MRT_OFFSET"
group 0--3
line.long 0 "WB0_MRT_OFFSET"
bitfld.long 0 3.--31. " WB0_MRT_OFFSET "  " "
tree.end

base ad:0x801d8124
tree "WB0_GLOBAL_TEST_ENABLE"
group 0--3
line.long 0 "WB0_GLOBAL_TEST_ENABLE"
bitfld.long 0 0. " WB0_GLOBAL_TEST_ENABLE "  "0 ,1 "
tree.end

base ad:0x801d8128
tree "WB0_GLOBAL_TEST_REF_VALUE"
group 0--3
line.long 0 "WB0_GLOBAL_TEST_REF_VALUE"
hexfld.word 0 " WB0_GLOBAL_TEST_REF_VALUE "
tree.end

base ad:0x801d812c
tree "WB0_GLOBAL_TEST_CMP_FUNC"
group 0--3
line.long 0 "WB0_GLOBAL_TEST_CMP_FUNC"
bitfld.long 0 0.--2. " WB0_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801d8200
tree "WB1_SOURCE_SELECT"
group 0--3
line.long 0 "WB1_SOURCE_SELECT"
bitfld.long 0 0.--1. " WB1_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x801d8204
tree "WB1_TARGET_ADDR"
group 0--3
line.long 0 "WB1_TARGET_ADDR"
bitfld.long 0 3.--31. " WB1_TARGET_ADDR "  " "
tree.end

base ad:0x801d8208
tree "WB1_TARGET_PIXEL_FORMAT"
group 0--3
line.long 0 "WB1_TARGET_PIXEL_FORMAT"
bitfld.long 0 0.--3. " WB1_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801d820c
tree "WB1_TARGET_AA_FORMAT"
group 0--3
line.long 0 "WB1_TARGET_AA_FORMAT"
bitfld.long 0 0.--2. " WB1_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB1_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB1_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801d8210
tree "WB1_TARGET_LAYOUT"
group 0--3
line.long 0 "WB1_TARGET_LAYOUT"
bitfld.long 0 0.--1. " WB1_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x801d8214
tree "WB1_TARGET_SCANLINE_LENGTH"
group 0--3
line.long 0 "WB1_TARGET_SCANLINE_LENGTH"
hexfld.word 0 " WB1_TARGET_SCANLINE_LENGTH "
tree.end

base ad:0x801d8218
tree "WB1_TARGET_FLAGS"
group 0--3
line.long 0 "WB1_TARGET_FLAGS"
bitfld.long 0 0. " WB1_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB1_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB1_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB1_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB1_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB1_BIG_ENDIAN "  "0 ,1 "
tree.end

base ad:0x801d821c
tree "WB1_MRT_ENABLE"
group 0--3
line.long 0 "WB1_MRT_ENABLE"
bitfld.long 0 0.--3. " WB1_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801d8220
tree "WB1_MRT_OFFSET"
group 0--3
line.long 0 "WB1_MRT_OFFSET"
bitfld.long 0 3.--31. " WB1_MRT_OFFSET "  " "
tree.end

base ad:0x801d8224
tree "WB1_GLOBAL_TEST_ENABLE"
group 0--3
line.long 0 "WB1_GLOBAL_TEST_ENABLE"
bitfld.long 0 0. " WB1_GLOBAL_TEST_ENABLE "  "0 ,1 "
tree.end

base ad:0x801d8228
tree "WB1_GLOBAL_TEST_REF_VALUE"
group 0--3
line.long 0 "WB1_GLOBAL_TEST_REF_VALUE"
hexfld.word 0 " WB1_GLOBAL_TEST_REF_VALUE "
tree.end

base ad:0x801d822c
tree "WB1_GLOBAL_TEST_CMP_FUNC"
group 0--3
line.long 0 "WB1_GLOBAL_TEST_CMP_FUNC"
bitfld.long 0 0.--2. " WB1_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801d8300
tree "WB2_SOURCE_SELECT"
group 0--3
line.long 0 "WB2_SOURCE_SELECT"
bitfld.long 0 0.--1. " WB2_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x801d8304
tree "WB2_TARGET_ADDR"
group 0--3
line.long 0 "WB2_TARGET_ADDR"
bitfld.long 0 3.--31. " WB2_TARGET_ADDR "  " "
tree.end

base ad:0x801d8308
tree "WB2_TARGET_PIXEL_FORMAT"
group 0--3
line.long 0 "WB2_TARGET_PIXEL_FORMAT"
bitfld.long 0 0.--3. " WB2_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801d830c
tree "WB2_TARGET_AA_FORMAT"
group 0--3
line.long 0 "WB2_TARGET_AA_FORMAT"
bitfld.long 0 0.--2. " WB2_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB2_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB2_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801d8310
tree "WB2_TARGET_LAYOUT"
group 0--3
line.long 0 "WB2_TARGET_LAYOUT"
bitfld.long 0 0.--1. " WB2_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x801d8314
tree "WB2_TARGET_SCANLINE_LENGTH"
group 0--3
line.long 0 "WB2_TARGET_SCANLINE_LENGTH"
hexfld.word 0 " WB2_TARGET_SCANLINE_LENGTH "
tree.end

base ad:0x801d8318
tree "WB2_TARGET_FLAGS"
group 0--3
line.long 0 "WB2_TARGET_FLAGS"
bitfld.long 0 0. " WB2_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB2_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB2_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB2_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB2_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB2_BIG_ENDIAN "  "0 ,1 "
tree.end

base ad:0x801d831c
tree "WB2_MRT_ENABLE"
group 0--3
line.long 0 "WB2_MRT_ENABLE"
bitfld.long 0 0.--3. " WB2_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801d8320
tree "WB2_MRT_OFFSET"
group 0--3
line.long 0 "WB2_MRT_OFFSET"
bitfld.long 0 3.--31. " WB2_MRT_OFFSET "  " "
tree.end

base ad:0x801d8324
tree "WB2_GLOBAL_TEST_ENABLE"
group 0--3
line.long 0 "WB2_GLOBAL_TEST_ENABLE"
bitfld.long 0 0. " WB2_GLOBAL_TEST_ENABLE "  "0 ,1 "
tree.end

base ad:0x801d8328
tree "WB2_GLOBAL_TEST_REF_VALUE"
group 0--3
line.long 0 "WB2_GLOBAL_TEST_REF_VALUE"
hexfld.word 0 " WB2_GLOBAL_TEST_REF_VALUE "
tree.end

base ad:0x801d832c
tree "WB2_GLOBAL_TEST_CMP_FUNC"
group 0--3
line.long 0 "WB2_GLOBAL_TEST_CMP_FUNC"
bitfld.long 0 0.--2. " WB2_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x801d9000
tree "MGMT_VERSION"
rgroup 0--3
line.long 0 "MGMT_VERSION"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 2 " PRODUCT_ID "
tree.end

base ad:0x801d9004
tree "MGMT_CURRENT_REND_LIST_ADDR"
group 0--3
line.long 0 "MGMT_CURRENT_REND_LIST_ADDR"
bitfld.long 0 5.--31. " CURRENT_REND_LIST_ADDR "  " "
tree.end

base ad:0x801d9008
tree "MGMT_STATUS"
group 0--3
line.long 0 "MGMT_STATUS"
bitfld.long 0 0. " RENDERING_ACTIVE "  "0 ,1 "
bitfld.long 0 1. " TILE_STOPPED "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 4. " BUS_STOPPED "  "0 ,1 "
bitfld.long 0 5. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 6. " INTERRUPT_ASSERTED "  "0 ,1 "
bitfld.long 0 7. " CLK_OVERRIDE "  "0 ,1 "
tree.end

base ad:0x801d900c
tree "MGMT_CTRL"
group 0--3
line.long 0 "MGMT_CTRL"
bitfld.long 0 0. " STOP_BUS "  "0 ,1 "
bitfld.long 0 1. " START_BUS "  "0 ,1 "
bitfld.long 0 2. " END_AFTER_TILE "  "0 ,1 "
bitfld.long 0 3. " FLUSH_CACHES "  "0 ,1 "
bitfld.long 0 4. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 5. " FORCE_RESET "  "0 ,1 "
bitfld.long 0 6. " START_RENDERING "  "0 ,1 "
bitfld.long 0 7. " SOFT_RESET "  "0 ,1 "
bitfld.long 0 8. " CLK_OVERRIDE "  "0 ,1 "
tree.end

base ad:0x801d9010
tree "MGMT_LAST_TILE_POS_START"
rgroup 0--3
line.long 0 "MGMT_LAST_TILE_POS_START"
hexfld.byte 0 " TILEX_START "
hexfld.byte 2 " TILEY_START "
tree.end

base ad:0x801d9014
tree "MGMT_LAST_TILE_POS_END"
rgroup 0--3
line.long 0 "MGMT_LAST_TILE_POS_END"
hexfld.byte 0 " TILEX_END "
hexfld.byte 2 " TILEY_END "
tree.end

base ad:0x801d9020
tree "MGMT_INT_RAWSTAT"
group 0--3
line.long 0 "MGMT_INT_RAWSTAT"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
tree.end

base ad:0x801d9024
tree "MGMT_INT_CLEAR"
group 0--3
line.long 0 "MGMT_INT_CLEAR"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
tree.end

base ad:0x801d9028
tree "MGMT_INT_MASK"
group 0--3
line.long 0 "MGMT_INT_MASK"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
tree.end

base ad:0x801d902c
tree "MGMT_INT_STATUS"
rgroup 0--3
line.long 0 "MGMT_INT_STATUS"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
tree.end

base ad:0x801d9040
tree "MGMT_WRITE_BOUNDARY_ENABLE"
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ENABLE"
bitfld.long 0 0. " WRITE_BOUNDARY_ENABLE "  "0 ,1 "
tree.end

base ad:0x801d9044
tree "MGMT_WRITE_BOUNDARY_LOW"
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_LOW"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_LOW "  " "
tree.end

base ad:0x801d9048
tree "MGMT_WRITE_BOUNDARY_HIGH"
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_HIGH"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_HIGH "  " "
tree.end

base ad:0x801d904c
tree "MGMT_WRITE_BOUNDARY_ADDRESS"
rgroup 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ADDRESS"
bitfld.long 0 2.--31. " WRITE_BOUNDARY_ADDRESS "  " "
tree.end

base ad:0x801d9050
tree "MGMT_BUS_ERROR_STATUS"
rgroup 0--3
line.long 0 "MGMT_BUS_ERROR_STATUS"
bitfld.long 0 0. " WRITE_ERROR "  "0 ,1 "
bitfld.long 0 1. " READ_ERROR "  "0 ,1 "
bitfld.long 0 2.--5. " WRITE_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--9. " READ_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x801d9060
tree "MGMT_WATCHDOG_DISABLE"
group 0--3
line.long 0 "MGMT_WATCHDOG_DISABLE"
bitfld.long 0 0. " WATCHDOG_DISABLE "  "0 ,1 "
tree.end

base ad:0x801d9064
tree "MGMT_WATCHDOG_TIMEOUT"
group 0--3
line.long 0 "MGMT_WATCHDOG_TIMEOUT"
hexfld.long 0 " WATCHDOG_TIMEOUT "
tree.end

base ad:0x801d9080
tree "MGMT_PERF_CNT_0_ENABLE"
group 0--3
line.long 0 "MGMT_PERF_CNT_0_ENABLE"
bitfld.long 0 0. " PERF_CNT_0_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_0_LIM_EN "  "0 ,1 "
tree.end

base ad:0x801d9084
tree "MGMT_PERF_CNT_0_SRC"
group 0--3
line.long 0 "MGMT_PERF_CNT_0_SRC"
bitfld.long 0 0.--5. " PERF_CNT_0_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x801d9088
tree "MGMT_PERF_CNT_0_LIMIT"
group 0--3
line.long 0 "MGMT_PERF_CNT_0_LIMIT"
hexfld.long 0 " PERF_CNT_0_LIMIT "
tree.end

base ad:0x801d908c
tree "MGMT_PERF_CNT_0_VALUE"
group 0--3
line.long 0 "MGMT_PERF_CNT_0_VALUE"
hexfld.long 0 " PERF_CNT_0_VALUE "
tree.end

base ad:0x801d90a0
tree "MGMT_PERF_CNT_1_ENABLE"
group 0--3
line.long 0 "MGMT_PERF_CNT_1_ENABLE"
bitfld.long 0 0. " PERF_CNT_1_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_1_LIM_EN "  "0 ,1 "
tree.end

base ad:0x801d90a4
tree "MGMT_PERF_CNT_1_SRC"
group 0--3
line.long 0 "MGMT_PERF_CNT_1_SRC"
bitfld.long 0 0.--5. " PERF_CNT_1_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x801d90a8
tree "MGMT_PERF_CNT_1_LIMIT"
group 0--3
line.long 0 "MGMT_PERF_CNT_1_LIMIT"
hexfld.long 0 " PERF_CNT_1_LIMIT "
tree.end

base ad:0x801d90ac
tree "MGMT_PERF_CNT_1_VALUE"
group 0--3
line.long 0 "MGMT_PERF_CNT_1_VALUE"
hexfld.long 0 " PERF_CNT_1_VALUE "
tree.end

base ad:0x801d90b0
tree "MGMT_PERFMON_CONTR"
group 0--3
line.long 0 "MGMT_PERFMON_CONTR"
bitfld.long 0 0. " PERFMON_ENABLE "  "0 ,1 "
bitfld.long 0 16.--25. " NUMBER_OF_TILEX "  " "
tree.end

base ad:0x801d90b4
tree "MGMT_PERFMON_BASE"
group 0--3
line.long 0 "MGMT_PERFMON_BASE"
bitfld.long 0 3.--31. " PERFMON_BASE_ADDR "  " "
tree.end

tree.end

;==============================================================
tree "SIA"
;==============================================================
base ad:0xa0102000
tree "SIA_RESET"
group 0--3
line.long 0 "SIA_RESET"
bitfld.long 0 0. " SIA_CORE_RST "  "0 ,1 "
bitfld.long 0 1. " IPP_RST "  "0 ,1 "
bitfld.long 0 2. " ISP_RST "  "0 ,1 "
tree.end

base ad:0xa0102004
tree "SIA_SOFT_RESET"
group 0--3
line.long 0 "SIA_SOFT_RESET"
bitfld.long 0 1. " PROJ_RST "  "0 ,1 "
bitfld.long 0 4. " IFP_RST "  "0 ,1 "
bitfld.long 0 5. " XMS0_RST "  "0 ,1 "
bitfld.long 0 6. " XMS1_RST "  "0 ,1 "
bitfld.long 0 7. " XML_RST "  "0 ,1 "
bitfld.long 0 8. " SDI_RST "  "0 ,1 "
tree.end

base ad:0xa0102010
tree "SIA_CLOCK_ENABLE"
group 0--3
line.long 0 "SIA_CLOCK_ENABLE"
bitfld.long 0 0. " IPP_CLK_EN "  "0 ,1 "
bitfld.long 0 1. " PROJ_CLK_EN "  "0 ,1 "
bitfld.long 0 2. " STBP_CLK_EN "  "0 ,1 "
bitfld.long 0 3. " DMA_CLK_EN "  "0 ,1 "
tree.end

base ad:0xa0102020
tree "SIA_IDN_HRV"
rgroup 0--3
line.long 0 "SIA_IDN_HRV"
bitfld.long 0 0.--3. " HW_REV0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " HW_REV1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " HW_REV2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0102080
tree "SIA_STATIC_PIPE_SELECT"
group 0--3
line.long 0 "SIA_STATIC_PIPE_SELECT"
bitfld.long 0 0.--1. " STATIC_PIPE_SEL "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0102090
tree "LICN_ITS"
rgroup 0--3
line.long 0 "LICN_ITS"
bitfld.long 0 0. " LICN_ITS "  "0 ,1 "
tree.end

base ad:0xa0102094
tree "LICN_ITS_BCLR"
wgroup 0--3
line.long 0 "LICN_ITS_BCLR"
bitfld.long 0 0. " LICN_ITS_BCLR "  "0 ,1 "
tree.end

base ad:0xa0102098
tree "LICN_ITS_BSET"
wgroup 0--3
line.long 0 "LICN_ITS_BSET"
bitfld.long 0 0. " LICN_ITS_BSET "  "0 ,1 "
tree.end

base ad:0xa010209c
tree "LICN_ITM"
rgroup 0--3
line.long 0 "LICN_ITM"
bitfld.long 0 0. " LICN_ITM "  "0 ,1 "
tree.end

base ad:0xa01020a0
tree "LICN_ITM_BCLR"
wgroup 0--3
line.long 0 "LICN_ITM_BCLR"
bitfld.long 0 0. " LICN_ITM_BCLR "  "0 ,1 "
tree.end

base ad:0xa01020a4
tree "LICN_ITM_BSET"
wgroup 0--3
line.long 0 "LICN_ITM_BSET"
bitfld.long 0 0. " LICN_ITM_BSET "  "0 ,1 "
tree.end

base ad:0xa01020c0
tree "SIA_HI_ITS"
group 0--3
line.long 0 "SIA_HI_ITS"
bitfld.long 0 0. " CRM_HI_ITS "  "0 ,1 "
bitfld.long 0 1. " SDI_HI_ITS "  "0 ,1 "
bitfld.long 0 2. " IFP_HI_ITS "  "0 ,1 "
bitfld.long 0 3. " XMS0_HI_ITS "  "0 ,1 "
bitfld.long 0 4. " XMS1_HI_ITS "  "0 ,1 "
bitfld.long 0 5. " DMA_HI_ITS "  "0 ,1 "
bitfld.long 0 6. " PROJ_HI_ITS "  "0 ,1 "
bitfld.long 0 7. " LICN_HI_ITS "  "0 ,1 "
bitfld.long 0 8. " STBP_HI_ITS "  "0 ,1 "
bitfld.long 0 12. " LBE_HI_ITS "  "0 ,1 "
bitfld.long 0 14. " ISP_RX_HI_ITS "  "0 ,1 "
bitfld.long 0 15. " VIDEO_COMPLETE_PIPE0_HI_ITS "  "0 ,1 "
bitfld.long 0 17. " HISTOGRAM_256_BINS_HI_ITS "  "0 ,1 "
bitfld.long 0 18. " EXPOSURE_6X8_HI_ITS "  "0 ,1 "
bitfld.long 0 19. " AF_STATS_HI_ITS "  "0 ,1 "
bitfld.long 0 20. " WB_STATS_HI_ITS "  "0 ,1 "
bitfld.long 0 23. " ARCTIC_HI_ITS "  "0 ,1 "
bitfld.long 0 24. " ACCWGZONE_HI_ITS "  "0 ,1 "
bitfld.long 0 25. " GLACE_HI_ITS "  "0 ,1 "
tree.end

base ad:0xa01020c4
tree "SIA_HI_ITS_BCLR"
wgroup 0--3
line.long 0 "SIA_HI_ITS_BCLR"
bitfld.long 0 0. " CRM_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 1. " SDI_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 2. " IFP_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 3. " XMS0_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 4. " XMS1_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 5. " DMA_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 6. " PROJ_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 7. " LICN_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 8. " STBP_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 12. " LBE_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 14. " ISP_RX_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 15. " VIDEO_COMPLETE_PIPE0_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 17. " HISTOGRAM_256_BINS_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 18. " EXPOSURE_6X8_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 19. " AF_STATS_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 20. " WB_STATS_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 23. " ARCTIC_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 24. " ACCWGZONE_HI_ITS_BCLR "  "0 ,1 "
bitfld.long 0 25. " GLACE_HI_ITS_BCLR "  "0 ,1 "
tree.end

base ad:0xa01020c8
tree "SIA_HI_ITS_BSET"
wgroup 0--3
line.long 0 "SIA_HI_ITS_BSET"
bitfld.long 0 0. " CRM_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 1. " SDI_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 2. " IFP_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 3. " XMS0_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 4. " XMS1_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 5. " DMA_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 6. " PROJ_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 7. " LICN_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 8. " STBP_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 12. " LBE_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 14. " ISP_RX_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 15. " VIDEO_COMPLETE_PIPE0_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 17. " HISTOGRAM_256_BINS_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 18. " EXPOSURE_6X8_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 19. " AF_STATS_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 20. " WB_STATS_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 23. " ARCTIC_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 24. " ACCWGZONE_HI_ITS_BSET "  "0 ,1 "
bitfld.long 0 25. " GLACE_HI_ITS_BSET "  "0 ,1 "
tree.end

base ad:0xa01020cc
tree "SIA_HI_ITM"
rgroup 0--3
line.long 0 "SIA_HI_ITM"
bitfld.long 0 0. " CRM_HI_ITM "  "0 ,1 "
bitfld.long 0 1. " SDI_HI_ITM "  "0 ,1 "
bitfld.long 0 2. " IFP_HI_ITM "  "0 ,1 "
bitfld.long 0 3. " XMS0_HI_ITM "  "0 ,1 "
bitfld.long 0 4. " XMS1_HI_ITM "  "0 ,1 "
bitfld.long 0 5. " DMA_HI_ITM "  "0 ,1 "
bitfld.long 0 6. " PROJ_HI_ITM "  "0 ,1 "
bitfld.long 0 7. " LICN_HI_ITM "  "0 ,1 "
bitfld.long 0 8. " STBP_HI_ITM "  "0 ,1 "
bitfld.long 0 12. " LBE_HI_ITM "  "0 ,1 "
bitfld.long 0 14. " ISP_RX_HI_ITM "  "0 ,1 "
bitfld.long 0 15. " VIDEO_COMPLETE_PIPE0_HI_ITM "  "0 ,1 "
bitfld.long 0 17. " HISTOGRAM_256_BINS_HI_ITM "  "0 ,1 "
bitfld.long 0 18. " EXPOSURE_6X8_HI_ITM "  "0 ,1 "
bitfld.long 0 19. " AF_STATS_HI_ITM "  "0 ,1 "
bitfld.long 0 20. " WB_STATS_HI_ITM "  "0 ,1 "
bitfld.long 0 23. " ARCTIC_HI_ITM "  "0 ,1 "
bitfld.long 0 24. " ACCWGZONE_HI_ITM "  "0 ,1 "
bitfld.long 0 25. " GLACE_HI_ITM "  "0 ,1 "
tree.end

base ad:0xa01020d0
tree "SIA_HI_ITM_BCLR"
wgroup 0--3
line.long 0 "SIA_HI_ITM_BCLR"
bitfld.long 0 0. " CRM_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 1. " SDI_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 2. " IFP_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 3. " XMS0_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 4. " XMS1_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 5. " DMA_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 6. " PROJ_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 7. " LICN_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 8. " STBP_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 12. " LBE_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 14. " ISP_RX_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 15. " VIDEO_COMPLETE_PIPE0_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 17. " HISTOGRAM_256_BINS_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 18. " EXPOSURE_6X8_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 19. " AF_STATS_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 20. " WB_STATS_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 23. " ARCTIC_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 24. " ACCWGZONE_HI_ITM_BCLR "  "0 ,1 "
bitfld.long 0 25. " GLACE_HI_ITM_BCLR "  "0 ,1 "
tree.end

base ad:0xa01020d4
tree "SIA_HI_ITM_BSET"
wgroup 0--3
line.long 0 "SIA_HI_ITM_BSET"
bitfld.long 0 0. " CRM_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 1. " SDI_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 2. " IFP_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 3. " XMS0_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 4. " XMS1_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 5. " DMA_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 6. " PROJ_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 7. " LICN_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 8. " STBP_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 12. " LBE_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 14. " ISP_RX_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 15. " VIDEO_COMPLETE_PIPE0_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 17. " HISTOGRAM_256_BINS_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 18. " EXPOSURE_6X8_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 19. " AF_STATS_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 20. " WB_STATS_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 23. " ARCTIC_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 24. " ACCWGZONE_HI_ITM_BSET "  "0 ,1 "
bitfld.long 0 25. " GLACE_HI_ITM_BSET "  "0 ,1 "
tree.end

base ad:0xa01020e0
tree "SIA_LO_ITS"
rgroup 0--3
line.long 0 "SIA_LO_ITS"
bitfld.long 0 0. " CRM_LO_ITS "  "0 ,1 "
bitfld.long 0 1. " SDI_LO_ITS "  "0 ,1 "
bitfld.long 0 2. " IFP_LO_ITS "  "0 ,1 "
bitfld.long 0 3. " XMS0_LO_ITS "  "0 ,1 "
bitfld.long 0 4. " XMS1_LO_ITS "  "0 ,1 "
bitfld.long 0 5. " DMA_LO_ITS "  "0 ,1 "
bitfld.long 0 6. " PROJ_LO_ITS "  "0 ,1 "
bitfld.long 0 7. " LICN_LO_ITS "  "0 ,1 "
bitfld.long 0 8. " STBP_LO_ITS "  "0 ,1 "
bitfld.long 0 12. " LBE_LO_ITS "  "0 ,1 "
bitfld.long 0 14. " ISP_RX_LO_ITS "  "0 ,1 "
bitfld.long 0 15. " VIDEO_COMPLETE_PIPE0_LO_ITS "  "0 ,1 "
bitfld.long 0 17. " HISTOGRAM_256_BINS_LO_ITS "  "0 ,1 "
bitfld.long 0 18. " EXPOSURE_6X8_LO_ITS "  "0 ,1 "
bitfld.long 0 19. " AF_STATS_LO_ITS "  "0 ,1 "
bitfld.long 0 20. " WB_STATS_LO_ITS "  "0 ,1 "
bitfld.long 0 23. " ARCTIC_LO_ITS "  "0 ,1 "
bitfld.long 0 24. " ACCWGZONE_LO_ITS "  "0 ,1 "
bitfld.long 0 25. " GLACE_LO_ITS "  "0 ,1 "
tree.end

base ad:0xa01020e4
tree "SIA_LO_ITS_BCLR"
wgroup 0--3
line.long 0 "SIA_LO_ITS_BCLR"
bitfld.long 0 0. " CRM_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 1. " SDI_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 2. " IFP_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 3. " XMS0_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 4. " XMS1_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 5. " DMA_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 6. " PROJ_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 7. " LICN_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 8. " STBP_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 12. " LBE_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 14. " ISP_RX_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 15. " VIDEO_COMPLETE_PIPE0_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 17. " HISTOGRAM_256_BINS_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 18. " EXPOSURE_6X8_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 19. " AF_STATS_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 20. " WB_STATS_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 23. " ARCTIC_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 24. " ACCWGZONE_LO_ITS_BCLR "  "0 ,1 "
bitfld.long 0 25. " GLACE_LO_ITS_BCLR "  "0 ,1 "
tree.end

base ad:0xa01020e8
tree "SIA_LO_ITS_BSET"
wgroup 0--3
line.long 0 "SIA_LO_ITS_BSET"
bitfld.long 0 0. " CRM_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 1. " SDI_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 2. " IFP_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 3. " XMS0_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 4. " XMS1_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 5. " DMA_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 6. " PROJ_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 7. " LICN_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 8. " STBP_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 12. " LBE_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 14. " ISP_RX_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 15. " VIDEO_COMPLETE_PIPE0_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 17. " HISTOGRAM_256_BINS_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 18. " EXPOSURE_6X8_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 19. " AF_STATS_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 20. " WB_STATS_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 23. " ARCTIC_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 24. " ACCWGZONE_LO_ITS_BSET "  "0 ,1 "
bitfld.long 0 25. " GLACE_LO_ITS_BSET "  "0 ,1 "
tree.end

base ad:0xa01020ec
tree "SIA_LO_ITM"
rgroup 0--3
line.long 0 "SIA_LO_ITM"
bitfld.long 0 0. " CRM_LO_ITM "  "0 ,1 "
bitfld.long 0 1. " SDI_LO_ITM "  "0 ,1 "
bitfld.long 0 2. " IFP_LO_ITM "  "0 ,1 "
bitfld.long 0 3. " XMS0_LO_ITM "  "0 ,1 "
bitfld.long 0 4. " XMS1_LO_ITM "  "0 ,1 "
bitfld.long 0 5. " DMA_LO_ITM "  "0 ,1 "
bitfld.long 0 6. " PROJ_LO_ITM "  "0 ,1 "
bitfld.long 0 7. " LICN_LO_ITM "  "0 ,1 "
bitfld.long 0 8. " STBP_LO_ITM "  "0 ,1 "
bitfld.long 0 12. " LBE_LO_ITM "  "0 ,1 "
bitfld.long 0 14. " ISP_RX_LO_ITM "  "0 ,1 "
bitfld.long 0 15. " VIDEO_COMPLETE_PIPE0_LO_ITM "  "0 ,1 "
bitfld.long 0 17. " HISTOGRAM_256_BINS_LO_ITM "  "0 ,1 "
bitfld.long 0 18. " EXPOSURE_6X8_LO_ITM "  "0 ,1 "
bitfld.long 0 19. " AF_STATS_LO_ITM "  "0 ,1 "
bitfld.long 0 20. " WB_STATS_LO_ITM "  "0 ,1 "
bitfld.long 0 23. " ARCTIC_LO_ITM "  "0 ,1 "
bitfld.long 0 24. " ACCWGZONE_LO_ITM "  "0 ,1 "
bitfld.long 0 25. " GLACE_LO_ITM "  "0 ,1 "
tree.end

base ad:0xa01020f0
tree "SIA_LO_ITM_BCLR"
wgroup 0--3
line.long 0 "SIA_LO_ITM_BCLR"
bitfld.long 0 0. " CRM_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 1. " SDI_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 2. " IFP_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 3. " XMS0_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 4. " XMS1_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 5. " DMA_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 6. " PROJ_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 7. " LICN_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 8. " STBP_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 12. " LBE_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 14. " ISP_RX_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 15. " VIDEO_COMPLETE_PIPE0_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 17. " HISTOGRAM_256_BINS_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 18. " EXPOSURE_6X8_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 19. " AF_STATS_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 20. " WB_STATS_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 23. " ARCTIC_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 24. " ACCWGZONE_LO_ITM_BCLR "  "0 ,1 "
bitfld.long 0 25. " GLACE_LO_ITM_BCLR "  "0 ,1 "
tree.end

base ad:0xa01020f4
tree "SIA_LO_ITM_BSET"
wgroup 0--3
line.long 0 "SIA_LO_ITM_BSET"
bitfld.long 0 0. " CRM_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 1. " SDI_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 2. " IFP_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 3. " XMS0_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 4. " XMS1_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 5. " DMA_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 6. " PROJ_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 7. " LICN_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 8. " STBP_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 12. " LBE_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 14. " ISP_RX_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 15. " VIDEO_COMPLETE_PIPE0_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 17. " HISTOGRAM_256_BINS_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 18. " EXPOSURE_6X8_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 19. " AF_STATS_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 20. " WB_STATS_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 23. " ARCTIC_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 24. " ACCWGZONE_LO_ITM_BSET "  "0 ,1 "
bitfld.long 0 25. " GLACE_LO_ITM_BSET "  "0 ,1 "
tree.end

base ad:0xa0102404
tree "STBP_PAGE_SZ"
group 0--3
line.long 0 "STBP_PAGE_SZ"
bitfld.long 0 0.--3. " PSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0102408
tree "STBP_MAX_PRI"
group 0--3
line.long 0 "STBP_MAX_PRI"
bitfld.long 0 0.--3. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0102420
tree "STBP_PEAK_LEVEL0"
rgroup 0--3
line.long 0 "STBP_PEAK_LEVEL0"
bitfld.long 0 0.--8. " PEAK "  " "
tree.end

base ad:0xa0102424
tree "STBP_PEAK_LEVEL1"
rgroup 0--3
line.long 0 "STBP_PEAK_LEVEL1"
bitfld.long 0 0.--8. " PEAK "  " "
tree.end

base ad:0xa0102428
tree "STBP_PEAK_LEVEL2"
rgroup 0--3
line.long 0 "STBP_PEAK_LEVEL2"
bitfld.long 0 0.--8. " PEAK "  " "
tree.end

base ad:0xa010242c
tree "STBP_PEAK_LEVEL3"
rgroup 0--3
line.long 0 "STBP_PEAK_LEVEL3"
bitfld.long 0 0.--8. " PEAK "  " "
tree.end

base ad:0xa0102440
tree "STBP_MAX_OPC_SZ0"
group 0--3
line.long 0 "STBP_MAX_OPC_SZ0"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0102444
tree "STBP_MAX_OPC_SZ1"
group 0--3
line.long 0 "STBP_MAX_OPC_SZ1"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0102448
tree "STBP_MAX_OPC_SZ2"
group 0--3
line.long 0 "STBP_MAX_OPC_SZ2"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa010244c
tree "STBP_MAX_OPC_SZ3"
group 0--3
line.long 0 "STBP_MAX_OPC_SZ3"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0102460
tree "STBP_MAX_CHCK_SZ0"
group 0--3
line.long 0 "STBP_MAX_CHCK_SZ0"
bitfld.long 0 0.--2. " MAX_CHK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0102464
tree "STBP_MAX_CHCK_SZ1"
group 0--3
line.long 0 "STBP_MAX_CHCK_SZ1"
bitfld.long 0 0.--2. " MAX_CHK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0102468
tree "STBP_MAX_CHCK_SZ2"
group 0--3
line.long 0 "STBP_MAX_CHCK_SZ2"
bitfld.long 0 0.--2. " MAX_CHK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa010246c
tree "STBP_MAX_CHCK_SZ3"
group 0--3
line.long 0 "STBP_MAX_CHCK_SZ3"
bitfld.long 0 0.--2. " MAX_CHK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0102480
tree "STBP_MAX_MSSG_SZ0"
group 0--3
line.long 0 "STBP_MAX_MSSG_SZ0"
bitfld.long 0 0.--2. " MAX_MSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0102484
tree "STBP_MAX_MSSG_SZ1"
group 0--3
line.long 0 "STBP_MAX_MSSG_SZ1"
bitfld.long 0 0.--2. " MAX_MSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0102488
tree "STBP_MAX_MSSG_SZ2"
group 0--3
line.long 0 "STBP_MAX_MSSG_SZ2"
bitfld.long 0 0.--2. " MAX_MSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa010248c
tree "STBP_MAX_MSSG_SZ3"
group 0--3
line.long 0 "STBP_MAX_MSSG_SZ3"
bitfld.long 0 0.--2. " MAX_MSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa01024a0
tree "STBP_PRIO_LEVEL0"
group 0--3
line.long 0 "STBP_PRIO_LEVEL0"
bitfld.long 0 0.--10. " FIXED_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa01024a4
tree "STBP_PRIO_LEVEL1"
group 0--3
line.long 0 "STBP_PRIO_LEVEL1"
bitfld.long 0 0.--10. " FIXED_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa01024a8
tree "STBP_PRIO_LEVEL2"
group 0--3
line.long 0 "STBP_PRIO_LEVEL2"
bitfld.long 0 0.--10. " FIXED_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa01024ac
tree "STBP_PRIO_LEVEL3"
group 0--3
line.long 0 "STBP_PRIO_LEVEL3"
bitfld.long 0 0.--10. " FIXED_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa01024c0
tree "STBP_ERR_ITS"
rgroup 0--3
line.long 0 "STBP_ERR_ITS"
bitfld.long 0 0. " ERR_ITS "  "0 ,1 "
tree.end

base ad:0xa01024c4
tree "STBP_ERR_ITS_BCLR"
wgroup 0--3
line.long 0 "STBP_ERR_ITS_BCLR"
bitfld.long 0 0. " ERR_ITS_BCLR "  "0 ,1 "
tree.end

base ad:0xa01024c8
tree "STBP_ERR_ITS_BSET"
wgroup 0--3
line.long 0 "STBP_ERR_ITS_BSET"
bitfld.long 0 0. " ERR_ITS_BSET "  "0 ,1 "
tree.end

base ad:0xa01024cc
tree "STBP_ERR_ITM"
rgroup 0--3
line.long 0 "STBP_ERR_ITM"
bitfld.long 0 0. " ERR_ITM "  "0 ,1 "
tree.end

base ad:0xa01024d0
tree "STBP_ERR_ITM_BCLR"
wgroup 0--3
line.long 0 "STBP_ERR_ITM_BCLR"
bitfld.long 0 0. " ERR_ITM_BCLR "  "0 ,1 "
tree.end

base ad:0xa01024d4
tree "STBP_ERR_ITM_BSET"
wgroup 0--3
line.long 0 "STBP_ERR_ITM_BSET"
bitfld.long 0 0. " ERR_ITM_BSET "  "0 ,1 "
tree.end

base ad:0xa01024e0
tree "STBP_ERR_INFO"
rgroup 0--3
line.long 0 "STBP_ERR_INFO"
hexfld.byte 0 " R_OPC "
hexfld.byte 1 " R_SRC "
tree.end

base ad:0xa01024e4
tree "STBP_ERR_INFO_CLR"
wgroup 0--3
line.long 0 "STBP_ERR_INFO_CLR"
bitfld.long 0 0. " CLR "  "0 ,1 "
tree.end

base ad:0xa0102800
tree "DMA_ENR"
wgroup 0--3
line.long 0 "DMA_ENR"
bitfld.long 0 0. " IPP_L_W "  "0 ,1 "
bitfld.long 0 1. " IPP_C_W "  "0 ,1 "
bitfld.long 0 8. " IPP_HVCP_W "  "0 ,1 "
bitfld.long 0 11. " IPP_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IPP_PRA_R "  "0 ,1 "
bitfld.long 0 15. " IPP_JPG_W "  "0 ,1 "
tree.end

base ad:0xa0102804
tree "DMA_DIR"
wgroup 0--3
line.long 0 "DMA_DIR"
bitfld.long 0 0. " IPP_L_W "  "0 ,1 "
bitfld.long 0 1. " IPP_C_W "  "0 ,1 "
bitfld.long 0 8. " IPP_HVCP_W "  "0 ,1 "
bitfld.long 0 11. " IPP_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IPP_PRA_R "  "0 ,1 "
bitfld.long 0 15. " IPP_JPG_W "  "0 ,1 "
tree.end

base ad:0xa0102808
tree "DMA_STA"
rgroup 0--3
line.long 0 "DMA_STA"
bitfld.long 0 0. " IPP_L_W "  "0 ,1 "
bitfld.long 0 1. " IPP_C_W "  "0 ,1 "
bitfld.long 0 8. " IPP_HVCP_W "  "0 ,1 "
bitfld.long 0 11. " IPP_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IPP_PRA_R "  "0 ,1 "
bitfld.long 0 15. " IPP_JPG_W "  "0 ,1 "
tree.end

base ad:0xa010280c
tree "DMA_PEN"
rgroup 0--3
line.long 0 "DMA_PEN"
bitfld.long 0 0. " IPP_L_W "  "0 ,1 "
bitfld.long 0 1. " IPP_C_W "  "0 ,1 "
bitfld.long 0 8. " IPP_HVCP_W "  "0 ,1 "
bitfld.long 0 11. " IPP_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IPP_PRA_R "  "0 ,1 "
bitfld.long 0 15. " IPP_JPG_W "  "0 ,1 "
tree.end

base ad:0xa0102820
tree "DMA_IPP_ITS"
rgroup 0--3
line.long 0 "DMA_IPP_ITS"
bitfld.long 0 0. " IPP_L_W_ITS "  "0 ,1 "
bitfld.long 0 1. " IPP_C_W_ITS "  "0 ,1 "
bitfld.long 0 8. " IPP_HVCP_W_ITS "  "0 ,1 "
bitfld.long 0 11. " IPP_PRA_W_ITS "  "0 ,1 "
bitfld.long 0 12. " IPP_PRA_R_ITS "  "0 ,1 "
bitfld.long 0 15. " IPP_JPG_W_ITS "  "0 ,1 "
tree.end

base ad:0xa0102824
tree "DMA_IPP_ITS_BCLR"
wgroup 0--3
line.long 0 "DMA_IPP_ITS_BCLR"
bitfld.long 0 0. " IPP_L_W_ITS_BCLR "  "0 ,1 "
bitfld.long 0 1. " IPP_C_W_ITS_BCLR "  "0 ,1 "
bitfld.long 0 8. " IPP_HVCP_W_ITS_BCLR "  "0 ,1 "
bitfld.long 0 11. " IPP_PRA_W_ITS_BCLR "  "0 ,1 "
bitfld.long 0 12. " IPP_PRA_R_ITS_BCLR "  "0 ,1 "
bitfld.long 0 15. " IPP_JPG_W_ITS_BCLR "  "0 ,1 "
tree.end

base ad:0xa0102828
tree "DMA_IPP_ITS_BSET"
wgroup 0--3
line.long 0 "DMA_IPP_ITS_BSET"
bitfld.long 0 0. " IPP_L_W_ITS_BSET "  "0 ,1 "
bitfld.long 0 1. " IPP_C_W_ITS_BSET "  "0 ,1 "
bitfld.long 0 8. " IPP_HVCP_W_ITS_BSET "  "0 ,1 "
bitfld.long 0 11. " IPP_PRA_W_ITS_BSET "  "0 ,1 "
bitfld.long 0 12. " IPP_PRA_R_ITS_BSET "  "0 ,1 "
bitfld.long 0 15. " IPP_JPG_W_ITS_BSET "  "0 ,1 "
tree.end

base ad:0xa010282c
tree "DMA_IPP_ITM"
rgroup 0--3
line.long 0 "DMA_IPP_ITM"
bitfld.long 0 0. " IPP_L_W_ITM "  "0 ,1 "
bitfld.long 0 1. " IPP_C_W_ITM "  "0 ,1 "
bitfld.long 0 8. " IPP_HVCP_W_ITM "  "0 ,1 "
bitfld.long 0 11. " IPP_PRA_W_ITM "  "0 ,1 "
bitfld.long 0 12. " IPP_PRA_R_ITM "  "0 ,1 "
bitfld.long 0 15. " IPP_JPG_W_ITM "  "0 ,1 "
tree.end

base ad:0xa0102830
tree "DMA_IPP_ITM_BCLR"
wgroup 0--3
line.long 0 "DMA_IPP_ITM_BCLR"
bitfld.long 0 0. " IPP_L_W_ITM_BCLR "  "0 ,1 "
bitfld.long 0 1. " IPP_C_W_ITM_BCLR "  "0 ,1 "
bitfld.long 0 8. " IPP_HVCP_W_ITM_BCLR "  "0 ,1 "
bitfld.long 0 11. " IPP_PRA_W_ITM_BCLR "  "0 ,1 "
bitfld.long 0 12. " IPP_PRA_R_ITM_BCLR "  "0 ,1 "
bitfld.long 0 15. " IPP_JPG_W_ITM_BCLR "  "0 ,1 "
tree.end

base ad:0xa0102834
tree "DMA_IPP_ITM_BSET"
wgroup 0--3
line.long 0 "DMA_IPP_ITM_BSET"
bitfld.long 0 0. " IPP_L_W_ITM_BSET "  "0 ,1 "
bitfld.long 0 1. " IPP_C_W_ITM_BSET "  "0 ,1 "
bitfld.long 0 8. " IPP_HVCP_W_ITM_BSET "  "0 ,1 "
bitfld.long 0 11. " IPP_PRA_W_ITM_BSET "  "0 ,1 "
bitfld.long 0 12. " IPP_PRA_R_ITM_BSET "  "0 ,1 "
bitfld.long 0 15. " IPP_JPG_W_ITM_BSET "  "0 ,1 "
tree.end

base ad:0xa0102840
tree "DMA_SOFT_RST"
wgroup 0--3
line.long 0 "DMA_SOFT_RST"
bitfld.long 0 0. " IPP_L_W "  "0 ,1 "
bitfld.long 0 1. " IPP_C_W "  "0 ,1 "
bitfld.long 0 8. " IPP_HVCP_W "  "0 ,1 "
bitfld.long 0 11. " IPP_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IPP_PRA_R "  "0 ,1 "
bitfld.long 0 15. " IPP_JPG_W "  "0 ,1 "
tree.end

base ad:0xa0102844
tree "DMA_FIFO_STA"
rgroup 0--3
line.long 0 "DMA_FIFO_STA"
bitfld.long 0 0. " IPP_L_W "  "0 ,1 "
bitfld.long 0 1. " IPP_C_W "  "0 ,1 "
bitfld.long 0 8. " IPP_HVCP_W "  "0 ,1 "
bitfld.long 0 11. " IPP_PRA_W "  "0 ,1 "
bitfld.long 0 15. " IPP_JPG_W "  "0 ,1 "
tree.end

base ad:0xa0102848
tree "DMA_FIFO_FLUSH"
wgroup 0--3
line.long 0 "DMA_FIFO_FLUSH"
bitfld.long 0 15. " IPP_JPG_W "  "0 ,1 "
tree.end

base ad:0xa0102860
tree "DMA_DLS"
group 0--3
line.long 0 "DMA_DLS"
bitfld.long 0 3.--31. " DMA_DLS "  " "
tree.end

base ad:0xa0102864
tree "DMA_DCS"
group 0--3
line.long 0 "DMA_DCS"
bitfld.long 0 3.--31. " DMA_DCS "  " "
tree.end

base ad:0xa0102868
tree "DMA_DRS"
group 0--3
line.long 0 "DMA_DRS"
bitfld.long 0 3.--31. " DMA_DRS "  " "
tree.end

base ad:0xa010286c
tree "DMA_HVCPS"
group 0--3
line.long 0 "DMA_HVCPS"
bitfld.long 0 3.--31. " DMA_HVCPS "  " "
tree.end

base ad:0xa0102874
tree "DMA_JPGS"
group 0--3
line.long 0 "DMA_JPGS"
bitfld.long 0 3.--31. " DMA_JPGS "  " "
tree.end

base ad:0xa0102880
tree "DMA_DFW"
group 0--3
line.long 0 "DMA_DFW"
bitfld.long 0 3.--15. " DMA_DFW "  " "
tree.end

base ad:0xa0102884
tree "DMA_DWW"
group 0--3
line.long 0 "DMA_DWW"
bitfld.long 0 3.--15. " DMA_DWW "  " "
tree.end

base ad:0xa0102888
tree "DMA_DWH"
group 0--3
line.long 0 "DMA_DWH"
hexfld.word 0 " DMA_DWH "
tree.end

base ad:0xa010288c
tree "DMA_HVCP_DBS"
group 0--3
line.long 0 "DMA_HVCP_DBS"
bitfld.long 0 3.--31. " DMA_HVCP_DBS "  " "
tree.end

base ad:0xa0102890
tree "DMA_JPG_DBS"
group 0--3
line.long 0 "DMA_JPG_DBS"
bitfld.long 0 3.--31. " DMA_JPG_DBS "  " "
tree.end

base ad:0xa01028a0
tree "DMA_SRS"
group 0--3
line.long 0 "DMA_SRS"
bitfld.long 0 3.--31. " DMA_SRS "  " "
tree.end

base ad:0xa01028b0
tree "DMA_SFW"
group 0--3
line.long 0 "DMA_SFW"
bitfld.long 0 3.--15. " DMA_SFW "  " "
tree.end

base ad:0xa01028b4
tree "DMA_SWW"
group 0--3
line.long 0 "DMA_SWW"
bitfld.long 0 3.--15. " DMA_SWW "  " "
tree.end

base ad:0xa01028b8
tree "DMA_SWH"
group 0--3
line.long 0 "DMA_SWH"
hexfld.word 0 " DMA_SWH "
tree.end

base ad:0xa01028c0
tree "DMA_TST_CID"
wgroup 0--3
line.long 0 "DMA_TST_CID"
bitfld.long 0 0.--3. " DMA_TST_CID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa01028c4
tree "DMA_TST_SADD"
rgroup 0--3
line.long 0 "DMA_TST_SADD"
bitfld.long 0 3.--31. " DMA_TST_SADD "  " "
tree.end

base ad:0xa0102c00
tree "PROJ_EN_SET"
wgroup 0--3
line.long 0 "PROJ_EN_SET"
bitfld.long 0 0. " HVCP "  "0 ,1 "
tree.end

base ad:0xa0102c10
tree "PROJ_ITS"
rgroup 0--3
line.long 0 "PROJ_ITS"
bitfld.long 0 0. " HVCP_EOT_ITS "  "0 ,1 "
bitfld.long 0 1. " HVCP_FS_ITS "  "0 ,1 "
bitfld.long 0 2. " HCP_ERR_ITS "  "0 ,1 "
bitfld.long 0 3. " VCP_ERR_ITS "  "0 ,1 "
tree.end

base ad:0xa0102c14
tree "PROJ_ITS_BCLR"
wgroup 0--3
line.long 0 "PROJ_ITS_BCLR"
bitfld.long 0 0. " HVCP_EOT_ITS_BCLR "  "0 ,1 "
bitfld.long 0 1. " HVCP_FS_ITS_BCLR "  "0 ,1 "
bitfld.long 0 2. " HCP_ERR_ITS_BCLR "  "0 ,1 "
bitfld.long 0 3. " VCP_ERR_ITS_BCLR "  "0 ,1 "
tree.end

base ad:0xa0102c18
tree "PROJ_ITS_BSET"
wgroup 0--3
line.long 0 "PROJ_ITS_BSET"
bitfld.long 0 0. " HVCP_EOT_ITS_BSET "  "0 ,1 "
bitfld.long 0 1. " HVCP_FS_ITS_BSET "  "0 ,1 "
bitfld.long 0 2. " HCP_ERR_ITS_BSET "  "0 ,1 "
bitfld.long 0 3. " VCP_ERR_ITS_BSET "  "0 ,1 "
tree.end

base ad:0xa0102c1c
tree "PROJ_ITM"
rgroup 0--3
line.long 0 "PROJ_ITM"
bitfld.long 0 0. " HVCP_EOT_ITM "  "0 ,1 "
bitfld.long 0 1. " HVCP_FS_ITM "  "0 ,1 "
bitfld.long 0 2. " HCP_ERR_ITM "  "0 ,1 "
bitfld.long 0 3. " VCP_ERR_ITM "  "0 ,1 "
tree.end

base ad:0xa0102c20
tree "PROJ_ITM_BCLR"
wgroup 0--3
line.long 0 "PROJ_ITM_BCLR"
bitfld.long 0 0. " HVCP_EOT_ITM_BCLR "  "0 ,1 "
bitfld.long 0 1. " HVCP_FS_ITM_BCLR "  "0 ,1 "
bitfld.long 0 2. " HCP_ERR_ITM_BCLR "  "0 ,1 "
bitfld.long 0 3. " VCP_ERR_ITM_BCLR "  "0 ,1 "
tree.end

base ad:0xa0102c24
tree "PROJ_ITM_BSET"
wgroup 0--3
line.long 0 "PROJ_ITM_BSET"
bitfld.long 0 0. " HVCP_EOT_ITM_BSET "  "0 ,1 "
bitfld.long 0 1. " HVCP_FS_ITM_BSET "  "0 ,1 "
bitfld.long 0 2. " HCP_ERR_ITM_BSET "  "0 ,1 "
bitfld.long 0 3. " VCP_ERR_ITM_BSET "  "0 ,1 "
tree.end

base ad:0xa0102c30
tree "PROJ_HSIZE"
group 0--3
line.long 0 "PROJ_HSIZE"
bitfld.long 0 3.--13. " HSIZE "  " "
tree.end

base ad:0xa0102c34
tree "PROJ_VSIZE"
group 0--3
line.long 0 "PROJ_VSIZE"
bitfld.long 0 1.--13. " VSIZE "  " "
tree.end

base ad:0xa0102c40
tree "PROJ_SMOOTH"
group 0--3
line.long 0 "PROJ_SMOOTH"
bitfld.long 0 0.--4. " SMOOTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0103000
tree "IFP_DATA_FORMAT"
group 0--3
line.long 0 "IFP_DATA_FORMAT"
bitfld.long 0 0. " IFP_JPEG_PADD_EN "  "0 ,1 "
bitfld.long 0 1. " IFP_BT601_EN "  "0 ,1 "
bitfld.long 0 2. " IFP_CHROMA_DECIM_EN "  "0 ,1 "
tree.end

base ad:0xa0103004
tree "IFP_CROP_EN"
group 0--3
line.long 0 "IFP_CROP_EN"
bitfld.long 0 0. " IFP_CROP_EN "  "0 ,1 "
tree.end

base ad:0xa0103008
tree "IFP_CROP_H0"
group 0--3
line.long 0 "IFP_CROP_H0"
bitfld.long 0 1.--11. " IFP_CROP_H0 "  " "
tree.end

base ad:0xa010300c
tree "IFP_CROP_V0"
group 0--3
line.long 0 "IFP_CROP_V0"
bitfld.long 0 0.--11. " IFP_CROP_V0 "  " "
tree.end

base ad:0xa0103010
tree "IFP_CROP_H1"
group 0--3
line.long 0 "IFP_CROP_H1"
bitfld.long 0 1.--11. " IFP_CROP_H1 "  " "
tree.end

base ad:0xa0103014
tree "IFP_CROP_V1"
group 0--3
line.long 0 "IFP_CROP_V1"
bitfld.long 0 0.--11. " IFP_CROP_V1 "  " "
tree.end

base ad:0xa0103018
tree "IFP_ITS"
rgroup 0--3
line.long 0 "IFP_ITS"
bitfld.long 0 0. " IFP_FE_ITS "  "0 ,1 "
bitfld.long 0 1. " IFP_LUMA_RAW_FIFO_OVERFLOW_ITS "  "0 ,1 "
bitfld.long 0 2. " IFP_CHROMA_FIFO_OVERFLOW_ITS "  "0 ,1 "
tree.end

base ad:0xa010301c
tree "IFP_ITS_BCLR"
wgroup 0--3
line.long 0 "IFP_ITS_BCLR"
bitfld.long 0 0. " IFP_FE_ITS_BCLR "  "0 ,1 "
bitfld.long 0 1. " IFP_LUMA_RAW_FIFO_OVERFLOW_ITS_BCLR "  "0 ,1 "
bitfld.long 0 2. " IFP_CHROMA_FIFO_OVERFLOW_ITS_BCLR "  "0 ,1 "
tree.end

base ad:0xa0103020
tree "IFP_ITS_BSET"
wgroup 0--3
line.long 0 "IFP_ITS_BSET"
bitfld.long 0 0. " IFP_FE_ITS_BSET "  "0 ,1 "
bitfld.long 0 1. " IFP_LUMA_RAW_FIFO_OVERFLOW_ITS_BSET "  "0 ,1 "
bitfld.long 0 2. " IFP_CHROMA_FIFO_OVERFLOW_ITS_BSET "  "0 ,1 "
tree.end

base ad:0xa0103024
tree "IFP_ITM"
rgroup 0--3
line.long 0 "IFP_ITM"
bitfld.long 0 0. " IFP_FE_ITM "  "0 ,1 "
bitfld.long 0 1. " IFP_LUMA_RAW_FIFO_OVERFLOW_ITM "  "0 ,1 "
bitfld.long 0 2. " IFP_CHROMA_FIFO_OVERFLOW_ITM "  "0 ,1 "
tree.end

base ad:0xa0103028
tree "IFP_ITM_BCLR"
wgroup 0--3
line.long 0 "IFP_ITM_BCLR"
bitfld.long 0 0. " IFP_FE_ITM_BCLR "  "0 ,1 "
bitfld.long 0 1. " IFP_LUMA_RAW_FIFO_OVERFLOW_ITM_BCLR "  "0 ,1 "
bitfld.long 0 2. " IFP_CHROMA_FIFO_OVERFLOW_ITM_BCLR "  "0 ,1 "
tree.end

base ad:0xa010302c
tree "IFP_ITM_BSET"
wgroup 0--3
line.long 0 "IFP_ITM_BSET"
bitfld.long 0 0. " IFP_FE_ITM_BSET "  "0 ,1 "
bitfld.long 0 1. " IFP_LUMA_RAW_FIFO_OVERFLOW_ITM_BSET "  "0 ,1 "
bitfld.long 0 2. " IFP_CHROMA_FIFO_OVERFLOW_ITM_BSET "  "0 ,1 "
tree.end

base ad:0xa0103400
tree "XMS0_ENABLE_SET"
wgroup 0--3
line.long 0 "XMS0_ENABLE_SET"
bitfld.long 0 0. " XMS0_ENABLE_SET "  "0 ,1 "
tree.end

base ad:0xa0103404
tree "XMS0_CONFIG"
group 0--3
line.long 0 "XMS0_CONFIG"
bitfld.long 0 0.--2. " XMS0_FORMAT_SEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " XMS0_PADD_MODE "  "0 ,1 "
bitfld.long 0 9. " XMS0_ACTIVE_DATA_ONLY "  "0 ,1 "
bitfld.long 0 16.--18. " XMS0_IDP_SEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0103408
tree "XMS0_ITS"
rgroup 0--3
line.long 0 "XMS0_ITS"
bitfld.long 0 0. " XMS0_FS_ITS "  "0 ,1 "
bitfld.long 0 1. " XMS0_FE_ITS "  "0 ,1 "
bitfld.long 0 2. " XMS0_FIFO_OVERFLOW_ITS "  "0 ,1 "
tree.end

base ad:0xa010340c
tree "XMS0_ITS_BCLR"
wgroup 0--3
line.long 0 "XMS0_ITS_BCLR"
bitfld.long 0 0. " XMS0_FS_ITS_BCLR "  "0 ,1 "
bitfld.long 0 1. " XMS0_FE_ITS_BCLR "  "0 ,1 "
bitfld.long 0 2. " XMS0_FIFO_OVERFLOW_ITS_BCLR "  "0 ,1 "
tree.end

base ad:0xa0103410
tree "XMS0_ITS_BSET"
wgroup 0--3
line.long 0 "XMS0_ITS_BSET"
bitfld.long 0 0. " XMS0_FS_ITS_BSET "  "0 ,1 "
bitfld.long 0 1. " XMS0_FE_ITS_BSET "  "0 ,1 "
bitfld.long 0 2. " XMS0_FIFO_OVERFLOW_ITS_BSET "  "0 ,1 "
tree.end

base ad:0xa0103414
tree "XMS0_ITM"
rgroup 0--3
line.long 0 "XMS0_ITM"
bitfld.long 0 0. " XMS0_FS_ITM "  "0 ,1 "
bitfld.long 0 1. " XMS0_FE_ITM "  "0 ,1 "
bitfld.long 0 2. " XMS0_FIFO_OVERFLOW_ITM "  "0 ,1 "
tree.end

base ad:0xa0103418
tree "XMS0_ITM_BCLR"
wgroup 0--3
line.long 0 "XMS0_ITM_BCLR"
bitfld.long 0 0. " XMS0_FS_ITM_BCLR "  "0 ,1 "
bitfld.long 0 1. " XMS0_FE_ITM_BCLR "  "0 ,1 "
bitfld.long 0 2. " XMS0_FIFO_OVERFLOW_ITM_BCLR "  "0 ,1 "
tree.end

base ad:0xa010341c
tree "XMS0_ITM_BSET"
wgroup 0--3
line.long 0 "XMS0_ITM_BSET"
bitfld.long 0 0. " XMS0_FS_ITM_BSET "  "0 ,1 "
bitfld.long 0 1. " XMS0_FE_ITM_BSET "  "0 ,1 "
bitfld.long 0 2. " XMS0_FIFO_OVERFLOW_ITM_BSET "  "0 ,1 "
tree.end

base ad:0xa0103800
tree "XMS1_ENABLE_SET"
wgroup 0--3
line.long 0 "XMS1_ENABLE_SET"
bitfld.long 0 0. " XMS1_ENABLE_SET "  "0 ,1 "
tree.end

base ad:0xa0103804
tree "XMS1_CONFIG"
group 0--3
line.long 0 "XMS1_CONFIG"
bitfld.long 0 10. " XMS1_CHROMA_SWAP "  "0 ,1 "
bitfld.long 0 11. " XMS1_EXT_SYNC_MODE "  "0 ,1 "
tree.end

base ad:0xa0103808
tree "XMS1_ITS"
rgroup 0--3
line.long 0 "XMS1_ITS"
bitfld.long 0 0. " XMS1_FS_ITS "  "0 ,1 "
bitfld.long 0 1. " XMS1_FE_ITS "  "0 ,1 "
bitfld.long 0 2. " XMS1_FIFO_OVERFLOW_ITS "  "0 ,1 "
tree.end

base ad:0xa010380c
tree "XMS1_ITS_BCLR"
wgroup 0--3
line.long 0 "XMS1_ITS_BCLR"
bitfld.long 0 0. " XMS1_FS_ITS_BCLR "  "0 ,1 "
bitfld.long 0 1. " XMS1_FE_ITS_BCLR "  "0 ,1 "
bitfld.long 0 2. " XMS1_FIFO_OVERFLOW_ITS_BCLR "  "0 ,1 "
tree.end

base ad:0xa0103810
tree "XMS1_ITS_BSET"
wgroup 0--3
line.long 0 "XMS1_ITS_BSET"
bitfld.long 0 0. " XMS1_FS_ITS_BSET "  "0 ,1 "
bitfld.long 0 1. " XMS1_FE_ITS_BSET "  "0 ,1 "
bitfld.long 0 2. " XMS1_FIFO_OVERFLOW_ITS_BSET "  "0 ,1 "
tree.end

base ad:0xa0103814
tree "XMS1_ITM"
rgroup 0--3
line.long 0 "XMS1_ITM"
bitfld.long 0 0. " XMS1_FS_ITM "  "0 ,1 "
bitfld.long 0 1. " XMS1_FE_ITM "  "0 ,1 "
bitfld.long 0 2. " XMS1_FIFO_OVERFLOW_ITM "  "0 ,1 "
tree.end

base ad:0xa0103818
tree "XMS1_ITM_BCLR"
wgroup 0--3
line.long 0 "XMS1_ITM_BCLR"
bitfld.long 0 0. " XMS1_FS_ITM_BCLR "  "0 ,1 "
bitfld.long 0 1. " XMS1_FE_ITM_BCLR "  "0 ,1 "
bitfld.long 0 2. " XMS1_FIFO_OVERFLOW_ITM_BCLR "  "0 ,1 "
tree.end

base ad:0xa010381c
tree "XMS1_ITM_BSET"
wgroup 0--3
line.long 0 "XMS1_ITM_BSET"
bitfld.long 0 0. " XMS1_FS_ITM_BSET "  "0 ,1 "
bitfld.long 0 1. " XMS1_FE_ITM_BSET "  "0 ,1 "
bitfld.long 0 2. " XMS1_FIFO_OVERFLOW_ITM_BSET "  "0 ,1 "
tree.end

base ad:0xa0103c00
tree "XML_EN"
group 0--3
line.long 0 "XML_EN"
bitfld.long 0 0. " XML_EN "  "0 ,1 "
tree.end

base ad:0xa0103c04
tree "XML_CONFIG_MODE"
group 0--3
line.long 0 "XML_CONFIG_MODE"
bitfld.long 0 0.--2. " XML_CONFIG_FORMAT_SEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9. " XML_CONFIG_CHROMA_SWAP "  "0 ,1 "
bitfld.long 0 16.--17. " XML_CONFIG_IDP_SEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " XML_CONFIG_PIXEL_ORDER "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0103c08
tree "XML_CONFIG_WDW"
group 0--3
line.long 0 "XML_CONFIG_WDW"
bitfld.long 0 0.--11. " XML_CONFIG_WDW "  " "
tree.end

base ad:0xa0103c0c
tree "XML_CONFIG_INTERLINE_TIME"
group 0--3
line.long 0 "XML_CONFIG_INTERLINE_TIME"
hexfld.long 0 " XML_CONFIG_INTERLINE_TIME "
tree.end

base ad:0xa0103c10
tree "XML_CONFIG_LOAD_LINETYPE0"
group 0--3
line.long 0 "XML_CONFIG_LOAD_LINETYPE0"
bitfld.long 0 0.--12. " XML_CONFIG_LOAD_LINETYPE_HEIGHT "  " "
bitfld.long 0 16.--19. " XML_CONFIG_LOAD_LINETYPE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0103c14
tree "XML_CONFIG_LOAD_LINETYPE1"
group 0--3
line.long 0 "XML_CONFIG_LOAD_LINETYPE1"
bitfld.long 0 0.--12. " XML_CONFIG_LOAD_LINETYPE_HEIGHT "  " "
bitfld.long 0 16.--19. " XML_CONFIG_LOAD_LINETYPE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0103c18
tree "XML_CONFIG_LOAD_LINETYPE2"
group 0--3
line.long 0 "XML_CONFIG_LOAD_LINETYPE2"
bitfld.long 0 0.--12. " XML_CONFIG_LOAD_LINETYPE_HEIGHT "  " "
bitfld.long 0 16.--19. " XML_CONFIG_LOAD_LINETYPE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0103c1c
tree "XML_CONFIG_LOAD_LINETYPE3"
group 0--3
line.long 0 "XML_CONFIG_LOAD_LINETYPE3"
bitfld.long 0 0.--12. " XML_CONFIG_LOAD_LINETYPE_HEIGHT "  " "
bitfld.long 0 16.--19. " XML_CONFIG_LOAD_LINETYPE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0103c20
tree "XML_CONFIG_LOAD_LINETYPE4"
group 0--3
line.long 0 "XML_CONFIG_LOAD_LINETYPE4"
bitfld.long 0 0.--12. " XML_CONFIG_LOAD_LINETYPE_HEIGHT "  " "
bitfld.long 0 16.--19. " XML_CONFIG_LOAD_LINETYPE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0103c24
tree "XML_CONFIG_LOAD_LINETYPE5"
group 0--3
line.long 0 "XML_CONFIG_LOAD_LINETYPE5"
bitfld.long 0 0.--12. " XML_CONFIG_LOAD_LINETYPE_HEIGHT "  " "
bitfld.long 0 16.--19. " XML_CONFIG_LOAD_LINETYPE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0103c28
tree "XML_CONFIG_LOAD_LINETYPE6"
group 0--3
line.long 0 "XML_CONFIG_LOAD_LINETYPE6"
bitfld.long 0 0.--12. " XML_CONFIG_LOAD_LINETYPE_HEIGHT "  " "
bitfld.long 0 16.--19. " XML_CONFIG_LOAD_LINETYPE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0103c2c
tree "XML_CONFIG_LOAD_LINETYPE7"
group 0--3
line.long 0 "XML_CONFIG_LOAD_LINETYPE7"
bitfld.long 0 0.--12. " XML_CONFIG_LOAD_LINETYPE_HEIGHT "  " "
bitfld.long 0 16.--19. " XML_CONFIG_LOAD_LINETYPE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0104000
tree "SDI_DPHY_TOP_IF_EN"
group 0--3
line.long 0 "SDI_DPHY_TOP_IF_EN"
bitfld.long 0 0. " SDI_DPHY_TOP_IF_EN "  "0 ,1 "
tree.end

base ad:0xa0104004
tree "SDI_STATIC_TOP_IF_SEL"
group 0--3
line.long 0 "SDI_STATIC_TOP_IF_SEL"
bitfld.long 0 0.--1. " SDI_STATIC_TOP_IF_SEL "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0104008
tree "SDI_STATIC_TOP_CCP_IF"
group 0--3
line.long 0 "SDI_STATIC_TOP_CCP_IF"
bitfld.long 0 0. " SDI_STATIC_CCP_DSCLK "  "0 ,1 "
bitfld.long 0 8.--11. " SDI_STATIC_CCP_BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa010400c
tree "SDI_EN_CLK_CCP"
group 0--3
line.long 0 "SDI_EN_CLK_CCP"
bitfld.long 0 0. " SDI_EN_CLK_CCP "  "0 ,1 "
tree.end

base ad:0xa0104010
tree "SDI_STATIC_CSI0_DATA_LANES"
group 0--3
line.long 0 "SDI_STATIC_CSI0_DATA_LANES"
bitfld.long 0 0. " SDI_STATIC_CSI0_DATA_LANES_MAP "  "0 ,1 "
bitfld.long 0 8. " SDI_STATIC_CSI0_DATA_LANES_NB "  "0 ,1 "
tree.end

base ad:0xa0104014
tree "SDI_DPHY_COMPENSATION_CTRL"
group 0--3
line.long 0 "SDI_DPHY_COMPENSATION_CTRL"
bitfld.long 0 0. " SDI_DPHY_COMPENSATION_START "  "0 ,1 "
bitfld.long 0 1. " SDI_DPHY_COMPENSATION_CALIB_WRITE_EN "  "0 ,1 "
bitfld.long 0 2.--4. " SDI_DPHY_COMPENSATION_CALIB_WRITE_CODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0104018
tree "SDI_DPHY_COMPENSATION_STATUS"
rgroup 0--3
line.long 0 "SDI_DPHY_COMPENSATION_STATUS"
bitfld.long 0 0. " SDI_DPHY_COMPENSATION_OK "  "0 ,1 "
bitfld.long 0 1.--3. " SDI_DPHY_COMPENSATION_CALIB_READ_CODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4. " SDI_DPHY_COMPENSATION_DBG_COMP_FLAG "  "0 ,1 "
tree.end

base ad:0xa010401c
tree "SDI_CSI2_DPHY0_CL_CTRL"
group 0--3
line.long 0 "SDI_CSI2_DPHY0_CL_CTRL"
bitfld.long 0 0.--5. " SDI_CSI0_UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8. " SDI_CSI0_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 9. " SDI_CSI0_SWAP_PINS_CL "  "0 ,1 "
bitfld.long 0 10. " SDI_CSI0_HS_INVERT_CL "  "0 ,1 "
bitfld.long 0 11. " SDI_CSI0_HSRX_TERM_SHIFT_UP_CL "  "0 ,1 "
bitfld.long 0 12. " SDI_CSI0_HSRX_TERM_SHIFT_DOWN_CL "  "0 ,1 "
bitfld.long 0 13. " SDI_CSI0_TEST_RESERVED_1_CL "  "0 ,1 "
tree.end

base ad:0xa0104020
tree "SDI_CSI2_DPHY0_DL1_CTRL"
group 0--3
line.long 0 "SDI_CSI2_DPHY0_DL1_CTRL"
bitfld.long 0 0. " SDI_CSI0_SWAP_PINS_DL1 "  "0 ,1 "
bitfld.long 0 1. " SDI_CSI0_HS_INVERT_DL1 "  "0 ,1 "
bitfld.long 0 2. " SDI_CSI0_FORCE_RX_MODE_DL1 "  "0 ,1 "
bitfld.long 0 3. " SDI_CSI0_CD_OFF_DL1 "  "0 ,1 "
bitfld.long 0 4. " SDI_CSI0_EOT_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 5. " SDI_CSI0_HSRX_TERM_SHIFT_UP_DL1 "  "0 ,1 "
bitfld.long 0 6. " SDI_CSI0_HSRX_TERM_SHIFT_DOWN_DL1 "  "0 ,1 "
bitfld.long 0 7. " SDI_CSI0_TEST_RESERVED_1_DL1 "  "0 ,1 "
tree.end

base ad:0xa0104024
tree "SDI_CSI2_DPHY0_DL2_CTRL"
group 0--3
line.long 0 "SDI_CSI2_DPHY0_DL2_CTRL"
bitfld.long 0 0. " SDI_CSI0_SWAP_PINS_DL2 "  "0 ,1 "
bitfld.long 0 1. " SDI_CSI0_HS_INVERT_DL2 "  "0 ,1 "
bitfld.long 0 2. " SDI_CSI0_FORCE_RX_MODE_DL2 "  "0 ,1 "
bitfld.long 0 3. " SDI_CSI0_CD_OFF_DL2 "  "0 ,1 "
bitfld.long 0 4. " SDI_CSI0_EOT_BYPASS_DL2 "  "0 ,1 "
bitfld.long 0 5. " SDI_CSI0_HSRX_TERM_SHIFT_UP_DL2 "  "0 ,1 "
bitfld.long 0 6. " SDI_CSI0_HSRX_TERM_SHIFT_DOWN_DL2 "  "0 ,1 "
bitfld.long 0 7. " SDI_CSI0_TEST_RESERVED_1_DL2 "  "0 ,1 "
tree.end

base ad:0xa0104028
tree "SDI_CSI2_DPHY0_CL_DBG"
group 0--3
line.long 0 "SDI_CSI2_DPHY0_CL_DBG"
bitfld.long 0 0.--2. " SDI_CSI0_HS_RX_OFFSET_CL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " SDI_CSI0_MIPI_IN_SHORT_CL "  "0 ,1 "
bitfld.long 0 8. " SDI_CSI0_LP_HS_BYPASS_CL "  "0 ,1 "
bitfld.long 0 9.--10. " SDI_CSI0_LP_RX_VIL_CL "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " SDI_CSI0_DIRECT_DYN_ACCESS_CL "  "0 ,1 "
tree.end

base ad:0xa010402c
tree "SDI_CSI2_DPHY0_DL1_DBG"
group 0--3
line.long 0 "SDI_CSI2_DPHY0_DL1_DBG"
bitfld.long 0 0.--2. " SDI_CSI0_HS_RX_OFFSET_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " SDI_CSI0_MIPI_IN_SHORT_DL1 "  "0 ,1 "
bitfld.long 0 4.--6. " SDI_CSI0_SKEW_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " SDI_CSI0_OVERSAMPLE_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 8. " SDI_CSI0_LP_HS_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 9.--10. " SDI_CSI0_LP_RX_VIL_DL1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " SDI_CSI0_DIRECT_DYN_ACCES_DL1 "  "0 ,1 "
tree.end

base ad:0xa0104030
tree "SDI_CSI2_DPHY0_DL2_DBG"
group 0--3
line.long 0 "SDI_CSI2_DPHY0_DL2_DBG"
bitfld.long 0 0.--2. " SDI_CSI0_HS_RX_OFFSET_DL2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " SDI_CSI0_MIPI_IN_SHORT_DL2 "  "0 ,1 "
bitfld.long 0 4.--6. " SDI_CSI0_SKEW_DL2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " SDI_CSI0_OVERSAMPLE_BYPASS_DL2 "  "0 ,1 "
bitfld.long 0 8. " SDI_CSI0_LP_HS_BYPASS_DL2 "  "0 ,1 "
bitfld.long 0 9.--10. " SDI_CSI0_LP_RX_VIL_DL2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " SDI_CSI0_DIRECT_DYN_ACCESS_DL2 "  "0 ,1 "
tree.end

base ad:0xa0104034
tree "SDI_CSI2_DPHY0_XL_DBG_OBS"
rgroup 0--3
line.long 0 "SDI_CSI2_DPHY0_XL_DBG_OBS"
bitfld.long 0 0. " SDI_CSI0_OVERSAMPLE_FLAG1_DL1 "  "0 ,1 "
bitfld.long 0 1. " SDI_CSI0_OVERSAMPLE_FLAG1_DL2 "  "0 ,1 "
bitfld.long 0 3. " SDI_CSI0_OVERSAMPLE_FLAG2_DL1 "  "0 ,1 "
bitfld.long 0 4. " SDI_CSI0_OVERSAMPLE_FLAG2_DL2 "  "0 ,1 "
bitfld.long 0 6. " SDI_CSI0_HS_RX_ZM_CL "  "0 ,1 "
bitfld.long 0 7. " SDI_CSI0_HS_RX_ZM_DL1 "  "0 ,1 "
bitfld.long 0 8. " SDI_CSI0_HS_RX_ZM_DL2 "  "0 ,1 "
bitfld.long 0 10. " SDI_CSI0_RX_INIT_CLK "  "0 ,1 "
bitfld.long 0 16. " SDI_CSI0_STOP_STATE_CL "  "0 ,1 "
bitfld.long 0 17. " SDI_CSI0_STOP_STATE_DL1 "  "0 ,1 "
bitfld.long 0 18. " SDI_CSI0_STOP_STATE_DL2 "  "0 ,1 "
bitfld.long 0 20. " SDI_CSI0_ULP_ACTIVE_NOT_CL "  "0 ,1 "
bitfld.long 0 21. " SDI_CSI0_ULP_ACTIVE_NOT_DL1 "  "0 ,1 "
bitfld.long 0 22. " SDI_CSI0_ULP_ACTIVE_NOT_DL2 "  "0 ,1 "
tree.end

base ad:0xa0104038
tree "SDI_CSI2_DPHY1_CL_CTRL"
group 0--3
line.long 0 "SDI_CSI2_DPHY1_CL_CTRL"
bitfld.long 0 0.--5. " SDI_CSI1_UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8. " SDI_CSI1_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 9. " SDI_CSI1_SWAP_PINS_CL "  "0 ,1 "
bitfld.long 0 10. " SDI_CSI1_HS_INVERT_CL "  "0 ,1 "
bitfld.long 0 11. " SDI_CSI1_HSRX_TERM_SHIFT_UP_CL "  "0 ,1 "
bitfld.long 0 12. " SDI_CSI1_HSRX_TERM_SHIFT_DOWN_CL "  "0 ,1 "
bitfld.long 0 13. " SDI_CSI1_TEST_RESERVED_1_CL "  "0 ,1 "
tree.end

base ad:0xa010403c
tree "SDI_CSI2_DPHY1_DL1_CTRL"
group 0--3
line.long 0 "SDI_CSI2_DPHY1_DL1_CTRL"
bitfld.long 0 0. " SDI_CSI1_SWAP_PINS_DL1 "  "0 ,1 "
bitfld.long 0 1. " SDI_CSI1_HS_INVERT_DL1 "  "0 ,1 "
bitfld.long 0 2. " SDI_CSI1_FORCE_RX_MODE_DL1 "  "0 ,1 "
bitfld.long 0 3. " SDI_CSI1_CD_OFF_DL1 "  "0 ,1 "
bitfld.long 0 4. " SDI_CSI1_EOT_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 5. " SDI_CSI1_HSRX_TERM_SHIFT_UP_DL1 "  "0 ,1 "
bitfld.long 0 6. " SDI_CSI1_HSRX_TERM_SHIFT_DOWN_DL1 "  "0 ,1 "
bitfld.long 0 7. " SDI_CSI1_TEST_RESERVED_1_DL1 "  "0 ,1 "
tree.end

base ad:0xa0104040
tree "SDI_CSI2_DPHY1_CL_DBG"
group 0--3
line.long 0 "SDI_CSI2_DPHY1_CL_DBG"
bitfld.long 0 0.--2. " SDI_CSI1_HS_RX_OFFSET_CL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " SDI_CSI1_MIPI_IN_SHORT_CL "  "0 ,1 "
bitfld.long 0 8. " SDI_CSI1_LP_HS_BYPASS_CL "  "0 ,1 "
bitfld.long 0 9.--10. " SDI_CSI1_LP_RX_VIL_CL "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " SDI_CSI1_DIRECT_DYN_ACCESS_CL "  "0 ,1 "
tree.end

base ad:0xa0104044
tree "SDI_CSI2_DPHY1_DL1_DBG"
group 0--3
line.long 0 "SDI_CSI2_DPHY1_DL1_DBG"
bitfld.long 0 0.--2. " SDI_CSI1_HS_RX_OFFSET_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " SDI_CSI1_MIPI_IN_SHORT_DL1 "  "0 ,1 "
bitfld.long 0 4.--6. " SDI_CSI1_SKEW_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " SDI_CSI1_OVERSAMPLE_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 8. " SDI_CSI1_LP_HS_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 9.--10. " SDI_CSI1_LP_RX_VIL_DL1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " SDI_CSI1_DIRECT_DYN_ACCESS_DL1 "  "0 ,1 "
tree.end

base ad:0xa0104048
tree "SDI_CSI2_DPHY1_XL_DBG_OBS"
rgroup 0--3
line.long 0 "SDI_CSI2_DPHY1_XL_DBG_OBS"
bitfld.long 0 0. " SDI_CSI1_OVERSAMPLE_FLAG1_DL1 "  "0 ,1 "
bitfld.long 0 1. " SDI_CSI1_OVERSAMPLE_FLAG2_DL1 "  "0 ,1 "
bitfld.long 0 2. " SDI_CSI1_HS_RX_ZM_CL "  "0 ,1 "
bitfld.long 0 3. " SDI_CSI1_HS_RX_ZM_DL1 "  "0 ,1 "
bitfld.long 0 4. " SDI_CSI1_RX_INIT_CLK "  "0 ,1 "
bitfld.long 0 8. " SDI_CSI1_STOP_STATE_CL "  "0 ,1 "
bitfld.long 0 9. " SDI_CSI1_STOP_STATE_DL1 "  "0 ,1 "
bitfld.long 0 10. " SDI_CSI1_ULP_ACTIVE_NOT_CL "  "0 ,1 "
bitfld.long 0 11. " SDI_CSI1_ULP_ACTIVE_NOT_DL1 "  "0 ,1 "
tree.end

base ad:0xa010404c
tree "SDI_CSI2RX_VC_DATA_TYPE_R"
rgroup 0--3
line.long 0 "SDI_CSI2RX_VC_DATA_TYPE_R"
bitfld.long 0 0.--5. " SDI_CSI2RX_DATA_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--7. " SDI_CSI2RX_VC "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0104050
tree "SDI_STATIC_CSI2RX_DATA_TYPE_W"
group 0--3
line.long 0 "SDI_STATIC_CSI2RX_DATA_TYPE_W"
bitfld.long 0 0.--5. " SDI_STATIC_CSI2RX_DATA_TYPE0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8.--13. " SDI_STATIC_CSI2RX_DATA_TYPE1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--21. " SDI_STATIC_CSI2RX_DATA_TYPE2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0104054
tree "SDI_STATIC_CSI2RX_VC_EN_W"
group 0--3
line.long 0 "SDI_STATIC_CSI2RX_VC_EN_W"
bitfld.long 0 0. " SDI_STATIC_CSI2RX_VC0_EN "  "0 ,1 "
bitfld.long 0 1. " SDI_STATIC_CSI2RX_VC1_EN "  "0 ,1 "
bitfld.long 0 2. " SDI_STATIC_CSI2RX_VC2_EN "  "0 ,1 "
bitfld.long 0 3. " SDI_STATIC_CSI2RX_VC3_EN "  "0 ,1 "
tree.end

base ad:0xa0104058
tree "SDI_CSI2RX_FRAME_NB_R"
rgroup 0--3
line.long 0 "SDI_CSI2RX_FRAME_NB_R"
hexfld.word 0 " SDI_CSI2RX_FRAME_NB "
tree.end

base ad:0xa010405c
tree "SDI_CSI2RX_DATA_FIELD_R"
rgroup 0--3
line.long 0 "SDI_CSI2RX_DATA_FIELD_R"
hexfld.word 0 " SDI_CSI2RX_DATA_FIELD "
tree.end

base ad:0xa0104060
tree "SDI_STATIC_CSI2RX_PIX_WIDTH_W"
group 0--3
line.long 0 "SDI_STATIC_CSI2RX_PIX_WIDTH_W"
bitfld.long 0 0.--3. " SDI_STATIC_CSI2RX_DATATYPE0_PIXWIDTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " SDI_STATIC_CSI2RX_DATATYPE1_PIXWIDTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " SDI_STATIC_CSI2RX_DATATYPE2_PIXWIDTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0104064
tree "SDI_ITS"
rgroup 0--3
line.long 0 "SDI_ITS"
bitfld.long 0 0. " SDI_CSI0_ERR_EOT_SYNC_HS_DL1_ITS "  "0 ,1 "
bitfld.long 0 1. " SDI_CSI0_ERR_EOT_SYNC_HS_DL2_ITS "  "0 ,1 "
bitfld.long 0 2. " SDI_CSI0_ERR_SOT_HS_DL1_ITS "  "0 ,1 "
bitfld.long 0 3. " SDI_CSI0_ERR_SOT_HS_DL2_ITS "  "0 ,1 "
bitfld.long 0 4. " SDI_CSI0_ERR_SOT_SYNC_HS_DL1_ITS "  "0 ,1 "
bitfld.long 0 5. " SDI_CSI0_ERR_SOT_SYNC_HS_DL2_ITS "  "0 ,1 "
bitfld.long 0 6. " SDI_CSI0_ERR_CONTROL_DL1_ITS "  "0 ,1 "
bitfld.long 0 7. " SDI_CSI0_ERR_CONTROL_DL2_ITS "  "0 ,1 "
bitfld.long 0 8. " SDI_CSI1_ERR_EOT_SYNC_HS_DL1_ITS "  "0 ,1 "
bitfld.long 0 9. " SDI_CSI1_ERR_SOT_HS_DL1_ITS "  "0 ,1 "
bitfld.long 0 10. " SDI_CSI1_ERR_SOT_SYNC_HS_DL1_ITS "  "0 ,1 "
bitfld.long 0 11. " SDI_CSI1_ERR_CONTROL_DL1_ITS "  "0 ,1 "
bitfld.long 0 12. " SDI_CSI0_ERR_ESC_DL1_DBG_ITS "  "0 ,1 "
bitfld.long 0 13. " SDI_CSI0_ERR_ESC_DL2_DBG_ITS "  "0 ,1 "
bitfld.long 0 14. " SDI_CSI0_ERR_SYNC_ESC_DL1_DBG_ITS "  "0 ,1 "
bitfld.long 0 15. " SDI_CSI0_ERR_SYNC_ESC_DL2_DBG_ITS "  "0 ,1 "
bitfld.long 0 16. " SDI_CSI1_ERR_ESC_DL1_DBG_ITS "  "0 ,1 "
bitfld.long 0 17. " SDI_CSI1_ERR_SYNC_ESC_DL1_DBG_ITS "  "0 ,1 "
bitfld.long 0 18. " SDI_CSI2RX_PACKET_PAYLOAD_CRC_ERROR_ITS "  "0 ,1 "
bitfld.long 0 19. " SDI_CSI2RX_PACKET_HEADER_ECC_ERROR_ITS "  "0 ,1 "
bitfld.long 0 20. " SDI_CSI2RX_PACKET_ECC_CORRECTED_DBG_ITS "  "0 ,1 "
bitfld.long 0 21. " SDI_SDG_CCP_SHIFT_SYNC_ITS "  "0 ,1 "
bitfld.long 0 22. " SDI_SDG_CCP_FALSE_SYNC_ITS "  "0 ,1 "
bitfld.long 0 23. " SDI_SDG_CCP_CRC_ERROR_ITS "  "0 ,1 "
bitfld.long 0 24. " SDI_CDG_CCP_SYNC_LINE_ERROR_ITS "  "0 ,1 "
bitfld.long 0 25. " SDI_CDG_CCP_SYNC_FS_FS_ERROR_ITS "  "0 ,1 "
bitfld.long 0 26. " SDI_CDG_CCP_SYNC_FS_LS_ERROR_ITS "  "0 ,1 "
bitfld.long 0 27. " SDI_CDG_CCP_SYNC_LE_FS_ERROR_ITS "  "0 ,1 "
bitfld.long 0 28. " SDI_CDG_CCP_SYNC_LE_FE_ERROR_ITS "  "0 ,1 "
bitfld.long 0 29. " SDI_CDG_CCP_SYNC_LE_LE_ERROR_ITS "  "0 ,1 "
bitfld.long 0 30. " SDI_CDG_CCP_SYNC_LS_FS_ERROR_ITS "  "0 ,1 "
bitfld.long 0 31. " SDI_CDG_CCP_SYNC_LS_LS_ERROR_ITS "  "0 ,1 "
tree.end

base ad:0xa0104068
tree "SDI_ITS_BCLR"
wgroup 0--3
line.long 0 "SDI_ITS_BCLR"
bitfld.long 0 0. " SDI_CSI0_ERR_EOT_SYNC_HS_DL1_ITS_BCLR "  "0 ,1 "
bitfld.long 0 1. " SDI_CSI0_ERR_EOT_SYNC_HS_DL2_ITS_BCLR "  "0 ,1 "
bitfld.long 0 2. " SDI_CSI0_ERR_SOT_HS_DL1_ITS_BCLR "  "0 ,1 "
bitfld.long 0 3. " SDI_CSI0_ERR_SOT_HS_DL2_ITS_BCLR "  "0 ,1 "
bitfld.long 0 4. " SDI_CSI0_ERR_SOT_SYNC_HS_DL1_ITS_BCLR "  "0 ,1 "
bitfld.long 0 5. " SDI_CSI0_ERR_SOT_SYNC_HS_DL2_ITS_BCLR "  "0 ,1 "
bitfld.long 0 6. " SDI_CSI0_ERR_CONTROL_DL1_ITS_BCLR "  "0 ,1 "
bitfld.long 0 7. " SDI_CSI0_ERR_CONTROL_DL2_ITS_BCLR "  "0 ,1 "
bitfld.long 0 8. " SDI_CSI1_ERR_EOT_SYNC_HS_DL1_ITS_BCLR "  "0 ,1 "
bitfld.long 0 9. " SDI_CSI1_ERR_SOT_HS_DL1_ITS_BCLR "  "0 ,1 "
bitfld.long 0 10. " SDI_CSI1_ERR_SOT_SYNC_HS_DL1_ITS_BCLR "  "0 ,1 "
bitfld.long 0 11. " SDI_CSI1_ERR_CONTROL_DL1_ITS_BCLR "  "0 ,1 "
bitfld.long 0 12. " SDI_CSI0_ERR_ESC_DL1_DBG_ITS_BCLR "  "0 ,1 "
bitfld.long 0 13. " SDI_CSI0_ERR_ESC_DL2_DBG_ITS_BCLR "  "0 ,1 "
bitfld.long 0 14. " SDI_CSI0_ERR_SYNC_ESC_DL1_DBG_ITS_BCLR "  "0 ,1 "
bitfld.long 0 15. " SDI_CSI0_ERR_SYNC_ESC_DL2_DBG_ITS_BCLR "  "0 ,1 "
bitfld.long 0 16. " SDI_CSI1_ERR_ESC_DL1_DBG_ITS_BCLR "  "0 ,1 "
bitfld.long 0 17. " SDI_CSI1_ERR_SYNC_ESC_DL1_DBG_ITS_BCLR "  "0 ,1 "
bitfld.long 0 18. " SDI_CSI2RX_PACKET_PAYLOAD_CRC_ERROR_ITS_BCLR "  "0 ,1 "
bitfld.long 0 19. " SDI_CSI2RX_PACKET_HEADER_ECC_ERROR_ITS_BCLR "  "0 ,1 "
bitfld.long 0 20. " SDI_CSI2RX_PACKET_ECC_CORRECTED_DBG_ITS_BCLR "  "0 ,1 "
bitfld.long 0 21. " SDI_SDG_CCP_SHIFT_SYNC_ITS_BCLR "  "0 ,1 "
bitfld.long 0 22. " SDI_SDG_CCP_FALSE_SYNC_ITS_BCLR "  "0 ,1 "
bitfld.long 0 23. " SDI_SDG_CCP_CRC_ERROR_ITS_BCLR "  "0 ,1 "
bitfld.long 0 24. " SDI_CDG_CCP_SYNC_LINE_ERROR_ITS_BCLR "  "0 ,1 "
bitfld.long 0 25. " SDI_CDG_CCP_SYNC_FS_FS_ERROR_ITS_BCLR "  "0 ,1 "
bitfld.long 0 26. " SDI_CDG_CCP_SYNC_FS_LS_ERROR_ITS_BCLR "  "0 ,1 "
bitfld.long 0 27. " SDI_CDG_CCP_SYNC_LE_FS_ERROR_ITS_BCLR "  "0 ,1 "
bitfld.long 0 28. " SDI_CDG_CCP_SYNC_LE_FE_ERROR_ITS_BCLR "  "0 ,1 "
bitfld.long 0 29. " SDI_CDG_CCP_SYNC_LE_LE_ERROR_ITS_BCLR "  "0 ,1 "
bitfld.long 0 30. " SDI_CDG_CCP_SYNC_LS_FS_ERROR_ITS_BCLR "  "0 ,1 "
bitfld.long 0 31. " SDI_CDG_CCP_SYNC_LS_LS_ERROR_ITS_BCLR "  "0 ,1 "
tree.end

base ad:0xa010406c
tree "SDI_ITS_BSET"
wgroup 0--3
line.long 0 "SDI_ITS_BSET"
bitfld.long 0 0. " SDI_CSI0_ERR_EOT_SYNC_HS_DL1_ITS_BSET "  "0 ,1 "
bitfld.long 0 1. " SDI_CSI0_ERR_EOT_SYNC_HS_DL2_ITS_BSET "  "0 ,1 "
bitfld.long 0 2. " SDI_CSI0_ERR_SOT_HS_DL1_ITS_BSET "  "0 ,1 "
bitfld.long 0 3. " SDI_CSI0_ERR_SOT_HS_DL2_ITS_BSET "  "0 ,1 "
bitfld.long 0 4. " SDI_CSI0_ERR_SOT_SYNC_HS_DL1_ITS_BSET "  "0 ,1 "
bitfld.long 0 5. " SDI_CSI0_ERR_SOT_SYNC_HS_DL2_ITS_BSET "  "0 ,1 "
bitfld.long 0 6. " SDI_CSI0_ERR_CONTROL_DL1_ITS_BSET "  "0 ,1 "
bitfld.long 0 7. " SDI_CSI0_ERR_CONTROL_DL2_ITS_BSET "  "0 ,1 "
bitfld.long 0 8. " SDI_CSI1_ERR_EOT_SYNC_HS_DL1_ITS_BSET "  "0 ,1 "
bitfld.long 0 9. " SDI_CSI1_ERR_SOT_HS_DL1_ITS_BSET "  "0 ,1 "
bitfld.long 0 10. " SDI_CSI1_ERR_SOT_SYNC_HS_DL1_ITS_BSET "  "0 ,1 "
bitfld.long 0 11. " SDI_CSI1_ERR_CONTROL_DL1_ITS_BSET "  "0 ,1 "
bitfld.long 0 12. " SDI_CSI0_ERR_ESC_DL1_DBG_ITS_BSET "  "0 ,1 "
bitfld.long 0 13. " SDI_CSI0_ERR_ESC_DL2_DBG_ITS_BSET "  "0 ,1 "
bitfld.long 0 14. " SDI_CSI0_ERR_SYNC_ESC_DL1_DBG_ITS_BSET "  "0 ,1 "
bitfld.long 0 15. " SDI_CSI0_ERR_SYNC_ESC_DL2_DBG_ITS_BSET "  "0 ,1 "
bitfld.long 0 16. " SDI_CSI1_ERR_ESC_DL1_DBG_ITS_BSET "  "0 ,1 "
bitfld.long 0 17. " SDI_CSI1_ERR_SYNC_ESC_DL1_DBG_ITS_BSET "  "0 ,1 "
bitfld.long 0 18. " SDI_CSI2RX_PACKET_PAYLOAD_CRC_ERROR_ITS_BSET "  "0 ,1 "
bitfld.long 0 19. " SDI_CSI2RX_PACKET_HEADER_ECC_ERROR_ITS_BSET "  "0 ,1 "
bitfld.long 0 20. " SDI_CSI2RX_PACKET_ECC_CORRECTED_DBG_ITS_BSET "  "0 ,1 "
bitfld.long 0 21. " SDI_SDG_CCP_SHIFT_SYNC_ITS_BSET "  "0 ,1 "
bitfld.long 0 22. " SDI_SDG_CCP_FALSE_SYNC_ITS_BSET "  "0 ,1 "
bitfld.long 0 23. " SDI_SDG_CCP_CRC_ERROR_ITS_BSET "  "0 ,1 "
bitfld.long 0 24. " SDI_CDG_CCP_SYNC_LINE_ERROR_ITS_BSET "  "0 ,1 "
bitfld.long 0 25. " SDI_CDG_CCP_SYNC_FS_FS_ERROR_ITS_BSET "  "0 ,1 "
bitfld.long 0 26. " SDI_CDG_CCP_SYNC_FS_LS_ERROR_ITS_BSET "  "0 ,1 "
bitfld.long 0 27. " SDI_CDG_CCP_SYNC_LE_FS_ERROR_ITS_BSET "  "0 ,1 "
bitfld.long 0 28. " SDI_CDG_CCP_SYNC_LE_FE_ERROR_ITS_BSET "  "0 ,1 "
bitfld.long 0 29. " SDI_CDG_CCP_SYNC_LE_LE_ERROR_ITS_BSET "  "0 ,1 "
bitfld.long 0 30. " SDI_CDG_CCP_SYNC_LS_FS_ERROR_ITS_BSET "  "0 ,1 "
bitfld.long 0 31. " SDI_CDG_CCP_SYNC_LS_LS_ERROR_ITS_BSET "  "0 ,1 "
tree.end

base ad:0xa0104070
tree "SDI_ITM"
rgroup 0--3
line.long 0 "SDI_ITM"
bitfld.long 0 0. " SDI_CSI0_ERR_EOT_SYNC_HS_DL1_ITM "  "0 ,1 "
bitfld.long 0 1. " SDI_CSI0_ERR_EOT_SYNC_HS_DL2_ITM "  "0 ,1 "
bitfld.long 0 2. " SDI_CSI0_ERR_SOT_HS_DL1_ITM "  "0 ,1 "
bitfld.long 0 3. " SDI_CSI0_ERR_SOT_HS_DL2_ITM "  "0 ,1 "
bitfld.long 0 4. " SDI_CSI0_ERR_SOT_SYNC_HS_DL1_ITM "  "0 ,1 "
bitfld.long 0 5. " SDI_CSI0_ERR_SOT_SYNC_HS_DL2_ITM "  "0 ,1 "
bitfld.long 0 6. " SDI_CSI0_ERR_CONTROL_DL1_ITM "  "0 ,1 "
bitfld.long 0 7. " SDI_CSI0_ERR_CONTROL_DL2_ITM "  "0 ,1 "
bitfld.long 0 8. " SDI_CSI1_ERR_EOT_SYNC_HS_DL1_ITM "  "0 ,1 "
bitfld.long 0 9. " SDI_CSI1_ERR_SOT_HS_DL1_ITM "  "0 ,1 "
bitfld.long 0 10. " SDI_CSI1_ERR_SOT_SYNC_HS_DL1_ITM "  "0 ,1 "
bitfld.long 0 11. " SDI_CSI1_ERR_CONTROL_DL1_ITM "  "0 ,1 "
bitfld.long 0 12. " SDI_CSI0_ERR_ESC_DL1_DBG_ITM "  "0 ,1 "
bitfld.long 0 13. " SDI_CSI0_ERR_ESC_DL2_DBG_ITM "  "0 ,1 "
bitfld.long 0 14. " SDI_CSI0_ERR_SYNC_ESC_DL1_DBG_ITM "  "0 ,1 "
bitfld.long 0 15. " SDI_CSI0_ERR_SYNC_ESC_DL2_DBG_ITM "  "0 ,1 "
bitfld.long 0 16. " SDI_CSI1_ERR_ESC_DL1_DBG_ITM "  "0 ,1 "
bitfld.long 0 17. " SDI_CSI1_ERR_SYNC_ESC_DL1_DBG_ITM "  "0 ,1 "
bitfld.long 0 18. " SDI_CSI2RX_PACKET_PAYLOAD_CRC_ERROR_ITM "  "0 ,1 "
bitfld.long 0 19. " SDI_CSI2RX_PACKET_HEADER_ECC_ERROR_ITM "  "0 ,1 "
bitfld.long 0 20. " SDI_CSI2RX_PACKET_ECC_CORRECTED_DBG_ITM "  "0 ,1 "
bitfld.long 0 21. " SDI_SDG_CCP_SHIFT_SYNC_ITM "  "0 ,1 "
bitfld.long 0 22. " SDI_SDG_CCP_FALSE_SYNC_ITM "  "0 ,1 "
bitfld.long 0 23. " SDI_SDG_CCP_CRC_ERROR_ITM "  "0 ,1 "
bitfld.long 0 24. " SDI_CDG_CCP_SYNC_LINE_ERROR_ITM "  "0 ,1 "
bitfld.long 0 25. " SDI_CDG_CCP_SYNC_FS_FS_ERROR_ITM "  "0 ,1 "
bitfld.long 0 26. " SDI_CDG_CCP_SYNC_FS_LS_ERROR_ITM "  "0 ,1 "
bitfld.long 0 27. " SDI_CDG_CCP_SYNC_LE_FS_ERROR_ITM "  "0 ,1 "
bitfld.long 0 28. " SDI_CDG_CCP_SYNC_LE_FE_ERROR_ITM "  "0 ,1 "
bitfld.long 0 29. " SDI_CDG_CCP_SYNC_LE_LE_ERROR_ITM "  "0 ,1 "
bitfld.long 0 30. " SDI_CDG_CCP_SYNC_LS_FS_ERROR_ITM "  "0 ,1 "
bitfld.long 0 31. " SDI_CDG_CCP_SYNC_LS_LS_ERROR_ITM "  "0 ,1 "
tree.end

base ad:0xa0104074
tree "SDI_ITM_BCLR"
wgroup 0--3
line.long 0 "SDI_ITM_BCLR"
bitfld.long 0 0. " SDI_CSI0_ERR_EOT_SYNC_HS_DL1_ITM_BCLR "  "0 ,1 "
bitfld.long 0 1. " SDI_CSI0_ERR_EOT_SYNC_HS_DL2_ITM_BCLR "  "0 ,1 "
bitfld.long 0 2. " SDI_CSI0_ERR_SOT_HS_DL1_ITM_BCLR "  "0 ,1 "
bitfld.long 0 3. " SDI_CSI0_ERR_SOT_HS_DL2_ITM_BCLR "  "0 ,1 "
bitfld.long 0 4. " SDI_CSI0_ERR_SOT_SYNC_HS_DL1_ITM_BCLR "  "0 ,1 "
bitfld.long 0 5. " SDI_CSI0_ERR_SOT_SYNC_HS_DL2_ITM_BCLR "  "0 ,1 "
bitfld.long 0 6. " SDI_CSI0_ERR_CONTROL_DL1_ITM_BCLR "  "0 ,1 "
bitfld.long 0 7. " SDI_CSI0_ERR_CONTROL_DL2_ITM_BCLR "  "0 ,1 "
bitfld.long 0 8. " SDI_CSI1_ERR_EOT_SYNC_HS_DL1_ITM_BCLR "  "0 ,1 "
bitfld.long 0 9. " SDI_CSI1_ERR_SOT_HS_DL1_ITM_BCLR "  "0 ,1 "
bitfld.long 0 10. " SDI_CSI1_ERR_SOT_SYNC_HS_DL1_ITM_BCLR "  "0 ,1 "
bitfld.long 0 11. " SDI_CSI1_ERR_CONTROL_DL1_ITM_BCLR "  "0 ,1 "
bitfld.long 0 12. " SDI_CSI0_ERR_ESC_DL1_DBG_ITM_BCLR "  "0 ,1 "
bitfld.long 0 13. " SDI_CSI0_ERR_ESC_DL2_DBG_ITM_BCLR "  "0 ,1 "
bitfld.long 0 14. " SDI_CSI0_ERR_SYNC_ESC_DL1_DBG_ITM_BCLR "  "0 ,1 "
bitfld.long 0 15. " SDI_CSI0_ERR_SYNC_ESC_DL2_DBG_ITM_BCLR "  "0 ,1 "
bitfld.long 0 16. " SDI_CSI1_ERR_ESC_DL1_DBG_ITM_BCLR "  "0 ,1 "
bitfld.long 0 17. " SDI_CSI1_ERR_SYNC_ESC_DL1_DBG_ITM_BCLR "  "0 ,1 "
bitfld.long 0 18. " SDI_CSI2RX_PACKET_PAYLOAD_CRC_ERROR_ITM_BCLR "  "0 ,1 "
bitfld.long 0 19. " SDI_CSI2RX_PACKET_HEADER_ECC_ERROR_ITM_BCLR "  "0 ,1 "
bitfld.long 0 20. " SDI_CSI2RX_PACKET_ECC_CORRECTED_DBG_ITM_BCLR "  "0 ,1 "
bitfld.long 0 21. " SDI_SDG_CCP_SHIFT_SYNC_ITM_BCLR "  "0 ,1 "
bitfld.long 0 22. " SDI_SDG_CCP_FALSE_SYNC_ITM_BCLR "  "0 ,1 "
bitfld.long 0 23. " SDI_SDG_CCP_CRC_ERROR_ITM_BCLR "  "0 ,1 "
bitfld.long 0 24. " SDI_CDG_CCP_SYNC_LINE_ERROR_ITM_BCLR "  "0 ,1 "
bitfld.long 0 25. " SDI_CDG_CCP_SYNC_FS_FS_ERROR_ITM_BCLR "  "0 ,1 "
bitfld.long 0 26. " SDI_CDG_CCP_SYNC_FS_LS_ERROR_ITM_BCLR "  "0 ,1 "
bitfld.long 0 27. " SDI_CDG_CCP_SYNC_LE_FS_ERROR_ITM_BCLR "  "0 ,1 "
bitfld.long 0 28. " SDI_CDG_CCP_SYNC_LE_FE_ERROR_ITM_BCLR "  "0 ,1 "
bitfld.long 0 29. " SDI_CDG_CCP_SYNC_LE_LE_ERROR_ITM_BCLR "  "0 ,1 "
bitfld.long 0 30. " SDI_CDG_CCP_SYNC_LS_FS_ERROR_ITM_BCLR "  "0 ,1 "
bitfld.long 0 31. " SDI_CDG_CCP_SYNC_LS_LS_ERROR_ITM_BCLR "  "0 ,1 "
tree.end

base ad:0xa0104078
tree "SDI_ITM_BSET"
wgroup 0--3
line.long 0 "SDI_ITM_BSET"
bitfld.long 0 0. " SDI_CSI0_ERR_EOT_SYNC_HS_DL1_ITM_BSET "  "0 ,1 "
bitfld.long 0 1. " SDI_CSI0_ERR_EOT_SYNC_HS_DL2_ITM_BSET "  "0 ,1 "
bitfld.long 0 2. " SDI_CSI0_ERR_SOT_HS_DL1_ITM_BSET "  "0 ,1 "
bitfld.long 0 3. " SDI_CSI0_ERR_SOT_HS_DL2_ITM_BSET "  "0 ,1 "
bitfld.long 0 4. " SDI_CSI0_ERR_SOT_SYNC_HS_DL1_ITM_BSET "  "0 ,1 "
bitfld.long 0 5. " SDI_CSI0_ERR_SOT_SYNC_HS_DL2_ITM_BSET "  "0 ,1 "
bitfld.long 0 6. " SDI_CSI0_ERR_CONTROL_DL1_ITM_BSET "  "0 ,1 "
bitfld.long 0 7. " SDI_CSI0_ERR_CONTROL_DL2_ITM_BSET "  "0 ,1 "
bitfld.long 0 8. " SDI_CSI1_ERR_EOT_SYNC_HS_DL1_ITM_BSET "  "0 ,1 "
bitfld.long 0 9. " SDI_CSI1_ERR_SOT_HS_DL1_ITM_BSET "  "0 ,1 "
bitfld.long 0 10. " SDI_CSI1_ERR_SOT_SYNC_HS_DL1_ITM_BSET "  "0 ,1 "
bitfld.long 0 11. " SDI_CSI1_ERR_CONTROL_DL1_ITM_BSET "  "0 ,1 "
bitfld.long 0 12. " SDI_CSI0_ERR_ESC_DL1_DBG_ITM_BSET "  "0 ,1 "
bitfld.long 0 13. " SDI_CSI0_ERR_ESC_DL2_DBG_ITM_BSET "  "0 ,1 "
bitfld.long 0 14. " SDI_CSI0_ERR_SYNC_ESC_DL1_DBG_ITM_BSET "  "0 ,1 "
bitfld.long 0 15. " SDI_CSI0_ERR_SYNC_ESC_DL2_DBG_ITM_BSET "  "0 ,1 "
bitfld.long 0 16. " SDI_CSI1_ERR_ESC_DL1_DBG_ITM_BSET "  "0 ,1 "
bitfld.long 0 17. " SDI_CSI1_ERR_SYNC_ESC_DL1_DBG_ITM_BSET "  "0 ,1 "
bitfld.long 0 18. " SDI_CSI2RX_PACKET_PAYLOAD_CRC_ERROR_ITM_BSET "  "0 ,1 "
bitfld.long 0 19. " SDI_CSI2RX_PACKET_HEADER_ECC_ERROR_ITM_BSET "  "0 ,1 "
bitfld.long 0 20. " SDI_CSI2RX_PACKET_ECC_CORRECTED_DBG_ITM_BSET "  "0 ,1 "
bitfld.long 0 21. " SDI_SDG_CCP_SHIFT_SYNC_ITM_BSET "  "0 ,1 "
bitfld.long 0 22. " SDI_SDG_CCP_FALSE_SYNC_ITM_BSET "  "0 ,1 "
bitfld.long 0 23. " SDI_SDG_CCP_CRC_ERROR_ITM_BSET "  "0 ,1 "
bitfld.long 0 24. " SDI_CDG_CCP_SYNC_LINE_ERROR_ITM_BSET "  "0 ,1 "
bitfld.long 0 25. " SDI_CDG_CCP_SYNC_FS_FS_ERROR_ITM_BSET "  "0 ,1 "
bitfld.long 0 26. " SDI_CDG_CCP_SYNC_FS_LS_ERROR_ITM_BSET "  "0 ,1 "
bitfld.long 0 27. " SDI_CDG_CCP_SYNC_LE_FS_ERROR_ITM_BSET "  "0 ,1 "
bitfld.long 0 28. " SDI_CDG_CCP_SYNC_LE_FE_ERROR_ITM_BSET "  "0 ,1 "
bitfld.long 0 29. " SDI_CDG_CCP_SYNC_LE_LE_ERROR_ITM_BSET "  "0 ,1 "
bitfld.long 0 30. " SDI_CDG_CCP_SYNC_LS_FS_ERROR_ITM_BSET "  "0 ,1 "
bitfld.long 0 31. " SDI_CDG_CCP_SYNC_LS_LS_ERROR_ITM_BSET "  "0 ,1 "
tree.end

base ad:0xa0104100
tree "SDI_STATIC_SD_CCP_EN"
group 0--3
line.long 0 "SDI_STATIC_SD_CCP_EN"
bitfld.long 0 0. " SDI_STATIC_SD_CCP_EN "  "0 ,1 "
tree.end

base ad:0xa0104104
tree "SDI_STATIC_SDG_CSI_MODE"
group 0--3
line.long 0 "SDI_STATIC_SDG_CSI_MODE"
bitfld.long 0 0. " SDI_STATIC_SDG_CSI_MODE "  "0 ,1 "
tree.end

base ad:0xa0104200
tree "SDI_STATIC_CD_EN"
group 0--3
line.long 0 "SDI_STATIC_CD_EN"
bitfld.long 0 0. " SDI_STATIC_CD_EN "  "0 ,1 "
tree.end

base ad:0xa0104204
tree "SDI_CDG_START"
wgroup 0--3
line.long 0 "SDI_CDG_START"
bitfld.long 0 0. " SDI_CDG_START "  "0 ,1 "
tree.end

base ad:0xa0104208
tree "SDI_STATIC_CDG_CSI_PADD_EN"
group 0--3
line.long 0 "SDI_STATIC_CDG_CSI_PADD_EN"
bitfld.long 0 0. " SDI_STATIC_CDG_CSI_PADD_EN "  "0 ,1 "
tree.end

base ad:0xa010420c
tree "SDI_STATIC_CDG_CCP_SYNC_CODES"
group 0--3
line.long 0 "SDI_STATIC_CDG_CCP_SYNC_CODES"
hexfld.byte 0 " SDI_STATIC_CDG_CCP_FS "
hexfld.byte 1 " SDI_STATIC_CDG_CCP_FE "
hexfld.byte 2 " SDI_STATIC_CDG_CCP_LS "
hexfld.byte 3 " SDI_STATIC_CDG_CCP_LE "
tree.end

base ad:0xa0104210
tree "SDI_CDG_CCP_DATA_FORMAT"
group 0--3
line.long 0 "SDI_CDG_CCP_DATA_FORMAT"
bitfld.long 0 0. " SDI_CDG_CCP_DATA_FORMAT "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "SPI (4 instances)"
;==============================================================
base ad:0x80100000
;********************************************
tree "SPI-0"
;********************************************
base ad:0x80100000
tree "0CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
bitfld.long 0 16. " CS1 "  "0 ,1 "
bitfld.long 0 17. " CS2 "  "0 ,1 "
bitfld.long 0 18. " CS3 "  "0 ,1 "
tree.end

base ad:0x80100004
tree "0CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " LBM "  "0 ,1 "
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--15. " FBCLKDEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16. " TS "  "0 ,1 "
bitfld.long 0 17. " CSF "  "0 ,1 "
bitfld.long 0 18. " TSPOL "  "0 ,1 "
tree.end

base ad:0x80100008
tree "0DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010000c
tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
tree.end

base ad:0x80100010
tree "0CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
tree.end

base ad:0x80100014
tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
tree.end

base ad:0x80100018
tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
tree.end

base ad:0x8010001c
tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
tree.end

base ad:0x80100020
tree "0ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
tree.end

base ad:0x80100024
tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
tree.end

base ad:0x80100fe0
tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0x80100fe4
tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80100fe8
tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80100fec
tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80100ff0
tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
tree.end

base ad:0x80100ff4
tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
tree.end

base ad:0x80100ff8
tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
tree.end

base ad:0x80100ffc
tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
tree.end

tree.end

base ad:0x80101000
;********************************************
tree "SPI-1"
;********************************************
base ad:0x80101000
tree "1CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
bitfld.long 0 16. " CS1 "  "0 ,1 "
bitfld.long 0 17. " CS2 "  "0 ,1 "
bitfld.long 0 18. " CS3 "  "0 ,1 "
tree.end

base ad:0x80101004
tree "1CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " LBM "  "0 ,1 "
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--15. " FBCLKDEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16. " TS "  "0 ,1 "
bitfld.long 0 17. " CSF "  "0 ,1 "
bitfld.long 0 18. " TSPOL "  "0 ,1 "
tree.end

base ad:0x80101008
tree "1DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010100c
tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
tree.end

base ad:0x80101010
tree "1CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
tree.end

base ad:0x80101014
tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
tree.end

base ad:0x80101018
tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
tree.end

base ad:0x8010101c
tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
tree.end

base ad:0x80101020
tree "1ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
tree.end

base ad:0x80101024
tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
tree.end

base ad:0x80101fe0
tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0x80101fe4
tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80101fe8
tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80101fec
tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80101ff0
tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
tree.end

base ad:0x80101ff4
tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
tree.end

base ad:0x80101ff8
tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
tree.end

base ad:0x80101ffc
tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
tree.end

tree.end

base ad:0x80102000
;********************************************
tree "SPI-2"
;********************************************
base ad:0x80102000
tree "2CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
bitfld.long 0 16. " CS1 "  "0 ,1 "
bitfld.long 0 17. " CS2 "  "0 ,1 "
bitfld.long 0 18. " CS3 "  "0 ,1 "
tree.end

base ad:0x80102004
tree "2CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " LBM "  "0 ,1 "
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--15. " FBCLKDEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16. " TS "  "0 ,1 "
bitfld.long 0 17. " CSF "  "0 ,1 "
bitfld.long 0 18. " TSPOL "  "0 ,1 "
tree.end

base ad:0x80102008
tree "2DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010200c
tree "2SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
tree.end

base ad:0x80102010
tree "2CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
tree.end

base ad:0x80102014
tree "2IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
tree.end

base ad:0x80102018
tree "2RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
tree.end

base ad:0x8010201c
tree "2MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
tree.end

base ad:0x80102020
tree "2ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
tree.end

base ad:0x80102024
tree "2DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
tree.end

base ad:0x80102fe0
tree "2PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0x80102fe4
tree "2PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80102fe8
tree "2PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80102fec
tree "2PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80102ff0
tree "2PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
tree.end

base ad:0x80102ff4
tree "2PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
tree.end

base ad:0x80102ff8
tree "2PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
tree.end

base ad:0x80102ffc
tree "2PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
tree.end

tree.end

base ad:0x80103000
;********************************************
tree "SPI-3"
;********************************************
base ad:0x80103000
tree "3CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
bitfld.long 0 16. " CS1 "  "0 ,1 "
bitfld.long 0 17. " CS2 "  "0 ,1 "
bitfld.long 0 18. " CS3 "  "0 ,1 "
tree.end

base ad:0x80103004
tree "3CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " LBM "  "0 ,1 "
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--15. " FBCLKDEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16. " TS "  "0 ,1 "
bitfld.long 0 17. " CSF "  "0 ,1 "
bitfld.long 0 18. " TSPOL "  "0 ,1 "
tree.end

base ad:0x80103008
tree "3DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
tree.end

base ad:0x8010300c
tree "3SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
tree.end

base ad:0x80103010
tree "3CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
tree.end

base ad:0x80103014
tree "3IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
tree.end

base ad:0x80103018
tree "3RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
tree.end

base ad:0x8010301c
tree "3MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
tree.end

base ad:0x80103020
tree "3ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
tree.end

base ad:0x80103024
tree "3DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
tree.end

base ad:0x80103fe0
tree "3PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
tree.end

base ad:0x80103fe4
tree "3PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80103fe8
tree "3PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80103fec
tree "3PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80103ff0
tree "3PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
tree.end

base ad:0x80103ff4
tree "3PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
tree.end

base ad:0x80103ff8
tree "3PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
tree.end

base ad:0x80103ffc
tree "3PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
tree.end

tree.end

tree.end

;==============================================================
tree "SPITB (4 instances)"
;==============================================================
base ad:0x63680000
;********************************************
tree "SPITB-0"
;********************************************
base ad:0x63680000
tree "0PRE"
group 0--3
line.long 0 "PRE"
hexfld.byte 0 " PRESCALE "
tree.end

base ad:0x63680004
tree "0CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " FRF "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " ENABLE "  "0 ,1 "
hexfld.byte 1 " SCR "
tree.end

base ad:0x63680008
tree "0CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " SPO "  "0 ,1 "
bitfld.long 0 1. " SPH "  "0 ,1 "
bitfld.long 0 2.--3. " RXW "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MS "  "0 ,1 "
bitfld.long 0 5. " OD "  "0 ,1 "
tree.end

base ad:0x6368000c
tree "0TDR"
group 0--3
line.long 0 "TDR"
hexfld.word 0 " DATA "
tree.end

base ad:0x63680010
tree "0RDR"
group 0--3
line.long 0 "RDR"
hexfld.word 0 " DATA "
tree.end

base ad:0x63680014
tree "0SR"
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXFF "  "0 ,1 "
bitfld.long 0 2. " TXFE "  "0 ,1 "
bitfld.long 0 3. " TXFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
bitfld.long 0 5. " SPIINT "  "0 ,1 "
bitfld.long 0 6. " RXWFLG "  "0 ,1 "
bitfld.long 0 7. " RFSFLG "  "0 ,1 "
bitfld.long 0 8. " TFSFLG "  "0 ,1 "
bitfld.long 0 9. " RORFLG "  "0 ,1 "
bitfld.long 0 10. " PCLKON "  "0 ,1 "
bitfld.long 0 11. " REFCLKON "  "0 ,1 "
bitfld.long 0 12. " REFCLK1ON "  "0 ,1 "
tree.end

base ad:0x63680018
tree "0SCANMODE"
group 0--3
line.long 0 "SCANMODE"
bitfld.long 0 0. " SCANMODE "  "0 ,1 "
bitfld.long 0 1. " RSTMODE "  "0 ,1 "
bitfld.long 0 2. " GENCLK "  "0 ,1 "
bitfld.long 0 3. " SPICLKSEL "  "0 ,1 "
bitfld.long 0 4. " SPICLK1SEL "  "0 ,1 "
bitfld.long 0 5. " GENCLK1 "  "0 ,1 "
tree.end

base ad:0x6368001c
tree "0CLKREG"
group 0--3
line.long 0 "CLKREG"
hexfld.word 0 " CLKPERIOD "
tree.end

base ad:0x63680020
tree "0CR2"
group 0--3
line.long 0 "CR2"
hexfld.byte 0 " ESFRM "
bitfld.long 0 8. " FRC "  "0 ,1 "
bitfld.long 0 9. " SPISFRMEn "  "0 ,1 "
bitfld.long 0 10. " TIDASFRM "  "0 ,1 "
tree.end

base ad:0x63680024
tree "0CLKREG1"
group 0--3
line.long 0 "CLKREG1"
hexfld.word 0 " CLKPERIOD "
tree.end

tree.end

base ad:0x63c80000
;********************************************
tree "SPITB-1"
;********************************************
base ad:0x63c80000
tree "1PRE"
group 0--3
line.long 0 "PRE"
hexfld.byte 0 " PRESCALE "
tree.end

base ad:0x63c80004
tree "1CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " FRF "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " ENABLE "  "0 ,1 "
hexfld.byte 1 " SCR "
tree.end

base ad:0x63c80008
tree "1CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " SPO "  "0 ,1 "
bitfld.long 0 1. " SPH "  "0 ,1 "
bitfld.long 0 2.--3. " RXW "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MS "  "0 ,1 "
bitfld.long 0 5. " OD "  "0 ,1 "
tree.end

base ad:0x63c8000c
tree "1TDR"
group 0--3
line.long 0 "TDR"
hexfld.word 0 " DATA "
tree.end

base ad:0x63c80010
tree "1RDR"
group 0--3
line.long 0 "RDR"
hexfld.word 0 " DATA "
tree.end

base ad:0x63c80014
tree "1SR"
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXFF "  "0 ,1 "
bitfld.long 0 2. " TXFE "  "0 ,1 "
bitfld.long 0 3. " TXFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
bitfld.long 0 5. " SPIINT "  "0 ,1 "
bitfld.long 0 6. " RXWFLG "  "0 ,1 "
bitfld.long 0 7. " RFSFLG "  "0 ,1 "
bitfld.long 0 8. " TFSFLG "  "0 ,1 "
bitfld.long 0 9. " RORFLG "  "0 ,1 "
bitfld.long 0 10. " PCLKON "  "0 ,1 "
bitfld.long 0 11. " REFCLKON "  "0 ,1 "
bitfld.long 0 12. " REFCLK1ON "  "0 ,1 "
tree.end

base ad:0x63c80018
tree "1SCANMODE"
group 0--3
line.long 0 "SCANMODE"
bitfld.long 0 0. " SCANMODE "  "0 ,1 "
bitfld.long 0 1. " RSTMODE "  "0 ,1 "
bitfld.long 0 2. " GENCLK "  "0 ,1 "
bitfld.long 0 3. " SPICLKSEL "  "0 ,1 "
bitfld.long 0 4. " SPICLK1SEL "  "0 ,1 "
bitfld.long 0 5. " GENCLK1 "  "0 ,1 "
tree.end

base ad:0x63c8001c
tree "1CLKREG"
group 0--3
line.long 0 "CLKREG"
hexfld.word 0 " CLKPERIOD "
tree.end

base ad:0x63c80020
tree "1CR2"
group 0--3
line.long 0 "CR2"
hexfld.byte 0 " ESFRM "
bitfld.long 0 8. " FRC "  "0 ,1 "
bitfld.long 0 9. " SPISFRMEn "  "0 ,1 "
bitfld.long 0 10. " TIDASFRM "  "0 ,1 "
tree.end

base ad:0x63c80024
tree "1CLKREG1"
group 0--3
line.long 0 "CLKREG1"
hexfld.word 0 " CLKPERIOD "
tree.end

tree.end

base ad:0x63d00000
;********************************************
tree "SPITB-2"
;********************************************
base ad:0x63d00000
tree "2PRE"
group 0--3
line.long 0 "PRE"
hexfld.byte 0 " PRESCALE "
tree.end

base ad:0x63d00004
tree "2CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " FRF "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " ENABLE "  "0 ,1 "
hexfld.byte 1 " SCR "
tree.end

base ad:0x63d00008
tree "2CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " SPO "  "0 ,1 "
bitfld.long 0 1. " SPH "  "0 ,1 "
bitfld.long 0 2.--3. " RXW "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MS "  "0 ,1 "
bitfld.long 0 5. " OD "  "0 ,1 "
tree.end

base ad:0x63d0000c
tree "2TDR"
group 0--3
line.long 0 "TDR"
hexfld.word 0 " DATA "
tree.end

base ad:0x63d00010
tree "2RDR"
group 0--3
line.long 0 "RDR"
hexfld.word 0 " DATA "
tree.end

base ad:0x63d00014
tree "2SR"
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXFF "  "0 ,1 "
bitfld.long 0 2. " TXFE "  "0 ,1 "
bitfld.long 0 3. " TXFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
bitfld.long 0 5. " SPIINT "  "0 ,1 "
bitfld.long 0 6. " RXWFLG "  "0 ,1 "
bitfld.long 0 7. " RFSFLG "  "0 ,1 "
bitfld.long 0 8. " TFSFLG "  "0 ,1 "
bitfld.long 0 9. " RORFLG "  "0 ,1 "
bitfld.long 0 10. " PCLKON "  "0 ,1 "
bitfld.long 0 11. " REFCLKON "  "0 ,1 "
bitfld.long 0 12. " REFCLK1ON "  "0 ,1 "
tree.end

base ad:0x63d00018
tree "2SCANMODE"
group 0--3
line.long 0 "SCANMODE"
bitfld.long 0 0. " SCANMODE "  "0 ,1 "
bitfld.long 0 1. " RSTMODE "  "0 ,1 "
bitfld.long 0 2. " GENCLK "  "0 ,1 "
bitfld.long 0 3. " SPICLKSEL "  "0 ,1 "
bitfld.long 0 4. " SPICLK1SEL "  "0 ,1 "
bitfld.long 0 5. " GENCLK1 "  "0 ,1 "
tree.end

base ad:0x63d0001c
tree "2CLKREG"
group 0--3
line.long 0 "CLKREG"
hexfld.word 0 " CLKPERIOD "
tree.end

base ad:0x63d00020
tree "2CR2"
group 0--3
line.long 0 "CR2"
hexfld.byte 0 " ESFRM "
bitfld.long 0 8. " FRC "  "0 ,1 "
bitfld.long 0 9. " SPISFRMEn "  "0 ,1 "
bitfld.long 0 10. " TIDASFRM "  "0 ,1 "
tree.end

base ad:0x63d00024
tree "2CLKREG1"
group 0--3
line.long 0 "CLKREG1"
hexfld.word 0 " CLKPERIOD "
tree.end

tree.end

base ad:0x63e80000
;********************************************
tree "SPITB-3"
;********************************************
base ad:0x63e80000
tree "3PRE"
group 0--3
line.long 0 "PRE"
hexfld.byte 0 " PRESCALE "
tree.end

base ad:0x63e80004
tree "3CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " FRF "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " ENABLE "  "0 ,1 "
hexfld.byte 1 " SCR "
tree.end

base ad:0x63e80008
tree "3CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " SPO "  "0 ,1 "
bitfld.long 0 1. " SPH "  "0 ,1 "
bitfld.long 0 2.--3. " RXW "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MS "  "0 ,1 "
bitfld.long 0 5. " OD "  "0 ,1 "
tree.end

base ad:0x63e8000c
tree "3TDR"
group 0--3
line.long 0 "TDR"
hexfld.word 0 " DATA "
tree.end

base ad:0x63e80010
tree "3RDR"
group 0--3
line.long 0 "RDR"
hexfld.word 0 " DATA "
tree.end

base ad:0x63e80014
tree "3SR"
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXFF "  "0 ,1 "
bitfld.long 0 2. " TXFE "  "0 ,1 "
bitfld.long 0 3. " TXFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
bitfld.long 0 5. " SPIINT "  "0 ,1 "
bitfld.long 0 6. " RXWFLG "  "0 ,1 "
bitfld.long 0 7. " RFSFLG "  "0 ,1 "
bitfld.long 0 8. " TFSFLG "  "0 ,1 "
bitfld.long 0 9. " RORFLG "  "0 ,1 "
bitfld.long 0 10. " PCLKON "  "0 ,1 "
bitfld.long 0 11. " REFCLKON "  "0 ,1 "
bitfld.long 0 12. " REFCLK1ON "  "0 ,1 "
tree.end

base ad:0x63e80018
tree "3SCANMODE"
group 0--3
line.long 0 "SCANMODE"
bitfld.long 0 0. " SCANMODE "  "0 ,1 "
bitfld.long 0 1. " RSTMODE "  "0 ,1 "
bitfld.long 0 2. " GENCLK "  "0 ,1 "
bitfld.long 0 3. " SPICLKSEL "  "0 ,1 "
bitfld.long 0 4. " SPICLK1SEL "  "0 ,1 "
bitfld.long 0 5. " GENCLK1 "  "0 ,1 "
tree.end

base ad:0x63e8001c
tree "3CLKREG"
group 0--3
line.long 0 "CLKREG"
hexfld.word 0 " CLKPERIOD "
tree.end

base ad:0x63e80020
tree "3CR2"
group 0--3
line.long 0 "CR2"
hexfld.byte 0 " ESFRM "
bitfld.long 0 8. " FRC "  "0 ,1 "
bitfld.long 0 9. " SPISFRMEn "  "0 ,1 "
bitfld.long 0 10. " TIDASFRM "  "0 ,1 "
tree.end

base ad:0x63e80024
tree "3CLKREG1"
group 0--3
line.long 0 "CLKREG1"
hexfld.word 0 " CLKPERIOD "
tree.end

tree.end

tree.end

;==============================================================
tree "SSPTB (2 instances)"
;==============================================================
base ad:0x63500000
;********************************************
tree "SSPTB-0"
;********************************************
base ad:0x63500000
tree "0PRE"
group 0--3
line.long 0 "PRE"
hexfld.byte 0 " PRESCALE "
tree.end

base ad:0x63500004
tree "0CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " FRF "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " ENABLE "  "0 ,1 "
hexfld.byte 1 " SCR "
tree.end

base ad:0x63500008
tree "0CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " SPO "  "0 ,1 "
bitfld.long 0 1. " SPH "  "0 ,1 "
bitfld.long 0 2.--3. " RXW "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MS "  "0 ,1 "
bitfld.long 0 5. " OD "  "0 ,1 "
tree.end

base ad:0x6350000c
tree "0TDR"
group 0--3
line.long 0 "TDR"
hexfld.word 0 " DATA "
tree.end

base ad:0x63500010
tree "0RDR"
group 0--3
line.long 0 "RDR"
hexfld.word 0 " DATA "
tree.end

base ad:0x63500014
tree "0SR"
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXFF "  "0 ,1 "
bitfld.long 0 2. " TXFE "  "0 ,1 "
bitfld.long 0 3. " TXFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
bitfld.long 0 5. " SSPINT "  "0 ,1 "
bitfld.long 0 6. " RXWFLG "  "0 ,1 "
bitfld.long 0 7. " RFSFLG "  "0 ,1 "
bitfld.long 0 8. " TFSFLG "  "0 ,1 "
bitfld.long 0 9. " RORFLG "  "0 ,1 "
bitfld.long 0 10. " PCLKON "  "0 ,1 "
bitfld.long 0 11. " REFCLKON "  "0 ,1 "
bitfld.long 0 12. " REFCLK1ON "  "0 ,1 "
tree.end

base ad:0x63500018
tree "0SCANMODE"
group 0--3
line.long 0 "SCANMODE"
bitfld.long 0 0. " SCANMODE "  "0 ,1 "
bitfld.long 0 1. " RSTMODE "  "0 ,1 "
bitfld.long 0 2. " GENCLK "  "0 ,1 "
bitfld.long 0 3. " SSPCLKSEL "  "0 ,1 "
bitfld.long 0 4. " SSPCLK1SEL "  "0 ,1 "
bitfld.long 0 5. " GENCLK1 "  "0 ,1 "
tree.end

base ad:0x6350001c
tree "0CLKREG"
group 0--3
line.long 0 "CLKREG"
hexfld.word 0 " CLKPERIOD "
tree.end

base ad:0x63500020
tree "0CR2"
group 0--3
line.long 0 "CR2"
hexfld.byte 0 " ESFRM "
bitfld.long 0 8. " FRC "  "0 ,1 "
bitfld.long 0 9. " SPISFRMEn "  "0 ,1 "
bitfld.long 0 10. " TIDASFRM "  "0 ,1 "
tree.end

base ad:0x63500024
tree "0CLKREG1"
group 0--3
line.long 0 "CLKREG1"
hexfld.word 0 " CLKPERIOD "
tree.end

tree.end

base ad:0x63580000
;********************************************
tree "SSPTB-1"
;********************************************
base ad:0x63580000
tree "1PRE"
group 0--3
line.long 0 "PRE"
hexfld.byte 0 " PRESCALE "
tree.end

base ad:0x63580004
tree "1CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " FRF "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " ENABLE "  "0 ,1 "
hexfld.byte 1 " SCR "
tree.end

base ad:0x63580008
tree "1CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " SPO "  "0 ,1 "
bitfld.long 0 1. " SPH "  "0 ,1 "
bitfld.long 0 2.--3. " RXW "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MS "  "0 ,1 "
bitfld.long 0 5. " OD "  "0 ,1 "
tree.end

base ad:0x6358000c
tree "1TDR"
group 0--3
line.long 0 "TDR"
hexfld.word 0 " DATA "
tree.end

base ad:0x63580010
tree "1RDR"
group 0--3
line.long 0 "RDR"
hexfld.word 0 " DATA "
tree.end

base ad:0x63580014
tree "1SR"
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXFF "  "0 ,1 "
bitfld.long 0 2. " TXFE "  "0 ,1 "
bitfld.long 0 3. " TXFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
bitfld.long 0 5. " SSPINT "  "0 ,1 "
bitfld.long 0 6. " RXWFLG "  "0 ,1 "
bitfld.long 0 7. " RFSFLG "  "0 ,1 "
bitfld.long 0 8. " TFSFLG "  "0 ,1 "
bitfld.long 0 9. " RORFLG "  "0 ,1 "
bitfld.long 0 10. " PCLKON "  "0 ,1 "
bitfld.long 0 11. " REFCLKON "  "0 ,1 "
bitfld.long 0 12. " REFCLK1ON "  "0 ,1 "
tree.end

base ad:0x63580018
tree "1SCANMODE"
group 0--3
line.long 0 "SCANMODE"
bitfld.long 0 0. " SCANMODE "  "0 ,1 "
bitfld.long 0 1. " RSTMODE "  "0 ,1 "
bitfld.long 0 2. " GENCLK "  "0 ,1 "
bitfld.long 0 3. " SSPCLKSEL "  "0 ,1 "
bitfld.long 0 4. " SSPCLK1SEL "  "0 ,1 "
bitfld.long 0 5. " GENCLK1 "  "0 ,1 "
tree.end

base ad:0x6358001c
tree "1CLKREG"
group 0--3
line.long 0 "CLKREG"
hexfld.word 0 " CLKPERIOD "
tree.end

base ad:0x63580020
tree "1CR2"
group 0--3
line.long 0 "CR2"
hexfld.byte 0 " ESFRM "
bitfld.long 0 8. " FRC "  "0 ,1 "
bitfld.long 0 9. " SPISFRMEn "  "0 ,1 "
bitfld.long 0 10. " TIDASFRM "  "0 ,1 "
tree.end

base ad:0x63580024
tree "1CLKREG1"
group 0--3
line.long 0 "CLKREG1"
hexfld.word 0 " CLKPERIOD "
tree.end

tree.end

tree.end

;==============================================================
tree "STM"
;==============================================================
base ad:0x9002f000
tree "CR_L"
group 0--3
line.long 0 "CR_L"
bitfld.long 0 0. " PLP0 "  "0 ,1 "
bitfld.long 0 1. " PLP1 "  "0 ,1 "
bitfld.long 0 2. " PLP2 "  "0 ,1 "
bitfld.long 0 3. " TSnTS "  "0 ,1 "
bitfld.long 0 4.--5. " DWNG "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--8. " XCKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9. " SWAP_PRCMU "  "0 ,1 "
tree.end

base ad:0x9002f004
tree "CR_H"
group 0--3
line.long 0 "CR_H"
tree.end

base ad:0x9002f008
tree "MMCR_L"
group 0--3
line.long 0 "MMCR_L"
bitfld.long 0 0. " HWnSW0 "  "0 ,1 "
bitfld.long 0 1. " HWnSW1 "  "0 ,1 "
bitfld.long 0 2. " HWnSW2 "  "0 ,1 "
bitfld.long 0 3. " HWnSW3 "  "0 ,1 "
bitfld.long 0 4. " HWnSW4 "  "0 ,1 "
bitfld.long 0 5. " HWnSW5 "  "0 ,1 "
tree.end

base ad:0x9002f00c
tree "MMCR_H"
group 0--3
line.long 0 "MMCR_H"
tree.end

base ad:0x9002f010
tree "TER_L"
group 0--3
line.long 0 "TER_L"
bitfld.long 0 0. " TE0 "  "0 ,1 "
bitfld.long 0 2. " TE2 "  "0 ,1 "
bitfld.long 0 3. " TE3 "  "0 ,1 "
bitfld.long 0 4. " TE4 "  "0 ,1 "
bitfld.long 0 5. " TE5 "  "0 ,1 "
bitfld.long 0 9. " TE9 "  "0 ,1 "
tree.end

base ad:0x9002f014
tree "TER_H"
group 0--3
line.long 0 "TER_H"
tree.end

base ad:0x9002f018
tree "OFSR_L"
rgroup 0--3
line.long 0 "OFSR_L"
bitfld.long 0 0. " ovF0 "  "0 ,1 "
bitfld.long 0 1. " ovF1 "  "0 ,1 "
bitfld.long 0 2. " ovF2 "  "0 ,1 "
bitfld.long 0 3. " ovF3 "  "0 ,1 "
bitfld.long 0 4. " ovF4 "  "0 ,1 "
bitfld.long 0 5. " ovF5 "  "0 ,1 "
bitfld.long 0 9. " ovF9 "  "0 ,1 "
bitfld.long 0 10. " SecTrej "  "0 ,1 "
bitfld.long 0 11. " DecErr "  "0 ,1 "
bitfld.long 0 12.--16. " AddrErr "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x9002f01c
tree "OFSR_H"
rgroup 0--3
line.long 0 "OFSR_H"
tree.end

base ad:0x9002f020
tree "TFSR_L"
rgroup 0--3
line.long 0 "TFSR_L"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TFF "  "0 ,1 "
bitfld.long 0 2. " PRCME "  "0 ,1 "
bitfld.long 0 3. " PRCMF "  "0 ,1 "
bitfld.long 0 4. " CHGCFG "  "0 ,1 "
tree.end

base ad:0x9002f024
tree "TFSR_H"
rgroup 0--3
line.long 0 "TFSR_H"
tree.end

base ad:0x9002f028
tree "SBSR_L"
rgroup 0--3
line.long 0 "SBSR_L"
bitfld.long 0 0. " SBFE "  "0 ,1 "
bitfld.long 0 1. " SBFF "  "0 ,1 "
bitfld.long 0 2. " SBOv "  "0 ,1 "
bitfld.long 0 3.--7. " SBOvNb "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x9002f02c
tree "SBSR_H"
rgroup 0--3
line.long 0 "SBSR_H"
tree.end

base ad:0x9002f040
tree "TSR_L"
rgroup 0--3
line.long 0 "TSR_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " Stamp "  "0 ,1 "
bitfld.long 0 2. " Time "  "0 ,1 "
tree.end

base ad:0x9002f044
tree "TSR_H"
rgroup 0--3
line.long 0 "TSR_H"
tree.end

base ad:0x9002f048
tree "SCCR_L"
group 0--3
line.long 0 "SCCR_L"
hexfld.long 0 " SCC "
tree.end

base ad:0x9002f04c
tree "SCCR_H"
group 0--3
line.long 0 "SCCR_H"
tree.end

base ad:0x9002f030
tree "DBG_L"
group 0--3
line.long 0 "DBG_L"
bitfld.long 0 0. " DBGEn "  "0 ,1 "
bitfld.long 0 1. " DBGM "  "0 ,1 "
bitfld.long 0 3.--5. " PTICSSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--10. " FTFSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 12. " FSBFF "  "0 ,1 "
bitfld.long 0 16.--24. " PTI_State "  " "
tree.end

base ad:0x9002f034
tree "DBG_H"
group 0--3
line.long 0 "DBG_H"
tree.end

base ad:0x9002ffc0
tree "PeriphlD0_L"
rgroup 0--3
line.long 0 "PeriphlD0_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " PartNumber0 "  "0 ,1 "
tree.end

base ad:0x9002ffc4
tree "PeriphlD0_H"
rgroup 0--3
line.long 0 "PeriphlD0_H"
tree.end

base ad:0x9002ffc8
tree "PeriphlD1_L"
rgroup 0--3
line.long 0 "PeriphlD1_L"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x9002ffcc
tree "PeriphlD1_H"
rgroup 0--3
line.long 0 "PeriphlD1_H"
tree.end

base ad:0x9002ffd0
tree "PeriphlD2_L"
rgroup 0--3
line.long 0 "PeriphlD2_L"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x9002ffd4
tree "PeriphlD2_H"
rgroup 0--3
line.long 0 "PeriphlD2_H"
tree.end

base ad:0x9002ffd8
tree "PeriphlD3_L"
rgroup 0--3
line.long 0 "PeriphlD3_L"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x9002ffdc
tree "PeriphD3_H"
rgroup 0--3
line.long 0 "PeriphD3_H"
tree.end

base ad:0x9002ffe0
tree "PCelllD0_L"
rgroup 0--3
line.long 0 "PCelllD0_L"
hexfld.byte 0 " STMPCelllD0 "
tree.end

base ad:0x9002ffe4
tree "PCelllD0_H"
rgroup 0--3
line.long 0 "PCelllD0_H"
tree.end

base ad:0x9002ffe8
tree "PCelllD1_L"
rgroup 0--3
line.long 0 "PCelllD1_L"
hexfld.byte 0 " STMPCelllD1 "
tree.end

base ad:0x9002ffec
tree "PCelllD1_H"
rgroup 0--3
line.long 0 "PCelllD1_H"
tree.end

base ad:0x9002fff0
tree "PCelllD2_L"
rgroup 0--3
line.long 0 "PCelllD2_L"
hexfld.byte 0 " STMPCelllD2 "
tree.end

base ad:0x9002fff4
tree "PCelllD2_H"
rgroup 0--3
line.long 0 "PCelllD2_H"
tree.end

base ad:0x9002fff8
tree "PCelllD3_L"
rgroup 0--3
line.long 0 "PCelllD3_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " STMPCelllD3 "  "0 ,1 "
tree.end

base ad:0x9002fffc
tree "PCelllD3_H"
rgroup 0--3
line.long 0 "PCelllD3_H"
tree.end

tree.end

;==============================================================
tree "THSENS"
;==============================================================
base ad:0x801573c0
tree "THSENS_CTRL"
group 0--3
line.long 0 "THSENS_CTRL"
bitfld.long 0 0. " START "  "0 ,1 "
tree.end

base ad:0x801573c4
tree "THSENS_STATUS"
rgroup 0--3
line.long 0 "THSENS_STATUS"
bitfld.long 0 0.--3. " DATA_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " OVERFLOW "  "0 ,1 "
bitfld.long 0 5. " IT_STATUS "  "0 ,1 "
bitfld.long 0 6. " RUN "  "0 ,1 "
tree.end

base ad:0x801573c8
tree "THSENS_IT_CLR"
wgroup 0--3
line.long 0 "THSENS_IT_CLR"
bitfld.long 0 0. " IT_CLR "  "0 ,1 "
tree.end

base ad:0x801573cc
tree "THSENS_CLKDIV"
group 0--3
line.long 0 "THSENS_CLKDIV"
hexfld.byte 0 " CLKDIV "
tree.end

base ad:0x801573d0
tree "THSENS_DCORRECT"
group 0--3
line.long 0 "THSENS_DCORRECT"
bitfld.long 0 0.--4. " DCORRECT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0x801573d4
tree "THSENS_TEMP"
rgroup 0--3
line.long 0 "THSENS_TEMP"
bitfld.long 0 0.--6. " DATA "  " "
bitfld.long 0 7. " OVERFLOW "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "TIMER (2 instances)"
;==============================================================
base ad:0x80126000
;********************************************
tree "TIMER-0"
;********************************************
base ad:0x80126000
tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " T0IM "  "0 ,1 "
bitfld.long 0 1. " T1IM "  "0 ,1 "
bitfld.long 0 2. " T2IM "  "0 ,1 "
bitfld.long 0 3. " T3IM "  "0 ,1 "
tree.end

base ad:0x80126004
tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " T0RIS "  "0 ,1 "
bitfld.long 0 1. " T1RIS "  "0 ,1 "
bitfld.long 0 2. " T2RIS "  "0 ,1 "
bitfld.long 0 3. " T3RIS "  "0 ,1 "
tree.end

base ad:0x80126008
tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " T0MIS "  "0 ,1 "
bitfld.long 0 1. " T1MIS "  "0 ,1 "
bitfld.long 0 2. " T2MIS "  "0 ,1 "
bitfld.long 0 3. " T3MIS "  "0 ,1 "
tree.end

base ad:0x8012600c
tree "0ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " T0IC "  "0 ,1 "
bitfld.long 0 1. " T1IC "  "0 ,1 "
bitfld.long 0 2. " T2IC "  "0 ,1 "
bitfld.long 0 3. " T3IC "  "0 ,1 "
tree.end

base ad:0x80126010
tree "0T0LR"
group 0--3
line.long 0 "T0LR"
hexfld.long 0 " T0LOAD "
tree.end

base ad:0x80126014
tree "0T0VAL"
rgroup 0--3
line.long 0 "T0VAL"
tree.end

base ad:0x80126018
tree "0T0CR"
group 0--3
line.long 0 "T0CR"
bitfld.long 0 0. " T0OS "  "0 ,1 "
bitfld.long 0 1. " T0SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T0PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T0MOD "  "0 ,1 "
bitfld.long 0 7. " T0En "  "0 ,1 "
tree.end

base ad:0x8012601c
tree "0T0BGLR"
group 0--3
line.long 0 "T0BGLR"
bitfld.long 0 0. " T0BGLOAD "  "0 ,1 "
tree.end

base ad:0x80126020
tree "0T1LR"
group 0--3
line.long 0 "T1LR"
hexfld.long 0 " T1LOAD "
tree.end

base ad:0x80126024
tree "0T1VAL"
rgroup 0--3
line.long 0 "T1VAL"
tree.end

base ad:0x80126028
tree "0T1CR"
group 0--3
line.long 0 "T1CR"
bitfld.long 0 0. " T1OS "  "0 ,1 "
bitfld.long 0 1. " T1SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T1PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T1MOD "  "0 ,1 "
bitfld.long 0 7. " T1En "  "0 ,1 "
tree.end

base ad:0x8012602c
tree "0T1BGLR"
group 0--3
line.long 0 "T1BGLR"
bitfld.long 0 0. " T1BGLOAD "  "0 ,1 "
tree.end

base ad:0x80126030
tree "0T2LR"
group 0--3
line.long 0 "T2LR"
hexfld.long 0 " T2LOAD "
tree.end

base ad:0x80126034
tree "0T2VAL"
rgroup 0--3
line.long 0 "T2VAL"
tree.end

base ad:0x80126038
tree "0T2CR"
group 0--3
line.long 0 "T2CR"
bitfld.long 0 0. " T2OS "  "0 ,1 "
bitfld.long 0 1. " T2SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T2PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T2MOD "  "0 ,1 "
bitfld.long 0 7. " T2En "  "0 ,1 "
tree.end

base ad:0x8012603c
tree "0T2BGLR"
group 0--3
line.long 0 "T2BGLR"
bitfld.long 0 0. " T2BGLOAD "  "0 ,1 "
tree.end

base ad:0x80126040
tree "0T3LR"
group 0--3
line.long 0 "T3LR"
hexfld.long 0 " T3LOAD "
tree.end

base ad:0x80126044
tree "0T3VAL"
rgroup 0--3
line.long 0 "T3VAL"
tree.end

base ad:0x80126048
tree "0T3CR"
group 0--3
line.long 0 "T3CR"
bitfld.long 0 0. " T3OS "  "0 ,1 "
bitfld.long 0 1. " T3SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T3PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T3MOD "  "0 ,1 "
bitfld.long 0 7. " T3En "  "0 ,1 "
tree.end

base ad:0x8012604c
tree "0T3BGLR"
group 0--3
line.long 0 "T3BGLR"
bitfld.long 0 0. " T3BGLOAD "  "0 ,1 "
tree.end

base ad:0x80126f00
tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITME "  "0 ,1 "
tree.end

base ad:0x80126f04
tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " INTCT0 "  "0 ,1 "
bitfld.long 0 1. " INTCT1 "  "0 ,1 "
bitfld.long 0 2. " INTCT2 "  "0 ,1 "
bitfld.long 0 3. " INTCT3 "  "0 ,1 "
tree.end

base ad:0x80126fe0
tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x80126fe4
tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80126fe8
tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80126fec
tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80126ff0
tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " MTUPCellID0 "
tree.end

base ad:0x80126ff4
tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " MTUPCellID1 "
tree.end

base ad:0x80126ff8
tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " MTUPCellID2 "
tree.end

base ad:0x80126ffc
tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " MTUPCellID3 "
tree.end

tree.end

base ad:0x80127000
;********************************************
tree "TIMER-1"
;********************************************
base ad:0x80127000
tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " T0IM "  "0 ,1 "
bitfld.long 0 1. " T1IM "  "0 ,1 "
bitfld.long 0 2. " T2IM "  "0 ,1 "
bitfld.long 0 3. " T3IM "  "0 ,1 "
tree.end

base ad:0x80127004
tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " T0RIS "  "0 ,1 "
bitfld.long 0 1. " T1RIS "  "0 ,1 "
bitfld.long 0 2. " T2RIS "  "0 ,1 "
bitfld.long 0 3. " T3RIS "  "0 ,1 "
tree.end

base ad:0x80127008
tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " T0MIS "  "0 ,1 "
bitfld.long 0 1. " T1MIS "  "0 ,1 "
bitfld.long 0 2. " T2MIS "  "0 ,1 "
bitfld.long 0 3. " T3MIS "  "0 ,1 "
tree.end

base ad:0x8012700c
tree "1ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " T0IC "  "0 ,1 "
bitfld.long 0 1. " T1IC "  "0 ,1 "
bitfld.long 0 2. " T2IC "  "0 ,1 "
bitfld.long 0 3. " T3IC "  "0 ,1 "
tree.end

base ad:0x80127010
tree "1T0LR"
group 0--3
line.long 0 "T0LR"
hexfld.long 0 " T0LOAD "
tree.end

base ad:0x80127014
tree "1T0VAL"
rgroup 0--3
line.long 0 "T0VAL"
tree.end

base ad:0x80127018
tree "1T0CR"
group 0--3
line.long 0 "T0CR"
bitfld.long 0 0. " T0OS "  "0 ,1 "
bitfld.long 0 1. " T0SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T0PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T0MOD "  "0 ,1 "
bitfld.long 0 7. " T0En "  "0 ,1 "
tree.end

base ad:0x8012701c
tree "1T0BGLR"
group 0--3
line.long 0 "T0BGLR"
bitfld.long 0 0. " T0BGLOAD "  "0 ,1 "
tree.end

base ad:0x80127020
tree "1T1LR"
group 0--3
line.long 0 "T1LR"
hexfld.long 0 " T1LOAD "
tree.end

base ad:0x80127024
tree "1T1VAL"
rgroup 0--3
line.long 0 "T1VAL"
tree.end

base ad:0x80127028
tree "1T1CR"
group 0--3
line.long 0 "T1CR"
bitfld.long 0 0. " T1OS "  "0 ,1 "
bitfld.long 0 1. " T1SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T1PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T1MOD "  "0 ,1 "
bitfld.long 0 7. " T1En "  "0 ,1 "
tree.end

base ad:0x8012702c
tree "1T1BGLR"
group 0--3
line.long 0 "T1BGLR"
bitfld.long 0 0. " T1BGLOAD "  "0 ,1 "
tree.end

base ad:0x80127030
tree "1T2LR"
group 0--3
line.long 0 "T2LR"
hexfld.long 0 " T2LOAD "
tree.end

base ad:0x80127034
tree "1T2VAL"
rgroup 0--3
line.long 0 "T2VAL"
tree.end

base ad:0x80127038
tree "1T2CR"
group 0--3
line.long 0 "T2CR"
bitfld.long 0 0. " T2OS "  "0 ,1 "
bitfld.long 0 1. " T2SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T2PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T2MOD "  "0 ,1 "
bitfld.long 0 7. " T2En "  "0 ,1 "
tree.end

base ad:0x8012703c
tree "1T2BGLR"
group 0--3
line.long 0 "T2BGLR"
bitfld.long 0 0. " T2BGLOAD "  "0 ,1 "
tree.end

base ad:0x80127040
tree "1T3LR"
group 0--3
line.long 0 "T3LR"
hexfld.long 0 " T3LOAD "
tree.end

base ad:0x80127044
tree "1T3VAL"
rgroup 0--3
line.long 0 "T3VAL"
tree.end

base ad:0x80127048
tree "1T3CR"
group 0--3
line.long 0 "T3CR"
bitfld.long 0 0. " T3OS "  "0 ,1 "
bitfld.long 0 1. " T3SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T3PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T3MOD "  "0 ,1 "
bitfld.long 0 7. " T3En "  "0 ,1 "
tree.end

base ad:0x8012704c
tree "1T3BGLR"
group 0--3
line.long 0 "T3BGLR"
bitfld.long 0 0. " T3BGLOAD "  "0 ,1 "
tree.end

base ad:0x80127f00
tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITME "  "0 ,1 "
tree.end

base ad:0x80127f04
tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " INTCT0 "  "0 ,1 "
bitfld.long 0 1. " INTCT1 "  "0 ,1 "
bitfld.long 0 2. " INTCT2 "  "0 ,1 "
bitfld.long 0 3. " INTCT3 "  "0 ,1 "
tree.end

base ad:0x80127fe0
tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x80127fe4
tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80127fe8
tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80127fec
tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80127ff0
tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " MTUPCellID0 "
tree.end

base ad:0x80127ff4
tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " MTUPCellID1 "
tree.end

base ad:0x80127ff8
tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " MTUPCellID2 "
tree.end

base ad:0x80127ffc
tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " MTUPCellID3 "
tree.end

tree.end

tree.end

;==============================================================
tree "UART (4 instances)"
;==============================================================
base ad:0xa0023000
;********************************************
tree "UART-0"
;********************************************
base ad:0xa0023000
tree "0DR"
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
tree.end

base ad:0xa0023004
tree "0RSR_ECR"
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
tree.end

base ad:0xa0023008
tree "0DMAWM"
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa002300c
tree "0TIMEOUT"
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0. " TIMEOUT_PERIOD "  "0 ,1 "
tree.end

base ad:0xa0023018
tree "0FR"
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
tree.end

base ad:0xa002301c
tree "0LCRH_RX"
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
tree.end

base ad:0xa0023020
tree "0ILPR"
group 0--3
line.long 0 "ILPR"
hexfld.byte 0 " ILPDVSR "
tree.end

base ad:0xa0023024
tree "0IBRD"
group 0--3
line.long 0 "IBRD"
hexfld.word 0 " DIVINT "
tree.end

base ad:0xa0023028
tree "0FBRD"
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa002302c
tree "0LCRH_TX"
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
tree.end

base ad:0xa0023030
tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
tree.end

base ad:0xa0023034
tree "0IFLS"
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0023038
tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
tree.end

base ad:0xa002303c
tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
tree.end

base ad:0xa0023040
tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
tree.end

base ad:0xa0023044
tree "0ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
tree.end

base ad:0xa0023048
tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
tree.end

base ad:0xa0023050
tree "0XFCR"
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
tree.end

base ad:0xa0023054
tree "0XON1"
group 0--3
line.long 0 "XON1"
hexfld.byte 0 " XON1 "
tree.end

base ad:0xa0023058
tree "0XON2"
group 0--3
line.long 0 "XON2"
hexfld.byte 0 " XON2 "
tree.end

base ad:0xa002305c
tree "0XOFF1"
group 0--3
line.long 0 "XOFF1"
hexfld.byte 0 " XOFF1 "
tree.end

base ad:0xa0023060
tree "0XOFF2"
group 0--3
line.long 0 "XOFF2"
hexfld.byte 0 " XOFF2 "
tree.end

base ad:0xa0023080
tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0xa0023084
tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
tree.end

base ad:0xa0023088
tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
tree.end

base ad:0xa002308c
tree "0TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
tree.end

base ad:0xa0023100
tree "0ABCR"
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
tree.end

base ad:0xa0023104
tree "0ABSR"
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " BYTE1S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
tree.end

base ad:0xa0023108
tree "0ABFMT"
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0023150
tree "0ABDR"
rgroup 0--3
line.long 0 "ABDR"
hexfld.word 0 " AUTOBAUDBDR "
tree.end

base ad:0xa0023154
tree "0ABDFR"
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0xa0023158
tree "0ABMR"
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
tree.end

base ad:0xa002315c
tree "0ABIMSC"
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
tree.end

base ad:0xa0023160
tree "0ABRIS"
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
tree.end

base ad:0xa0023164
tree "0ABMIS"
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
tree.end

base ad:0xa0023168
tree "0ABICR"
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
tree.end

base ad:0xa0023fe0
tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0xa0023fe4
tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0023fe8
tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0023fec
tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0xa0023ff0
tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " IDO "
tree.end

base ad:0xa0023ff4
tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " ID1 "
tree.end

base ad:0xa0023ff8
tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " ID2 "
tree.end

base ad:0xa0023ffc
tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " ID3 "
tree.end

tree.end

base ad:0x80104000
;********************************************
tree "UART-1"
;********************************************
base ad:0x80104000
tree "1DR"
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
tree.end

base ad:0x80104004
tree "1RSR_ECR"
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
tree.end

base ad:0x80104008
tree "1DMAWM"
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8010400c
tree "1TIMEOUT"
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0. " TIMEOUT_PERIOD "  "0 ,1 "
tree.end

base ad:0x80104018
tree "1FR"
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
tree.end

base ad:0x8010401c
tree "1LCRH_RX"
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
tree.end

base ad:0x80104020
tree "1ILPR"
group 0--3
line.long 0 "ILPR"
hexfld.byte 0 " ILPDVSR "
tree.end

base ad:0x80104024
tree "1IBRD"
group 0--3
line.long 0 "IBRD"
hexfld.word 0 " DIVINT "
tree.end

base ad:0x80104028
tree "1FBRD"
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x8010402c
tree "1LCRH_TX"
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
tree.end

base ad:0x80104030
tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
tree.end

base ad:0x80104034
tree "1IFLS"
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80104038
tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
tree.end

base ad:0x8010403c
tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
tree.end

base ad:0x80104040
tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
tree.end

base ad:0x80104044
tree "1ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
tree.end

base ad:0x80104048
tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
tree.end

base ad:0x80104050
tree "1XFCR"
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
tree.end

base ad:0x80104054
tree "1XON1"
group 0--3
line.long 0 "XON1"
hexfld.byte 0 " XON1 "
tree.end

base ad:0x80104058
tree "1XON2"
group 0--3
line.long 0 "XON2"
hexfld.byte 0 " XON2 "
tree.end

base ad:0x8010405c
tree "1XOFF1"
group 0--3
line.long 0 "XOFF1"
hexfld.byte 0 " XOFF1 "
tree.end

base ad:0x80104060
tree "1XOFF2"
group 0--3
line.long 0 "XOFF2"
hexfld.byte 0 " XOFF2 "
tree.end

base ad:0x80104080
tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0x80104084
tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
tree.end

base ad:0x80104088
tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
tree.end

base ad:0x8010408c
tree "1TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
tree.end

base ad:0x80104100
tree "1ABCR"
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
tree.end

base ad:0x80104104
tree "1ABSR"
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " BYTE1S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
tree.end

base ad:0x80104108
tree "1ABFMT"
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80104150
tree "1ABDR"
rgroup 0--3
line.long 0 "ABDR"
hexfld.word 0 " AUTOBAUDBDR "
tree.end

base ad:0x80104154
tree "1ABDFR"
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x80104158
tree "1ABMR"
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
tree.end

base ad:0x8010415c
tree "1ABIMSC"
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
tree.end

base ad:0x80104160
tree "1ABRIS"
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
tree.end

base ad:0x80104164
tree "1ABMIS"
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
tree.end

base ad:0x80104168
tree "1ABICR"
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
tree.end

base ad:0x80104fe0
tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x80104fe4
tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80104fe8
tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80104fec
tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80104ff0
tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " IDO "
tree.end

base ad:0x80104ff4
tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " ID1 "
tree.end

base ad:0x80104ff8
tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " ID2 "
tree.end

base ad:0x80104ffc
tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " ID3 "
tree.end

tree.end

base ad:0x80105000
;********************************************
tree "UART-2"
;********************************************
base ad:0x80105000
tree "2DR"
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
tree.end

base ad:0x80105004
tree "2RSR_ECR"
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
tree.end

base ad:0x80105008
tree "2DMAWM"
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8010500c
tree "2TIMEOUT"
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0. " TIMEOUT_PERIOD "  "0 ,1 "
tree.end

base ad:0x80105018
tree "2FR"
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
tree.end

base ad:0x8010501c
tree "2LCRH_RX"
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
tree.end

base ad:0x80105020
tree "2ILPR"
group 0--3
line.long 0 "ILPR"
hexfld.byte 0 " ILPDVSR "
tree.end

base ad:0x80105024
tree "2IBRD"
group 0--3
line.long 0 "IBRD"
hexfld.word 0 " DIVINT "
tree.end

base ad:0x80105028
tree "2FBRD"
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x8010502c
tree "2LCRH_TX"
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
tree.end

base ad:0x80105030
tree "2CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
tree.end

base ad:0x80105034
tree "2IFLS"
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80105038
tree "2IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
tree.end

base ad:0x8010503c
tree "2RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
tree.end

base ad:0x80105040
tree "2MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
tree.end

base ad:0x80105044
tree "2ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
tree.end

base ad:0x80105048
tree "2DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
tree.end

base ad:0x80105050
tree "2XFCR"
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
tree.end

base ad:0x80105054
tree "2XON1"
group 0--3
line.long 0 "XON1"
hexfld.byte 0 " XON1 "
tree.end

base ad:0x80105058
tree "2XON2"
group 0--3
line.long 0 "XON2"
hexfld.byte 0 " XON2 "
tree.end

base ad:0x8010505c
tree "2XOFF1"
group 0--3
line.long 0 "XOFF1"
hexfld.byte 0 " XOFF1 "
tree.end

base ad:0x80105060
tree "2XOFF2"
group 0--3
line.long 0 "XOFF2"
hexfld.byte 0 " XOFF2 "
tree.end

base ad:0x80105080
tree "2ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0x80105084
tree "2ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
tree.end

base ad:0x80105088
tree "2ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
tree.end

base ad:0x8010508c
tree "2TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
tree.end

base ad:0x80105100
tree "2ABCR"
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
tree.end

base ad:0x80105104
tree "2ABSR"
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " BYTE1S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
tree.end

base ad:0x80105108
tree "2ABFMT"
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80105150
tree "2ABDR"
rgroup 0--3
line.long 0 "ABDR"
hexfld.word 0 " AUTOBAUDBDR "
tree.end

base ad:0x80105154
tree "2ABDFR"
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x80105158
tree "2ABMR"
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
tree.end

base ad:0x8010515c
tree "2ABIMSC"
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
tree.end

base ad:0x80105160
tree "2ABRIS"
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
tree.end

base ad:0x80105164
tree "2ABMIS"
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
tree.end

base ad:0x80105168
tree "2ABICR"
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
tree.end

base ad:0x80105fe0
tree "2PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x80105fe4
tree "2PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80105fe8
tree "2PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80105fec
tree "2PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80105ff0
tree "2PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " IDO "
tree.end

base ad:0x80105ff4
tree "2PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " ID1 "
tree.end

base ad:0x80105ff8
tree "2PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " ID2 "
tree.end

base ad:0x80105ffc
tree "2PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " ID3 "
tree.end

tree.end

base ad:0x80106000
;********************************************
tree "UART-3"
;********************************************
base ad:0x80106000
tree "3DR"
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
tree.end

base ad:0x80106004
tree "3RSR_ECR"
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
tree.end

base ad:0x80106008
tree "3DMAWM"
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x8010600c
tree "3TIMEOUT"
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0. " TIMEOUT_PERIOD "  "0 ,1 "
tree.end

base ad:0x80106018
tree "3FR"
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
tree.end

base ad:0x8010601c
tree "3LCRH_RX"
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
tree.end

base ad:0x80106020
tree "3ILPR"
group 0--3
line.long 0 "ILPR"
hexfld.byte 0 " ILPDVSR "
tree.end

base ad:0x80106024
tree "3IBRD"
group 0--3
line.long 0 "IBRD"
hexfld.word 0 " DIVINT "
tree.end

base ad:0x80106028
tree "3FBRD"
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x8010602c
tree "3LCRH_TX"
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
tree.end

base ad:0x80106030
tree "3CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
tree.end

base ad:0x80106034
tree "3IFLS"
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0x80106038
tree "3IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
tree.end

base ad:0x8010603c
tree "3RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
tree.end

base ad:0x80106040
tree "3MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
tree.end

base ad:0x80106044
tree "3ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
tree.end

base ad:0x80106048
tree "3DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
tree.end

base ad:0x80106050
tree "3XFCR"
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
tree.end

base ad:0x80106054
tree "3XON1"
group 0--3
line.long 0 "XON1"
hexfld.byte 0 " XON1 "
tree.end

base ad:0x80106058
tree "3XON2"
group 0--3
line.long 0 "XON2"
hexfld.byte 0 " XON2 "
tree.end

base ad:0x8010605c
tree "3XOFF1"
group 0--3
line.long 0 "XOFF1"
hexfld.byte 0 " XOFF1 "
tree.end

base ad:0x80106060
tree "3XOFF2"
group 0--3
line.long 0 "XOFF2"
hexfld.byte 0 " XOFF2 "
tree.end

base ad:0x80106080
tree "3ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base ad:0x80106084
tree "3ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
tree.end

base ad:0x80106088
tree "3ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
tree.end

base ad:0x8010608c
tree "3TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
tree.end

base ad:0x80106100
tree "3ABCR"
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
tree.end

base ad:0x80106104
tree "3ABSR"
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " BYTE1S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
tree.end

base ad:0x80106108
tree "3ABFMT"
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
tree.end

base ad:0x80106150
tree "3ABDR"
rgroup 0--3
line.long 0 "ABDR"
hexfld.word 0 " AUTOBAUDBDR "
tree.end

base ad:0x80106154
tree "3ABDFR"
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
tree.end

base ad:0x80106158
tree "3ABMR"
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
tree.end

base ad:0x8010615c
tree "3ABIMSC"
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
tree.end

base ad:0x80106160
tree "3ABRIS"
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
tree.end

base ad:0x80106164
tree "3ABMIS"
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
tree.end

base ad:0x80106168
tree "3ABICR"
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
tree.end

base ad:0x80106fe0
tree "3PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
tree.end

base ad:0x80106fe4
tree "3PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80106fe8
tree "3PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0x80106fec
tree "3PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
tree.end

base ad:0x80106ff0
tree "3PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " IDO "
tree.end

base ad:0x80106ff4
tree "3PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " ID1 "
tree.end

base ad:0x80106ff8
tree "3PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " ID2 "
tree.end

base ad:0x80106ffc
tree "3PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " ID3 "
tree.end

tree.end

tree.end

;==============================================================
tree "USB"
;==============================================================
base ad:0xa0010000
tree "INTTX_PWR_FADDR"
group 0--3
line.long 0 "INTTX_PWR_FADDR"
bitfld.long 0 0.--6. " FADDR "  " "
bitfld.long 0 8. " SUSPEN "  "0 ,1 "
bitfld.long 0 9. " SUSPM "  "0 ,1 "
bitfld.long 0 10. " RSM "  "0 ,1 "
bitfld.long 0 11. " RST "  "0 ,1 "
bitfld.long 0 12. " HSMD "  "0 ,1 "
bitfld.long 0 13. " HSEN "  "0 ,1 "
bitfld.long 0 14. " SFCN "  "0 ,1 "
bitfld.long 0 15. " ISO_UP "  "0 ,1 "
hexfld.word 2 " EPTX "
tree.end

base ad:0xa0010004
tree "INTTXEN_INTRX"
group 0--3
line.long 0 "INTTXEN_INTRX"
bitfld.long 0 1.--15. " EPRX "  " "
hexfld.word 2 " EPTXEN "
tree.end

base ad:0xa0010008
tree "INTRUSB_INTRXEN"
group 0--3
line.long 0 "INTRUSB_INTRXEN"
bitfld.long 0 1.--15. " EPRXEN "  " "
bitfld.long 0 16. " SUSP "  "0 ,1 "
bitfld.long 0 17. " RES "  "0 ,1 "
bitfld.long 0 18. " RST "  "0 ,1 "
bitfld.long 0 19. " SOF "  "0 ,1 "
bitfld.long 0 20. " CONN "  "0 ,1 "
bitfld.long 0 21. " DISCON "  "0 ,1 "
bitfld.long 0 22. " SESSREQ "  "0 ,1 "
bitfld.long 0 23. " VBERR "  "0 ,1 "
bitfld.long 0 24. " SUSPEN "  "0 ,1 "
bitfld.long 0 25. " RESEN "  "0 ,1 "
bitfld.long 0 26. " RSTEN "  "0 ,1 "
bitfld.long 0 27. " SOFEN "  "0 ,1 "
bitfld.long 0 28. " CONNEN "  "0 ,1 "
bitfld.long 0 29. " DISCONEN "  "0 ,1 "
bitfld.long 0 30. " SESSREDEN "  "0 ,1 "
bitfld.long 0 31. " VBERREN "  "0 ,1 "
tree.end

base ad:0xa001000c
tree "TM_INDX_FMNO"
group 0--3
line.long 0 "TM_INDX_FMNO"
bitfld.long 0 0.--10. " FMNO "  " "
bitfld.long 0 16.--19. " EPNO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24. " TSTNAK "  "0 ,1 "
bitfld.long 0 25. " TSTJ "  "0 ,1 "
bitfld.long 0 26. " TSTK "  "0 ,1 "
bitfld.long 0 27. " TSTPKT "  "0 ,1 "
bitfld.long 0 28. " FHS "  "0 ,1 "
bitfld.long 0 29. " FFS "  "0 ,1 "
bitfld.long 0 30. " FIFOA "  "0 ,1 "
bitfld.long 0 31. " FRH "  "0 ,1 "
tree.end

base ad:0xa0010010
tree "TXCSR_TXMAXP"
group 0--3
line.long 0 "TXCSR_TXMAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TXPKTRDY "  "0 ,1 "
bitfld.long 0 17. " FNOTEM "  "0 ,1 "
bitfld.long 0 18. " ERR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " STPPKT "  "0 ,1 "
bitfld.long 0 21. " RXSTALL "  "0 ,1 "
bitfld.long 0 22. " CLRDTTOG "  "0 ,1 "
bitfld.long 0 23. " INCTX "  "0 ,1 "
bitfld.long 0 24. " DTTOG "  "0 ,1 "
bitfld.long 0 25. " DTTOGW "  "0 ,1 "
bitfld.long 0 26. " DMAREQMD "  "0 ,1 "
bitfld.long 0 27. " FDTTOG "  "0 ,1 "
bitfld.long 0 28. " DMAREQEN "  "0 ,1 "
bitfld.long 0 29. " MODE "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010014
tree "RXCSR_RXMAXP"
group 0--3
line.long 0 "RXCSR_RXMAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RXPKTRDY "  "0 ,1 "
bitfld.long 0 17. " FF "  "0 ,1 "
bitfld.long 0 18. " ERR "  "0 ,1 "
bitfld.long 0 19. " DTERR "  "0 ,1 "
bitfld.long 0 20. " FLUSHF "  "0 ,1 "
bitfld.long 0 21. " REQPKT "  "0 ,1 "
bitfld.long 0 22. " RXSTALL "  "0 ,1 "
bitfld.long 0 23. " CLRDTTOG "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 25. " DTTOG "  "0 ,1 "
bitfld.long 0 26. " DTTOGW "  "0 ,1 "
bitfld.long 0 27. " DMAREQMD "  "0 ,1 "
bitfld.long 0 28. " PIDERR "  "0 ,1 "
bitfld.long 0 29. " DMAREQEN "  "0 ,1 "
bitfld.long 0 30. " AREQ "  "0 ,1 "
bitfld.long 0 31. " ACLR "  "0 ,1 "
tree.end

base ad:0xa0010018
tree "TXIN_TXTYPE_RXCOUNT"
group 0--3
line.long 0 "TXIN_TXTYPE_RXCOUNT"
bitfld.long 0 0.--13. " RXCOUNT "  " "
bitfld.long 0 16.--19. " TEPNO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--21. " PROT "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " SPEED "  "0 ,1 ,2 ,3 "
hexfld.byte 3 " TXPI "
tree.end

base ad:0xa001001c
tree "CFG_RXIN_RXTYPE"
group 0--3
line.long 0 "CFG_RXIN_RXTYPE"
bitfld.long 0 0.--3. " TEP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " PROT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " SPEED "  "0 ,1 ,2 ,3 "
hexfld.byte 1 " RXPI "
bitfld.long 0 24. " UI "  "0 ,1 "
bitfld.long 0 25. " SC "  "0 ,1 "
bitfld.long 0 26. " DYNF "  "0 ,1 "
bitfld.long 0 27. " HBTXE "  "0 ,1 "
bitfld.long 0 28. " HBRXE "  "0 ,1 "
bitfld.long 0 29. " BE "  "0 ,1 "
bitfld.long 0 30. " MPTXE "  "0 ,1 "
bitfld.long 0 31. " MPRXE "  "0 ,1 "
tree.end

base ad:0xa0010020
tree "EP0_FIFO"
group 0--3
line.long 0 "EP0_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa0010024
tree "EP1_FIFO"
group 0--3
line.long 0 "EP1_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa0010028
tree "EP2_FIFO"
group 0--3
line.long 0 "EP2_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa001002c
tree "EP3_FIFO"
group 0--3
line.long 0 "EP3_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa0010030
tree "EP4_FIFO"
group 0--3
line.long 0 "EP4_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa0010034
tree "EP5_FIFO"
group 0--3
line.long 0 "EP5_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa0010038
tree "EP6_FIFO"
group 0--3
line.long 0 "EP6_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa001003c
tree "EP7_FIFO"
group 0--3
line.long 0 "EP7_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa0010040
tree "EP8_FIFO"
group 0--3
line.long 0 "EP8_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa0010044
tree "EP9_FIFO"
group 0--3
line.long 0 "EP9_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa0010048
tree "EP10_FIFO"
group 0--3
line.long 0 "EP10_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa001004c
tree "EP11_FIFO"
group 0--3
line.long 0 "EP11_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa0010050
tree "EP12_FIFO"
group 0--3
line.long 0 "EP12_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa0010054
tree "EP13_FIFO"
group 0--3
line.long 0 "EP13_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa0010058
tree "EP14_FIFO"
group 0--3
line.long 0 "EP14_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa001005c
tree "EP15_FIFO"
group 0--3
line.long 0 "EP15_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa0010060
tree "FIFOSZ_DEVCTL"
group 0--3
line.long 0 "FIFOSZ_DEVCTL"
bitfld.long 0 0. " SESS "  "0 ,1 "
bitfld.long 0 1. " HREQ "  "0 ,1 "
bitfld.long 0 2. " HOST "  "0 ,1 "
bitfld.long 0 3.--4. " VBUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " LSDEV "  "0 ,1 "
bitfld.long 0 6. " FSDEV "  "0 ,1 "
bitfld.long 0 7. " BDEV "  "0 ,1 "
bitfld.long 0 8. " RXEDMA "  "0 ,1 "
bitfld.long 0 9. " TXEDMA "  "0 ,1 "
bitfld.long 0 16.--19. " DPB_TXFSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 23.--26. " DPB_RXFSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0010064
tree "FIFOADDR"
group 0--3
line.long 0 "FIFOADDR"
bitfld.long 0 0.--13. " TXFADDDR "  " "
bitfld.long 0 16.--29. " RXFADDR "  " "
tree.end

base ad:0xa0010068
tree "VCNTL"
group 0--3
line.long 0 "VCNTL"
hexfld.byte 0 " VCNTL "
hexfld.byte 1 " VSTATUS "
tree.end

base ad:0xa001006c
tree "HWVER"
rgroup 0--3
line.long 0 "HWVER"
bitfld.long 0 0.--9. " VMIN "  " "
bitfld.long 0 10.--14. " VMAJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 15. " RC "  "0 ,1 "
tree.end

base ad:0xa0010070
tree "ULPI_1"
group 0--3
line.long 0 "ULPI_1"
bitfld.long 0 0. " EXTVB "  "0 ,1 "
bitfld.long 0 1. " EXTVI "  "0 ,1 "
bitfld.long 0 2. " STP "  "0 ,1 "
bitfld.long 0 8. " CKC_DISU "  "0 ,1 "
bitfld.long 0 9. " CKC_CKACT "  "0 ,1 "
bitfld.long 0 10. " CKC_ALTINT "  "0 ,1 "
bitfld.long 0 11. " CKC_CANCK "  "0 ,1 "
bitfld.long 0 12. " CKC_RXCMD "  "0 ,1 "
bitfld.long 0 13. " CKC_CKAE "  "0 ,1 "
bitfld.long 0 16. " IMASK_REGINT_INEN "  "0 ,1 "
bitfld.long 0 17. " IMASK_ALTINT_INEN "  "0 ,1 "
bitfld.long 0 18. " IMASK_AEND_INEN "  "0 ,1 "
bitfld.long 0 19. " IMASK_RXCMD_IE "  "0 ,1 "
bitfld.long 0 24. " ISRC_REGINT "  "0 ,1 "
bitfld.long 0 25. " ISRC_ALTINT "  "0 ,1 "
bitfld.long 0 26. " ISRC_AENDI "  "0 ,1 "
bitfld.long 0 27. " ISRC_RXCMDI "  "0 ,1 "
tree.end

base ad:0xa0010074
tree "ULPI_2"
group 0--3
line.long 0 "ULPI_2"
hexfld.byte 0 " UREGDATA "
hexfld.byte 1 " UREGADDR "
hexfld.byte 2 " UREGCTRL "
hexfld.byte 3 " URAWDATA "
tree.end

base ad:0xa0010078
tree "EP_INFO"
group 0--7
line.long 0 "EP_INFO"
bitfld.long 0 0.--3. " TXEPINFO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " RXEPINFO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " RAMBITS "
hexfld.byte 2 " DMACH "
bitfld.long 0 24.--27. " WTID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " WTCON "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa001007c
tree "EOF_REG"
group 0--3
line.long 0 "EOF_REG"
hexfld.byte 0 " HSEOF1 "
hexfld.byte 1 " FSEOF1 "
hexfld.byte 2 " LSEOF1 "
bitfld.long 0 24.--25. " SRST "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0010080
tree "TXFUNCADDR_EP0"
group 0--3
line.long 0 "TXFUNCADDR_EP0"
bitfld.long 0 0.--6. " TXADDR0 "  " "
tree.end

base ad:0xa0010088
tree "TXFUNCADDR_EP1"
group 0--3
line.long 0 "TXFUNCADDR_EP1"
bitfld.long 0 0.--6. " TXADDR "  " "
tree.end

base ad:0xa001008c
tree "RXFUNCADDR_EP1"
group 0--3
line.long 0 "RXFUNCADDR_EP1"
bitfld.long 0 0.--6. " RXADDR "  " "
tree.end

base ad:0xa0010090
tree "TXFUNCADDR_EP2"
group 0--3
line.long 0 "TXFUNCADDR_EP2"
bitfld.long 0 0.--6. " TXADDR2 "  " "
tree.end

base ad:0xa0010094
tree "RXFUNCADDR_EP2"
group 0--3
line.long 0 "RXFUNCADDR_EP2"
bitfld.long 0 0.--6. " RXADDR2 "  " "
tree.end

base ad:0xa0010098
tree "TXFUNCADDR_EP3"
group 0--3
line.long 0 "TXFUNCADDR_EP3"
bitfld.long 0 0.--6. " TXADDR3 "  " "
tree.end

base ad:0xa00100a0
tree "RXFUNCADDR_EP3"
group 0--3
line.long 0 "RXFUNCADDR_EP3"
bitfld.long 0 0.--6. " RXADDR3 "  " "
tree.end

base ad:0xa00100a4
tree "TXFUNCADDR_EP4"
group 0--3
line.long 0 "TXFUNCADDR_EP4"
bitfld.long 0 0.--6. " TXADDR4 "  " "
tree.end

base ad:0xa00100a8
tree "RXFUNCADDR_EP4"
group 0--3
line.long 0 "RXFUNCADDR_EP4"
bitfld.long 0 0.--6. " RXADDR4 "  " "
tree.end

base ad:0xa00100ac
tree "TXFUNCADDR_EP5"
group 0--3
line.long 0 "TXFUNCADDR_EP5"
bitfld.long 0 0.--6. " TXADDR5 "  " "
tree.end

base ad:0xa00100b0
tree "RXFUNCADDR_EP5"
group 0--3
line.long 0 "RXFUNCADDR_EP5"
bitfld.long 0 0.--6. " RXADDR5 "  " "
tree.end

base ad:0xa0010200
tree "DMA_INTR"
group 0--3
line.long 0 "DMA_INTR"
bitfld.long 0 0. " DMAINTR "  "0 ,1 "
tree.end

base ad:0xa0010304
tree "EP1_RQPKTCOUNT"
group 0--3
line.long 0 "EP1_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010308
tree "EP2_RQPKTCOUNT"
group 0--3
line.long 0 "EP2_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa001030c
tree "EP3_RQPKTCOUNT"
group 0--3
line.long 0 "EP3_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010310
tree "EP4_RQPKTCOUNT"
group 0--3
line.long 0 "EP4_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010314
tree "EP5_RQPKTCOUNT"
group 0--3
line.long 0 "EP5_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010318
tree "EP6_RQPKTCOUNT"
group 0--3
line.long 0 "EP6_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa001031c
tree "EP7_RQPKTCOUNT"
group 0--3
line.long 0 "EP7_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010320
tree "EP8_RQPKTCOUNT"
group 0--3
line.long 0 "EP8_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010324
tree "EP9_RQPKTCOUNT"
group 0--3
line.long 0 "EP9_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010328
tree "EP10_RQPKTCOUNT"
group 0--3
line.long 0 "EP10_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa001032c
tree "EP11_RQPKTCOUNT"
group 0--3
line.long 0 "EP11_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010330
tree "EP12_RQPKTCOUNT"
group 0--3
line.long 0 "EP12_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010334
tree "EP13_RQPKTCOUNT"
group 0--3
line.long 0 "EP13_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010338
tree "EP14_RQPKTCOUNT"
group 0--3
line.long 0 "EP14_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa001033c
tree "EP15_RQPKTCOUNT"
group 0--3
line.long 0 "EP15_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010340
tree "DPKTBUFDIS"
group 0--3
line.long 0 "DPKTBUFDIS"
bitfld.long 0 1.--15. " EP_RXDIS "  " "
bitfld.long 0 17.--31. " EP_TXDIS "  " "
tree.end

base ad:0xa0010344
tree "C_T_UCH"
group 0--3
line.long 0 "C_T_UCH"
hexfld.word 0 " C_T_UCH "
hexfld.word 2 " C_T_HSRTN "
tree.end

base ad:0xa0010348
tree "C_T_HSBT"
group 0--3
line.long 0 "C_T_HSBT"
bitfld.long 0 0.--3. " HSTADDR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0010360
tree "LPM_ATTR"
group 0--3
line.long 0 "LPM_ATTR"
bitfld.long 0 0.--3. " LINKSTATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " HIRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " RMTWAK "  "0 ,1 "
bitfld.long 0 12.--15. " EP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " LPMXMT "  "0 ,1 "
bitfld.long 0 17. " LPMRES "  "0 ,1 "
bitfld.long 0 18.--19. " LPMEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " LPMNAK "  "0 ,1 "
bitfld.long 0 21. " LPMSTEN "  "0 ,1 "
bitfld.long 0 22. " LPMNYEN "  "0 ,1 "
bitfld.long 0 23. " LPMACKEN "  "0 ,1 "
bitfld.long 0 24. " LPMNCEN "  "0 ,1 "
bitfld.long 0 25. " LPMRESEN "  "0 ,1 "
bitfld.long 0 26. " LPMERREN "  "0 ,1 "
tree.end

base ad:0xa0010364
tree "LPM_INTR"
group 0--3
line.long 0 "LPM_INTR"
bitfld.long 0 0. " LPMST "  "0 ,1 "
bitfld.long 0 1. " LPMNY "  "0 ,1 "
bitfld.long 0 2. " LPMACK "  "0 ,1 "
bitfld.long 0 3. " LPMNC "  "0 ,1 "
bitfld.long 0 4. " LPMRES "  "0 ,1 "
bitfld.long 0 5. " LPMERR "  "0 ,1 "
bitfld.long 0 8.--14. " FADDR "  " "
tree.end

tree.end

;==============================================================
tree "USBOTGM"
;==============================================================
base ad:0xa0010000
tree "INTTX_PWR_FADDR"
group 0--3
line.long 0 "INTTX_PWR_FADDR"
bitfld.long 0 0.--6. " FADDR "  " "
bitfld.long 0 8. " SUSPM "  "0 ,1 "
bitfld.long 0 9. " SUSP "  "0 ,1 "
bitfld.long 0 10. " RSM "  "0 ,1 "
bitfld.long 0 11. " RST "  "0 ,1 "
bitfld.long 0 12. " HSMD "  "0 ,1 "
bitfld.long 0 13. " HSEN "  "0 ,1 "
bitfld.long 0 14. " SFCN "  "0 ,1 "
bitfld.long 0 15. " ISO_UP "  "0 ,1 "
hexfld.word 2 " EPTX "
tree.end

base ad:0xa0010004
tree "INTTXEN_RX"
group 0--3
line.long 0 "INTTXEN_RX"
hexfld.word 0 " EPRX "
hexfld.word 2 " EPTXEN "
tree.end

base ad:0xa0010008
tree "INTRXEN"
group 0--3
line.long 0 "INTRXEN"
hexfld.word 0 " EPRXEN "
hexfld.word 2 " INTUSB "
tree.end

base ad:0xa001000c
tree "TM_INDX_FMNO"
group 0--3
line.long 0 "TM_INDX_FMNO"
bitfld.long 0 0.--10. " FMNO "  " "
bitfld.long 0 16.--19. " EPNO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24. " TSTNAK "  "0 ,1 "
bitfld.long 0 25. " TSTJ "  "0 ,1 "
bitfld.long 0 26. " TSTK "  "0 ,1 "
bitfld.long 0 27. " TSTPKT "  "0 ,1 "
bitfld.long 0 28. " FHS "  "0 ,1 "
bitfld.long 0 29. " FFS "  "0 ,1 "
bitfld.long 0 30. " FIFOA "  "0 ,1 "
bitfld.long 0 31. " FRH "  "0 ,1 "
tree.end

base ad:0xa0010010
tree "INDX_TXCSR"
group 0--3
line.long 0 "INDX_TXCSR"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.word 2 " TXCSR0 "
tree.end

base ad:0xa0010014
tree "INDX_RXCSR"
group 0--3
line.long 0 "INDX_RXCSR"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.word 2 " RXCSR "
tree.end

base ad:0xa0010018
tree "INDX_COUNT0"
group 0--3
line.long 0 "INDX_COUNT0"
bitfld.long 0 0.--12. " RXCOUNT "  " "
bitfld.long 0 13.--16. " EP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--18. " PROT "  "0 ,1 ,2 ,3 "
bitfld.long 0 19.--20. " SPEED "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--28. " TXPI "  " "
tree.end

base ad:0xa001001c
tree "INDX_CFD"
rgroup 0--7
line.long 0 "INDX_CFD"
bitfld.long 0 0.--3. " EP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " PROT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " SPEED "  "0 ,1 ,2 ,3 "
hexfld.byte 2 " RXPI "
bitfld.long 0 20. " UI "  "0 ,1 "
bitfld.long 0 21. " SC "  "0 ,1 "
bitfld.long 0 22. " DYNF "  "0 ,1 "
bitfld.long 0 23. " HBTXE "  "0 ,1 "
bitfld.long 0 24. " HBRXE "  "0 ,1 "
bitfld.long 0 25. " BE "  "0 ,1 "
bitfld.long 0 26. " MPTXE "  "0 ,1 "
bitfld.long 0 27. " MPRXE "  "0 ,1 "
tree.end

base ad:0xa0010020
tree "EP0_FIFO"
group 0--3
line.long 0 "EP0_FIFO"
hexfld.long 0 " FIFO "
tree.end

base ad:0xa0010060
tree "FIFOSZ_DEVCTL"
group 0--3
line.long 0 "FIFOSZ_DEVCTL"
bitfld.long 0 0. " SESS "  "0 ,1 "
bitfld.long 0 1. " HREQ "  "0 ,1 "
bitfld.long 0 2. " HOST "  "0 ,1 "
bitfld.long 0 3.--4. " VBUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " LSDEV "  "0 ,1 "
bitfld.long 0 6. " FSDEV "  "0 ,1 "
bitfld.long 0 7. " BDEV "  "0 ,1 "
bitfld.long 0 8.--11. " TXSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " TXDPB "  "0 ,1 "
bitfld.long 0 16.--19. " RXSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20. " RXDPB "  "0 ,1 "
tree.end

base ad:0xa0010064
tree "FIFOADDR"
group 0--3
line.long 0 "FIFOADDR"
bitfld.long 0 0.--12. " TXAD "  " "
bitfld.long 0 16.--28. " RXAD "  " "
tree.end

base ad:0xa0010068
tree "VCNTL"
rgroup 0--3
line.long 0 "VCNTL"
hexfld.byte 0 " VCNTL "
tree.end

base ad:0xa001006c
tree "HWVER"
rgroup 0--3
line.long 0 "HWVER"
bitfld.long 0 0.--9. " VMIN "  " "
bitfld.long 0 10.--14. " VMAJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 15. " RC "  "0 ,1 "
tree.end

base ad:0xa0010070
tree "ULPI_1"
group 0--3
line.long 0 "ULPI_1"
hexfld.byte 0 " UVBCTRL "
hexfld.byte 1 " UCKIT "
hexfld.byte 2 " UINTMASK "
hexfld.byte 3 " UINT "
tree.end

base ad:0xa0010074
tree "ULPI_2"
group 0--3
line.long 0 "ULPI_2"
hexfld.byte 0 " UREGDATA "
hexfld.byte 1 " UREGADDR "
hexfld.byte 2 " UREGCTRL "
hexfld.byte 3 " URAWDATA "
tree.end

base ad:0xa0010078
tree "INFO_REG"
rgroup 0--3
line.long 0 "INFO_REG"
hexfld.byte 0 " EPINFO "
hexfld.byte 1 " RAMINFO "
hexfld.byte 2 " LINKINFO "
hexfld.byte 3 " VPLEN "
tree.end

base ad:0xa001007c
tree "EOF_REG"
group 0--3
line.long 0 "EOF_REG"
hexfld.byte 0 " HSEOF "
hexfld.byte 1 " FSEOF "
hexfld.byte 2 " LSEOF "
bitfld.long 0 24.--25. " SRST "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0010100
tree "EP0_TXCSR0"
group 0--3
line.long 0 "EP0_TXCSR0"
hexfld.word 2 " TXCSR0 "
tree.end

base ad:0xa0010108
tree "EP0_COUNT0"
rgroup 0--3
line.long 0 "EP0_COUNT0"
bitfld.long 0 0.--6. " RXCOUNT "  " "
tree.end

base ad:0xa001010c
tree "EP0_CFD"
rgroup 0--3
line.long 0 "EP0_CFD"
bitfld.long 0 24. " UI "  "0 ,1 "
bitfld.long 0 25. " SC "  "0 ,1 "
bitfld.long 0 26. " DYNF "  "0 ,1 "
bitfld.long 0 27. " HBTXE "  "0 ,1 "
bitfld.long 0 28. " HBRXE "  "0 ,1 "
bitfld.long 0 29. " BE "  "0 ,1 "
bitfld.long 0 30. " MPTXE "  "0 ,1 "
bitfld.long 0 31. " MPRXE "  "0 ,1 "
tree.end

base ad:0xa0010110
tree "EP1_TXCSR_MAXP"
group 0--3
line.long 0 "EP1_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010114
tree "EP1_RXCSR_MAXP"
group 0--3
line.long 0 "EP1_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010118
tree "EP1_RXCOUNT"
rgroup 0--3
line.long 0 "EP1_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base ad:0xa001011c
tree "EP1_FIFOSZ"
rgroup 0--3
line.long 0 "EP1_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0010120
tree "EP2_TXCSR_MAXP"
group 0--3
line.long 0 "EP2_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010124
tree "EP2_RXCSR_MAXP"
group 0--3
line.long 0 "EP2_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010128
tree "EP2_RXCOUNT"
rgroup 0--3
line.long 0 "EP2_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base ad:0xa001012c
tree "EP2_FIFOSZ"
rgroup 0--3
line.long 0 "EP2_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0010130
tree "EP3_TXCSR_MAXP"
group 0--3
line.long 0 "EP3_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010134
tree "EP3_RXCSR_MAXP"
group 0--3
line.long 0 "EP3_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010138
tree "EP3_RXCOUNT"
rgroup 0--3
line.long 0 "EP3_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base ad:0xa001013c
tree "EP3_FIFOSZ"
rgroup 0--3
line.long 0 "EP3_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0010140
tree "EP4_TXCSR_MAXP"
group 0--3
line.long 0 "EP4_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010144
tree "EP4_RXCSR_MAXP"
group 0--3
line.long 0 "EP4_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010148
tree "EP4_RXCOUNT"
rgroup 0--3
line.long 0 "EP4_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base ad:0xa001014c
tree "EP4_FIFOSZ"
rgroup 0--3
line.long 0 "EP4_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0010150
tree "EP5_TXCSR_MAXP"
group 0--3
line.long 0 "EP5_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010154
tree "EP5_RXCSR_MAXP"
group 0--3
line.long 0 "EP5_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010158
tree "EP5_RXCOUNT"
rgroup 0--3
line.long 0 "EP5_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base ad:0xa001015c
tree "EP5_FIFOSZ"
rgroup 0--3
line.long 0 "EP5_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0010160
tree "EP6_TXCSR_MAXP"
group 0--3
line.long 0 "EP6_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010164
tree "EP6_RXCSR_MAXP"
group 0--3
line.long 0 "EP6_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010168
tree "EP6_RXCOUNT"
rgroup 0--3
line.long 0 "EP6_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base ad:0xa001016c
tree "EP6_FIFOSZ"
rgroup 0--3
line.long 0 "EP6_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0010170
tree "EP7_TXCSR_MAXP"
group 0--3
line.long 0 "EP7_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
