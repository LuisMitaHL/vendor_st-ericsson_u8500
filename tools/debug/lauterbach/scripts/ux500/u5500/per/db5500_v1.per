bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010174
tree "EP7_RXCSR_MAXP"
group 0--3
line.long 0 "EP7_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base ad:0xa0010178
tree "EP7_RXCOUNT"
rgroup 0--3
line.long 0 "EP7_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base ad:0xa001017c
tree "EP7_FIFOSZ"
rgroup 0--3
line.long 0 "EP7_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0010204
tree "TOPCTRL"
group 0--3
line.long 0 "TOPCTRL"
bitfld.long 0 0. " ULPI_ON "  "0 ,1 "
bitfld.long 0 3. " XGATE "  "0 ,1 "
bitfld.long 0 4.--5. " FSINTF "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " HDEV "  "0 ,1 "
bitfld.long 0 7. " VP_DAT "  "0 ,1 "
bitfld.long 0 8. " USEL "  "0 ,1 "
bitfld.long 0 9. " I2C_OFF "  "0 ,1 "
bitfld.long 0 10. " VBUSLO "  "0 ,1 "
tree.end

base ad:0xa0010208
tree "IRQMUX"
group 0--3
line.long 0 "IRQMUX"
hexfld.byte 0 " INTRX "
hexfld.byte 1 " INTTX "
tree.end

base ad:0xa0010300
tree "EP0_RQPKTCOUNT"
group 0--3
line.long 0 "EP0_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010304
tree "EP1_RQPKTCOUNT"
group 0--3
line.long 0 "EP1_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010308
tree "EP2_RQPKTCOUNT"
group 0--3
line.long 0 "EP2_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa001030c
tree "EP3_RQPKTCOUNT"
group 0--3
line.long 0 "EP3_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010310
tree "EP4_RQPKTCOUNT"
group 0--3
line.long 0 "EP4_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010314
tree "EP5_RQPKTCOUNT"
group 0--3
line.long 0 "EP5_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010318
tree "EP6_RQPKTCOUNT"
group 0--3
line.long 0 "EP6_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa001031c
tree "EP7_RQPKTCOUNT"
group 0--3
line.long 0 "EP7_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010320
tree "EP8_RQPKTCOUNT"
group 0--3
line.long 0 "EP8_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010324
tree "EP9_RQPKTCOUNT"
group 0--3
line.long 0 "EP9_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010328
tree "EP10_RQPKTCOUNT"
group 0--3
line.long 0 "EP10_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa001032c
tree "EP11_RQPKTCOUNT"
group 0--3
line.long 0 "EP11_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010330
tree "EP12_RQPKTCOUNT"
group 0--3
line.long 0 "EP12_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010334
tree "EP13_RQPKTCOUNT"
group 0--3
line.long 0 "EP13_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010338
tree "EP14_RQPKTCOUNT"
group 0--3
line.long 0 "EP14_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa001033c
tree "EP15_RQPKTCOUNT"
group 0--3
line.long 0 "EP15_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
tree.end

base ad:0xa0010340
tree "DPKTBUFDIS"
group 0--3
line.long 0 "DPKTBUFDIS"
hexfld.word 0 " EP_RXDIS "
hexfld.word 2 " EP_TXDIS "
tree.end

base ad:0xa0010344
tree "C_T_CTRL"
group 0--3
line.long 0 "C_T_CTRL"
hexfld.word 0 " C_T_UCH_CTRL "
hexfld.word 2 " C_T_HSRTN_CTRL "
tree.end

tree.end

;==============================================================
tree "PL310"
;==============================================================
base ad:0xa0412000
tree "ID"
rgroup 0--3
line.long 0 "ID"
bitfld.long 0 0.--5. " REL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--9. " PART "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10.--15. " ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
hexfld.byte 3 " IMPL "
tree.end

base ad:0xa0412004
tree "Type"
rgroup 0--3
line.long 0 "Type"
bitfld.long 0 0. " ILINELEN "  "0 ,1 "
bitfld.long 0 5. " IASSOC "  "0 ,1 "
bitfld.long 0 6.--10. " ISIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--12. " DLINELEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 17. " DASSOC "  "0 ,1 "
bitfld.long 0 18.--22. " DSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 23. " H "  "0 ,1 "
bitfld.long 0 24.--27. " CTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0412100
tree "Control"
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " EN "  "0 ,1 "
tree.end

base ad:0xa0412104
tree "AuxControl"
group 0--3
line.long 0 "AuxControl"
bitfld.long 0 0. " FLZE "  "0 ,1 "
bitfld.long 0 10. " HPRE "  "0 ,1 "
bitfld.long 0 12. " EXCONF "  "0 ,1 "
bitfld.long 0 13. " SAIE "  "0 ,1 "
bitfld.long 0 16. " ASSOC "  "0 ,1 "
bitfld.long 0 17.--19. " WAYSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " EMBEN "  "0 ,1 "
bitfld.long 0 21. " PAREN "  "0 ,1 "
bitfld.long 0 22. " SAOEN "  "0 ,1 "
bitfld.long 0 23.--24. " FWALLOC "  "0 ,1 ,2 ,3 "
bitfld.long 0 26. " NSLCKEN "  "0 ,1 "
bitfld.long 0 27. " NSIAC "  "0 ,1 "
bitfld.long 0 28. " DPFEN "  "0 ,1 "
bitfld.long 0 29. " IPFEN "  "0 ,1 "
bitfld.long 0 30. " EBRESPEN "  "0 ,1 "
tree.end

base ad:0xa0412108
tree "TagLatControl"
group 0--3
line.long 0 "TagLatControl"
bitfld.long 0 0.--2. " SLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " RLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " WLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa041210c
tree "DataLatControl"
group 0--3
line.long 0 "DataLatControl"
bitfld.long 0 0.--2. " SLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " RLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " WLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
tree.end

base ad:0xa0412200
tree "EventCountControl"
group 0--3
line.long 0 "EventCountControl"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 1.--2. " RES "  "0 ,1 ,2 ,3 "
tree.end

base ad:0xa0412204
tree "EventCount1Conf"
group 0--3
line.long 0 "EventCount1Conf"
bitfld.long 0 0.--1. " EVINTGEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--5. " EVSRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa0412208
tree "EventCount0Conf"
group 0--3
line.long 0 "EventCount0Conf"
bitfld.long 0 0.--1. " EVINTGEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--5. " EVSRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa041220c
tree "EventCount1Value"
group 0--3
line.long 0 "EventCount1Value"
hexfld.long 0 " DATA "
tree.end

base ad:0xa0412210
tree "EventCount0Value"
group 0--3
line.long 0 "EventCount0Value"
hexfld.long 0 " DATA "
tree.end

base ad:0xa0412214
tree "IntMask"
group 0--3
line.long 0 "IntMask"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
tree.end

base ad:0xa0412218
tree "MaskedIntStatus"
rgroup 0--3
line.long 0 "MaskedIntStatus"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
tree.end

base ad:0xa041221c
tree "RawIntStatus"
rgroup 0--3
line.long 0 "RawIntStatus"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
tree.end

base ad:0xa0412220
tree "IntClear"
wgroup 0--3
line.long 0 "IntClear"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
tree.end

base ad:0xa0412730
tree "CacheSync"
group 0--3
line.long 0 "CacheSync"
hexfld.long 0 " SYNC "
tree.end

base ad:0xa0412770
tree "InvalidateLine"
group 0--3
line.long 0 "InvalidateLine"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
tree.end

base ad:0xa041277c
tree "InvalidateByWay"
group 0--3
line.long 0 "InvalidateByWay"
hexfld.word 0 " WAYBITS "
tree.end

base ad:0xa04127b0
tree "CleanLine"
group 0--3
line.long 0 "CleanLine"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
tree.end

base ad:0xa04127b8
tree "CleanLineByWay"
group 0--3
line.long 0 "CleanLineByWay"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 28.--31. " WAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa04127bc
tree "CleanByWay"
group 0--3
line.long 0 "CleanByWay"
hexfld.word 0 " WAYBITS "
tree.end

base ad:0xa04127f0
tree "CleanInvLine"
group 0--3
line.long 0 "CleanInvLine"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
tree.end

base ad:0xa04127f8
tree "CleanInvLineByWay"
group 0--3
line.long 0 "CleanInvLineByWay"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 28.--31. " WAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
tree.end

base ad:0xa04127fc
tree "CleanInvByWay"
group 0--3
line.long 0 "CleanInvByWay"
hexfld.word 0 " WAYBITS "
tree.end

base ad:0xa0412900
tree "DataLockdownByWay_0"
group 0--3
line.long 0 "DataLockdownByWay_0"
hexfld.word 0 " DATALOCK000 "
tree.end

base ad:0xa0412904
tree "InstLockdownByWay_0"
group 0--3
line.long 0 "InstLockdownByWay_0"
hexfld.word 0 " INSTRLOCK000 "
tree.end

base ad:0xa0412908
tree "DataLockdownByWay_1"
group 0--3
line.long 0 "DataLockdownByWay_1"
hexfld.word 0 " DATALOCK001 "
tree.end

base ad:0xa041290c
tree "InstLockdownByWay_1"
group 0--3
line.long 0 "InstLockdownByWay_1"
hexfld.word 0 " INSTRLOCK001 "
tree.end

base ad:0xa0412910
tree "DataLockdownByWay_2"
group 0--3
line.long 0 "DataLockdownByWay_2"
hexfld.word 0 " DATALOCK010 "
tree.end

base ad:0xa0412914
tree "InstLockdownByWay_2"
group 0--3
line.long 0 "InstLockdownByWay_2"
hexfld.word 0 " INSTRLOCK010 "
tree.end

base ad:0xa0412918
tree "DataLockdownByWay_3"
group 0--3
line.long 0 "DataLockdownByWay_3"
hexfld.word 0 " DATALOCK011 "
tree.end

base ad:0xa041291c
tree "InstLockdownByWay_3"
group 0--3
line.long 0 "InstLockdownByWay_3"
hexfld.word 0 " INSTRLOCK011 "
tree.end

base ad:0xa0412920
tree "DataLockdownByWay_4"
group 0--3
line.long 0 "DataLockdownByWay_4"
hexfld.word 0 " DATALOCK100 "
tree.end

base ad:0xa0412924
tree "InstLockdownByWay_4"
group 0--3
line.long 0 "InstLockdownByWay_4"
hexfld.word 0 " INSTRLOCK100 "
tree.end

base ad:0xa0412928
tree "DataLockdownByWay_5"
group 0--3
line.long 0 "DataLockdownByWay_5"
hexfld.word 0 " DATALOCK101 "
tree.end

base ad:0xa041292c
tree "InstLockdownByWay_5"
group 0--3
line.long 0 "InstLockdownByWay_5"
hexfld.word 0 " INSTRLOCK101 "
tree.end

base ad:0xa0412930
tree "DataLockdownByWay_6"
group 0--3
line.long 0 "DataLockdownByWay_6"
hexfld.word 0 " DATALOCK110 "
tree.end

base ad:0xa0412934
tree "InstLockdownByWay_6"
group 0--3
line.long 0 "InstLockdownByWay_6"
hexfld.word 0 " INSTRLOCK110 "
tree.end

base ad:0xa0412938
tree "DataLockdownByWay_7"
group 0--3
line.long 0 "DataLockdownByWay_7"
hexfld.word 0 " DATALOCK111 "
tree.end

base ad:0xa041293c
tree "InstLockdownByWay_7"
group 0--3
line.long 0 "InstLockdownByWay_7"
hexfld.word 0 " INSTRLOCK111 "
tree.end

base ad:0xa0412950
tree "LockdownByLineEnable"
group 0--3
line.long 0 "LockdownByLineEnable"
bitfld.long 0 0. " EN "  "0 ,1 "
tree.end

base ad:0xa0412954
tree "UnlockAllLinesByWay"
group 0--3
line.long 0 "UnlockAllLinesByWay"
hexfld.word 0 " UNLOCK "
tree.end

base ad:0xa0412c00
tree "AddrFilterStart"
group 0--3
line.long 0 "AddrFilterStart"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 20.--31. " AFS "  " "
tree.end

base ad:0xa0412c04
tree "AddrFilterEnd"
group 0--3
line.long 0 "AddrFilterEnd"
bitfld.long 0 20.--31. " AFE "  " "
tree.end

base ad:0xa0412f40
tree "DebugControl"
group 0--3
line.long 0 "DebugControl"
bitfld.long 0 0. " DCL "  "0 ,1 "
bitfld.long 0 1. " DWB "  "0 ,1 "
bitfld.long 0 2. " SPNIDEN "  "0 ,1 "
tree.end

base ad:0xa0412f60
tree "PrefetchOffset"
group 0--3
line.long 0 "PrefetchOffset"
bitfld.long 0 0.--4. " OFFSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
tree.end

base ad:0xa0412f80
tree "PowerControl"
group 0--3
line.long 0 "PowerControl"
bitfld.long 0 0. " STANDBYEN "  "0 ,1 "
bitfld.long 0 1. " DYNCLKGEN "  "0 ,1 "
tree.end

tree.end

