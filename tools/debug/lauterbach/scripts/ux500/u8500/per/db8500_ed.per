;tree.end

base ad:0xA0158756
;tree "DMA_MAX_OPC_SZ11"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ11"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158758
;tree "DMA_MAX_OPC_SZ12"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ12"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015875A
;tree "DMA_MAX_OPC_SZ13"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ13"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015875C
;tree "DMA_MAX_OPC_SZ14"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ14"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015875E
;tree "DMA_MAX_OPC_SZ15"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ15"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158760
;tree "DMA_PRIO_0"
group 0--3
line.long 0 "DMA_PRIO_0"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158762
;tree "DMA_PRIO_1"
group 0--3
line.long 0 "DMA_PRIO_1"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158764
;tree "DMA_PRIO_2"
group 0--3
line.long 0 "DMA_PRIO_2"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158766
;tree "DMA_PRIO_3"
group 0--3
line.long 0 "DMA_PRIO_3"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158768
;tree "DMA_PRIO_4"
group 0--3
line.long 0 "DMA_PRIO_4"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA015876A
;tree "DMA_PRIO_5"
group 0--3
line.long 0 "DMA_PRIO_5"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA015876C
;tree "DMA_PRIO_6"
group 0--3
line.long 0 "DMA_PRIO_6"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA015876E
;tree "DMA_PRIO_7"
group 0--3
line.long 0 "DMA_PRIO_7"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158770
;tree "DMA_PRIO_8"
group 0--3
line.long 0 "DMA_PRIO_8"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158772
;tree "DMA_PRIO_9"
group 0--3
line.long 0 "DMA_PRIO_9"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158774
;tree "DMA_PRIO_10"
group 0--3
line.long 0 "DMA_PRIO_10"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158776
;tree "DMA_PRIO_11"
group 0--3
line.long 0 "DMA_PRIO_11"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158778
;tree "DMA_PRIO_12"
group 0--3
line.long 0 "DMA_PRIO_12"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA015877A
;tree "DMA_PRIO_13"
group 0--3
line.long 0 "DMA_PRIO_13"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA015877C
;tree "DMA_PRIO_14"
group 0--3
line.long 0 "DMA_PRIO_14"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA015877E
;tree "DMA_PRIO_15"
group 0--3
line.long 0 "DMA_PRIO_15"
bitfld.long 0 0.--4. " PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158780
;tree "DMA_MAX_MSSG_SZ0"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ0"
;tree.end

base ad:0xA0158782
;tree "DMA_MAX_MSSG_SZ1"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ1"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158784
;tree "DMA_MAX_MSSG_SZ2"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ2"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158786
;tree "DMA_MAX_MSSG_SZ3"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ3"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158788
;tree "DMA_MAX_MSSG_SZ4"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ4"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015878A
;tree "DMA_MAX_MSSG_SZ5"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ5"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015878C
;tree "DMA_MAX_MSSG_SZ6"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ6"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015878E
;tree "DMA_MAX_MSSG_SZ7"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ7"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158790
;tree "DMA_MAX_MSSG_SZ8"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ8"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158792
;tree "DMA_MAX_MSSG_SZ9"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ9"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158794
;tree "DMA_MAX_MSSG_SZ10"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ10"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158796
;tree "DMA_MAX_MSSG_SZ11"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ11"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158798
;tree "DMA_MAX_MSSG_SZ12"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ12"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015879A
;tree "DMA_MAX_MSSG_SZ13"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ13"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015879C
;tree "DMA_MAX_MSSG_SZ14"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ14"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015879E
;tree "DMA_MAX_MSSG_SZ15"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ15"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587A0
;tree "DMA_MAX_CHCK_SZ0"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ0"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587A2
;tree "DMA_MAX_CHCK_SZ1"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ1"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587A4
;tree "DMA_MAX_CHCK_SZ2"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ2"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587A6
;tree "DMA_MAX_CHCK_SZ3"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ3"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587A8
;tree "DMA_MAX_CHCK_SZ4"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ4"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587AA
;tree "DMA_MAX_CHCK_SZ5"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ5"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587AC
;tree "DMA_MAX_CHCK_SZ6"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ6"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587AE
;tree "DMA_MAX_CHCK_SZ7"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ7"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587B0
;tree "DMA_MAX_CHCK_SZ8"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ8"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587B2
;tree "DMA_MAX_CHCK_SZ9"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ9"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587B4
;tree "DMA_MAX_CHCK_SZ10"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ10"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587B6
;tree "DMA_MAX_CHCK_SZ11"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ11"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587B8
;tree "DMA_MAX_CHCK_SZ12"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ12"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587BA
;tree "DMA_MAX_CHCK_SZ13"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ13"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587BC
;tree "DMA_MAX_CHCK_SZ14"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ14"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587BE
;tree "DMA_MAX_CHCK_SZ15"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ15"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA01587C2
;tree "DMA_MAX_PRI"
group 0--3
line.long 0 "DMA_MAX_PRI"
bitfld.long 0 0.--3. " STBUS_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

endif

endif

tree.end

;==============================================================
tree "TIMER (2 instances)"
;==============================================================
base ad:0xa03da000
;********************************************
tree "TIMER-0"
;********************************************
base ad:0xa03da000
;tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " T0IM "  "0 ,1 "
bitfld.long 0 1. " T1IM "  "0 ,1 "
bitfld.long 0 2. " T2IM "  "0 ,1 "
bitfld.long 0 3. " T3IM "  "0 ,1 "
;tree.end

base ad:0xa03da004
;tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " T0RIS "  "0 ,1 "
bitfld.long 0 1. " T1RIS "  "0 ,1 "
bitfld.long 0 2. " T2RIS "  "0 ,1 "
bitfld.long 0 3. " T3RIS "  "0 ,1 "
;tree.end

base ad:0xa03da008
;tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " T0MIS "  "0 ,1 "
bitfld.long 0 1. " T1MIS "  "0 ,1 "
bitfld.long 0 2. " T2MIS "  "0 ,1 "
bitfld.long 0 3. " T3MIS "  "0 ,1 "
;tree.end

base ad:0xa03da00c
;tree "0ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " T0IC "  "0 ,1 "
bitfld.long 0 1. " T1IC "  "0 ,1 "
bitfld.long 0 2. " T2IC "  "0 ,1 "
bitfld.long 0 3. " T3IC "  "0 ,1 "
;tree.end

base ad:0xa03da010
;tree "0T0LR"
group 0--3
line.long 0 "T0LR"
hexfld.long 0 " T0LOAD "
;tree.end

base ad:0xa03da014
;tree "0T0VAL"
rgroup 0--3
line.long 0 "T0VAL"
;tree.end

base ad:0xa03da018
;tree "0T0CR"
group 0--3
line.long 0 "T0CR"
bitfld.long 0 0. " T0OS "  "0 ,1 "
bitfld.long 0 1. " T0SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T0PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T0MOD "  "0 ,1 "
bitfld.long 0 7. " T0En "  "0 ,1 "
;tree.end

base ad:0xa03da01c
;tree "0T0BGLR"
group 0--3
line.long 0 "T0BGLR"
bitfld.long 0 0. " T0BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03da020
;tree "0T1LR"
group 0--3
line.long 0 "T1LR"
hexfld.long 0 " T1LOAD "
;tree.end

base ad:0xa03da024
;tree "0T1VAL"
rgroup 0--3
line.long 0 "T1VAL"
;tree.end

base ad:0xa03da028
;tree "0T1CR"
group 0--3
line.long 0 "T1CR"
bitfld.long 0 0. " T1OS "  "0 ,1 "
bitfld.long 0 1. " T1SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T1PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T1MOD "  "0 ,1 "
bitfld.long 0 7. " T1En "  "0 ,1 "
;tree.end

base ad:0xa03da02c
;tree "0T1BGLR"
group 0--3
line.long 0 "T1BGLR"
bitfld.long 0 0. " T1BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03da030
;tree "0T2LR"
group 0--3
line.long 0 "T2LR"
hexfld.long 0 " T2LOAD "
;tree.end

base ad:0xa03da034
;tree "0T2VAL"
rgroup 0--3
line.long 0 "T2VAL"
;tree.end

base ad:0xa03da038
;tree "0T2CR"
group 0--3
line.long 0 "T2CR"
bitfld.long 0 0. " T2OS "  "0 ,1 "
bitfld.long 0 1. " T2SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T2PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T2MOD "  "0 ,1 "
bitfld.long 0 7. " T2En "  "0 ,1 "
;tree.end

base ad:0xa03da03c
;tree "0T2BGLR"
group 0--3
line.long 0 "T2BGLR"
bitfld.long 0 0. " T2BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03da040
;tree "0T3LR"
group 0--3
line.long 0 "T3LR"
hexfld.long 0 " T3LOAD "
;tree.end

base ad:0xa03da044
;tree "0T3VAL"
rgroup 0--3
line.long 0 "T3VAL"
;tree.end

base ad:0xa03da048
;tree "0T3CR"
group 0--3
line.long 0 "T3CR"
bitfld.long 0 0. " T3OS "  "0 ,1 "
bitfld.long 0 1. " T3SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T3PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T3MOD "  "0 ,1 "
bitfld.long 0 7. " T3En "  "0 ,1 "
;tree.end

base ad:0xa03da04c
;tree "0T3BGLR"
group 0--3
line.long 0 "T3BGLR"
bitfld.long 0 0. " T3BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03daf00
;tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITME "  "0 ,1 "
;tree.end

base ad:0xa03daf04
;tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " INTCT0 "  "0 ,1 "
bitfld.long 0 1. " INTCT1 "  "0 ,1 "
bitfld.long 0 2. " INTCT2 "  "0 ,1 "
bitfld.long 0 3. " INTCT3 "  "0 ,1 "
;tree.end

base ad:0xa03dafe0
;tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03dafe4
;tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03dafe8
;tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03dafec
;tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03daff0
;tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " MTUPCellID0 "
;tree.end

base ad:0xa03daff4
;tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " MTUPCellID1 "
;tree.end

base ad:0xa03daff8
;tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " MTUPCellID2 "
;tree.end

base ad:0xa03daffc
;tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " MTUPCellID3 "
;tree.end

tree.end

base ad:0xa03db000
;********************************************
tree "TIMER-1"
;********************************************
base ad:0xa03db000
;tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " T0IM "  "0 ,1 "
bitfld.long 0 1. " T1IM "  "0 ,1 "
bitfld.long 0 2. " T2IM "  "0 ,1 "
bitfld.long 0 3. " T3IM "  "0 ,1 "
;tree.end

base ad:0xa03db004
;tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " T0RIS "  "0 ,1 "
bitfld.long 0 1. " T1RIS "  "0 ,1 "
bitfld.long 0 2. " T2RIS "  "0 ,1 "
bitfld.long 0 3. " T3RIS "  "0 ,1 "
;tree.end

base ad:0xa03db008
;tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " T0MIS "  "0 ,1 "
bitfld.long 0 1. " T1MIS "  "0 ,1 "
bitfld.long 0 2. " T2MIS "  "0 ,1 "
bitfld.long 0 3. " T3MIS "  "0 ,1 "
;tree.end

base ad:0xa03db00c
;tree "1ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " T0IC "  "0 ,1 "
bitfld.long 0 1. " T1IC "  "0 ,1 "
bitfld.long 0 2. " T2IC "  "0 ,1 "
bitfld.long 0 3. " T3IC "  "0 ,1 "
;tree.end

base ad:0xa03db010
;tree "1T0LR"
group 0--3
line.long 0 "T0LR"
hexfld.long 0 " T0LOAD "
;tree.end

base ad:0xa03db014
;tree "1T0VAL"
rgroup 0--3
line.long 0 "T0VAL"
;tree.end

base ad:0xa03db018
;tree "1T0CR"
group 0--3
line.long 0 "T0CR"
bitfld.long 0 0. " T0OS "  "0 ,1 "
bitfld.long 0 1. " T0SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T0PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T0MOD "  "0 ,1 "
bitfld.long 0 7. " T0En "  "0 ,1 "
;tree.end

base ad:0xa03db01c
;tree "1T0BGLR"
group 0--3
line.long 0 "T0BGLR"
bitfld.long 0 0. " T0BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03db020
;tree "1T1LR"
group 0--3
line.long 0 "T1LR"
hexfld.long 0 " T1LOAD "
;tree.end

base ad:0xa03db024
;tree "1T1VAL"
rgroup 0--3
line.long 0 "T1VAL"
;tree.end

base ad:0xa03db028
;tree "1T1CR"
group 0--3
line.long 0 "T1CR"
bitfld.long 0 0. " T1OS "  "0 ,1 "
bitfld.long 0 1. " T1SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T1PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T1MOD "  "0 ,1 "
bitfld.long 0 7. " T1En "  "0 ,1 "
;tree.end

base ad:0xa03db02c
;tree "1T1BGLR"
group 0--3
line.long 0 "T1BGLR"
bitfld.long 0 0. " T1BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03db030
;tree "1T2LR"
group 0--3
line.long 0 "T2LR"
hexfld.long 0 " T2LOAD "
;tree.end

base ad:0xa03db034
;tree "1T2VAL"
rgroup 0--3
line.long 0 "T2VAL"
;tree.end

base ad:0xa03db038
;tree "1T2CR"
group 0--3
line.long 0 "T2CR"
bitfld.long 0 0. " T2OS "  "0 ,1 "
bitfld.long 0 1. " T2SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T2PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T2MOD "  "0 ,1 "
bitfld.long 0 7. " T2En "  "0 ,1 "
;tree.end

base ad:0xa03db03c
;tree "1T2BGLR"
group 0--3
line.long 0 "T2BGLR"
bitfld.long 0 0. " T2BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03db040
;tree "1T3LR"
group 0--3
line.long 0 "T3LR"
hexfld.long 0 " T3LOAD "
;tree.end

base ad:0xa03db044
;tree "1T3VAL"
rgroup 0--3
line.long 0 "T3VAL"
;tree.end

base ad:0xa03db048
;tree "1T3CR"
group 0--3
line.long 0 "T3CR"
bitfld.long 0 0. " T3OS "  "0 ,1 "
bitfld.long 0 1. " T3SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T3PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T3MOD "  "0 ,1 "
bitfld.long 0 7. " T3En "  "0 ,1 "
;tree.end

base ad:0xa03db04c
;tree "1T3BGLR"
group 0--3
line.long 0 "T3BGLR"
bitfld.long 0 0. " T3BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03dbf00
;tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITME "  "0 ,1 "
;tree.end

base ad:0xa03dbf04
;tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " INTCT0 "  "0 ,1 "
bitfld.long 0 1. " INTCT1 "  "0 ,1 "
bitfld.long 0 2. " INTCT2 "  "0 ,1 "
bitfld.long 0 3. " INTCT3 "  "0 ,1 "
;tree.end

base ad:0xa03dbfe0
;tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03dbfe4
;tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03dbfe8
;tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03dbfec
;tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03dbff0
;tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " MTUPCellID0 "
;tree.end

base ad:0xa03dbff4
;tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " MTUPCellID1 "
;tree.end

base ad:0xa03dbff8
;tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " MTUPCellID2 "
;tree.end

base ad:0xa03dbffc
;tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " MTUPCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "TZPC1"
;==============================================================
base apb:0xa03dc000
;tree "R0SIZE"
group 0--3
line.long 0 "R0SIZE"
bitfld.long 0 0.--9. " TZPCR0SIZE "  " "
;tree.end

base apb:0xa03dc004
;tree "R0SIZE1"
group 0--3
line.long 0 "R0SIZE1"
bitfld.long 0 0.--9. " TZPCR0SIZE "  " "
;tree.end

base apb:0xa03dc800
;tree "DECPROT0SR"
rgroup 0--3
line.long 0 "DECPROT0SR"
hexfld.byte 0 " DECPROT0STATUS "
;tree.end

base apb:0xa03dc804
;tree "DECPROT0SET"
wgroup 0--3
line.long 0 "DECPROT0SET"
hexfld.byte 0 " DECPROT0SET "
;tree.end

base apb:0xa03dc808
;tree "DECPROT0CL"
wgroup 0--3
line.long 0 "DECPROT0CL"
hexfld.byte 0 " DECPROT0CLEAR "
;tree.end

base apb:0xa03dc80c
;tree "DECPROT1SR"
rgroup 0--3
line.long 0 "DECPROT1SR"
hexfld.byte 0 " DECPROT1STATUS "
;tree.end

base apb:0xa03dc810
;tree "DECPROT1SET"
wgroup 0--3
line.long 0 "DECPROT1SET"
hexfld.byte 0 " DECPROT1SET "
;tree.end

base apb:0xa03dc814
;tree "DECPROT1CL"
wgroup 0--3
line.long 0 "DECPROT1CL"
hexfld.byte 0 " DECPROT1CLEAR "
;tree.end

base apb:0xa03dc818
;tree "DECPROT2SR"
rgroup 0--3
line.long 0 "DECPROT2SR"
hexfld.byte 0 " DECPROT2STATUS "
;tree.end

base apb:0xa03dc81c
;tree "DECPROT2SET"
wgroup 0--3
line.long 0 "DECPROT2SET"
hexfld.byte 0 " DECPROT2SET "
;tree.end

base apb:0xa03dc820
;tree "DECPROT2CL"
wgroup 0--3
line.long 0 "DECPROT2CL"
hexfld.byte 0 " DECPROT2CLEAR "
;tree.end

base apb:0xa03dcfe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base apb:0xa03dcfe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base apb:0xa03dcfe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base apb:0xa03dcfec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base apb:0xa03dcff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " LCDPCellID0 "
;tree.end

base apb:0xa03dcff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " LCDPCellID1 "
;tree.end

base apb:0xa03dcff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " LCDPCellID2 "
;tree.end

base apb:0xa03dcffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " LCDPCellID3 "
;tree.end

tree.end

;==============================================================
tree "UART (3 instances)"
;==============================================================
base ad:0x80120000
;********************************************
tree "UART-0"
;********************************************
base ad:0x80120000
;tree "0DR"
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
;tree.end

base ad:0x80120004
;tree "0RSR_ECR"
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
;tree.end

base ad:0x80120008
;tree "0DMAWM"
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80120018
;tree "0FR"
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
;tree.end

base ad:0x8012001c
;tree "0LCRH_RX"
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
;tree.end

base ad:0x80120020
;tree "0ILPR"
group 0--3
line.long 0 "ILPR"
hexfld.byte 0 " ILPDVSR "
;tree.end

base ad:0x80120024
;tree "0IBRD"
group 0--3
line.long 0 "IBRD"
hexfld.word 0 " DIVINT "
;tree.end

base ad:0x80120028
;tree "0FBRD"
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8012002c
;tree "0LCRH_TX"
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
;tree.end

base ad:0x80120030
;tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
;tree.end

base ad:0x80120034
;tree "0IFLS"
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80120038
;tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
;tree.end

base ad:0x8012003c
;tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
;tree.end

base ad:0x80120040
;tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
;tree.end

base ad:0x80120044
;tree "0ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
;tree.end

base ad:0x80120048
;tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
;tree.end

base ad:0x80120050
;tree "0XFCR"
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
;tree.end

base ad:0x80120054
;tree "0XON1"
group 0--3
line.long 0 "XON1"
hexfld.byte 0 " XON1 "
;tree.end

base ad:0x80120058
;tree "0XON2"
group 0--3
line.long 0 "XON2"
hexfld.byte 0 " XON2 "
;tree.end

base ad:0x8012005c
;tree "0XOFF1"
group 0--3
line.long 0 "XOFF1"
hexfld.byte 0 " XOFF1 "
;tree.end

base ad:0x80120060
;tree "0XOFF2"
group 0--3
line.long 0 "XOFF2"
hexfld.byte 0 " XOFF2 "
;tree.end

base ad:0x80120080
;tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80120084
;tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
;tree.end

base ad:0x80120088
;tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
;tree.end

base ad:0x8012008c
;tree "0TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
;tree.end

base ad:0x80120100
;tree "0ABCR"
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
;tree.end

base ad:0x80120104
;tree "0ABSR"
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " BYTE1S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
;tree.end

base ad:0x80120108
;tree "0ABFMT"
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80120150
;tree "0ABDR"
rgroup 0--3
line.long 0 "ABDR"
hexfld.word 0 " AUTOBAUDBDR "
;tree.end

base ad:0x80120154
;tree "0ABDFR"
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80120158
;tree "0ABMR"
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
;tree.end

base ad:0x8012015c
;tree "0ABIMSC"
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
;tree.end

base ad:0x80120160
;tree "0ABRIS"
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
;tree.end

base ad:0x80120164
;tree "0ABMIS"
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
;tree.end

base ad:0x80120168
;tree "0ABICR"
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
;tree.end

base ad:0x80120fe0
;tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80120fe4
;tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80120fe8
;tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80120fec
;tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80120ff0
;tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " IDO "
;tree.end

base ad:0x80120ff4
;tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " ID1 "
;tree.end

base ad:0x80120ff8
;tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " ID2 "
;tree.end

base ad:0x80120ffc
;tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " ID3 "
;tree.end

tree.end

base ad:0x80121000
;********************************************
tree "UART-1"
;********************************************
base ad:0x80121000
;tree "1DR"
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
;tree.end

base ad:0x80121004
;tree "1RSR_ECR"
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
;tree.end

base ad:0x80121008
;tree "1DMAWM"
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80121018
;tree "1FR"
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
;tree.end

base ad:0x8012101c
;tree "1LCRH_RX"
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
;tree.end

base ad:0x80121020
;tree "1ILPR"
group 0--3
line.long 0 "ILPR"
hexfld.byte 0 " ILPDVSR "
;tree.end

base ad:0x80121024
;tree "1IBRD"
group 0--3
line.long 0 "IBRD"
hexfld.word 0 " DIVINT "
;tree.end

base ad:0x80121028
;tree "1FBRD"
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8012102c
;tree "1LCRH_TX"
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
;tree.end

base ad:0x80121030
;tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
;tree.end

base ad:0x80121034
;tree "1IFLS"
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80121038
;tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
;tree.end

base ad:0x8012103c
;tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
;tree.end

base ad:0x80121040
;tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
;tree.end

base ad:0x80121044
;tree "1ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
;tree.end

base ad:0x80121048
;tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
;tree.end

base ad:0x80121050
;tree "1XFCR"
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
;tree.end

base ad:0x80121054
;tree "1XON1"
group 0--3
line.long 0 "XON1"
hexfld.byte 0 " XON1 "
;tree.end

base ad:0x80121058
;tree "1XON2"
group 0--3
line.long 0 "XON2"
hexfld.byte 0 " XON2 "
;tree.end

base ad:0x8012105c
;tree "1XOFF1"
group 0--3
line.long 0 "XOFF1"
hexfld.byte 0 " XOFF1 "
;tree.end

base ad:0x80121060
;tree "1XOFF2"
group 0--3
line.long 0 "XOFF2"
hexfld.byte 0 " XOFF2 "
;tree.end

base ad:0x80121080
;tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80121084
;tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
;tree.end

base ad:0x80121088
;tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
;tree.end

base ad:0x8012108c
;tree "1TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
;tree.end

base ad:0x80121100
;tree "1ABCR"
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
;tree.end

base ad:0x80121104
;tree "1ABSR"
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " BYTE1S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
;tree.end

base ad:0x80121108
;tree "1ABFMT"
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80121150
;tree "1ABDR"
rgroup 0--3
line.long 0 "ABDR"
hexfld.word 0 " AUTOBAUDBDR "
;tree.end

base ad:0x80121154
;tree "1ABDFR"
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80121158
;tree "1ABMR"
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
;tree.end

base ad:0x8012115c
;tree "1ABIMSC"
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
;tree.end

base ad:0x80121160
;tree "1ABRIS"
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
;tree.end

base ad:0x80121164
;tree "1ABMIS"
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
;tree.end

base ad:0x80121168
;tree "1ABICR"
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
;tree.end

base ad:0x80121fe0
;tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80121fe4
;tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80121fe8
;tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80121fec
;tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80121ff0
;tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " IDO "
;tree.end

base ad:0x80121ff4
;tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " ID1 "
;tree.end

base ad:0x80121ff8
;tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " ID2 "
;tree.end

base ad:0x80121ffc
;tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " ID3 "
;tree.end

tree.end

base ad:0x80007000
;********************************************
tree "UART-2"
;********************************************
base ad:0x80007000
;tree "2DR"
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
;tree.end

base ad:0x80007004
;tree "2RSR_ECR"
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
;tree.end

base ad:0x80007008
;tree "2DMAWM"
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80007018
;tree "2FR"
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
;tree.end

base ad:0x8000701c
;tree "2LCRH_RX"
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
;tree.end

base ad:0x80007020
;tree "2ILPR"
group 0--3
line.long 0 "ILPR"
hexfld.byte 0 " ILPDVSR "
;tree.end

base ad:0x80007024
;tree "2IBRD"
group 0--3
line.long 0 "IBRD"
hexfld.word 0 " DIVINT "
;tree.end

base ad:0x80007028
;tree "2FBRD"
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8000702c
;tree "2LCRH_TX"
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
;tree.end

base ad:0x80007030
;tree "2CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
;tree.end

base ad:0x80007034
;tree "2IFLS"
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80007038
;tree "2IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
;tree.end

base ad:0x8000703c
;tree "2RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
;tree.end

base ad:0x80007040
;tree "2MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
;tree.end

base ad:0x80007044
;tree "2ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
;tree.end

base ad:0x80007048
;tree "2DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
;tree.end

base ad:0x80007050
;tree "2XFCR"
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
;tree.end

base ad:0x80007054
;tree "2XON1"
group 0--3
line.long 0 "XON1"
hexfld.byte 0 " XON1 "
;tree.end

base ad:0x80007058
;tree "2XON2"
group 0--3
line.long 0 "XON2"
hexfld.byte 0 " XON2 "
;tree.end

base ad:0x8000705c
;tree "2XOFF1"
group 0--3
line.long 0 "XOFF1"
hexfld.byte 0 " XOFF1 "
;tree.end

base ad:0x80007060
;tree "2XOFF2"
group 0--3
line.long 0 "XOFF2"
hexfld.byte 0 " XOFF2 "
;tree.end

base ad:0x80007080
;tree "2ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80007084
;tree "2ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
;tree.end

base ad:0x80007088
;tree "2ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
;tree.end

base ad:0x8000708c
;tree "2TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
;tree.end

base ad:0x80007100
;tree "2ABCR"
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
;tree.end

base ad:0x80007104
;tree "2ABSR"
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " BYTE1S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
;tree.end

base ad:0x80007108
;tree "2ABFMT"
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80007150
;tree "2ABDR"
rgroup 0--3
line.long 0 "ABDR"
hexfld.word 0 " AUTOBAUDBDR "
;tree.end

base ad:0x80007154
;tree "2ABDFR"
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80007158
;tree "2ABMR"
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
;tree.end

base ad:0x8000715c
;tree "2ABIMSC"
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
;tree.end

base ad:0x80007160
;tree "2ABRIS"
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
;tree.end

base ad:0x80007164
;tree "2ABMIS"
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
;tree.end

base ad:0x80007168
;tree "2ABICR"
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
;tree.end

base ad:0x80007fe0
;tree "2PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80007fe4
;tree "2PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80007fe8
;tree "2PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80007fec
;tree "2PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80007ff0
;tree "2PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " IDO "
;tree.end

base ad:0x80007ff4
;tree "2PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " ID1 "
;tree.end

base ad:0x80007ff8
;tree "2PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " ID2 "
;tree.end

base ad:0x80007ffc
;tree "2PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " ID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "USB"
;==============================================================
base ad:0xa03e0000
;tree "INTTX_PWR_FADDR"
group 0--3
line.long 0 "INTTX_PWR_FADDR"
bitfld.long 0 0.--6. " FADDR "  " "
bitfld.long 0 8. " SUSPM "  "0 ,1 "
bitfld.long 0 9. " SUSP "  "0 ,1 "
bitfld.long 0 10. " RSM "  "0 ,1 "
bitfld.long 0 11. " RST "  "0 ,1 "
bitfld.long 0 12. " HSMD "  "0 ,1 "
bitfld.long 0 13. " HSEN "  "0 ,1 "
bitfld.long 0 14. " SFCN "  "0 ,1 "
bitfld.long 0 15. " ISO_UP "  "0 ,1 "
hexfld.word 0 " EPTX "
;tree.end

base ad:0xa03e0004
;tree "INTTXEN_RX"
group 0--3
line.long 0 "INTTXEN_RX"
hexfld.word 0 " EPRX "
hexfld.word 0 " EPTXEN "
;tree.end

base ad:0xa03e0008
;tree "INTRXEN"
group 0--3
line.long 0 "INTRXEN"
hexfld.word 0 " EPRXEN "
bitfld.long 0 16. " SUSP "  "0 ,1 "
bitfld.long 0 17. " RES "  "0 ,1 "
bitfld.long 0 18. " RST "  "0 ,1 "
bitfld.long 0 19. " SOF "  "0 ,1 "
bitfld.long 0 20. " CONN "  "0 ,1 "
bitfld.long 0 21. " DISCON "  "0 ,1 "
bitfld.long 0 22. " SREQ "  "0 ,1 "
bitfld.long 0 23. " VBE "  "0 ,1 "
bitfld.long 0 24. " SSPEN "  "0 ,1 "
bitfld.long 0 25. " RESEN "  "0 ,1 "
bitfld.long 0 26. " RSTEN "  "0 ,1 "
bitfld.long 0 27. " SOFEN "  "0 ,1 "
bitfld.long 0 28. " CONEN "  "0 ,1 "
bitfld.long 0 29. " DSCEN "  "0 ,1 "
bitfld.long 0 30. " SREQN "  "0 ,1 "
bitfld.long 0 31. " VBEN "  "0 ,1 "
;tree.end

base ad:0xa03e000c
;tree "TM_INDX_FMNO"
group 0--3
line.long 0 "TM_INDX_FMNO"
bitfld.long 0 0.--10. " FMNO "  " "
bitfld.long 0 16.--19. " EPNO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24. " TSTNAK "  "0 ,1 "
bitfld.long 0 25. " TSTJ "  "0 ,1 "
bitfld.long 0 26. " TSTK "  "0 ,1 "
bitfld.long 0 27. " TSTPKT "  "0 ,1 "
bitfld.long 0 28. " FHS "  "0 ,1 "
bitfld.long 0 29. " FFS "  "0 ,1 "
bitfld.long 0 30. " FIFOA "  "0 ,1 "
bitfld.long 0 31. " FRH "  "0 ,1 "
;tree.end

base ad:0xa03e0010
;tree "INDX_TXCSR"
group 0--3
line.long 0 "INDX_TXCSR"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.word 0 " TXCSR "
;tree.end

base ad:0xa03e0014
;tree "INDX_RXCSR"
group 0--3
line.long 0 "INDX_RXCSR"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.word 0 " RXCSR "
;tree.end

base ad:0xa03e0018
;tree "INDX_COUNT0"
group 0--3
line.long 0 "INDX_COUNT0"
bitfld.long 0 0.--12. " RXCOUNT "  " "
bitfld.long 0 13.--16. " EP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--18. " PROT "  "0 ,1 ,2 ,3 "
bitfld.long 0 19.--20. " SPEED "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--28. " TXPI "  " "
;tree.end

base ad:0xa03e001c
;tree "INDX_CFD"
rgroup 0--3
line.long 0 "INDX_CFD"
bitfld.long 0 0.--3. " EP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " PROT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " SPEED "  "0 ,1 ,2 ,3 "
hexfld.byte 1 " RXPI "
bitfld.long 0 24. " UI "  "0 ,1 "
bitfld.long 0 25. " SC "  "0 ,1 "
bitfld.long 0 26. " DYNF "  "0 ,1 "
bitfld.long 0 27. " HBTXE "  "0 ,1 "
bitfld.long 0 28. " HBRXE "  "0 ,1 "
bitfld.long 0 29. " BE "  "0 ,1 "
bitfld.long 0 30. " MPTXE "  "0 ,1 "
bitfld.long 0 31. " MPRXE "  "0 ,1 "
;tree.end

base ad:0xa03e0020
;tree "EP0_FIFO"
group 0--3
line.long 0 "EP0_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0060
;tree "FIFOSZ_DEVCTL"
group 0--3
line.long 0 "FIFOSZ_DEVCTL"
bitfld.long 0 0. " SESS "  "0 ,1 "
bitfld.long 0 1. " HREQ "  "0 ,1 "
bitfld.long 0 2. " HOST "  "0 ,1 "
bitfld.long 0 3.--4. " VBUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " LSDEV "  "0 ,1 "
bitfld.long 0 6. " FSDEV "  "0 ,1 "
bitfld.long 0 7. " BDEV "  "0 ,1 "
bitfld.long 0 8. " RXEDMA "  "0 ,1 "
bitfld.long 0 9. " TXEDMA "  "0 ,1 "
bitfld.long 0 16.--19. " TXSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20. " TXDPB "  "0 ,1 "
bitfld.long 0 24.--27. " RXSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28. " RXDPB "  "0 ,1 "
;tree.end

base ad:0xa03e0064
;tree "FIFOADDR"
group 0--3
line.long 0 "FIFOADDR"
bitfld.long 0 0.--12. " TXAD "  " "
bitfld.long 0 16.--28. " RXAD "  " "
;tree.end

base ad:0xa03e0068
;tree "VCNTL"
rgroup 0--3
line.long 0 "VCNTL"
hexfld.byte 0 " VCNTL "
;tree.end

base ad:0xa03e006c
;tree "HWVER"
rgroup 0--3
line.long 0 "HWVER"
bitfld.long 0 0.--9. " VMIN "  " "
bitfld.long 0 10.--14. " VMAJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 15. " RC "  "0 ,1 "
;tree.end

base ad:0xa03e0070
;tree "ULPI_1"
group 0--3
line.long 0 "ULPI_1"
bitfld.long 0 0. " EXTVB "  "0 ,1 "
bitfld.long 0 1. " EXTVI "  "0 ,1 "
bitfld.long 0 8. " DISU "  "0 ,1 "
bitfld.long 0 9. " CKACT "  "0 ,1 "
bitfld.long 0 10. " ALTINT "  "0 ,1 "
bitfld.long 0 11. " CANCK "  "0 ,1 "
bitfld.long 0 12. " RXCMD "  "0 ,1 "
bitfld.long 0 13. " CKAE "  "0 ,1 "
bitfld.long 0 16. " REGINT_IE "  "0 ,1 "
bitfld.long 0 17. " ALTINT_IE "  "0 ,1 "
bitfld.long 0 18. " AEND_IE "  "0 ,1 "
bitfld.long 0 19. " RXCMD_IE "  "0 ,1 "
bitfld.long 0 24. " REGINTI "  "0 ,1 "
bitfld.long 0 25. " ALTINTI "  "0 ,1 "
bitfld.long 0 26. " AENDI "  "0 ,1 "
bitfld.long 0 27. " RXCMDI "  "0 ,1 "
;tree.end

base ad:0xa03e0074
;tree "ULPI_2"
group 0--3
line.long 0 "ULPI_2"
hexfld.byte 0 " UREGDATA "
hexfld.byte 1 " UREGADDR "
hexfld.byte 2 " UREGCTRL "
hexfld.byte 3 " URAWDATA "
;tree.end

base ad:0xa03e0078
;tree "INFO_REG"
group 0--3
line.long 0 "INFO_REG"
hexfld.byte 0 " EPINFO "
hexfld.byte 1 " RAMINFO "
hexfld.byte 2 " LINKINFO "
hexfld.byte 3 " VPLEN "
;tree.end

base ad:0xa03e007c
;tree "EOF_REG"
group 0--3
line.long 0 "EOF_REG"
hexfld.byte 0 " HSEOF "
hexfld.byte 1 " FSEOF "
hexfld.byte 2 " LSEOF "
bitfld.long 0 24.--25. " SRST "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa03e0100
;tree "EP0_TXCSR0"
group 0--3
line.long 0 "EP0_TXCSR0"
hexfld.word 0 " TXCSR0 "
;tree.end

base ad:0xa03e0108
;tree "EP0_COUNT0"
rgroup 0--3
line.long 0 "EP0_COUNT0"
bitfld.long 0 0.--6. " RXCOUNT "  " "
;tree.end

base ad:0xa03e010c
;tree "EP0_CFD"
rgroup 0--3
line.long 0 "EP0_CFD"
bitfld.long 0 24. " UI "  "0 ,1 "
bitfld.long 0 25. " SC "  "0 ,1 "
bitfld.long 0 26. " DYNF "  "0 ,1 "
bitfld.long 0 27. " HBTXE "  "0 ,1 "
bitfld.long 0 28. " HBRXE "  "0 ,1 "
bitfld.long 0 29. " BE "  "0 ,1 "
bitfld.long 0 30. " MPTXE "  "0 ,1 "
bitfld.long 0 31. " MPRXE "  "0 ,1 "
;tree.end

base ad:0xa03e0110
;tree "EP1_TXCSR_MAXP"
group 0--3
line.long 0 "EP1_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0114
;tree "EP1_RXCSR_MAXP"
group 0--3
line.long 0 "EP1_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0118
;tree "EP1_RXCOUNT"
rgroup 0--3
line.long 0 "EP1_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e011c
;tree "EP1_FIFOSZ"
rgroup 0--3
line.long 0 "EP1_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0120
;tree "EP2_TXCSR_MAXP"
group 0--3
line.long 0 "EP2_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0124
;tree "EP2_RXCSR_MAXP"
group 0--3
line.long 0 "EP2_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0128
;tree "EP2_RXCOUNT"
rgroup 0--3
line.long 0 "EP2_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e012c
;tree "EP2_FIFOSZ"
rgroup 0--3
line.long 0 "EP2_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0130
;tree "EP3_TXCSR_MAXP"
group 0--3
line.long 0 "EP3_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0134
;tree "EP3_RXCSR_MAXP"
group 0--3
line.long 0 "EP3_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0138
;tree "EP3_RXCOUNT"
rgroup 0--3
line.long 0 "EP3_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e013c
;tree "EP3_FIFOSZ"
rgroup 0--3
line.long 0 "EP3_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0140
;tree "EP4_TXCSR_MAXP"
group 0--3
line.long 0 "EP4_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0144
;tree "EP4_RXCSR_MAXP"
group 0--3
line.long 0 "EP4_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0148
;tree "EP4_RXCOUNT"
rgroup 0--3
line.long 0 "EP4_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e014c
;tree "EP4_FIFOSZ"
rgroup 0--3
line.long 0 "EP4_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0150
;tree "EP5_TXCSR_MAXP"
group 0--3
line.long 0 "EP5_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0154
;tree "EP5_RXCSR_MAXP"
group 0--3
line.long 0 "EP5_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0158
;tree "EP5_RXCOUNT"
rgroup 0--3
line.long 0 "EP5_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e015c
;tree "EP5_FIFOSZ"
rgroup 0--3
line.long 0 "EP5_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0160
;tree "EP6_TXCSR_MAXP"
group 0--3
line.long 0 "EP6_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0164
;tree "EP6_RXCSR_MAXP"
group 0--3
line.long 0 "EP6_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0168
;tree "EP6_RXCOUNT"
rgroup 0--3
line.long 0 "EP6_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e016c
;tree "EP6_FIFOSZ"
rgroup 0--3
line.long 0 "EP6_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0170
;tree "EP7_TXCSR_MAXP"
group 0--3
line.long 0 "EP7_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0174
;tree "EP7_RXCSR_MAXP"
group 0--3
line.long 0 "EP7_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0178
;tree "EP7_RXCOUNT"
rgroup 0--3
line.long 0 "EP7_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e017c
;tree "EP7_FIFOSZ"
rgroup 0--3
line.long 0 "EP7_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0180
;tree "EP8_TXCSR_MAXP"
group 0--3
line.long 0 "EP8_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0184
;tree "EP8_RXCSR_MAXP"
group 0--3
line.long 0 "EP8_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0188
;tree "EP8_RXCOUNT"
rgroup 0--3
line.long 0 "EP8_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e018c
;tree "EP8_FIFOSZ"
rgroup 0--3
line.long 0 "EP8_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0190
;tree "EP9_TXCSR_MAXP"
group 0--3
line.long 0 "EP9_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0194
;tree "EP9_RXCSR_MAXP"
group 0--3
line.long 0 "EP9_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0198
;tree "EP9_RXCOUNT"
rgroup 0--3
line.long 0 "EP9_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e019c
;tree "EP9_FIFOSZ"
rgroup 0--3
line.long 0 "EP9_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e01a0
;tree "EP10_TXCSR_MAXP"
group 0--3
line.long 0 "EP10_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e01a4
;tree "EP10_RXCSR_MAXP"
group 0--3
line.long 0 "EP10_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e01a8
;tree "EP10_RXCOUNT"
rgroup 0--3
line.long 0 "EP10_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e01ac
;tree "EP10_FIFOSZ"
rgroup 0--3
line.long 0 "EP10_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e01b0
;tree "EP11_TXCSR_MAXP"
group 0--3
line.long 0 "EP11_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e01b4
;tree "EP11_RXCSR_MAXP"
group 0--3
line.long 0 "EP11_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e01b8
;tree "EP11_RXCOUNT"
rgroup 0--3
line.long 0 "EP11_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e01bc
;tree "EP11_FIFOSZ"
rgroup 0--3
line.long 0 "EP11_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e01c0
;tree "EP12_TXCSR_MAXP"
group 0--3
line.long 0 "EP12_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e01c4
;tree "EP12_RXCSR_MAXP"
group 0--3
line.long 0 "EP12_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e01c8
;tree "EP12_RXCOUNT"
rgroup 0--3
line.long 0 "EP12_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e01cc
;tree "EP12_FIFOSZ"
rgroup 0--3
line.long 0 "EP12_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e01d0
;tree "EP13_TXCSR_MAXP"
group 0--3
line.long 0 "EP13_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e01d4
;tree "EP13_RXCSR_MAXP"
group 0--3
line.long 0 "EP13_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e01d8
;tree "EP13_RXCOUNT"
rgroup 0--3
line.long 0 "EP13_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e01dc
;tree "EP13_FIFOSZ"
rgroup 0--3
line.long 0 "EP13_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e01e0
;tree "EP14_TXCSR_MAXP"
group 0--3
line.long 0 "EP14_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e01e4
;tree "EP14_RXCSR_MAXP"
group 0--3
line.long 0 "EP14_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e01e8
;tree "EP14_RXCOUNT"
rgroup 0--3
line.long 0 "EP14_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e01ec
;tree "EP14_FIFOSZ"
rgroup 0--3
line.long 0 "EP14_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e01f0
;tree "EP15_TXCSR_MAXP"
group 0--3
line.long 0 "EP15_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e01f4
;tree "EP15_RXCSR_MAXP"
group 0--3
line.long 0 "EP15_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e01f8
;tree "EP15_RXCOUNT"
rgroup 0--3
line.long 0 "EP15_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e01fc
;tree "EP15_FIFOSZ"
rgroup 0--3
line.long 0 "EP15_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0204
;tree "TOPCTRL"
group 0--3
line.long 0 "TOPCTRL"
bitfld.long 0 0. " ULPI_ON "  "0 ,1 "
bitfld.long 0 3. " XGATE "  "0 ,1 "
bitfld.long 0 4. " I2C_OFF "  "0 ,1 "
bitfld.long 0 5. " HDEV "  "0 ,1 "
bitfld.long 0 6. " VBUSLO "  "0 ,1 "
;tree.end

base ad:0xa03e0300
;tree "EP0_RQPKTCOUNT"
group 0--3
line.long 0 "EP0_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0304
;tree "EP1_RQPKTCOUNT"
group 0--3
line.long 0 "EP1_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0308
;tree "EP2_RQPKTCOUNT"
group 0--3
line.long 0 "EP2_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e030c
;tree "EP3_RQPKTCOUNT"
group 0--3
line.long 0 "EP3_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0310
;tree "EP4_RQPKTCOUNT"
group 0--3
line.long 0 "EP4_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0314
;tree "EP5_RQPKTCOUNT"
group 0--3
line.long 0 "EP5_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0318
;tree "EP6_RQPKTCOUNT"
group 0--3
line.long 0 "EP6_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e031c
;tree "EP7_RQPKTCOUNT"
group 0--3
line.long 0 "EP7_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0320
;tree "EP8_RQPKTCOUNT"
group 0--3
line.long 0 "EP8_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0324
;tree "EP9_RQPKTCOUNT"
group 0--3
line.long 0 "EP9_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0328
;tree "EP10_RQPKTCOUNT"
group 0--3
line.long 0 "EP10_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e032c
;tree "EP11_RQPKTCOUNT"
group 0--3
line.long 0 "EP11_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0330
;tree "EP12_RQPKTCOUNT"
group 0--3
line.long 0 "EP12_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0334
;tree "EP13_RQPKTCOUNT"
group 0--3
line.long 0 "EP13_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0338
;tree "EP14_RQPKTCOUNT"
group 0--3
line.long 0 "EP14_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e033c
;tree "EP15_RQPKTCOUNT"
group 0--3
line.long 0 "EP15_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0340
;tree "DPKTBUFDIS"
group 0--3
line.long 0 "DPKTBUFDIS"
hexfld.word 0 " EP_RXDIS "
hexfld.word 0 " EP_TXDIS "
;tree.end

base ad:0xa03e0344
;tree "C_T_CTRL"
group 0--3
line.long 0 "C_T_CTRL"
hexfld.word 0 " C_T_UCH_CTRL "
hexfld.word 0 " C_T_HSRTN_CTRL "
;tree.end

tree.end

