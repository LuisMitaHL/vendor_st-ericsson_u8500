;PER file generated from pmap 
;by script version 1.10 11-December-09
;Author : N. PERRIN - Modified : F.GOHIER

config 16. 8.
width  40. 8.

;==============================================================
tree "B2R2"
;==============================================================
if (((data.long(ad:0x80157078)&0x100)!=0x100)||((data.long(ad:0x801571ec)&0x0C)!=0x0C)||((data.long(ad:0x8015725c)&0x80)!=0x80))

base ad:0x80157078
;tree "prcm_b2r2clk_mgt_reg"
group 0--3
line.long 0 "prcm_b2r2clk_mgt_reg"
bitfld.long 0 8. " B2R2CLKEN "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 2. " B2R2_resetn "  "0 ,1 "
bitfld.long 0 3. " B2R2_init_n "  "0 ,1 "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 2. " B2R2_resetn "  "0 ,1 "
bitfld.long 0 3. " B2R2_init_n "  "0 ,1 "
;tree.end

base ad:0x8015725c
;tree "prcm_power_state_val"
group 0--3
line.long 0 "prcm_power_state_val"
bitfld.long 0 7. " B2R2_MCDE "  "0 ,1 "
;tree.end

else

base ad:0x80130a00
;tree "BLT_CTL"
group 0--3
line.long 0 "BLT_CTL"
bitfld.long 0 28. " Big_not_little "  "0 ,1 "
bitfld.long 0 29. " Step_By_Step "  "0 ,1 "
bitfld.long 0 31. " GLOBAL_soft_reset "  "0 ,1 "
;tree.end

base ad:0x80130a04
;tree "BLT_ITS"
group 0--3
line.long 0 "BLT_ITS"
bitfld.long 0 0. " CQ1_completed "  "0 ,1 "
bitfld.long 0 1. " CQ1_retriggered "  "0 ,1 "
bitfld.long 0 2. " CQ1_Node_Notif "  "0 ,1 "
bitfld.long 0 3. " CQ1_Repaced "  "0 ,1 "
bitfld.long 0 4. " CQ2_completed "  "0 ,1 "
bitfld.long 0 5. " CQ2_retriggered "  "0 ,1 "
bitfld.long 0 6. " CQ2_Node_Notif "  "0 ,1 "
bitfld.long 0 7. " CQ2_Repaced "  "0 ,1 "
bitfld.long 0 12. " AQ1_LNA_Reached "  "0 ,1 "
bitfld.long 0 13. " AQ1_Stopped "  "0 ,1 "
bitfld.long 0 14. " AQ1_Node_repeat "  "0 ,1 "
bitfld.long 0 15. " AQ1_Node_Notif "  "0 ,1 "
bitfld.long 0 16. " AQ2_LNA_Reached "  "0 ,1 "
bitfld.long 0 17. " AQ2_Stopped "  "0 ,1 "
bitfld.long 0 18. " AQ2_Node_repeat "  "0 ,1 "
bitfld.long 0 19. " AQ2_Node_Notif "  "0 ,1 "
bitfld.long 0 20. " AQ3_LNA_Reached "  "0 ,1 "
bitfld.long 0 21. " AQ3_Stopped "  "0 ,1 "
bitfld.long 0 22. " AQ3_Node_repeat "  "0 ,1 "
bitfld.long 0 23. " AQ3_Node_Notif "  "0 ,1 "
bitfld.long 0 24. " AQ4_LNA_Reached "  "0 ,1 "
bitfld.long 0 25. " AQ4_Stopped "  "0 ,1 "
bitfld.long 0 26. " AQ4_Node_repeat "  "0 ,1 "
bitfld.long 0 27. " AQ4_Node_Notif "  "0 ,1 "
bitfld.long 0 31. " RLD_ERROR "  "0 ,1 "
;tree.end

base ad:0x80130a08
;tree "BLT_STA1"
group 0--3
line.long 0 "BLT_STA1"
bitfld.long 0 0. " BDISP_IDLE "  "0 ,1 "
;tree.end

base ad:0x80130a10
;tree "BLT_SSBA1"
group 0--3
line.long 0 "BLT_SSBA1"
bitfld.long 0 0.--25. " SSBA1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA1_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a14
;tree "BLT_SSBA2"
group 0--3
line.long 0 "BLT_SSBA2"
bitfld.long 0 0.--25. " SSBA2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA2_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a18
;tree "BLT_SSBA3"
group 0--3
line.long 0 "BLT_SSBA3"
bitfld.long 0 0.--25. " SSBA3_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA3_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a1c
;tree "BLT_SSBA4"
group 0--3
line.long 0 "BLT_SSBA4"
bitfld.long 0 0.--25. " SSBA4_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA4_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a20
;tree "BLT_SSBA5"
group 0--3
line.long 0 "BLT_SSBA5"
bitfld.long 0 0.--25. " SSBA5_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA5_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a24
;tree "BLT_SSBA6"
group 0--3
line.long 0 "BLT_SSBA6"
bitfld.long 0 0.--25. " SSBA6_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA6_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a28
;tree "BLT_SSBA7"
group 0--3
line.long 0 "BLT_SSBA7"
bitfld.long 0 0.--25. " SSBA7_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA7_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a2c
;tree "BLT_SSBA8"
group 0--3
line.long 0 "BLT_SSBA8"
bitfld.long 0 0.--25. " SSBA8_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA8_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130aa0
;tree "BLT_SSBA9"
group 0--3
line.long 0 "BLT_SSBA9"
bitfld.long 0 0.--25. " SSBA9_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA9_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130aa4
;tree "BLT_SSBA10"
group 0--3
line.long 0 "BLT_SSBA10"
bitfld.long 0 0.--25. " SSBA10_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA10_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130aa8
;tree "BLT_SSBA11"
group 0--3
line.long 0 "BLT_SSBA11"
bitfld.long 0 0.--25. " SSBA11_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA11_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130aac
;tree "BLT_SSBA12"
group 0--3
line.long 0 "BLT_SSBA12"
bitfld.long 0 0.--25. " SSBA12_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA12_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130ab0
;tree "BLT_SSBA13"
group 0--3
line.long 0 "BLT_SSBA13"
bitfld.long 0 0.--25. " SSBA13_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA13_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130ab4
;tree "BLT_SSBA14"
group 0--3
line.long 0 "BLT_SSBA14"
bitfld.long 0 0.--25. " SSBA14_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA14_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130ab8
;tree "BLT_SSBA15"
group 0--3
line.long 0 "BLT_SSBA15"
bitfld.long 0 0.--25. " SSBA15_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA15_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130abc
;tree "BLT_SSBA16"
group 0--3
line.long 0 "BLT_SSBA16"
bitfld.long 0 0.--25. " SSBA16_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA16_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a30
;tree "BLT_STBA1"
group 0--3
line.long 0 "BLT_STBA1"
bitfld.long 0 0.--25. " STBA1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA1_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a34
;tree "BLT_STBA2"
group 0--3
line.long 0 "BLT_STBA2"
bitfld.long 0 0.--25. " STBA2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA2_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a38
;tree "BLT_STBA3"
group 0--3
line.long 0 "BLT_STBA3"
bitfld.long 0 0.--25. " STBA3_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA3_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a3c
;tree "BLT_STBA4"
group 0--3
line.long 0 "BLT_STBA4"
bitfld.long 0 0.--25. " STBA4_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA4_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a40
;tree "BLT_CQ1_TRIG_IP"
group 0--3
line.long 0 "BLT_CQ1_TRIG_IP"
bitfld.long 0 0.--25. " CQ1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " TRIG_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a50
;tree "BLT_CQ2_TRIG_IP"
group 0--3
line.long 0 "BLT_CQ2_TRIG_IP"
bitfld.long 0 0.--25. " CQ2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " TRIG_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a44
;tree "BLT_CQ1_TRIG_CTL"
group 0--3
line.long 0 "BLT_CQ1_TRIG_CTL"
bitfld.long 0 0.--11. " Trigger_line_num "  " "
bitfld.long 0 12.--15. " Trig_cond "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " Retrig_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

base ad:0x80130a54
;tree "BLT_CQ2_TRIG_CTL"
group 0--3
line.long 0 "BLT_CQ2_TRIG_CTL"
bitfld.long 0 0.--11. " Trigger_line_num "  " "
bitfld.long 0 12.--15. " Trig_cond "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " Retrig_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

base ad:0x80130a48
;tree "BLT_CQ1_PACE_CTL"
group 0--3
line.long 0 "BLT_CQ1_PACE_CTL"
bitfld.long 0 0.--11. " Pace_start "  " "
bitfld.long 0 16.--27. " Pace_Count "  " "
bitfld.long 0 31. " Dynamic_Pace "  "0 ,1 "
;tree.end

base ad:0x80130a58
;tree "BLT_CQ2_PACE_CTL"
group 0--3
line.long 0 "BLT_CQ2_PACE_CTL"
bitfld.long 0 0.--11. " Pace_start "  " "
bitfld.long 0 16.--27. " Pace_Count "  " "
bitfld.long 0 31. " Dynamic_Pace "  "0 ,1 "
;tree.end

base ad:0x80130a4c
;tree "BLT_CQ1_IP"
rgroup 0--3
line.long 0 "BLT_CQ1_IP"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a5c
;tree "BLT_CQ2_IP"
rgroup 0--3
line.long 0 "BLT_CQ2_IP"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a60
;tree "BLT_AQ1_CTL"
group 0--3
line.long 0 "BLT_AQ1_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

base ad:0x80130a70
;tree "BLT_AQ2_CTL"
group 0--3
line.long 0 "BLT_AQ2_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

base ad:0x80130a80
;tree "BLT_AQ3_CTL"
group 0--3
line.long 0 "BLT_AQ3_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

base ad:0x80130a90
;tree "BLT_AQ4_CTL"
group 0--3
line.long 0 "BLT_AQ4_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

base ad:0x80130a64
;tree "BLT_AQ1_IP"
group 0--3
line.long 0 "BLT_AQ1_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a74
;tree "BLT_AQ2_IP"
group 0--3
line.long 0 "BLT_AQ2_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a84
;tree "BLT_AQ3_IP"
group 0--3
line.long 0 "BLT_AQ3_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a94
;tree "BLT_AQ4_IP"
group 0--3
line.long 0 "BLT_AQ4_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a68
;tree "BLT_AQ1_LNA"
group 0--3
line.long 0 "BLT_AQ1_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a78
;tree "BLT_AQ2_LNA"
group 0--3
line.long 0 "BLT_AQ2_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a88
;tree "BLT_AQ3_LNA"
group 0--3
line.long 0 "BLT_AQ3_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a98
;tree "BLT_AQ4_LNA"
group 0--3
line.long 0 "BLT_AQ4_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a6c
;tree "BLT_AQ1_STA"
rgroup 0--3
line.long 0 "BLT_AQ1_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a7c
;tree "BLT_AQ2_STA"
rgroup 0--3
line.long 0 "BLT_AQ2_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a8c
;tree "BLT_AQ3_STA"
rgroup 0--3
line.long 0 "BLT_AQ3_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a9c
;tree "BLT_AQ4_STA"
rgroup 0--3
line.long 0 "BLT_AQ4_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130ac0
;tree "BLT_SGA1"
group 0--3
line.long 0 "BLT_SGA1"
hexfld.byte 0 " Alpha1 "
hexfld.byte 1 " Alpha2 "
hexfld.byte 2 " Alpha3 "
hexfld.byte 3 " Alpha4 "
;tree.end

base ad:0x80130ac4
;tree "BLT_SGA2"
group 0--3
line.long 0 "BLT_SGA2"
hexfld.byte 0 " Alpha5 "
hexfld.byte 1 " Alpha6 "
hexfld.byte 2 " Alpha7 "
hexfld.byte 3 " Alpha8 "
;tree.end

base ad:0x80130ad0
;tree "BLT_ITM0"
group 0--3
line.long 0 "BLT_ITM0"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

base ad:0x80130ad4
;tree "BLT_ITM1"
group 0--3
line.long 0 "BLT_ITM1"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

base ad:0x80130ad8
;tree "BLT_ITM2"
group 0--3
line.long 0 "BLT_ITM2"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

base ad:0x80130adc
;tree "BLT_ITM3"
group 0--3
line.long 0 "BLT_ITM3"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

base ad:0x80130af4
;tree "BLT_DFV1"
group 0--3
line.long 0 "BLT_DFV1"
bitfld.long 0 0.--11. " DFV1_Line_count "  " "
bitfld.long 0 12. " DFV1_ITM0_IT "  "0 ,1 "
bitfld.long 0 13. " DFV1_ITM1_IT "  "0 ,1 "
bitfld.long 0 14. " DFV1_ITM2_IT "  "0 ,1 "
bitfld.long 0 15. " DFV1_ITM3_IT "  "0 ,1 "
bitfld.long 0 16. " DFV1_AQ1_IT "  "0 ,1 "
bitfld.long 0 17. " DFV1_AQ2_IT "  "0 ,1 "
bitfld.long 0 18. " DFV1_AQ3_IT "  "0 ,1 "
bitfld.long 0 19. " DFV1_AQ4_IT "  "0 ,1 "
bitfld.long 0 20. " DFV1_CQ1_IT "  "0 ,1 "
bitfld.long 0 21. " DFV1_CQ2_IT "  "0 ,1 "
bitfld.long 0 24. " DFV1_GPO "  "0 ,1 "
bitfld.long 0 28. " DFV1_req "  "0 ,1 "
bitfld.long 0 29. " DFV1_ntop_bot "  "0 ,1 "
bitfld.long 0 30. " DFV1_Vsync "  "0 ,1 "
bitfld.long 0 31. " DFV1_Mode_En "  "0 ,1 "
;tree.end

base ad:0x80130af0
;tree "BLT_DFV2"
group 0--3
line.long 0 "BLT_DFV2"
bitfld.long 0 0.--11. " DFV2_Line_count "  " "
bitfld.long 0 28. " DFV2_req "  "0 ,1 "
bitfld.long 0 29. " DFV2_ntop_bot "  "0 ,1 "
bitfld.long 0 30. " DFV2_Vsync "  "0 ,1 "
bitfld.long 0 31. " DFV2_Mode_En "  "0 ,1 "
;tree.end

base ad:0x80130af8
;tree "BLT_PRI"
group 0--3
line.long 0 "BLT_PRI"
bitfld.long 0 0.--3. " CQ1_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " CQ2_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " AQ1_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " AQ2_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " AQ3_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " AQ4_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130900
;tree "BLT_SSBA17"
group 0--3
line.long 0 "BLT_SSBA17"
bitfld.long 0 0.--25. " SSBA17_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA17_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130904
;tree "BLT_SSBA18"
group 0--3
line.long 0 "BLT_SSBA18"
bitfld.long 0 0.--25. " SSBA18_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA18_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130908
;tree "BLT_SSBA19"
group 0--3
line.long 0 "BLT_SSBA19"
bitfld.long 0 0.--25. " SSBA19_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA19_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8013090c
;tree "BLT_SSBA20"
group 0--3
line.long 0 "BLT_SSBA20"
bitfld.long 0 0.--25. " SSBA20_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA20_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130910
;tree "BLT_SSBA21"
group 0--3
line.long 0 "BLT_SSBA21"
bitfld.long 0 0.--25. " SSBA21_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA21_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130914
;tree "BLT_SSBA22"
group 0--3
line.long 0 "BLT_SSBA22"
bitfld.long 0 0.--25. " SSBA22_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA22_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130918
;tree "BLT_SSBA23"
group 0--3
line.long 0 "BLT_SSBA23"
bitfld.long 0 0.--25. " SSBA23_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA23_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8013091c
;tree "BLT_SSBA24"
group 0--3
line.long 0 "BLT_SSBA24"
bitfld.long 0 0.--25. " SSBA24_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA24_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130940
;tree "BLT_STBA5"
group 0--3
line.long 0 "BLT_STBA5"
bitfld.long 0 0.--25. " STBA5_Mem_address "  " "
bitfld.long 0 26.--31. " STBA5_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130944
;tree "BLT_STBA6"
group 0--3
line.long 0 "BLT_STBA6"
bitfld.long 0 0.--25. " STBA6_Mem_address "  " "
bitfld.long 0 26.--31. " STBA6_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130948
;tree "BLT_STBA7"
group 0--3
line.long 0 "BLT_STBA7"
bitfld.long 0 0.--25. " STBA7_Mem_address "  " "
bitfld.long 0 26.--31. " STBA7_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8013094c
;tree "BLT_STBA8"
group 0--3
line.long 0 "BLT_STBA8"
bitfld.long 0 0.--25. " STBA8_Mem_address "  " "
bitfld.long 0 26.--31. " STBA8_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130b04
;tree "PLUGS1_OP2"
group 0--3
line.long 0 "PLUGS1_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b24
;tree "PLUGS2_OP2"
group 0--3
line.long 0 "PLUGS2_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b44
;tree "PLUGS3_OP2"
group 0--3
line.long 0 "PLUGS3_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b08
;tree "PLUGS1_CHZ"
group 0--3
line.long 0 "PLUGS1_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b28
;tree "PLUGS2_CHZ"
group 0--3
line.long 0 "PLUGS2_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b48
;tree "PLUGS3_CHZ"
group 0--3
line.long 0 "PLUGS3_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b0c
;tree "PLUGS1_MSZ"
group 0--3
line.long 0 "PLUGS1_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 0 " MinSpaceBetweenReq "
;tree.end

base ad:0x80130b2c
;tree "PLUGS2_MSZ"
group 0--3
line.long 0 "PLUGS2_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 0 " MinSpaceBetweenReq "
;tree.end

base ad:0x80130b4c
;tree "PLUGS3_MSZ"
group 0--3
line.long 0 "PLUGS3_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 0 " MinSpaceBetweenReq "
;tree.end

base ad:0x80130b10
;tree "PLUGS1_PGZ"
group 0--3
line.long 0 "PLUGS1_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130b30
;tree "PLUGS2_PGZ"
group 0--3
line.long 0 "PLUGS2_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130b50
;tree "PLUGS3_PGZ"
group 0--3
line.long 0 "PLUGS3_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130b84
;tree "PLUGT_OP2"
group 0--3
line.long 0 "PLUGT_OP2"
bitfld.long 0 0.--2. " Max_code "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b88
;tree "PLUGT_CHZ"
group 0--3
line.long 0 "PLUGT_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b8c
;tree "PLUGT_MSZ"
group 0--3
line.long 0 "PLUGT_MSZ"
bitfld.long 0 0.--2. " Message_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 0 " MinSpaceBetweenReq "
;tree.end

base ad:0x80130b90
;tree "PLUGT_PGZ"
group 0--3
line.long 0 "PLUGT_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130c00
;tree "BLT_NIP"
group 0--3
line.long 0 "BLT_NIP"
bitfld.long 0 0.--25. " NIP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " NIP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c04
;tree "BLT_CIC"
group 0--3
line.long 0 "BLT_CIC"
bitfld.long 0 2. " Group2 "  "0 ,1 "
bitfld.long 0 3. " Group3 "  "0 ,1 "
bitfld.long 0 4. " Group4 "  "0 ,1 "
bitfld.long 0 5. " Group5 "  "0 ,1 "
bitfld.long 0 6. " Group6 "  "0 ,1 "
bitfld.long 0 7. " Group7 "  "0 ,1 "
bitfld.long 0 8. " Group8 "  "0 ,1 "
bitfld.long 0 9. " Group9 "  "0 ,1 "
bitfld.long 0 10. " Group10 "  "0 ,1 "
bitfld.long 0 11. " Group11 "  "0 ,1 "
bitfld.long 0 12. " Group12 "  "0 ,1 "
bitfld.long 0 13. " Group13 "  "0 ,1 "
bitfld.long 0 14. " Group14 "  "0 ,1 "
bitfld.long 0 15. " Group15 "  "0 ,1 "
bitfld.long 0 16. " Group16 "  "0 ,1 "
bitfld.long 0 17. " Group17 "  "0 ,1 "
bitfld.long 0 18. " Group18 "  "0 ,1 "
;tree.end

base ad:0x80130c08
;tree "BLT_INS"
group 0--3
line.long 0 "BLT_INS"
bitfld.long 0 0.--2. " SOURCE1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--4. " SOURCE2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " SOURCE3 "  "0 ,1 "
bitfld.long 0 6. " IVMX "  "0 ,1 "
bitfld.long 0 7. " CLUTOP "  "0 ,1 "
bitfld.long 0 8. " 2DRESCALE "  "0 ,1 "
bitfld.long 0 9. " FILCK_FILT "  "0 ,1 "
bitfld.long 0 10. " RECT_CLIP "  "0 ,1 "
bitfld.long 0 11. " CKEY "  "0 ,1 "
bitfld.long 0 12. " OVMX "  "0 ,1 "
bitfld.long 0 13. " DEI "  "0 ,1 "
bitfld.long 0 14. " PLANE_MASK "  "0 ,1 "
bitfld.long 0 15. " XYL "  "0 ,1 "
bitfld.long 0 16. " DOT "  "0 ,1 "
bitfld.long 0 17. " VC1R "  "0 ,1 "
bitfld.long 0 18. " ROTATION "  "0 ,1 "
bitfld.long 0 30. " Pace_down "  "0 ,1 "
bitfld.long 0 31. " BlitCompIRQ "  "0 ,1 "
;tree.end

base ad:0x80130c0c
;tree "BLT_ACK"
group 0--3
line.long 0 "BLT_ACK"
bitfld.long 0 0.--3. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " SWAP_FG_BG "  "0 ,1 "
hexfld.byte 1 " GALPHA_ROPID "
bitfld.long 0 16.--21. " ACK_CKEY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--23. " CKEY_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80130c10
;tree "BLT_TBA"
group 0--3
line.long 0 "BLT_TBA"
bitfld.long 0 0.--25. " TBA_mem_addr "  " "
bitfld.long 0 26.--31. " TBA_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c14
;tree "BLT_TTY"
group 0--3
line.long 0 "BLT_TTY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 26. " RGB_ROUND "  "0 ,1 "
bitfld.long 0 27. " CHROMA_notLUMA "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

base ad:0x80130c18
;tree "BLT_TXY"
group 0--3
line.long 0 "BLT_TXY"
hexfld.word 0 " XCOORD "
hexfld.word 0 " YCOORD "
;tree.end

base ad:0x80130c1c
;tree "BLT_TSZ"
group 0--3
line.long 0 "BLT_TSZ"
bitfld.long 0 0.--11. " WIN_WIDTH "  " "
bitfld.long 0 16.--27. " WIN_HEIGHT "  " "
;tree.end

base ad:0x80130c20
;tree "BLT_S1CF"
group 0--3
line.long 0 "BLT_S1CF"
hexfld.long 0 " SRC1_COLOR_FILL "
;tree.end

base ad:0x80130c24
;tree "BLT_S2CF"
group 0--3
line.long 0 "BLT_S2CF"
hexfld.long 0 " SRC2_COLOR_FILL "
;tree.end

base ad:0x80130c28
;tree "BLT_S1BA"
group 0--3
line.long 0 "BLT_S1BA"
bitfld.long 0 0.--25. " S1BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S1BA_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c2c
;tree "BLT_S1TY"
group 0--3
line.long 0 "BLT_S1TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 22. " A1_SUBST "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 27. " ROTATION "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 29. " RGB_EXP "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

base ad:0x80130c30
;tree "BLT_S1XY"
group 0--3
line.long 0 "BLT_S1XY"
hexfld.word 0 " XCOORD "
hexfld.word 0 " YCOORD "
;tree.end

base ad:0x80130c38
;tree "BLT_S2BA"
group 0--3
line.long 0 "BLT_S2BA"
bitfld.long 0 0.--25. " S2BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S2BA_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c3c
;tree "BLT_S2TY"
group 0--3
line.long 0 "BLT_S2TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 22. " A1_SUBST "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 26. " CHROMA_LEFT "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 29. " RGB_EXP "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

base ad:0x80130c40
;tree "BLT_S2XY"
group 0--3
line.long 0 "BLT_S2XY"
hexfld.word 0 " XCOORD "
hexfld.word 0 " YCOORD "
;tree.end

base ad:0x80130c44
;tree "BLT_S2SZ"
group 0--3
line.long 0 "BLT_S2SZ"
bitfld.long 0 0.--11. " SRC2_WIN_WIDTH "  " "
bitfld.long 0 16.--27. " SRC2_WIN_HEIGHT "  " "
;tree.end

base ad:0x80130c48
;tree "BLT_S3BA"
group 0--3
line.long 0 "BLT_S3BA"
bitfld.long 0 0.--25. " S3BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S3BA_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c4c
;tree "BLT_S3TY"
group 0--3
line.long 0 "BLT_S3TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " VSO "  "0 ,1 "
bitfld.long 0 25. " HSO "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

base ad:0x80130c50
;tree "BLT_S3XY"
group 0--3
line.long 0 "BLT_S3XY"
hexfld.word 0 " XCOORD "
hexfld.word 0 " YCOORD "
;tree.end

base ad:0x80130c54
;tree "BLT_S3SZ"
group 0--3
line.long 0 "BLT_S3SZ"
bitfld.long 0 0.--11. " SRC3_WIN_WIDTH "  " "
bitfld.long 0 16.--27. " SRC3_WIN_HEIGHT "  " "
;tree.end

base ad:0x80130c58
;tree "BLT_CWO"
group 0--3
line.long 0 "BLT_CWO"
bitfld.long 0 0.--14. " XDO "  " "
bitfld.long 0 16.--26. " YDO "  " "
bitfld.long 0 31. " INTNL "  "0 ,1 "
;tree.end

base ad:0x80130c5c
;tree "BLT_CWS"
group 0--3
line.long 0 "BLT_CWS"
bitfld.long 0 0.--14. " XDS "  " "
bitfld.long 0 16.--26. " YDS "  " "
;tree.end

base ad:0x80130c60
;tree "BLT_CCO"
group 0--3
line.long 0 "BLT_CCO"
bitfld.long 0 15. " CLUT_NS2_1S1 "  "0 ,1 "
bitfld.long 0 16.--17. " CLUT_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " CLUT_UPDATE "  "0 ,1 "
bitfld.long 0 19.--22. " CLUT_ERRDIFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130c64
;tree "BLT_CML"
group 0--3
line.long 0 "BLT_CML"
bitfld.long 0 4.--25. " CML_MEM_ADDR "  " "
bitfld.long 0 26.--31. " CML_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c68
;tree "BLT_FCTL"
group 0--3
line.long 0 "BLT_FCTL"
bitfld.long 0 0.--2. " 2DHF_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " 2DVF_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12. " AB_Right "  "0 ,1 "
bitfld.long 0 13. " AB_Left "  "0 ,1 "
bitfld.long 0 14. " AB_BOT "  "0 ,1 "
bitfld.long 0 15. " AB_TOP "  "0 ,1 "
bitfld.long 0 24.--25. " Luma_2Dhf_mode "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " Luma_2Dvf_mode "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80130c6c
;tree "BLT_PMK"
group 0--3
line.long 0 "BLT_PMK"
bitfld.long 0 0. " PLANE_MASK "  "0 ,1 "
;tree.end

base ad:0x80130c70
;tree "BLT_RSF"
group 0--3
line.long 0 "BLT_RSF"
hexfld.word 0 " HSRC_INC "
hexfld.word 0 " VSRC_INC "
;tree.end

base ad:0x80130c74
;tree "BLT_RZI"
group 0--3
line.long 0 "BLT_RZI"
bitfld.long 0 0.--9. " HSRC_INIT "  " "
bitfld.long 0 12.--14. " Hnb_repeat "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--25. " VSRC_INIT "  " "
bitfld.long 0 28.--30. " Vnb_repeat "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130c78
;tree "BLT_HFP"
group 0--3
line.long 0 "BLT_HFP"
bitfld.long 0 0.--25. " HFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " HFP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c7c
;tree "BLT_VFP"
group 0--3
line.long 0 "BLT_VFP"
bitfld.long 0 0.--25. " VFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " VFP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c80
;tree "BLT_Y_RSF"
group 0--3
line.long 0 "BLT_Y_RSF"
hexfld.word 0 " Luma_HSRC_INC "
hexfld.word 0 " Luma_VSRC_INC "
;tree.end

base ad:0x80130c84
;tree "BLT_Y_RZI"
group 0--3
line.long 0 "BLT_Y_RZI"
bitfld.long 0 0.--9. " Hsrc_init_luma "  " "
bitfld.long 0 12.--14. " Hnb_repeat_luma "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--25. " Vsrc_init_luma "  " "
bitfld.long 0 28.--30. " Vnb_repeat_Luma "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130c88
;tree "BLT_Y_HFP"
group 0--3
line.long 0 "BLT_Y_HFP"
bitfld.long 0 0.--25. " Y_HFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " Y_Hfp_Bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c8c
;tree "BLT_Y_VFP"
group 0--3
line.long 0 "BLT_Y_VFP"
bitfld.long 0 0.--25. " Y_VFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " Y_Vfp_Bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130ca0
;tree "BLT_KEY1"
group 0--3
line.long 0 "BLT_KEY1"
hexfld.byte 0 " BLUE_MIN "
hexfld.byte 1 " GREEN_MIN "
hexfld.byte 2 " RED_MIN "
hexfld.byte 3 " ALPHA0 "
;tree.end

base ad:0x80130ca4
;tree "BLT_KEY2"
group 0--3
line.long 0 "BLT_KEY2"
hexfld.byte 0 " BLUE_MAX "
hexfld.byte 1 " GREEN_MAX "
hexfld.byte 2 " RED_MAX "
hexfld.byte 3 " ALPHA1 "
;tree.end

base ad:0x80130cb0
;tree "BLT_SAR"
group 0--3
line.long 0 "BLT_SAR"
bitfld.long 0 0.--4. " S1_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " S2_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " S3_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--27. " T_STBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " A_SGA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130cb4
;tree "BLT_USR"
group 0--3
line.long 0 "BLT_USR"
hexfld.long 0 " GENERAL_PURPOSE "
;tree.end

base ad:0x80130cc0
;tree "BLT_IVMX0"
group 0--3
line.long 0 "BLT_IVMX0"
bitfld.long 0 0.--9. " Coeff13 "  " "
bitfld.long 0 10.--20. " Coeff12 "  " "
bitfld.long 0 21.--31. " Coeff11 "  " "
;tree.end

base ad:0x80130cc4
;tree "BLT_IVMX1"
group 0--3
line.long 0 "BLT_IVMX1"
bitfld.long 0 0.--9. " Coeff23 "  " "
bitfld.long 0 10.--20. " Coeff22 "  " "
bitfld.long 0 21.--31. " Coeff21 "  " "
;tree.end

base ad:0x80130cc8
;tree "BLT_IVMX2"
group 0--3
line.long 0 "BLT_IVMX2"
bitfld.long 0 0.--9. " Coeff33 "  " "
bitfld.long 0 10.--20. " Coeff32 "  " "
bitfld.long 0 21.--31. " Coeff31 "  " "
;tree.end

base ad:0x80130ccc
;tree "BLT_IVMX3"
group 0--3
line.long 0 "BLT_IVMX3"
bitfld.long 0 0.--9. " Offset3 "  " "
bitfld.long 0 10.--19. " Offset2 "  " "
bitfld.long 0 20.--29. " Offset1 "  " "
;tree.end

base ad:0x80130cd0
;tree "BLT_OVMX0"
group 0--3
line.long 0 "BLT_OVMX0"
bitfld.long 0 0.--9. " Coeff13 "  " "
bitfld.long 0 10.--20. " Coeff12 "  " "
bitfld.long 0 21.--31. " Coeff11 "  " "
;tree.end

base ad:0x80130cd4
;tree "BLT_OVMX1"
group 0--3
line.long 0 "BLT_OVMX1"
bitfld.long 0 0.--9. " Coeff23 "  " "
bitfld.long 0 10.--20. " Coeff22 "  " "
bitfld.long 0 21.--31. " Coeff21 "  " "
;tree.end

base ad:0x80130cd8
;tree "BLT_OVMX2"
group 0--3
line.long 0 "BLT_OVMX2"
bitfld.long 0 0.--9. " Coeff33 "  " "
bitfld.long 0 10.--20. " Coeff32 "  " "
bitfld.long 0 21.--31. " Coeff31 "  " "
;tree.end

base ad:0x80130cdc
;tree "BLT_OVMX3"
group 0--3
line.long 0 "BLT_OVMX3"
bitfld.long 0 0.--9. " Offset3 "  " "
bitfld.long 0 10.--19. " Offset2 "  " "
bitfld.long 0 20.--29. " Offset1 "  " "
;tree.end

base ad:0x80130ce8
;tree "BLT_VC1R"
group 0--3
line.long 0 "BLT_VC1R"
bitfld.long 0 0.--2. " Luma_coeff "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " Luma_Map "  "0 ,1 "
bitfld.long 0 4.--6. " Chroma_coeff "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " Chroma_map "  "0 ,1 "
;tree.end

base ad:0x80130e00
;tree "BLT_HFC0"
group 0--3
line.long 0 "BLT_HFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

base ad:0x80130e04
;tree "BLT_HFC1"
group 0--3
line.long 0 "BLT_HFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K5 "
hexfld.byte 2 " K6 "
hexfld.byte 3 " K7 "
;tree.end

base ad:0x80130e08
;tree "BLT_HFC2"
group 0--3
line.long 0 "BLT_HFC2"
hexfld.byte 0 " K10 "
hexfld.byte 1 " K11 "
hexfld.byte 2 " K12 "
hexfld.byte 3 " K13 "
;tree.end

base ad:0x80130e0c
;tree "BLT_HFC3"
group 0--3
line.long 0 "BLT_HFC3"
hexfld.byte 0 " K14 "
hexfld.byte 1 " K15 "
hexfld.byte 2 " K16 "
hexfld.byte 3 " K17 "
;tree.end

base ad:0x80130e10
;tree "BLT_HFC4"
group 0--3
line.long 0 "BLT_HFC4"
hexfld.byte 0 " K20 "
hexfld.byte 1 " K21 "
hexfld.byte 2 " K22 "
hexfld.byte 3 " K23 "
;tree.end

base ad:0x80130e14
;tree "BLT_HFC5"
group 0--3
line.long 0 "BLT_HFC5"
hexfld.byte 0 " K24 "
hexfld.byte 1 " K25 "
hexfld.byte 2 " K26 "
hexfld.byte 3 " K27 "
;tree.end

base ad:0x80130e18
;tree "BLT_HFC6"
group 0--3
line.long 0 "BLT_HFC6"
hexfld.byte 0 " K30 "
hexfld.byte 1 " K31 "
hexfld.byte 2 " K32 "
hexfld.byte 3 " K33 "
;tree.end

base ad:0x80130e1c
;tree "BLT_HFC7"
group 0--3
line.long 0 "BLT_HFC7"
hexfld.byte 0 " K34 "
hexfld.byte 1 " K35 "
hexfld.byte 2 " K36 "
hexfld.byte 3 " K37 "
;tree.end

base ad:0x80130e20
;tree "BLT_HFC8"
group 0--3
line.long 0 "BLT_HFC8"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

base ad:0x80130e24
;tree "BLT_HFC9"
group 0--3
line.long 0 "BLT_HFC9"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K45 "
hexfld.byte 2 " K46 "
hexfld.byte 3 " K47 "
;tree.end

base ad:0x80130e28
;tree "BLT_HFC10"
group 0--3
line.long 0 "BLT_HFC10"
hexfld.byte 0 " K50 "
hexfld.byte 1 " K51 "
hexfld.byte 2 " K52 "
hexfld.byte 3 " K53 "
;tree.end

base ad:0x80130e2c
;tree "BLT_HFC11"
group 0--3
line.long 0 "BLT_HFC11"
hexfld.byte 0 " K54 "
hexfld.byte 1 " K55 "
hexfld.byte 2 " K56 "
hexfld.byte 3 " K57 "
;tree.end

base ad:0x80130e30
;tree "BLT_HFC12"
group 0--3
line.long 0 "BLT_HFC12"
hexfld.byte 0 " K60 "
hexfld.byte 1 " K61 "
hexfld.byte 2 " K62 "
hexfld.byte 3 " K63 "
;tree.end

base ad:0x80130e34
;tree "BLT_HFC13"
group 0--3
line.long 0 "BLT_HFC13"
hexfld.byte 0 " K64 "
hexfld.byte 1 " K65 "
hexfld.byte 2 " K66 "
hexfld.byte 3 " K67 "
;tree.end

base ad:0x80130e38
;tree "BLT_HFC14"
group 0--3
line.long 0 "BLT_HFC14"
hexfld.byte 0 " K70 "
hexfld.byte 1 " K71 "
hexfld.byte 2 " K72 "
hexfld.byte 3 " K73 "
;tree.end

base ad:0x80130e3c
;tree "BLT_HFC15"
group 0--3
line.long 0 "BLT_HFC15"
hexfld.byte 0 " K74 "
hexfld.byte 1 " K75 "
hexfld.byte 2 " K76 "
hexfld.byte 3 " K77 "
;tree.end

base ad:0x80130e90
;tree "BLT_VFC0"
group 0--3
line.long 0 "BLT_VFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

base ad:0x80130e94
;tree "BLT_VFC1"
group 0--3
line.long 0 "BLT_VFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K10 "
hexfld.byte 2 " K11 "
hexfld.byte 3 " K12 "
;tree.end

base ad:0x80130e98
;tree "BLT_VFC2"
group 0--3
line.long 0 "BLT_VFC2"
hexfld.byte 0 " K13 "
hexfld.byte 1 " K14 "
hexfld.byte 2 " K20 "
hexfld.byte 3 " K21 "
;tree.end

base ad:0x80130e9c
;tree "BLT_VFC3"
group 0--3
line.long 0 "BLT_VFC3"
hexfld.byte 0 " K22 "
hexfld.byte 1 " K23 "
hexfld.byte 2 " K24 "
hexfld.byte 3 " K30 "
;tree.end

base ad:0x80130ea0
;tree "BLT_VFC4"
group 0--3
line.long 0 "BLT_VFC4"
hexfld.byte 0 " K31 "
hexfld.byte 1 " K32 "
hexfld.byte 2 " K33 "
hexfld.byte 3 " K34 "
;tree.end

base ad:0x80130ea4
;tree "BLT_VFC5"
group 0--3
line.long 0 "BLT_VFC5"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

base ad:0x80130ea8
;tree "BLT_VFC6"
group 0--3
line.long 0 "BLT_VFC6"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K50 "
hexfld.byte 2 " K51 "
hexfld.byte 3 " K52 "
;tree.end

base ad:0x80130eac
;tree "BLT_VFC7"
group 0--3
line.long 0 "BLT_VFC7"
hexfld.byte 0 " K53 "
hexfld.byte 1 " K54 "
hexfld.byte 2 " K60 "
hexfld.byte 3 " K61 "
;tree.end

base ad:0x80130eb0
;tree "BLT_VFC8"
group 0--3
line.long 0 "BLT_VFC8"
hexfld.byte 0 " K62 "
hexfld.byte 1 " K63 "
hexfld.byte 2 " K64 "
hexfld.byte 3 " K70 "
;tree.end

base ad:0x80130eb4
;tree "BLT_VFC9"
group 0--3
line.long 0 "BLT_VFC9"
hexfld.byte 0 " K71 "
hexfld.byte 1 " K72 "
hexfld.byte 2 " K73 "
hexfld.byte 3 " K74 "
;tree.end

base ad:0x80130d00
;tree "BLT_Y_HFC0"
group 0--3
line.long 0 "BLT_Y_HFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

base ad:0x80130d04
;tree "BLT_Y_HFC1"
group 0--3
line.long 0 "BLT_Y_HFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K5 "
hexfld.byte 2 " K6 "
hexfld.byte 3 " K7 "
;tree.end

base ad:0x80130d08
;tree "BLT_Y_HFC2"
group 0--3
line.long 0 "BLT_Y_HFC2"
hexfld.byte 0 " K10 "
hexfld.byte 1 " K11 "
hexfld.byte 2 " K12 "
hexfld.byte 3 " K13 "
;tree.end

base ad:0x80130d0c
;tree "BLT_Y_HFC3"
group 0--3
line.long 0 "BLT_Y_HFC3"
hexfld.byte 0 " K14 "
hexfld.byte 1 " K15 "
hexfld.byte 2 " K16 "
hexfld.byte 3 " K17 "
;tree.end

base ad:0x80130d10
;tree "BLT_Y_HFC4"
group 0--3
line.long 0 "BLT_Y_HFC4"
hexfld.byte 0 " K20 "
hexfld.byte 1 " K21 "
hexfld.byte 2 " K22 "
hexfld.byte 3 " K23 "
;tree.end

base ad:0x80130d14
;tree "BLT_Y_HFC5"
group 0--3
line.long 0 "BLT_Y_HFC5"
hexfld.byte 0 " K24 "
hexfld.byte 1 " K25 "
hexfld.byte 2 " K26 "
hexfld.byte 3 " K27 "
;tree.end

base ad:0x80130d18
;tree "BLT_Y_HFC6"
group 0--3
line.long 0 "BLT_Y_HFC6"
hexfld.byte 0 " K30 "
hexfld.byte 1 " K31 "
hexfld.byte 2 " K32 "
hexfld.byte 3 " K33 "
;tree.end

base ad:0x80130d1c
;tree "BLT_Y_HFC7"
group 0--3
line.long 0 "BLT_Y_HFC7"
hexfld.byte 0 " K34 "
hexfld.byte 1 " K35 "
hexfld.byte 2 " K36 "
hexfld.byte 3 " K37 "
;tree.end

base ad:0x80130d20
;tree "BLT_Y_HFC8"
group 0--3
line.long 0 "BLT_Y_HFC8"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

base ad:0x80130d24
;tree "BLT_Y_HFC9"
group 0--3
line.long 0 "BLT_Y_HFC9"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K45 "
hexfld.byte 2 " K46 "
hexfld.byte 3 " K47 "
;tree.end

base ad:0x80130d28
;tree "BLT_Y_HFC10"
group 0--3
line.long 0 "BLT_Y_HFC10"
hexfld.byte 0 " K50 "
hexfld.byte 1 " K51 "
hexfld.byte 2 " K52 "
hexfld.byte 3 " K53 "
;tree.end

base ad:0x80130d2c
;tree "BLT_Y_HFC11"
group 0--3
line.long 0 "BLT_Y_HFC11"
hexfld.byte 0 " K54 "
hexfld.byte 1 " K55 "
hexfld.byte 2 " K56 "
hexfld.byte 3 " K57 "
;tree.end

base ad:0x80130d30
;tree "BLT_Y_HFC12"
group 0--3
line.long 0 "BLT_Y_HFC12"
hexfld.byte 0 " K60 "
hexfld.byte 1 " K61 "
hexfld.byte 2 " K62 "
hexfld.byte 3 " K63 "
;tree.end

base ad:0x80130d34
;tree "BLT_Y_HFC13"
group 0--3
line.long 0 "BLT_Y_HFC13"
hexfld.byte 0 " K64 "
hexfld.byte 1 " K65 "
hexfld.byte 2 " K66 "
hexfld.byte 3 " K67 "
;tree.end

base ad:0x80130d38
;tree "BLT_Y_HFC14"
group 0--3
line.long 0 "BLT_Y_HFC14"
hexfld.byte 0 " K70 "
hexfld.byte 1 " K71 "
hexfld.byte 2 " K72 "
hexfld.byte 3 " K73 "
;tree.end

base ad:0x80130d3c
;tree "BLT_Y_HFC15"
group 0--3
line.long 0 "BLT_Y_HFC15"
hexfld.byte 0 " K74 "
hexfld.byte 1 " K75 "
hexfld.byte 2 " K76 "
hexfld.byte 3 " K77 "
;tree.end

base ad:0x80130d90
;tree "BLT_Y_VFC0"
group 0--3
line.long 0 "BLT_Y_VFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

base ad:0x80130d94
;tree "BLT_Y_VFC1"
group 0--3
line.long 0 "BLT_Y_VFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K10 "
hexfld.byte 2 " K11 "
hexfld.byte 3 " K12 "
;tree.end

base ad:0x80130d98
;tree "BLT_Y_VFC2"
group 0--3
line.long 0 "BLT_Y_VFC2"
hexfld.byte 0 " K13 "
hexfld.byte 1 " K14 "
hexfld.byte 2 " K20 "
hexfld.byte 3 " K21 "
;tree.end

base ad:0x80130d9c
;tree "BLT_Y_VFC3"
group 0--3
line.long 0 "BLT_Y_VFC3"
hexfld.byte 0 " K22 "
hexfld.byte 1 " K23 "
hexfld.byte 2 " K24 "
hexfld.byte 3 " K30 "
;tree.end

base ad:0x80130da0
;tree "BLT_Y_VFC4"
group 0--3
line.long 0 "BLT_Y_VFC4"
hexfld.byte 0 " K31 "
hexfld.byte 1 " K32 "
hexfld.byte 2 " K33 "
hexfld.byte 3 " K34 "
;tree.end

base ad:0x80130da4
;tree "BLT_Y_VFC5"
group 0--3
line.long 0 "BLT_Y_VFC5"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

base ad:0x80130da8
;tree "BLT_Y_VFC6"
group 0--3
line.long 0 "BLT_Y_VFC6"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K50 "
hexfld.byte 2 " K51 "
hexfld.byte 3 " K52 "
;tree.end

base ad:0x80130dac
;tree "BLT_Y_VFC7"
group 0--3
line.long 0 "BLT_Y_VFC7"
hexfld.byte 0 " K53 "
hexfld.byte 1 " K54 "
hexfld.byte 2 " K60 "
hexfld.byte 3 " K61 "
;tree.end

base ad:0x80130db0
;tree "BLT_Y_VFC8"
group 0--3
line.long 0 "BLT_Y_VFC8"
hexfld.byte 0 " K62 "
hexfld.byte 1 " K63 "
hexfld.byte 2 " K64 "
hexfld.byte 3 " K70 "
;tree.end

base ad:0x80130db4
;tree "BLT_Y_VFC9"
group 0--3
line.long 0 "BLT_Y_VFC9"
hexfld.byte 0 " K71 "
hexfld.byte 1 " K72 "
hexfld.byte 2 " K73 "
hexfld.byte 3 " K74 "
;tree.end

endif

tree.end

;==============================================================
tree "CLK_RST1"
;==============================================================
base ad:0x8012f000
;tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERCKEN8 "  "0 ,1 "
bitfld.long 0 9. " PERCKEN9 "  "0 ,1 "
;tree.end

base ad:0x8012f004
;tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERCKDIS8 "  "0 ,1 "
bitfld.long 0 9. " PERCKDIS9 "  "0 ,1 "
;tree.end

base ad:0x8012f008
;tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERKCKEN8 "  "0 ,1 "
;tree.end

base ad:0x8012f00c
;tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERKCKDIS8 "  "0 ,1 "
;tree.end

base ad:0x8012f010
;tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERCKSR8 "  "0 ,1 "
bitfld.long 0 9. " PERCKSR9 "  "0 ,1 "
;tree.end

base ad:0x8012f014
;tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERKCKSR8 "  "0 ,1 "
;tree.end

base ad:0x8012ffe0
;tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8012ffe4
;tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012ffe8
;tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012ffec
;tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8012fff0
;tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

base ad:0x8012fff4
;tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

base ad:0x8012fff8
;tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

base ad:0x8012fffc
;tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "CLK_RST2"
;==============================================================
base ad:0x8011f000
;tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERCKEN8 "  "0 ,1 "
bitfld.long 0 9. " PERCKEN9 "  "0 ,1 "
bitfld.long 0 10. " PERCKEN10 "  "0 ,1 "
bitfld.long 0 11. " PERCKEN11 "  "0 ,1 "
bitfld.long 0 12. " PERCKEN12 "  "0 ,1 "
;tree.end

base ad:0x8011f004
;tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERCKDIS8 "  "0 ,1 "
bitfld.long 0 9. " PERCKDIS9 "  "0 ,1 "
bitfld.long 0 10. " PERCKDIS10 "  "0 ,1 "
bitfld.long 0 11. " PERCKDIS11 "  "0 ,1 "
bitfld.long 0 12. " PERCKDIS12 "  "0 ,1 "
;tree.end

base ad:0x8011f008
;tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERKCKEN8 "  "0 ,1 "
;tree.end

base ad:0x8011f00c
;tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERKCKDIS8 "  "0 ,1 "
;tree.end

base ad:0x8011f010
;tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERCKSR8 "  "0 ,1 "
bitfld.long 0 9. " PERCKSR9 "  "0 ,1 "
bitfld.long 0 10. " PERCKSR10 "  "0 ,1 "
bitfld.long 0 11. " PERCKSR11 "  "0 ,1 "
bitfld.long 0 12. " 0PERCKSR12 "  "0 ,1 "
;tree.end

base ad:0x8011f014
;tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERKCKSR8 "  "0 ,1 "
;tree.end

base ad:0x8011ffe0
;tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8011ffe4
;tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011ffe8
;tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011ffec
;tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8011fff0
;tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

base ad:0x8011fff4
;tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

base ad:0x8011fff8
;tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

base ad:0x8011fffc
;tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "CLK_RST3"
;==============================================================
base ad:0x8000f000
;tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERCKEN8 "  "0 ,1 "
;tree.end

base ad:0x8000f004
;tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERCKDIS8 "  "0 ,1 "
;tree.end

base ad:0x8000f008
;tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKEN7 "  "0 ,1 "
;tree.end

base ad:0x8000f00c
;tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKDIS7 "  "0 ,1 "
;tree.end

base ad:0x8000f010
;tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERCKSR8 "  "0 ,1 "
;tree.end

base ad:0x8000f014
;tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKSR7 "  "0 ,1 "
;tree.end

base ad:0x8000ffe0
;tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8000ffe4
;tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8000ffe8
;tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8000ffec
;tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8000fff0
;tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

base ad:0x8000fff4
;tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

base ad:0x8000fff8
;tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

base ad:0x8000fffc
;tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "CLK_RST5"
;==============================================================
base ad:0xa03ff000
;tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
;tree.end

base ad:0xa03ff004
;tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
;tree.end

base ad:0xa03ff008
;tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
;tree.end

base ad:0xa03ff00c
;tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
;tree.end

base ad:0xa03ff010
;tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
;tree.end

base ad:0xa03ff014
;tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
;tree.end

base ad:0xa03fffe0
;tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03fffe4
;tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03fffe8
;tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03fffec
;tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03ffff0
;tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

base ad:0xa03ffff4
;tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

base ad:0xa03ffff8
;tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

base ad:0xa03ffffc
;tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "CLK_RST6"
;==============================================================
base ad:0xa03cf000
;tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
;tree.end

base ad:0xa03cf004
;tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
;tree.end

base ad:0xa03cf008
;tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
;tree.end

base ad:0xa03cf00c
;tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
;tree.end

base ad:0xa03cf010
;tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
;tree.end

base ad:0xa03cf014
;tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
;tree.end

base ad:0xa03cffe0
;tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03cffe4
;tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cffe8
;tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cffec
;tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03cfff0
;tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

base ad:0xa03cfff4
;tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

base ad:0xa03cfff8
;tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

base ad:0xa03cfffc
;tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "CLK_RST7"
;==============================================================
base ad:0xa03df000
;tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
;tree.end

base ad:0xa03df004
;tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
;tree.end

base ad:0xa03df008
;tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
;tree.end

base ad:0xa03df00c
;tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
;tree.end

base ad:0xa03df010
;tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
;tree.end

base ad:0xa03df014
;tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
;tree.end

base ad:0xa03dffe0
;tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03dffe4
;tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03dffe8
;tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03dffec
;tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03dfff0
;tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

base ad:0xa03dfff4
;tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

base ad:0xa03dfff8
;tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

base ad:0xa03dfffc
;tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "CR"
;==============================================================
base ad:0xa03d8000
;tree "CR_REG0"
group 0--3
line.long 0 "CR_REG0"
bitfld.long 0 0.--2. " VPIPWM8MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " MSP0WR "  "0 ,1 "
bitfld.long 0 4.--7. " SPARE0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--12. " MDMTPDATSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " MDMTPCTL "  "0 ,1 "
bitfld.long 0 16.--17. " SXAGPIO "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--21. " SBAGD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 22.--25. " SBAGT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 26. " HTIMEN "  "0 ,1 "
bitfld.long 0 28.--31. " SPARE1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03d8008
;tree "CR_REG2"
group 0--3
line.long 0 "CR_REG2"
bitfld.long 0 0.--3. " KPSKA0MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " KPSKA1MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " KPSKA2MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " KPSKB0MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " KPSKB1MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " KPSKB2MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " KP08MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 27.--29. " KP09MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " KBDORETM "  "0 ,1 "
;tree.end

base ad:0xa03d800c
;tree "CR_REG3"
group 0--3
line.long 0 "CR_REG3"
bitfld.long 0 0.--1. " SVADMACH0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " SVADMACH1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " SVADMACH2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " SVADMACH3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--17. " SIADMACH0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " SIADMACH1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " SIADMACH2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " SIADMACH3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03d8010
;tree "CR_REG4"
group 0--3
line.long 0 "CR_REG4"
bitfld.long 0 0.--1. " SAADMACH0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " SAADMACH1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " SAADMACH2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " SAADMACH3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03d8014
;tree "CR_REG5"
group 0--3
line.long 0 "CR_REG5"
bitfld.long 0 0.--3. " HSISLIM0RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " HSISLIM0TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " HSISLIM1RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " HSISLIM1TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 30. " MSP0SLIM0RX "  "0 ,1 "
bitfld.long 0 31. " MSP0SLIM0TX "  "0 ,1 "
;tree.end

base ad:0xa03d8020
;tree "CR_XDBG"
group 0--3
line.long 0 "CR_XDBG"
bitfld.long 0 0. " XDBGEN "  "0 ,1 "
bitfld.long 0 1. " EXTBRKEn "  "0 ,1 "
bitfld.long 0 4.--9. " XDBGSRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa03d8fe0
;tree "CRPeriphID0"
rgroup 0--3
line.long 0 "CRPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03d8fe4
;tree "CRPeriphID1"
rgroup 0--3
line.long 0 "CRPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03d8fe8
;tree "CRPeriphID2"
rgroup 0--3
line.long 0 "CRPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03d8fec
;tree "CRPeriphID3"
rgroup 0--3
line.long 0 "CRPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03d8ff0
;tree "CRPCellID0"
rgroup 0--3
line.long 0 "CRPCellID0"
hexfld.byte 0 " CRPCellID0 "
;tree.end

base ad:0xa03d8ff4
;tree "CRPCellID1"
rgroup 0--3
line.long 0 "CRPCellID1"
hexfld.byte 0 " CRPCellID1 "
;tree.end

base ad:0xa03d8ff8
;tree "CRPCellID2"
rgroup 0--3
line.long 0 "CRPCellID2"
hexfld.byte 0 " CRPCellID2 "
;tree.end

base ad:0xa03d8ffc
;tree "CRPCellID3"
rgroup 0--3
line.long 0 "CRPCellID3"
hexfld.byte 0 " CRPCellID3 "
;tree.end

tree.end

;==============================================================
tree "CRYP (2 instances)"
;==============================================================
base ad:0xa03ca000
;********************************************
tree "CRYP-0"
;********************************************
base ad:0xa03ca000
;tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SEC "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGODIR "  "0 ,1 "
bitfld.long 0 3.--5. " ALGOMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--7. " DATATYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " KEYSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " KEYRDEN "  "0 ,1 "
bitfld.long 0 11. " KSE "  "0 ,1 "
bitfld.long 0 12. " EXD "  "0 ,1 "
bitfld.long 0 13. " INIT "  "0 ,1 "
bitfld.long 0 14. " FFLUSH "  "0 ,1 "
bitfld.long 0 15. " CRYPEN "  "0 ,1 "
bitfld.long 0 16. " SECONDLAST "  "0 ,1 "
;tree.end

base ad:0xa03ca004
;tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " IFEM "  "0 ,1 "
bitfld.long 0 1. " IFNF "  "0 ,1 "
bitfld.long 0 2. " OFNE "  "0 ,1 "
bitfld.long 0 3. " OFFU "  "0 ,1 "
bitfld.long 0 4. " BUSY "  "0 ,1 "
;tree.end

base ad:0xa03ca008
;tree "0DIN"
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa03ca00c
;tree "0DINSIZE"
group 0--3
line.long 0 "DINSIZE"
bitfld.long 0 0.--3. " DINSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03ca010
;tree "0DOUT"
rgroup 0--3
line.long 0 "DOUT"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa03ca014
;tree "0DOUTSIZE"
rgroup 0--3
line.long 0 "DOUTSIZE"
bitfld.long 0 0.--3. " DOUTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03ca018
;tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " DMAINEN "  "0 ,1 "
bitfld.long 0 1. " DMAOUTEN "  "0 ,1 "
;tree.end

base ad:0xa03ca01c
;tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " INIM "  "0 ,1 "
bitfld.long 0 1. " OUTIM "  "0 ,1 "
;tree.end

base ad:0xa03ca020
;tree "0RIS"
group 0--3
line.long 0 "RIS"
bitfld.long 0 0. " INRIS "  "0 ,1 "
bitfld.long 0 1. " OUTRIS "  "0 ,1 "
;tree.end

base ad:0xa03ca024
;tree "0MIS"
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " INMIS "  "0 ,1 "
bitfld.long 0 1. " OUTMIS "  "0 ,1 "
;tree.end

base ad:0xa03ca028
;tree "0K1L"
group 0--3
line.long 0 "K1L"
bitfld.long 0 0. " K31 "  "0 ,1 "
bitfld.long 0 1. " K30 "  "0 ,1 "
bitfld.long 0 2. " K29 "  "0 ,1 "
bitfld.long 0 3. " K28 "  "0 ,1 "
bitfld.long 0 4. " K27 "  "0 ,1 "
bitfld.long 0 5. " K26 "  "0 ,1 "
bitfld.long 0 6. " K25 "  "0 ,1 "
bitfld.long 0 7. " K24 "  "0 ,1 "
bitfld.long 0 8. " K23 "  "0 ,1 "
bitfld.long 0 9. " K22 "  "0 ,1 "
bitfld.long 0 10. " K21 "  "0 ,1 "
bitfld.long 0 11. " K20 "  "0 ,1 "
bitfld.long 0 12. " K19 "  "0 ,1 "
bitfld.long 0 13. " K18 "  "0 ,1 "
bitfld.long 0 14. " K17 "  "0 ,1 "
bitfld.long 0 15. " K16 "  "0 ,1 "
bitfld.long 0 16. " K15 "  "0 ,1 "
bitfld.long 0 17. " K14 "  "0 ,1 "
bitfld.long 0 18. " K13 "  "0 ,1 "
bitfld.long 0 19. " K12 "  "0 ,1 "
bitfld.long 0 20. " K11 "  "0 ,1 "
bitfld.long 0 21. " K10 "  "0 ,1 "
bitfld.long 0 22. " K9 "  "0 ,1 "
bitfld.long 0 23. " K8 "  "0 ,1 "
bitfld.long 0 24. " K7 "  "0 ,1 "
bitfld.long 0 25. " K6 "  "0 ,1 "
bitfld.long 0 26. " K5 "  "0 ,1 "
bitfld.long 0 27. " K4 "  "0 ,1 "
bitfld.long 0 28. " K3 "  "0 ,1 "
bitfld.long 0 29. " K2 "  "0 ,1 "
bitfld.long 0 30. " K1 "  "0 ,1 "
bitfld.long 0 31. " K0 "  "0 ,1 "
;tree.end

base ad:0xa03ca02c
;tree "0K1R"
group 0--3
line.long 0 "K1R"
bitfld.long 0 0. " K63 "  "0 ,1 "
bitfld.long 0 1. " K62 "  "0 ,1 "
bitfld.long 0 2. " K61 "  "0 ,1 "
bitfld.long 0 3. " K60 "  "0 ,1 "
bitfld.long 0 4. " K59 "  "0 ,1 "
bitfld.long 0 5. " K58 "  "0 ,1 "
bitfld.long 0 6. " K57 "  "0 ,1 "
bitfld.long 0 7. " K56 "  "0 ,1 "
bitfld.long 0 8. " K55 "  "0 ,1 "
bitfld.long 0 9. " K54 "  "0 ,1 "
bitfld.long 0 10. " K53 "  "0 ,1 "
bitfld.long 0 11. " K52 "  "0 ,1 "
bitfld.long 0 12. " K51 "  "0 ,1 "
bitfld.long 0 13. " K50 "  "0 ,1 "
bitfld.long 0 14. " K49 "  "0 ,1 "
bitfld.long 0 15. " K48 "  "0 ,1 "
bitfld.long 0 16. " K47 "  "0 ,1 "
bitfld.long 0 17. " K46 "  "0 ,1 "
bitfld.long 0 18. " K45 "  "0 ,1 "
bitfld.long 0 19. " K44 "  "0 ,1 "
bitfld.long 0 20. " K43 "  "0 ,1 "
bitfld.long 0 21. " K42 "  "0 ,1 "
bitfld.long 0 22. " K41 "  "0 ,1 "
bitfld.long 0 23. " K40 "  "0 ,1 "
bitfld.long 0 24. " K39 "  "0 ,1 "
bitfld.long 0 25. " K38 "  "0 ,1 "
bitfld.long 0 26. " K37 "  "0 ,1 "
bitfld.long 0 27. " K36 "  "0 ,1 "
bitfld.long 0 28. " K35 "  "0 ,1 "
bitfld.long 0 29. " K34 "  "0 ,1 "
bitfld.long 0 30. " K33 "  "0 ,1 "
bitfld.long 0 31. " K32 "  "0 ,1 "
;tree.end

base ad:0xa03ca030
;tree "0K2L"
group 0--3
line.long 0 "K2L"
bitfld.long 0 0. " K95 "  "0 ,1 "
bitfld.long 0 1. " K94 "  "0 ,1 "
bitfld.long 0 2. " K93 "  "0 ,1 "
bitfld.long 0 3. " K92 "  "0 ,1 "
bitfld.long 0 4. " K91 "  "0 ,1 "
bitfld.long 0 5. " K90 "  "0 ,1 "
bitfld.long 0 6. " K89 "  "0 ,1 "
bitfld.long 0 7. " K88 "  "0 ,1 "
bitfld.long 0 8. " K87 "  "0 ,1 "
bitfld.long 0 9. " K86 "  "0 ,1 "
bitfld.long 0 10. " K85 "  "0 ,1 "
bitfld.long 0 11. " K84 "  "0 ,1 "
bitfld.long 0 12. " K83 "  "0 ,1 "
bitfld.long 0 13. " K82 "  "0 ,1 "
bitfld.long 0 14. " K81 "  "0 ,1 "
bitfld.long 0 15. " K80 "  "0 ,1 "
bitfld.long 0 16. " K79 "  "0 ,1 "
bitfld.long 0 17. " K78 "  "0 ,1 "
bitfld.long 0 18. " K77 "  "0 ,1 "
bitfld.long 0 19. " K76 "  "0 ,1 "
bitfld.long 0 20. " K75 "  "0 ,1 "
bitfld.long 0 21. " K74 "  "0 ,1 "
bitfld.long 0 22. " K73 "  "0 ,1 "
bitfld.long 0 23. " K72 "  "0 ,1 "
bitfld.long 0 24. " K71 "  "0 ,1 "
bitfld.long 0 25. " K70 "  "0 ,1 "
bitfld.long 0 26. " K69 "  "0 ,1 "
bitfld.long 0 27. " K68 "  "0 ,1 "
bitfld.long 0 28. " K67 "  "0 ,1 "
bitfld.long 0 29. " K66 "  "0 ,1 "
bitfld.long 0 30. " K65 "  "0 ,1 "
bitfld.long 0 31. " K64 "  "0 ,1 "
;tree.end

base ad:0xa03ca034
;tree "0K2R"
group 0--3
line.long 0 "K2R"
bitfld.long 0 0. " K127 "  "0 ,1 "
bitfld.long 0 1. " K126 "  "0 ,1 "
bitfld.long 0 2. " K125 "  "0 ,1 "
bitfld.long 0 3. " K124 "  "0 ,1 "
bitfld.long 0 4. " K123 "  "0 ,1 "
bitfld.long 0 5. " K122 "  "0 ,1 "
bitfld.long 0 6. " K121 "  "0 ,1 "
bitfld.long 0 7. " K120 "  "0 ,1 "
bitfld.long 0 8. " K119 "  "0 ,1 "
bitfld.long 0 9. " K118 "  "0 ,1 "
bitfld.long 0 10. " K117 "  "0 ,1 "
bitfld.long 0 11. " K116 "  "0 ,1 "
bitfld.long 0 12. " K115 "  "0 ,1 "
bitfld.long 0 13. " K114 "  "0 ,1 "
bitfld.long 0 14. " K113 "  "0 ,1 "
bitfld.long 0 15. " K112 "  "0 ,1 "
bitfld.long 0 16. " K111 "  "0 ,1 "
bitfld.long 0 17. " K110 "  "0 ,1 "
bitfld.long 0 18. " K109 "  "0 ,1 "
bitfld.long 0 19. " K108 "  "0 ,1 "
bitfld.long 0 20. " K107 "  "0 ,1 "
bitfld.long 0 21. " K106 "  "0 ,1 "
bitfld.long 0 22. " K105 "  "0 ,1 "
bitfld.long 0 23. " K104 "  "0 ,1 "
bitfld.long 0 24. " K103 "  "0 ,1 "
bitfld.long 0 25. " K102 "  "0 ,1 "
bitfld.long 0 26. " K101 "  "0 ,1 "
bitfld.long 0 27. " K100 "  "0 ,1 "
bitfld.long 0 28. " K99 "  "0 ,1 "
bitfld.long 0 29. " K98 "  "0 ,1 "
bitfld.long 0 30. " K97 "  "0 ,1 "
bitfld.long 0 31. " K96 "  "0 ,1 "
;tree.end

base ad:0xa03ca038
;tree "0K3L"
group 0--3
line.long 0 "K3L"
bitfld.long 0 0. " K159 "  "0 ,1 "
bitfld.long 0 1. " K158 "  "0 ,1 "
bitfld.long 0 2. " K157 "  "0 ,1 "
bitfld.long 0 3. " K156 "  "0 ,1 "
bitfld.long 0 4. " K155 "  "0 ,1 "
bitfld.long 0 5. " K154 "  "0 ,1 "
bitfld.long 0 6. " K153 "  "0 ,1 "
bitfld.long 0 7. " K152 "  "0 ,1 "
bitfld.long 0 8. " K151 "  "0 ,1 "
bitfld.long 0 9. " K150 "  "0 ,1 "
bitfld.long 0 10. " K149 "  "0 ,1 "
bitfld.long 0 11. " K148 "  "0 ,1 "
bitfld.long 0 12. " K147 "  "0 ,1 "
bitfld.long 0 13. " K146 "  "0 ,1 "
bitfld.long 0 14. " K145 "  "0 ,1 "
bitfld.long 0 15. " K144 "  "0 ,1 "
bitfld.long 0 16. " K143 "  "0 ,1 "
bitfld.long 0 17. " K142 "  "0 ,1 "
bitfld.long 0 18. " K141 "  "0 ,1 "
bitfld.long 0 19. " K140 "  "0 ,1 "
bitfld.long 0 20. " K139 "  "0 ,1 "
bitfld.long 0 21. " K138 "  "0 ,1 "
bitfld.long 0 22. " K137 "  "0 ,1 "
bitfld.long 0 23. " K136 "  "0 ,1 "
bitfld.long 0 24. " K135 "  "0 ,1 "
bitfld.long 0 25. " K134 "  "0 ,1 "
bitfld.long 0 26. " K133 "  "0 ,1 "
bitfld.long 0 27. " K132 "  "0 ,1 "
bitfld.long 0 28. " K131 "  "0 ,1 "
bitfld.long 0 29. " K130 "  "0 ,1 "
bitfld.long 0 30. " K129 "  "0 ,1 "
bitfld.long 0 31. " K128 "  "0 ,1 "
;tree.end

base ad:0xa03ca03c
;tree "0K3R"
group 0--3
line.long 0 "K3R"
bitfld.long 0 0. " K191 "  "0 ,1 "
bitfld.long 0 1. " K190 "  "0 ,1 "
bitfld.long 0 2. " K189 "  "0 ,1 "
bitfld.long 0 3. " K188 "  "0 ,1 "
bitfld.long 0 4. " K187 "  "0 ,1 "
bitfld.long 0 5. " K186 "  "0 ,1 "
bitfld.long 0 6. " K185 "  "0 ,1 "
bitfld.long 0 7. " K184 "  "0 ,1 "
bitfld.long 0 8. " K183 "  "0 ,1 "
bitfld.long 0 9. " K182 "  "0 ,1 "
bitfld.long 0 10. " K181 "  "0 ,1 "
bitfld.long 0 11. " K180 "  "0 ,1 "
bitfld.long 0 12. " K179 "  "0 ,1 "
bitfld.long 0 13. " K178 "  "0 ,1 "
bitfld.long 0 14. " K177 "  "0 ,1 "
bitfld.long 0 15. " K176 "  "0 ,1 "
bitfld.long 0 16. " K175 "  "0 ,1 "
bitfld.long 0 17. " K174 "  "0 ,1 "
bitfld.long 0 18. " K173 "  "0 ,1 "
bitfld.long 0 19. " K172 "  "0 ,1 "
bitfld.long 0 20. " K171 "  "0 ,1 "
bitfld.long 0 21. " K170 "  "0 ,1 "
bitfld.long 0 22. " K169 "  "0 ,1 "
bitfld.long 0 23. " K168 "  "0 ,1 "
bitfld.long 0 24. " K167 "  "0 ,1 "
bitfld.long 0 25. " K166 "  "0 ,1 "
bitfld.long 0 26. " K165 "  "0 ,1 "
bitfld.long 0 27. " K164 "  "0 ,1 "
bitfld.long 0 28. " K163 "  "0 ,1 "
bitfld.long 0 29. " K162 "  "0 ,1 "
bitfld.long 0 30. " K161 "  "0 ,1 "
bitfld.long 0 31. " K160 "  "0 ,1 "
;tree.end

base ad:0xa03ca040
;tree "0K4L"
group 0--3
line.long 0 "K4L"
bitfld.long 0 0. " K223 "  "0 ,1 "
bitfld.long 0 1. " K222 "  "0 ,1 "
bitfld.long 0 2. " K221 "  "0 ,1 "
bitfld.long 0 3. " K220 "  "0 ,1 "
bitfld.long 0 4. " K219 "  "0 ,1 "
bitfld.long 0 5. " K218 "  "0 ,1 "
bitfld.long 0 6. " K217 "  "0 ,1 "
bitfld.long 0 7. " K216 "  "0 ,1 "
bitfld.long 0 8. " K215 "  "0 ,1 "
bitfld.long 0 9. " K214 "  "0 ,1 "
bitfld.long 0 10. " K213 "  "0 ,1 "
bitfld.long 0 11. " K212 "  "0 ,1 "
bitfld.long 0 12. " K211 "  "0 ,1 "
bitfld.long 0 13. " K210 "  "0 ,1 "
bitfld.long 0 14. " K209 "  "0 ,1 "
bitfld.long 0 15. " K208 "  "0 ,1 "
bitfld.long 0 16. " K207 "  "0 ,1 "
bitfld.long 0 17. " K206 "  "0 ,1 "
bitfld.long 0 18. " K205 "  "0 ,1 "
bitfld.long 0 19. " K204 "  "0 ,1 "
bitfld.long 0 20. " K203 "  "0 ,1 "
bitfld.long 0 21. " K202 "  "0 ,1 "
bitfld.long 0 22. " K201 "  "0 ,1 "
bitfld.long 0 23. " K200 "  "0 ,1 "
bitfld.long 0 24. " K199 "  "0 ,1 "
bitfld.long 0 25. " K198 "  "0 ,1 "
bitfld.long 0 26. " K197 "  "0 ,1 "
bitfld.long 0 27. " K196 "  "0 ,1 "
bitfld.long 0 28. " K195 "  "0 ,1 "
bitfld.long 0 29. " K194 "  "0 ,1 "
bitfld.long 0 30. " K193 "  "0 ,1 "
bitfld.long 0 31. " K192 "  "0 ,1 "
;tree.end

base ad:0xa03ca044
;tree "0K4R"
group 0--3
line.long 0 "K4R"
bitfld.long 0 0. " K255 "  "0 ,1 "
bitfld.long 0 1. " K254 "  "0 ,1 "
bitfld.long 0 2. " K253 "  "0 ,1 "
bitfld.long 0 3. " K252 "  "0 ,1 "
bitfld.long 0 4. " K251 "  "0 ,1 "
bitfld.long 0 5. " K250 "  "0 ,1 "
bitfld.long 0 6. " K249 "  "0 ,1 "
bitfld.long 0 7. " K248 "  "0 ,1 "
bitfld.long 0 8. " K247 "  "0 ,1 "
bitfld.long 0 9. " K246 "  "0 ,1 "
bitfld.long 0 10. " K245 "  "0 ,1 "
bitfld.long 0 11. " K244 "  "0 ,1 "
bitfld.long 0 12. " K243 "  "0 ,1 "
bitfld.long 0 13. " K242 "  "0 ,1 "
bitfld.long 0 14. " K241 "  "0 ,1 "
bitfld.long 0 15. " K240 "  "0 ,1 "
bitfld.long 0 16. " K239 "  "0 ,1 "
bitfld.long 0 17. " K238 "  "0 ,1 "
bitfld.long 0 18. " K237 "  "0 ,1 "
bitfld.long 0 19. " K236 "  "0 ,1 "
bitfld.long 0 20. " K235 "  "0 ,1 "
bitfld.long 0 21. " K234 "  "0 ,1 "
bitfld.long 0 22. " K233 "  "0 ,1 "
bitfld.long 0 23. " K232 "  "0 ,1 "
bitfld.long 0 24. " K231 "  "0 ,1 "
bitfld.long 0 25. " K230 "  "0 ,1 "
bitfld.long 0 26. " K229 "  "0 ,1 "
bitfld.long 0 27. " K228 "  "0 ,1 "
bitfld.long 0 28. " K227 "  "0 ,1 "
bitfld.long 0 29. " K226 "  "0 ,1 "
bitfld.long 0 30. " K225 "  "0 ,1 "
bitfld.long 0 31. " K224 "  "0 ,1 "
;tree.end

base ad:0xa03ca048
;tree "0IV0L"
group 0--3
line.long 0 "IV0L"
bitfld.long 0 0. " IV32 "  "0 ,1 "
bitfld.long 0 1. " IV31 "  "0 ,1 "
bitfld.long 0 2. " IV30 "  "0 ,1 "
bitfld.long 0 3. " IV29 "  "0 ,1 "
bitfld.long 0 4. " IV28 "  "0 ,1 "
bitfld.long 0 5. " IV27 "  "0 ,1 "
bitfld.long 0 6. " IV26 "  "0 ,1 "
bitfld.long 0 7. " IV25 "  "0 ,1 "
bitfld.long 0 8. " IV24 "  "0 ,1 "
bitfld.long 0 9. " IV23 "  "0 ,1 "
bitfld.long 0 10. " IV22 "  "0 ,1 "
bitfld.long 0 11. " IV21 "  "0 ,1 "
bitfld.long 0 12. " IV20 "  "0 ,1 "
bitfld.long 0 13. " IV19 "  "0 ,1 "
bitfld.long 0 14. " IV18 "  "0 ,1 "
bitfld.long 0 15. " IV17 "  "0 ,1 "
bitfld.long 0 16. " IV16 "  "0 ,1 "
bitfld.long 0 17. " IV15 "  "0 ,1 "
bitfld.long 0 18. " IV14 "  "0 ,1 "
bitfld.long 0 19. " IV13 "  "0 ,1 "
bitfld.long 0 20. " IV12 "  "0 ,1 "
bitfld.long 0 21. " IV11 "  "0 ,1 "
bitfld.long 0 22. " IV10 "  "0 ,1 "
bitfld.long 0 23. " IV9 "  "0 ,1 "
bitfld.long 0 24. " IV8 "  "0 ,1 "
bitfld.long 0 25. " IV7 "  "0 ,1 "
bitfld.long 0 26. " IV6 "  "0 ,1 "
bitfld.long 0 27. " IV5 "  "0 ,1 "
bitfld.long 0 28. " IV4 "  "0 ,1 "
bitfld.long 0 29. " IV3 "  "0 ,1 "
bitfld.long 0 30. " IV2 "  "0 ,1 "
bitfld.long 0 31. " IV1 "  "0 ,1 "
;tree.end

base ad:0xa03ca04c
;tree "0IV0R"
group 0--3
line.long 0 "IV0R"
bitfld.long 0 0. " IV64 "  "0 ,1 "
bitfld.long 0 1. " IV63 "  "0 ,1 "
bitfld.long 0 2. " IV62 "  "0 ,1 "
bitfld.long 0 3. " IV61 "  "0 ,1 "
bitfld.long 0 4. " IV60 "  "0 ,1 "
bitfld.long 0 5. " IV59 "  "0 ,1 "
bitfld.long 0 6. " IV58 "  "0 ,1 "
bitfld.long 0 7. " IV57 "  "0 ,1 "
bitfld.long 0 8. " IV56 "  "0 ,1 "
bitfld.long 0 9. " IV55 "  "0 ,1 "
bitfld.long 0 10. " IV54 "  "0 ,1 "
bitfld.long 0 11. " IV53 "  "0 ,1 "
bitfld.long 0 12. " IV52 "  "0 ,1 "
bitfld.long 0 13. " IV51 "  "0 ,1 "
bitfld.long 0 14. " IV50 "  "0 ,1 "
bitfld.long 0 15. " IV49 "  "0 ,1 "
bitfld.long 0 16. " IV48 "  "0 ,1 "
bitfld.long 0 17. " IV47 "  "0 ,1 "
bitfld.long 0 18. " IV46 "  "0 ,1 "
bitfld.long 0 19. " IV45 "  "0 ,1 "
bitfld.long 0 20. " IV44 "  "0 ,1 "
bitfld.long 0 21. " IV43 "  "0 ,1 "
bitfld.long 0 22. " IV42 "  "0 ,1 "
bitfld.long 0 23. " IV41 "  "0 ,1 "
bitfld.long 0 24. " IV40 "  "0 ,1 "
bitfld.long 0 25. " IV39 "  "0 ,1 "
bitfld.long 0 26. " IV38 "  "0 ,1 "
bitfld.long 0 27. " IV37 "  "0 ,1 "
bitfld.long 0 28. " IV36 "  "0 ,1 "
bitfld.long 0 29. " IV35 "  "0 ,1 "
bitfld.long 0 30. " IV34 "  "0 ,1 "
bitfld.long 0 31. " IV33 "  "0 ,1 "
;tree.end

base ad:0xa03ca050
;tree "0IV1L"
group 0--3
line.long 0 "IV1L"
bitfld.long 0 0. " IV96 "  "0 ,1 "
bitfld.long 0 1. " IV95 "  "0 ,1 "
bitfld.long 0 2. " IV94 "  "0 ,1 "
bitfld.long 0 3. " IV93 "  "0 ,1 "
bitfld.long 0 4. " IV92 "  "0 ,1 "
bitfld.long 0 5. " IV91 "  "0 ,1 "
bitfld.long 0 6. " IV90 "  "0 ,1 "
bitfld.long 0 7. " IV89 "  "0 ,1 "
bitfld.long 0 8. " IV88 "  "0 ,1 "
bitfld.long 0 9. " IV87 "  "0 ,1 "
bitfld.long 0 10. " IV86 "  "0 ,1 "
bitfld.long 0 11. " IV85 "  "0 ,1 "
bitfld.long 0 12. " IV84 "  "0 ,1 "
bitfld.long 0 13. " IV83 "  "0 ,1 "
bitfld.long 0 14. " IV82 "  "0 ,1 "
bitfld.long 0 15. " IV81 "  "0 ,1 "
bitfld.long 0 16. " IV80 "  "0 ,1 "
bitfld.long 0 17. " IV79 "  "0 ,1 "
bitfld.long 0 18. " IV78 "  "0 ,1 "
bitfld.long 0 19. " IV77 "  "0 ,1 "
bitfld.long 0 20. " IV76 "  "0 ,1 "
bitfld.long 0 21. " IV75 "  "0 ,1 "
bitfld.long 0 22. " IV74 "  "0 ,1 "
bitfld.long 0 23. " IV73 "  "0 ,1 "
bitfld.long 0 24. " IV72 "  "0 ,1 "
bitfld.long 0 25. " IV71 "  "0 ,1 "
bitfld.long 0 26. " IV70 "  "0 ,1 "
bitfld.long 0 27. " IV69 "  "0 ,1 "
bitfld.long 0 28. " IV68 "  "0 ,1 "
bitfld.long 0 29. " IV67 "  "0 ,1 "
bitfld.long 0 30. " IV66 "  "0 ,1 "
bitfld.long 0 31. " IV65 "  "0 ,1 "
;tree.end

base ad:0xa03ca054
;tree "0IV1R"
group 0--3
line.long 0 "IV1R"
bitfld.long 0 0. " IV128 "  "0 ,1 "
bitfld.long 0 1. " IV127 "  "0 ,1 "
bitfld.long 0 2. " IV126 "  "0 ,1 "
bitfld.long 0 3. " IV125 "  "0 ,1 "
bitfld.long 0 4. " IV124 "  "0 ,1 "
bitfld.long 0 5. " IV123 "  "0 ,1 "
bitfld.long 0 6. " IV122 "  "0 ,1 "
bitfld.long 0 7. " IV121 "  "0 ,1 "
bitfld.long 0 8. " IV120 "  "0 ,1 "
bitfld.long 0 9. " IV119 "  "0 ,1 "
bitfld.long 0 10. " IV118 "  "0 ,1 "
bitfld.long 0 11. " IV117 "  "0 ,1 "
bitfld.long 0 12. " IV116 "  "0 ,1 "
bitfld.long 0 13. " IV115 "  "0 ,1 "
bitfld.long 0 14. " IV114 "  "0 ,1 "
bitfld.long 0 15. " IV113 "  "0 ,1 "
bitfld.long 0 16. " IV112 "  "0 ,1 "
bitfld.long 0 17. " IV111 "  "0 ,1 "
bitfld.long 0 18. " IV110 "  "0 ,1 "
bitfld.long 0 19. " IV109 "  "0 ,1 "
bitfld.long 0 20. " IV108 "  "0 ,1 "
bitfld.long 0 21. " IV107 "  "0 ,1 "
bitfld.long 0 22. " IV106 "  "0 ,1 "
bitfld.long 0 23. " IV105 "  "0 ,1 "
bitfld.long 0 24. " IV104 "  "0 ,1 "
bitfld.long 0 25. " IV103 "  "0 ,1 "
bitfld.long 0 26. " IV102 "  "0 ,1 "
bitfld.long 0 27. " IV101 "  "0 ,1 "
bitfld.long 0 28. " IV100 "  "0 ,1 "
bitfld.long 0 29. " IV99 "  "0 ,1 "
bitfld.long 0 30. " IV98 "  "0 ,1 "
bitfld.long 0 31. " IV97 "  "0 ,1 "
;tree.end

base ad:0xa03ca080
;tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0xa03ca084
;tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMAIUTC "  "0 ,1 "
bitfld.long 0 1. " DMAOUTC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
;tree.end

base ad:0xa03ca088
;tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMAINBREQ "  "0 ,1 "
bitfld.long 0 1. " DMAOUTBREQ "  "0 ,1 "
bitfld.long 0 2. " DMAOUTSREQ "  "0 ,1 "
bitfld.long 0 3. " ININTR "  "0 ,1 "
bitfld.long 0 4. " OUTINTR "  "0 ,1 "
;tree.end

base ad:0xa03cafe0
;tree "0CRYPPeriphID0"
rgroup 0--3
line.long 0 "CRYPPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03cafe4
;tree "0CRYPPeriphID1"
rgroup 0--3
line.long 0 "CRYPPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cafe8
;tree "0CRYPPeriphID2"
rgroup 0--3
line.long 0 "CRYPPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cafec
;tree "0CRYPPeriphID3"
rgroup 0--3
line.long 0 "CRYPPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03caff0
;tree "0CRYPPCellID0"
rgroup 0--3
line.long 0 "CRYPPCellID0"
hexfld.byte 0 " CRYPPCellID0 "
;tree.end

base ad:0xa03caff4
;tree "0CRYPPCellID1"
rgroup 0--3
line.long 0 "CRYPPCellID1"
hexfld.byte 0 " CRYPPCellID1 "
;tree.end

base ad:0xa03caff8
;tree "0CRYPPCellID2"
rgroup 0--3
line.long 0 "CRYPPCellID2"
hexfld.byte 0 " CRYPPCellID2 "
;tree.end

base ad:0xa03caffc
;tree "0CRYPPCellID3"
rgroup 0--3
line.long 0 "CRYPPCellID3"
hexfld.byte 0 " CRYPPCellID3 "
;tree.end

tree.end

base ad:0xa03cb000
;********************************************
tree "CRYP-1"
;********************************************
base ad:0xa03cb000
;tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SEC "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGODIR "  "0 ,1 "
bitfld.long 0 3.--5. " ALGOMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--7. " DATATYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " KEYSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " KEYRDEN "  "0 ,1 "
bitfld.long 0 11. " KSE "  "0 ,1 "
bitfld.long 0 12. " EXD "  "0 ,1 "
bitfld.long 0 13. " INIT "  "0 ,1 "
bitfld.long 0 14. " FFLUSH "  "0 ,1 "
bitfld.long 0 15. " CRYPEN "  "0 ,1 "
bitfld.long 0 16. " SECONDLAST "  "0 ,1 "
;tree.end

base ad:0xa03cb004
;tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " IFEM "  "0 ,1 "
bitfld.long 0 1. " IFNF "  "0 ,1 "
bitfld.long 0 2. " OFNE "  "0 ,1 "
bitfld.long 0 3. " OFFU "  "0 ,1 "
bitfld.long 0 4. " BUSY "  "0 ,1 "
;tree.end

base ad:0xa03cb008
;tree "1DIN"
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa03cb00c
;tree "1DINSIZE"
group 0--3
line.long 0 "DINSIZE"
bitfld.long 0 0.--3. " DINSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cb010
;tree "1DOUT"
rgroup 0--3
line.long 0 "DOUT"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa03cb014
;tree "1DOUTSIZE"
rgroup 0--3
line.long 0 "DOUTSIZE"
bitfld.long 0 0.--3. " DOUTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cb018
;tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " DMAINEN "  "0 ,1 "
bitfld.long 0 1. " DMAOUTEN "  "0 ,1 "
;tree.end

base ad:0xa03cb01c
;tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " INIM "  "0 ,1 "
bitfld.long 0 1. " OUTIM "  "0 ,1 "
;tree.end

base ad:0xa03cb020
;tree "1RIS"
group 0--3
line.long 0 "RIS"
bitfld.long 0 0. " INRIS "  "0 ,1 "
bitfld.long 0 1. " OUTRIS "  "0 ,1 "
;tree.end

base ad:0xa03cb024
;tree "1MIS"
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " INMIS "  "0 ,1 "
bitfld.long 0 1. " OUTMIS "  "0 ,1 "
;tree.end

base ad:0xa03cb028
;tree "1K1L"
group 0--3
line.long 0 "K1L"
bitfld.long 0 0. " K31 "  "0 ,1 "
bitfld.long 0 1. " K30 "  "0 ,1 "
bitfld.long 0 2. " K29 "  "0 ,1 "
bitfld.long 0 3. " K28 "  "0 ,1 "
bitfld.long 0 4. " K27 "  "0 ,1 "
bitfld.long 0 5. " K26 "  "0 ,1 "
bitfld.long 0 6. " K25 "  "0 ,1 "
bitfld.long 0 7. " K24 "  "0 ,1 "
bitfld.long 0 8. " K23 "  "0 ,1 "
bitfld.long 0 9. " K22 "  "0 ,1 "
bitfld.long 0 10. " K21 "  "0 ,1 "
bitfld.long 0 11. " K20 "  "0 ,1 "
bitfld.long 0 12. " K19 "  "0 ,1 "
bitfld.long 0 13. " K18 "  "0 ,1 "
bitfld.long 0 14. " K17 "  "0 ,1 "
bitfld.long 0 15. " K16 "  "0 ,1 "
bitfld.long 0 16. " K15 "  "0 ,1 "
bitfld.long 0 17. " K14 "  "0 ,1 "
bitfld.long 0 18. " K13 "  "0 ,1 "
bitfld.long 0 19. " K12 "  "0 ,1 "
bitfld.long 0 20. " K11 "  "0 ,1 "
bitfld.long 0 21. " K10 "  "0 ,1 "
bitfld.long 0 22. " K9 "  "0 ,1 "
bitfld.long 0 23. " K8 "  "0 ,1 "
bitfld.long 0 24. " K7 "  "0 ,1 "
bitfld.long 0 25. " K6 "  "0 ,1 "
bitfld.long 0 26. " K5 "  "0 ,1 "
bitfld.long 0 27. " K4 "  "0 ,1 "
bitfld.long 0 28. " K3 "  "0 ,1 "
bitfld.long 0 29. " K2 "  "0 ,1 "
bitfld.long 0 30. " K1 "  "0 ,1 "
bitfld.long 0 31. " K0 "  "0 ,1 "
;tree.end

base ad:0xa03cb02c
;tree "1K1R"
group 0--3
line.long 0 "K1R"
bitfld.long 0 0. " K63 "  "0 ,1 "
bitfld.long 0 1. " K62 "  "0 ,1 "
bitfld.long 0 2. " K61 "  "0 ,1 "
bitfld.long 0 3. " K60 "  "0 ,1 "
bitfld.long 0 4. " K59 "  "0 ,1 "
bitfld.long 0 5. " K58 "  "0 ,1 "
bitfld.long 0 6. " K57 "  "0 ,1 "
bitfld.long 0 7. " K56 "  "0 ,1 "
bitfld.long 0 8. " K55 "  "0 ,1 "
bitfld.long 0 9. " K54 "  "0 ,1 "
bitfld.long 0 10. " K53 "  "0 ,1 "
bitfld.long 0 11. " K52 "  "0 ,1 "
bitfld.long 0 12. " K51 "  "0 ,1 "
bitfld.long 0 13. " K50 "  "0 ,1 "
bitfld.long 0 14. " K49 "  "0 ,1 "
bitfld.long 0 15. " K48 "  "0 ,1 "
bitfld.long 0 16. " K47 "  "0 ,1 "
bitfld.long 0 17. " K46 "  "0 ,1 "
bitfld.long 0 18. " K45 "  "0 ,1 "
bitfld.long 0 19. " K44 "  "0 ,1 "
bitfld.long 0 20. " K43 "  "0 ,1 "
bitfld.long 0 21. " K42 "  "0 ,1 "
bitfld.long 0 22. " K41 "  "0 ,1 "
bitfld.long 0 23. " K40 "  "0 ,1 "
bitfld.long 0 24. " K39 "  "0 ,1 "
bitfld.long 0 25. " K38 "  "0 ,1 "
bitfld.long 0 26. " K37 "  "0 ,1 "
bitfld.long 0 27. " K36 "  "0 ,1 "
bitfld.long 0 28. " K35 "  "0 ,1 "
bitfld.long 0 29. " K34 "  "0 ,1 "
bitfld.long 0 30. " K33 "  "0 ,1 "
bitfld.long 0 31. " K32 "  "0 ,1 "
;tree.end

base ad:0xa03cb030
;tree "1K2L"
group 0--3
line.long 0 "K2L"
bitfld.long 0 0. " K95 "  "0 ,1 "
bitfld.long 0 1. " K94 "  "0 ,1 "
bitfld.long 0 2. " K93 "  "0 ,1 "
bitfld.long 0 3. " K92 "  "0 ,1 "
bitfld.long 0 4. " K91 "  "0 ,1 "
bitfld.long 0 5. " K90 "  "0 ,1 "
bitfld.long 0 6. " K89 "  "0 ,1 "
bitfld.long 0 7. " K88 "  "0 ,1 "
bitfld.long 0 8. " K87 "  "0 ,1 "
bitfld.long 0 9. " K86 "  "0 ,1 "
bitfld.long 0 10. " K85 "  "0 ,1 "
bitfld.long 0 11. " K84 "  "0 ,1 "
bitfld.long 0 12. " K83 "  "0 ,1 "
bitfld.long 0 13. " K82 "  "0 ,1 "
bitfld.long 0 14. " K81 "  "0 ,1 "
bitfld.long 0 15. " K80 "  "0 ,1 "
bitfld.long 0 16. " K79 "  "0 ,1 "
bitfld.long 0 17. " K78 "  "0 ,1 "
bitfld.long 0 18. " K77 "  "0 ,1 "
bitfld.long 0 19. " K76 "  "0 ,1 "
bitfld.long 0 20. " K75 "  "0 ,1 "
bitfld.long 0 21. " K74 "  "0 ,1 "
bitfld.long 0 22. " K73 "  "0 ,1 "
bitfld.long 0 23. " K72 "  "0 ,1 "
bitfld.long 0 24. " K71 "  "0 ,1 "
bitfld.long 0 25. " K70 "  "0 ,1 "
bitfld.long 0 26. " K69 "  "0 ,1 "
bitfld.long 0 27. " K68 "  "0 ,1 "
bitfld.long 0 28. " K67 "  "0 ,1 "
bitfld.long 0 29. " K66 "  "0 ,1 "
bitfld.long 0 30. " K65 "  "0 ,1 "
bitfld.long 0 31. " K64 "  "0 ,1 "
;tree.end

base ad:0xa03cb034
;tree "1K2R"
group 0--3
line.long 0 "K2R"
bitfld.long 0 0. " K127 "  "0 ,1 "
bitfld.long 0 1. " K126 "  "0 ,1 "
bitfld.long 0 2. " K125 "  "0 ,1 "
bitfld.long 0 3. " K124 "  "0 ,1 "
bitfld.long 0 4. " K123 "  "0 ,1 "
bitfld.long 0 5. " K122 "  "0 ,1 "
bitfld.long 0 6. " K121 "  "0 ,1 "
bitfld.long 0 7. " K120 "  "0 ,1 "
bitfld.long 0 8. " K119 "  "0 ,1 "
bitfld.long 0 9. " K118 "  "0 ,1 "
bitfld.long 0 10. " K117 "  "0 ,1 "
bitfld.long 0 11. " K116 "  "0 ,1 "
bitfld.long 0 12. " K115 "  "0 ,1 "
bitfld.long 0 13. " K114 "  "0 ,1 "
bitfld.long 0 14. " K113 "  "0 ,1 "
bitfld.long 0 15. " K112 "  "0 ,1 "
bitfld.long 0 16. " K111 "  "0 ,1 "
bitfld.long 0 17. " K110 "  "0 ,1 "
bitfld.long 0 18. " K109 "  "0 ,1 "
bitfld.long 0 19. " K108 "  "0 ,1 "
bitfld.long 0 20. " K107 "  "0 ,1 "
bitfld.long 0 21. " K106 "  "0 ,1 "
bitfld.long 0 22. " K105 "  "0 ,1 "
bitfld.long 0 23. " K104 "  "0 ,1 "
bitfld.long 0 24. " K103 "  "0 ,1 "
bitfld.long 0 25. " K102 "  "0 ,1 "
bitfld.long 0 26. " K101 "  "0 ,1 "
bitfld.long 0 27. " K100 "  "0 ,1 "
bitfld.long 0 28. " K99 "  "0 ,1 "
bitfld.long 0 29. " K98 "  "0 ,1 "
bitfld.long 0 30. " K97 "  "0 ,1 "
bitfld.long 0 31. " K96 "  "0 ,1 "
;tree.end

base ad:0xa03cb038
;tree "1K3L"
group 0--3
line.long 0 "K3L"
bitfld.long 0 0. " K159 "  "0 ,1 "
bitfld.long 0 1. " K158 "  "0 ,1 "
bitfld.long 0 2. " K157 "  "0 ,1 "
bitfld.long 0 3. " K156 "  "0 ,1 "
bitfld.long 0 4. " K155 "  "0 ,1 "
bitfld.long 0 5. " K154 "  "0 ,1 "
bitfld.long 0 6. " K153 "  "0 ,1 "
bitfld.long 0 7. " K152 "  "0 ,1 "
bitfld.long 0 8. " K151 "  "0 ,1 "
bitfld.long 0 9. " K150 "  "0 ,1 "
bitfld.long 0 10. " K149 "  "0 ,1 "
bitfld.long 0 11. " K148 "  "0 ,1 "
bitfld.long 0 12. " K147 "  "0 ,1 "
bitfld.long 0 13. " K146 "  "0 ,1 "
bitfld.long 0 14. " K145 "  "0 ,1 "
bitfld.long 0 15. " K144 "  "0 ,1 "
bitfld.long 0 16. " K143 "  "0 ,1 "
bitfld.long 0 17. " K142 "  "0 ,1 "
bitfld.long 0 18. " K141 "  "0 ,1 "
bitfld.long 0 19. " K140 "  "0 ,1 "
bitfld.long 0 20. " K139 "  "0 ,1 "
bitfld.long 0 21. " K138 "  "0 ,1 "
bitfld.long 0 22. " K137 "  "0 ,1 "
bitfld.long 0 23. " K136 "  "0 ,1 "
bitfld.long 0 24. " K135 "  "0 ,1 "
bitfld.long 0 25. " K134 "  "0 ,1 "
bitfld.long 0 26. " K133 "  "0 ,1 "
bitfld.long 0 27. " K132 "  "0 ,1 "
bitfld.long 0 28. " K131 "  "0 ,1 "
bitfld.long 0 29. " K130 "  "0 ,1 "
bitfld.long 0 30. " K129 "  "0 ,1 "
bitfld.long 0 31. " K128 "  "0 ,1 "
;tree.end

base ad:0xa03cb03c
;tree "1K3R"
group 0--3
line.long 0 "K3R"
bitfld.long 0 0. " K191 "  "0 ,1 "
bitfld.long 0 1. " K190 "  "0 ,1 "
bitfld.long 0 2. " K189 "  "0 ,1 "
bitfld.long 0 3. " K188 "  "0 ,1 "
bitfld.long 0 4. " K187 "  "0 ,1 "
bitfld.long 0 5. " K186 "  "0 ,1 "
bitfld.long 0 6. " K185 "  "0 ,1 "
bitfld.long 0 7. " K184 "  "0 ,1 "
bitfld.long 0 8. " K183 "  "0 ,1 "
bitfld.long 0 9. " K182 "  "0 ,1 "
bitfld.long 0 10. " K181 "  "0 ,1 "
bitfld.long 0 11. " K180 "  "0 ,1 "
bitfld.long 0 12. " K179 "  "0 ,1 "
bitfld.long 0 13. " K178 "  "0 ,1 "
bitfld.long 0 14. " K177 "  "0 ,1 "
bitfld.long 0 15. " K176 "  "0 ,1 "
bitfld.long 0 16. " K175 "  "0 ,1 "
bitfld.long 0 17. " K174 "  "0 ,1 "
bitfld.long 0 18. " K173 "  "0 ,1 "
bitfld.long 0 19. " K172 "  "0 ,1 "
bitfld.long 0 20. " K171 "  "0 ,1 "
bitfld.long 0 21. " K170 "  "0 ,1 "
bitfld.long 0 22. " K169 "  "0 ,1 "
bitfld.long 0 23. " K168 "  "0 ,1 "
bitfld.long 0 24. " K167 "  "0 ,1 "
bitfld.long 0 25. " K166 "  "0 ,1 "
bitfld.long 0 26. " K165 "  "0 ,1 "
bitfld.long 0 27. " K164 "  "0 ,1 "
bitfld.long 0 28. " K163 "  "0 ,1 "
bitfld.long 0 29. " K162 "  "0 ,1 "
bitfld.long 0 30. " K161 "  "0 ,1 "
bitfld.long 0 31. " K160 "  "0 ,1 "
;tree.end

base ad:0xa03cb040
;tree "1K4L"
group 0--3
line.long 0 "K4L"
bitfld.long 0 0. " K223 "  "0 ,1 "
bitfld.long 0 1. " K222 "  "0 ,1 "
bitfld.long 0 2. " K221 "  "0 ,1 "
bitfld.long 0 3. " K220 "  "0 ,1 "
bitfld.long 0 4. " K219 "  "0 ,1 "
bitfld.long 0 5. " K218 "  "0 ,1 "
bitfld.long 0 6. " K217 "  "0 ,1 "
bitfld.long 0 7. " K216 "  "0 ,1 "
bitfld.long 0 8. " K215 "  "0 ,1 "
bitfld.long 0 9. " K214 "  "0 ,1 "
bitfld.long 0 10. " K213 "  "0 ,1 "
bitfld.long 0 11. " K212 "  "0 ,1 "
bitfld.long 0 12. " K211 "  "0 ,1 "
bitfld.long 0 13. " K210 "  "0 ,1 "
bitfld.long 0 14. " K209 "  "0 ,1 "
bitfld.long 0 15. " K208 "  "0 ,1 "
bitfld.long 0 16. " K207 "  "0 ,1 "
bitfld.long 0 17. " K206 "  "0 ,1 "
bitfld.long 0 18. " K205 "  "0 ,1 "
bitfld.long 0 19. " K204 "  "0 ,1 "
bitfld.long 0 20. " K203 "  "0 ,1 "
bitfld.long 0 21. " K202 "  "0 ,1 "
bitfld.long 0 22. " K201 "  "0 ,1 "
bitfld.long 0 23. " K200 "  "0 ,1 "
bitfld.long 0 24. " K199 "  "0 ,1 "
bitfld.long 0 25. " K198 "  "0 ,1 "
bitfld.long 0 26. " K197 "  "0 ,1 "
bitfld.long 0 27. " K196 "  "0 ,1 "
bitfld.long 0 28. " K195 "  "0 ,1 "
bitfld.long 0 29. " K194 "  "0 ,1 "
bitfld.long 0 30. " K193 "  "0 ,1 "
bitfld.long 0 31. " K192 "  "0 ,1 "
;tree.end

base ad:0xa03cb044
;tree "1K4R"
group 0--3
line.long 0 "K4R"
bitfld.long 0 0. " K255 "  "0 ,1 "
bitfld.long 0 1. " K254 "  "0 ,1 "
bitfld.long 0 2. " K253 "  "0 ,1 "
bitfld.long 0 3. " K252 "  "0 ,1 "
bitfld.long 0 4. " K251 "  "0 ,1 "
bitfld.long 0 5. " K250 "  "0 ,1 "
bitfld.long 0 6. " K249 "  "0 ,1 "
bitfld.long 0 7. " K248 "  "0 ,1 "
bitfld.long 0 8. " K247 "  "0 ,1 "
bitfld.long 0 9. " K246 "  "0 ,1 "
bitfld.long 0 10. " K245 "  "0 ,1 "
bitfld.long 0 11. " K244 "  "0 ,1 "
bitfld.long 0 12. " K243 "  "0 ,1 "
bitfld.long 0 13. " K242 "  "0 ,1 "
bitfld.long 0 14. " K241 "  "0 ,1 "
bitfld.long 0 15. " K240 "  "0 ,1 "
bitfld.long 0 16. " K239 "  "0 ,1 "
bitfld.long 0 17. " K238 "  "0 ,1 "
bitfld.long 0 18. " K237 "  "0 ,1 "
bitfld.long 0 19. " K236 "  "0 ,1 "
bitfld.long 0 20. " K235 "  "0 ,1 "
bitfld.long 0 21. " K234 "  "0 ,1 "
bitfld.long 0 22. " K233 "  "0 ,1 "
bitfld.long 0 23. " K232 "  "0 ,1 "
bitfld.long 0 24. " K231 "  "0 ,1 "
bitfld.long 0 25. " K230 "  "0 ,1 "
bitfld.long 0 26. " K229 "  "0 ,1 "
bitfld.long 0 27. " K228 "  "0 ,1 "
bitfld.long 0 28. " K227 "  "0 ,1 "
bitfld.long 0 29. " K226 "  "0 ,1 "
bitfld.long 0 30. " K225 "  "0 ,1 "
bitfld.long 0 31. " K224 "  "0 ,1 "
;tree.end

base ad:0xa03cb048
;tree "1IV0L"
group 0--3
line.long 0 "IV0L"
bitfld.long 0 0. " IV32 "  "0 ,1 "
bitfld.long 0 1. " IV31 "  "0 ,1 "
bitfld.long 0 2. " IV30 "  "0 ,1 "
bitfld.long 0 3. " IV29 "  "0 ,1 "
bitfld.long 0 4. " IV28 "  "0 ,1 "
bitfld.long 0 5. " IV27 "  "0 ,1 "
bitfld.long 0 6. " IV26 "  "0 ,1 "
bitfld.long 0 7. " IV25 "  "0 ,1 "
bitfld.long 0 8. " IV24 "  "0 ,1 "
bitfld.long 0 9. " IV23 "  "0 ,1 "
bitfld.long 0 10. " IV22 "  "0 ,1 "
bitfld.long 0 11. " IV21 "  "0 ,1 "
bitfld.long 0 12. " IV20 "  "0 ,1 "
bitfld.long 0 13. " IV19 "  "0 ,1 "
bitfld.long 0 14. " IV18 "  "0 ,1 "
bitfld.long 0 15. " IV17 "  "0 ,1 "
bitfld.long 0 16. " IV16 "  "0 ,1 "
bitfld.long 0 17. " IV15 "  "0 ,1 "
bitfld.long 0 18. " IV14 "  "0 ,1 "
bitfld.long 0 19. " IV13 "  "0 ,1 "
bitfld.long 0 20. " IV12 "  "0 ,1 "
bitfld.long 0 21. " IV11 "  "0 ,1 "
bitfld.long 0 22. " IV10 "  "0 ,1 "
bitfld.long 0 23. " IV9 "  "0 ,1 "
bitfld.long 0 24. " IV8 "  "0 ,1 "
bitfld.long 0 25. " IV7 "  "0 ,1 "
bitfld.long 0 26. " IV6 "  "0 ,1 "
bitfld.long 0 27. " IV5 "  "0 ,1 "
bitfld.long 0 28. " IV4 "  "0 ,1 "
bitfld.long 0 29. " IV3 "  "0 ,1 "
bitfld.long 0 30. " IV2 "  "0 ,1 "
bitfld.long 0 31. " IV1 "  "0 ,1 "
;tree.end

base ad:0xa03cb04c
;tree "1IV0R"
group 0--3
line.long 0 "IV0R"
bitfld.long 0 0. " IV64 "  "0 ,1 "
bitfld.long 0 1. " IV63 "  "0 ,1 "
bitfld.long 0 2. " IV62 "  "0 ,1 "
bitfld.long 0 3. " IV61 "  "0 ,1 "
bitfld.long 0 4. " IV60 "  "0 ,1 "
bitfld.long 0 5. " IV59 "  "0 ,1 "
bitfld.long 0 6. " IV58 "  "0 ,1 "
bitfld.long 0 7. " IV57 "  "0 ,1 "
bitfld.long 0 8. " IV56 "  "0 ,1 "
bitfld.long 0 9. " IV55 "  "0 ,1 "
bitfld.long 0 10. " IV54 "  "0 ,1 "
bitfld.long 0 11. " IV53 "  "0 ,1 "
bitfld.long 0 12. " IV52 "  "0 ,1 "
bitfld.long 0 13. " IV51 "  "0 ,1 "
bitfld.long 0 14. " IV50 "  "0 ,1 "
bitfld.long 0 15. " IV49 "  "0 ,1 "
bitfld.long 0 16. " IV48 "  "0 ,1 "
bitfld.long 0 17. " IV47 "  "0 ,1 "
bitfld.long 0 18. " IV46 "  "0 ,1 "
bitfld.long 0 19. " IV45 "  "0 ,1 "
bitfld.long 0 20. " IV44 "  "0 ,1 "
bitfld.long 0 21. " IV43 "  "0 ,1 "
bitfld.long 0 22. " IV42 "  "0 ,1 "
bitfld.long 0 23. " IV41 "  "0 ,1 "
bitfld.long 0 24. " IV40 "  "0 ,1 "
bitfld.long 0 25. " IV39 "  "0 ,1 "
bitfld.long 0 26. " IV38 "  "0 ,1 "
bitfld.long 0 27. " IV37 "  "0 ,1 "
bitfld.long 0 28. " IV36 "  "0 ,1 "
bitfld.long 0 29. " IV35 "  "0 ,1 "
bitfld.long 0 30. " IV34 "  "0 ,1 "
bitfld.long 0 31. " IV33 "  "0 ,1 "
;tree.end

base ad:0xa03cb050
;tree "1IV1L"
group 0--3
line.long 0 "IV1L"
bitfld.long 0 0. " IV96 "  "0 ,1 "
bitfld.long 0 1. " IV95 "  "0 ,1 "
bitfld.long 0 2. " IV94 "  "0 ,1 "
bitfld.long 0 3. " IV93 "  "0 ,1 "
bitfld.long 0 4. " IV92 "  "0 ,1 "
bitfld.long 0 5. " IV91 "  "0 ,1 "
bitfld.long 0 6. " IV90 "  "0 ,1 "
bitfld.long 0 7. " IV89 "  "0 ,1 "
bitfld.long 0 8. " IV88 "  "0 ,1 "
bitfld.long 0 9. " IV87 "  "0 ,1 "
bitfld.long 0 10. " IV86 "  "0 ,1 "
bitfld.long 0 11. " IV85 "  "0 ,1 "
bitfld.long 0 12. " IV84 "  "0 ,1 "
bitfld.long 0 13. " IV83 "  "0 ,1 "
bitfld.long 0 14. " IV82 "  "0 ,1 "
bitfld.long 0 15. " IV81 "  "0 ,1 "
bitfld.long 0 16. " IV80 "  "0 ,1 "
bitfld.long 0 17. " IV79 "  "0 ,1 "
bitfld.long 0 18. " IV78 "  "0 ,1 "
bitfld.long 0 19. " IV77 "  "0 ,1 "
bitfld.long 0 20. " IV76 "  "0 ,1 "
bitfld.long 0 21. " IV75 "  "0 ,1 "
bitfld.long 0 22. " IV74 "  "0 ,1 "
bitfld.long 0 23. " IV73 "  "0 ,1 "
bitfld.long 0 24. " IV72 "  "0 ,1 "
bitfld.long 0 25. " IV71 "  "0 ,1 "
bitfld.long 0 26. " IV70 "  "0 ,1 "
bitfld.long 0 27. " IV69 "  "0 ,1 "
bitfld.long 0 28. " IV68 "  "0 ,1 "
bitfld.long 0 29. " IV67 "  "0 ,1 "
bitfld.long 0 30. " IV66 "  "0 ,1 "
bitfld.long 0 31. " IV65 "  "0 ,1 "
;tree.end

base ad:0xa03cb054
;tree "1IV1R"
group 0--3
line.long 0 "IV1R"
bitfld.long 0 0. " IV128 "  "0 ,1 "
bitfld.long 0 1. " IV127 "  "0 ,1 "
bitfld.long 0 2. " IV126 "  "0 ,1 "
bitfld.long 0 3. " IV125 "  "0 ,1 "
bitfld.long 0 4. " IV124 "  "0 ,1 "
bitfld.long 0 5. " IV123 "  "0 ,1 "
bitfld.long 0 6. " IV122 "  "0 ,1 "
bitfld.long 0 7. " IV121 "  "0 ,1 "
bitfld.long 0 8. " IV120 "  "0 ,1 "
bitfld.long 0 9. " IV119 "  "0 ,1 "
bitfld.long 0 10. " IV118 "  "0 ,1 "
bitfld.long 0 11. " IV117 "  "0 ,1 "
bitfld.long 0 12. " IV116 "  "0 ,1 "
bitfld.long 0 13. " IV115 "  "0 ,1 "
bitfld.long 0 14. " IV114 "  "0 ,1 "
bitfld.long 0 15. " IV113 "  "0 ,1 "
bitfld.long 0 16. " IV112 "  "0 ,1 "
bitfld.long 0 17. " IV111 "  "0 ,1 "
bitfld.long 0 18. " IV110 "  "0 ,1 "
bitfld.long 0 19. " IV109 "  "0 ,1 "
bitfld.long 0 20. " IV108 "  "0 ,1 "
bitfld.long 0 21. " IV107 "  "0 ,1 "
bitfld.long 0 22. " IV106 "  "0 ,1 "
bitfld.long 0 23. " IV105 "  "0 ,1 "
bitfld.long 0 24. " IV104 "  "0 ,1 "
bitfld.long 0 25. " IV103 "  "0 ,1 "
bitfld.long 0 26. " IV102 "  "0 ,1 "
bitfld.long 0 27. " IV101 "  "0 ,1 "
bitfld.long 0 28. " IV100 "  "0 ,1 "
bitfld.long 0 29. " IV99 "  "0 ,1 "
bitfld.long 0 30. " IV98 "  "0 ,1 "
bitfld.long 0 31. " IV97 "  "0 ,1 "
;tree.end

base ad:0xa03cb080
;tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0xa03cb084
;tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMAIUTC "  "0 ,1 "
bitfld.long 0 1. " DMAOUTC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
;tree.end

base ad:0xa03cb088
;tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMAINBREQ "  "0 ,1 "
bitfld.long 0 1. " DMAOUTBREQ "  "0 ,1 "
bitfld.long 0 2. " DMAOUTSREQ "  "0 ,1 "
bitfld.long 0 3. " ININTR "  "0 ,1 "
bitfld.long 0 4. " OUTINTR "  "0 ,1 "
;tree.end

base ad:0xa03cbfe0
;tree "1CRYPPeriphID0"
rgroup 0--3
line.long 0 "CRYPPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03cbfe4
;tree "1CRYPPeriphID1"
rgroup 0--3
line.long 0 "CRYPPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cbfe8
;tree "1CRYPPeriphID2"
rgroup 0--3
line.long 0 "CRYPPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cbfec
;tree "1CRYPPeriphID3"
rgroup 0--3
line.long 0 "CRYPPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03cbff0
;tree "1CRYPPCellID0"
rgroup 0--3
line.long 0 "CRYPPCellID0"
hexfld.byte 0 " CRYPPCellID0 "
;tree.end

base ad:0xa03cbff4
;tree "1CRYPPCellID1"
rgroup 0--3
line.long 0 "CRYPPCellID1"
hexfld.byte 0 " CRYPPCellID1 "
;tree.end

base ad:0xa03cbff8
;tree "1CRYPPCellID2"
rgroup 0--3
line.long 0 "CRYPPCellID2"
hexfld.byte 0 " CRYPPCellID2 "
;tree.end

base ad:0xa03cbffc
;tree "1CRYPPCellID3"
rgroup 0--3
line.long 0 "CRYPPCellID3"
hexfld.byte 0 " CRYPPCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "CTI"
;==============================================================
base edap:0x80180000
;tree "CTICONTROL"
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
;tree.end

base edap:0x80180010
;tree "CTIINTACK"
wgroup 0--3
line.long 0 "CTIINTACK"
hexfld.byte 0 " INTACK "
;tree.end

base edap:0x80180014
;tree "CTIAPPSET"
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180018
;tree "CTIAPPCLEAR"
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x8018001c
;tree "CTIAPPPULSE"
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180020
;tree "CTIINEN0"
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180024
;tree "CTIINEN1"
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180028
;tree "CTIINEN2"
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x8018002c
;tree "CTIINEN3"
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180030
;tree "CTIINEN4"
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180034
;tree "CTIINEN5"
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180038
;tree "CTIINEN6"
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x8018003c
;tree "CTIINEN7"
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800a0
;tree "CTIOUTEN0"
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800a4
;tree "CTIOUTEN1"
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800a8
;tree "CTIOUTEN2"
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800ac
;tree "CTIOUTEN3"
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800b0
;tree "CTIOUTEN4"
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800b4
;tree "CTIOUTEN5"
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800b8
;tree "CTIOUTEN6"
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800bc
;tree "CTIOUTEN7"
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180130
;tree "CTITRIGINSTATUS"
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
hexfld.byte 0 " TRIGINSTATUS "
;tree.end

base edap:0x80180134
;tree "CTITRIGOUTSTATUS"
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
hexfld.byte 0 " TRIGOUTSTATUS "
;tree.end

base edap:0x80180138
;tree "CTICHINSTATUS"
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x8018013c
;tree "CTICHOUTSTATUS"
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180140
;tree "CTIGATE"
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
;tree.end

base edap:0x80180144
;tree "ASICCTL"
group 0--3
line.long 0 "ASICCTL"
hexfld.byte 0 " ASICCTL "
;tree.end

base edap:0x80180edc
;tree "ITCHINACK"
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180ee0
;tree "ITTRIGINACK"
wgroup 0--3
line.long 0 "ITTRIGINACK"
hexfld.byte 0 " CTTRIGINACK "
;tree.end

base edap:0x80180ee4
;tree "ITCHOUT"
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180ee8
;tree "ITTRFLIN"
wgroup 0--3
line.long 0 "ITTRFLIN"
hexfld.byte 0 " CTTRIGOUT "
;tree.end

base edap:0x80180eec
;tree "ITCHOUTACK"
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180ef0
;tree "ITTRIGOUTACK"
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
hexfld.byte 0 " CTTRIGOUTACK "
;tree.end

base edap:0x80180ef4
;tree "ITCHIN"
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180ef8
;tree "ITRIGIN"
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
;tree.end

base edap:0x80180fa0
;tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180fa4
;tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180fb0
;tree "LAR"
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

base edap:0x80180fb4
;tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

base edap:0x80180fb8
;tree "ASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180fc8
;tree "DID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
;tree.end

base edap:0x80180fcc
;tree "DTIR"
rgroup 0--3
line.long 0 "DTIR"
hexfld.byte 0 " DTIR "
;tree.end

base edap:0x80180fd0
;tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

base edap:0x80180fd4
;tree "PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

base edap:0x80180fd8
;tree "PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

base edap:0x80180fdc
;tree "PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

base edap:0x80180fe0
;tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

base edap:0x80180fe4
;tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

base edap:0x80180fe8
;tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

base edap:0x80180fec
;tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

base edap:0x80180ff0
;tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

base edap:0x80180ff4
;tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

base edap:0x80180ff8
;tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

base edap:0x80180ffc
;tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

;==============================================================
tree "DBAHN"
;==============================================================
base ad:0x80156000
;tree "DENALI_CTL_00"
group 0--3
line.long 0 "DENALI_CTL_00"
bitfld.long 0 0. " ACTIVE_AGING "  "0 ,1 "
bitfld.long 0 8. " ADDR_CMP_EN "  "0 ,1 "
bitfld.long 0 16. " AP "  "0 ,1 "
bitfld.long 0 24. " AREFRESH "  "0 ,1 "
;tree.end

base ad:0x80156004
;tree "DENALI_CTL_01"
group 0--3
line.long 0 "DENALI_CTL_01"
bitfld.long 0 0. " AUTO_REFRESH_MODE "  "0 ,1 "
bitfld.long 0 8. " AXI0_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 16. " AXI1_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 24. " AXI2_BDW_OVFLOW "  "0 ,1 "
;tree.end

base ad:0x80156008
;tree "DENALI_CTL_02"
group 0--3
line.long 0 "DENALI_CTL_02"
bitfld.long 0 0. " AXI3_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 8. " BANK_SPLIT_EN "  "0 ,1 "
bitfld.long 0 16. " CONCURRENTAP "  "0 ,1 "
bitfld.long 0 24. " DLLLOCKREG "  "0 ,1 "
;tree.end

base ad:0x8015600c
;tree "DENALI_CTL_03"
group 0--3
line.long 0 "DENALI_CTL_03"
bitfld.long 0 0. " DLL_BYPASS_MODE "  "0 ,1 "
bitfld.long 0 8. " DRIVE_DQ_DQS "  "0 ,1 "
bitfld.long 0 16. " ENABLE_QUICK_SREFRESH "  "0 ,1 "
;tree.end

base ad:0x80156010
;tree "DENALI_CTL_04"
group 0--3
line.long 0 "DENALI_CTL_04"
bitfld.long 0 0. " FAST_WRITE "  "0 ,1 "
bitfld.long 0 8. " INTRPTAPBURST "  "0 ,1 "
bitfld.long 0 16. " INTRPTREADA "  "0 ,1 "
bitfld.long 0 24. " INTRPTWRITEA "  "0 ,1 "
;tree.end

base ad:0x80156014
;tree "DENALI_CTL_05"
group 0--3
line.long 0 "DENALI_CTL_05"
bitfld.long 0 0. " NO_CMD_INIT "  "0 ,1 "
bitfld.long 0 8. " PLACEMENT_EN "  "0 ,1 "
bitfld.long 0 16. " POWER_DOWN "  "0 ,1 "
bitfld.long 0 24. " PRIORITY_EN "  "0 ,1 "
;tree.end

base ad:0x80156018
;tree "DENALI_CTL_06"
group 0--3
line.long 0 "DENALI_CTL_06"
bitfld.long 0 0. " PWRUP_SREFRESH_EXIT "  "0 ,1 "
bitfld.long 0 8. " RD2RD_TURN "  "0 ,1 "
bitfld.long 0 16. " REDUC "  "0 ,1 "
bitfld.long 0 24. " REG_DIMM_ENABLE "  "0 ,1 "
;tree.end

base ad:0x8015601c
;tree "DENALI_CTL_07"
group 0--3
line.long 0 "DENALI_CTL_07"
bitfld.long 0 0. " RW_SAME_EN "  "0 ,1 "
bitfld.long 0 8. " SREFRESH "  "0 ,1 "
bitfld.long 0 16. " START "  "0 ,1 "
bitfld.long 0 24. " SWAP_EN "  "0 ,1 "
;tree.end

base ad:0x80156020
;tree "DENALI_CTL_08"
group 0--3
line.long 0 "DENALI_CTL_08"
bitfld.long 0 0. " TRAS_LOCKOUT "  "0 ,1 "
bitfld.long 0 8. " TREF_ENABLE "  "0 ,1 "
bitfld.long 0 16. " WRITEINTERP "  "0 ,1 "
bitfld.long 0 24. " WRITE_MODEREG "  "0 ,1 "
;tree.end

base ad:0x80156024
;tree "DENALI_CTL_09"
group 0--3
line.long 0 "DENALI_CTL_09"
bitfld.long 0 0. " WRLAT "  "0 ,1 "
bitfld.long 0 8.--9. " AXI0_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI0_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI0_W_PRIORITY "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80156028
;tree "DENALI_CTL_10"
group 0--3
line.long 0 "DENALI_CTL_10"
bitfld.long 0 0.--1. " AXI1_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI1_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI1_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI2_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8015602c
;tree "DENALI_CTL_11"
group 0--3
line.long 0 "DENALI_CTL_11"
bitfld.long 0 0.--1. " AXI2_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI2_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI3_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI3_R_PRIORITY "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80156030
;tree "DENALI_CTL_12"
group 0--3
line.long 0 "DENALI_CTL_12"
bitfld.long 0 0.--1. " AXI3_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " CS_MAP "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " LOWPOWER_REFRESH_ENABLE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80156034
;tree "DENALI_CTL_13"
group 0--3
line.long 0 "DENALI_CTL_13"
bitfld.long 0 0.--1. " MAX_CS_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " WRTPRCT_ENABLE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--26. " ADDR_PINS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80156038
;tree "DENALI_CTL_14"
group 0--3
line.long 0 "DENALI_CTL_14"
bitfld.long 0 0.--2. " ARB_CMD_Q_THRESHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " BSTLEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " CASLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " CKE_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8015603c
;tree "DENALI_CTL_15"
group 0--3
line.long 0 "DENALI_CTL_15"
bitfld.long 0 0.--2. " COLUMN_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " PORT_DATA_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " Q_FULLNESS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TCKE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80156040
;tree "DENALI_CTL_16"
group 0--3
line.long 0 "DENALI_CTL_16"
bitfld.long 0 0.--2. " TDFI_CTRL_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDFI_DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " TDFI_DRAM_CLK_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TRRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80156044
;tree "DENALI_CTL_17"
group 0--3
line.long 0 "DENALI_CTL_17"
bitfld.long 0 0.--2. " TWTR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--11. " AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " APREBIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " CASLAT_LIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156048
;tree "DENALI_CTL_18"
group 0--3
line.long 0 "DENALI_CTL_18"
bitfld.long 0 0.--3. " CASLAT_LIN_GATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " COMMAND_AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " INITAREF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAX_COL_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8015604c
;tree "DENALI_CTL_19"
group 0--3
line.long 0 "DENALI_CTL_19"
bitfld.long 0 0.--3. " MAX_ROW_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " PORT_CMD_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_CTRLUPD_MIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156050
;tree "DENALI_CTL_20"
group 0--3
line.long 0 "DENALI_CTL_20"
bitfld.long 0 0.--3. " TDFI_PHY_RDLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TDFI_PHY_WRLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDFI_PHY_WRLAT_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_RDDATA_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156054
;tree "DENALI_CTL_21"
group 0--3
line.long 0 "DENALI_CTL_21"
bitfld.long 0 0.--3. " TDFI_RDDATA_EN_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TRP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TWR_INT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--28. " DLL_LOCK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x80156058
;tree "DENALI_CTL_22"
group 0--3
line.long 0 "DENALI_CTL_22"
bitfld.long 0 0.--4. " LOWPOWER_AUTO_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " LOWPOWER_CONTROL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " OUT_OF_RANGE_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--28. " TMRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8015605c
;tree "DENALI_CTL_23"
group 0--3
line.long 0 "DENALI_CTL_23"
bitfld.long 0 0.--4. " TRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--14. " AXI0_BDW "  " "
bitfld.long 0 16.--22. " AXI0_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI1_BDW "  " "
;tree.end

base ad:0x80156060
;tree "DENALI_CTL_24"
group 0--3
line.long 0 "DENALI_CTL_24"
bitfld.long 0 0.--6. " AXI1_CURRENT_BDW "  " "
bitfld.long 0 8.--14. " AXI2_BDW "  " "
bitfld.long 0 16.--22. " AXI2_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI3_BDW "  " "
;tree.end

base ad:0x80156064
;tree "DENALI_CTL_25"
group 0--3
line.long 0 "DENALI_CTL_25"
bitfld.long 0 0.--6. " AXI3_CURRENT_BDW "  " "
bitfld.long 0 8.--14. " INT_ACK "  " "
bitfld.long 0 16.--22. " OUT_OF_RANGE_LENGTH "  " "
bitfld.long 0 24.--30. " WRTPRCT_ERROR_LENGTH "  " "
;tree.end

base ad:0x80156068
;tree "DENALI_CTL_26"
group 0--3
line.long 0 "DENALI_CTL_26"
hexfld.byte 0 " INT_MASK "
hexfld.byte 1 " INT_STATUS "
hexfld.byte 2 " TRAS_MIN "
hexfld.byte 3 " TRCD_INT "
;tree.end

base ad:0x8015606c
;tree "DENALI_CTL_27"
group 0--3
line.long 0 "DENALI_CTL_27"
hexfld.byte 0 " TRFC "
bitfld.long 0 8.--17. " OUT_OF_RANGE_SOURCE_ID "  " "
;tree.end

base ad:0x80156070
;tree "DENALI_CTL_28"
rgroup 0--3
line.long 0 "DENALI_CTL_28"
bitfld.long 0 0.--9. " PORT_CMD_ERROR_ID "  " "
bitfld.long 0 16.--25. " PORT_DATA_ERROR_ID "  " "
;tree.end

base ad:0x80156074
;tree "DENALI_CTL_29"
rgroup 0--3
line.long 0 "DENALI_CTL_29"
bitfld.long 0 0.--11. " TDFI_CTRLUPD_MAX "  " "
bitfld.long 0 16.--27. " TDFI_PHYUPD_RESP "  " "
;tree.end

base ad:0x80156078
;tree "DENALI_CTL_30"
group 0--3
line.long 0 "DENALI_CTL_30"
bitfld.long 0 0.--11. " TDFI_PHYUPD_TYPE0 "  " "
bitfld.long 0 16.--27. " TREF "  " "
;tree.end

base ad:0x8015607c
;tree "DENALI_CTL_31"
group 0--3
line.long 0 "DENALI_CTL_31"
bitfld.long 0 16.--29. " EMRS2_DATA_0 "  " "
;tree.end

base ad:0x80156080
;tree "DENALI_CTL_32"
group 0--3
line.long 0 "DENALI_CTL_32"
bitfld.long 0 0.--13. " EMRS2_DATA_1 "  " "
hexfld.word 0 " AXI0_EN_SIZE_LT_WIDTH_INSTR "
;tree.end

base ad:0x80156084
;tree "DENALI_CTL_33"
group 0--3
line.long 0 "DENALI_CTL_33"
hexfld.word 0 " AXI1_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 0 " AXI2_EN_SIZE_LT_WIDTH_INSTR "
;tree.end

base ad:0x80156088
;tree "DENALI_CTL_34"
group 0--3
line.long 0 "DENALI_CTL_34"
hexfld.word 0 " AXI3_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 0 " LOWPOWER_EXTERNAL_CNT "
;tree.end

base ad:0x8015608c
;tree "DENALI_CTL_35"
group 0--3
line.long 0 "DENALI_CTL_35"
hexfld.word 0 " LOWPOWER_INTERNAL_CNT "
hexfld.word 0 " LOWPOWER_POWER_DOWN_CNT "
;tree.end

base ad:0x80156090
;tree "DENALI_CTL_36"
group 0--3
line.long 0 "DENALI_CTL_36"
hexfld.word 0 " LOWPOWER_REFRESH_HOLD "
hexfld.word 0 " LOWPOWER_SELF_REFRESH_CNT "
;tree.end

base ad:0x80156094
;tree "DENALI_CTL_37"
group 0--3
line.long 0 "DENALI_CTL_37"
hexfld.word 0 " TDLL "
hexfld.word 0 " TPDEX "
;tree.end

base ad:0x80156098
;tree "DENALI_CTL_38"
group 0--3
line.long 0 "DENALI_CTL_38"
hexfld.word 0 " TRAS_MAX "
hexfld.word 0 " TXSNR "
;tree.end

base ad:0x8015609c
;tree "DENALI_CTL_39"
group 0--3
line.long 0 "DENALI_CTL_39"
hexfld.word 0 " TXSR "
hexfld.word 0 " VERSION "
;tree.end

base ad:0x801560a0
;tree "DENALI_CTL_40"
group 0--3
line.long 0 "DENALI_CTL_40"
bitfld.long 0 0.--23. " TINIT "  " "
;tree.end

base ad:0x801560a4
;tree "DENALI_CTL_41"
rgroup 0--3
line.long 0 "DENALI_CTL_41"
bitfld.long 0 0.--29. " OUT_OF_RANGE_ADDR "  " "
;tree.end

base ad:0x801560a8
;tree "DENALI_CTL_42"
rgroup 0--3
line.long 0 "DENALI_CTL_42"
bitfld.long 0 0.--29. " PORT_CMD_ERROR_ADDR "  " "
;tree.end

base ad:0x801560ac
;tree "DENALI_CTL_43"
rgroup 0--3
line.long 0 "DENALI_CTL_43"
bitfld.long 0 0.--29. " WRTPRCT_ERROR_ADDRESS "  " "
;tree.end

base ad:0x801560b0
;tree "DENALI_CTL_44"
group 0--3
line.long 0 "DENALI_CTL_44"
bitfld.long 0 0.--29. " WRTPRCT_LOWER_ADDRESS_0 "  " "
;tree.end

base ad:0x801560b4
;tree "DENALI_CTL_45"
group 0--3
line.long 0 "DENALI_CTL_45"
bitfld.long 0 0.--29. " WRTPRCT_LOWER_ADDRESS_1 "  " "
;tree.end

base ad:0x801560b8
;tree "DENALI_CTL_46"
group 0--3
line.long 0 "DENALI_CTL_46"
bitfld.long 0 0.--29. " WRTPRCT_UPPER_ADDRESS_0 "  " "
;tree.end

base ad:0x801560bc
;tree "DENALI_CTL_47"
group 0--3
line.long 0 "DENALI_CTL_47"
bitfld.long 0 0.--29. " WRTPRCT_UPPER_ADDRESS_1 "  " "
;tree.end

base ad:0x801560c0
;tree "DENALI_CTL_48"
group 0--3
line.long 0 "DENALI_CTL_48"
hexfld.long 0 " DFT_CTRL_REG "
;tree.end

base ad:0x801560c4
;tree "DENALI_CTL_49"
group 0--3
line.long 0 "DENALI_CTL_49"
hexfld.long 0 " PAD_CTRL_REG_0 "
;tree.end

base ad:0x801560c8
;tree "DENALI_CTL_50"
group 0--3
line.long 0 "DENALI_CTL_50"
hexfld.long 0 " PHY_CTRL_REG_0_0 "
;tree.end

base ad:0x801560cc
;tree "DENALI_CTL_51"
group 0--3
line.long 0 "DENALI_CTL_51"
hexfld.long 0 " PHY_CTRL_REG_0_1 "
;tree.end

base ad:0x801560d0
;tree "DENALI_CTL_52"
group 0--3
line.long 0 "DENALI_CTL_52"
hexfld.long 0 " PHY_CTRL_REG_0_2 "
;tree.end

base ad:0x801560d4
;tree "DENALI_CTL_53"
group 0--3
line.long 0 "DENALI_CTL_53"
hexfld.long 0 " PHY_CTRL_REG_0_3 "
;tree.end

base ad:0x801560d8
;tree "DENALI_CTL_54"
group 0--3
line.long 0 "DENALI_CTL_54"
hexfld.long 0 " PHY_CTRL_REG_1_0 "
;tree.end

base ad:0x801560dc
;tree "DENALI_CTL_55"
group 0--3
line.long 0 "DENALI_CTL_55"
hexfld.long 0 " PHY_CTRL_REG_1_1 "
;tree.end

base ad:0x801560e0
;tree "DENALI_CTL_56"
group 0--3
line.long 0 "DENALI_CTL_56"
hexfld.long 0 " PHY_CTRL_REG_1_2 "
;tree.end

base ad:0x801560e4
;tree "DENALI_CTL_57"
group 0--3
line.long 0 "DENALI_CTL_57"
hexfld.long 0 " PHY_CTRL_REG_1_3 "
;tree.end

base ad:0x801560e8
;tree "DENALI_CTL_58"
group 0--3
line.long 0 "DENALI_CTL_58"
hexfld.long 0 " PHY_CTRL_REG_2 "
;tree.end

base ad:0x801560ec
;tree "DENALI_CTL_59"
group 0--3
line.long 0 "DENALI_CTL_59"
hexfld.long 0 " USER_DEF_REG_0 "
;tree.end

base ad:0x801560f0
;tree "DENALI_CTL_60"
group 0--3
line.long 0 "DENALI_CTL_60"
hexfld.long 0 " USER_DEF_REG_1 "
;tree.end

base ad:0x801560f4
;tree "DENALI_CTL_61"
group 0--3
line.long 0 "DENALI_CTL_61"
hexfld.long 0 " USER_DEF_REG_RO_0 "
;tree.end

base ad:0x801560f8
;tree "DENALI_CTL_62"
group 0--3
line.long 0 "DENALI_CTL_62"
hexfld.long 0 " USER_DEF_REG_RO_1 "
;tree.end

base ad:0x801560fc
;tree "DENALI_CTL_63"
group 0--3
line.long 0 "DENALI_CTL_63"
bitfld.long 0 0. " WRLAT_ADJ "  "0 ,1 "
bitfld.long 0 8.--10. " W2R_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " W2R_SAMECS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--27. " DRAM_CLASS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156100
;tree "DENALI_CTL_64"
group 0--3
line.long 0 "DENALI_CTL_64"
bitfld.long 0 0.--3. " RDLAT_ADJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DLL_RST_ADJ_DLY "
hexfld.byte 2 " TMOD "
;tree.end

base ad:0x80156104
;tree "DENALI_CTL_65"
group 0--3
line.long 0 "DENALI_CTL_65"
bitfld.long 0 0.--13. " EMRS1_DATA_0 "  " "
bitfld.long 0 16.--29. " EMRS1_DATA_1 "  " "
;tree.end

base ad:0x80156108
;tree "DENALI_CTL_66"
group 0--3
line.long 0 "DENALI_CTL_66"
bitfld.long 0 0.--13. " MRS_DATA_0 "  " "
bitfld.long 0 16.--29. " MRS_DATA_1 "  " "
;tree.end

base ad:0x8015610c
;tree "DENALI_CTL_67"
group 0--3
line.long 0 "DENALI_CTL_67"
hexfld.word 0 " DLL_RST_DELAY "
;tree.end

base ad:0x80156110
;tree "DENALI_CTL_68"
group 0--3
line.long 0 "DENALI_CTL_68"
hexfld.long 0 " DLL_CTRL_REG_0_0 "
;tree.end

base ad:0x80156114
;tree "DENALI_CTL_69"
group 0--3
line.long 0 "DENALI_CTL_69"
hexfld.long 0 " DLL_CTRL_REG_0_1 "
;tree.end

base ad:0x80156118
;tree "DENALI_CTL_70"
group 0--3
line.long 0 "DENALI_CTL_70"
hexfld.long 0 " DLL_CTRL_REG_0_2 "
;tree.end

base ad:0x8015611c
;tree "DENALI_CTL_71"
group 0--3
line.long 0 "DENALI_CTL_71"
hexfld.long 0 " DLL_CTRL_REG_0_3 "
;tree.end

base ad:0x80156120
;tree "DENALI_CTL_72"
group 0--3
line.long 0 "DENALI_CTL_72"
hexfld.long 0 " USER_DEF_REG_2 "
;tree.end

base ad:0x80156124
;tree "DENALI_CTL_73"
group 0--3
line.long 0 "DENALI_CTL_73"
hexfld.long 0 " USER_DEF_REG_3 "
;tree.end

base ad:0x80156128
;tree "DENALI_CTL_74"
rgroup 0--3
line.long 0 "DENALI_CTL_74"
hexfld.long 0 " USER_DEF_REG_RO_2 "
;tree.end

base ad:0x8015612c
;tree "DENALI_CTL_75"
rgroup 0--3
line.long 0 "DENALI_CTL_75"
hexfld.long 0 " USER_DEF_REG_RO_3 "
;tree.end

tree.end

;==============================================================
tree "DMAC"
;==============================================================
base ad:0xa0362000
;tree "GCC"
group 0--3
line.long 0 "GCC"
bitfld.long 0 0. " ENA "  "0 ,1 "
bitfld.long 0 8. " SE0 "  "0 ,1 "
bitfld.long 0 9. " DE0 "  "0 ,1 "
bitfld.long 0 10. " SE1 "  "0 ,1 "
bitfld.long 0 11. " DE1 "  "0 ,1 "
bitfld.long 0 12. " SE2 "  "0 ,1 "
bitfld.long 0 13. " DE2 "  "0 ,1 "
bitfld.long 0 14. " SE3 "  "0 ,1 "
bitfld.long 0 15. " DE3 "  "0 ,1 "
;tree.end

base ad:0xa0362004
;tree "PRTYP"
group 0--3
line.long 0 "PRTYP"
bitfld.long 0 0.--1. " CP0TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " CP1TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " CP2TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " CP3TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " CP4TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " CP5TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " CP6TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " CP7TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " CP8TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " CP9TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " CP10TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " CP11TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " CP12TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " CP13TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " CP14TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " CP15TYP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0362008
;tree "PRSME"
group 0--3
line.long 0 "PRSME"
bitfld.long 0 0.--1. " PR0SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR1SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR2SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR3SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR4SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR5SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR6SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR7SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR8SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR9SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR10SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR11SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR12SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR13SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR14SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR15SEC "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa036200c
;tree "PRSMO"
group 0--3
line.long 0 "PRSMO"
bitfld.long 0 0.--1. " PR0SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR1SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR2SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR3SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR4SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR5SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR6SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR7SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR8SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR9SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR10SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR11SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR12SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR13SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR14SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR15SEC "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0362010
;tree "PRMSE"
group 0--3
line.long 0 "PRMSE"
bitfld.long 0 0.--1. " PR0MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR1MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR2MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR3MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR4MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR5MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR6MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR7MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR8MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR9MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR10MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR11MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR12MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR13MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR14MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR15MOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0362014
;tree "PRMSO"
group 0--3
line.long 0 "PRMSO"
bitfld.long 0 0.--1. " PR0MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR1MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR2MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR3MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR4MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR5MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR6MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR7MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR8MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR9MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR10MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR11MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR12MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR13MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR14MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR15MOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0362018
;tree "PRMOE"
group 0--3
line.long 0 "PRMOE"
bitfld.long 0 0.--1. " PR0OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR1OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR2OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR3OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR4OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR5OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR6OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR7OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR8OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR9OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR10OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR11OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR12OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR13OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR14OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR15OPT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa036201c
;tree "PRMOO"
group 0--3
line.long 0 "PRMOO"
bitfld.long 0 0.--1. " PR0OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR1OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR2OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR3OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR4OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR5OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR6OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR7OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR8OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR9OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR10OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR11OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR12OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR13OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR14OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR15OPT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0362020
;tree "LCPA"
group 0--3
line.long 0 "LCPA"
bitfld.long 0 3.--31. " LCPA "  " "
;tree.end

base ad:0xa0362024
;tree "LCLA"
group 0--3
line.long 0 "LCLA"
bitfld.long 0 3.--31. " LCLA "  " "
;tree.end

base ad:0xa0362028
;tree "SLCPA"
wgroup 0--3
line.long 0 "SLCPA"
bitfld.long 0 3.--31. " SLCPA "  " "
;tree.end

base ad:0xa036202c
;tree "SLCLA"
wgroup 0--3
line.long 0 "SLCLA"
bitfld.long 0 3.--31. " SLCLA "  " "
;tree.end

base ad:0xa0362030
;tree "SSEG1"
group 0--3
line.long 0 "SSEG1"
hexfld.word 0 " SSSEL "
hexfld.word 0 " SSDEL "
;tree.end

base ad:0xa0362034
;tree "SSEG2"
group 0--3
line.long 0 "SSEG2"
hexfld.word 0 " SSSEL "
hexfld.word 0 " SSDEL "
;tree.end

base ad:0xa0362038
;tree "SSEG3"
group 0--3
line.long 0 "SSEG3"
hexfld.word 0 " SSSEL "
hexfld.word 0 " SSDEL "
;tree.end

base ad:0xa036203c
;tree "SSEG4"
group 0--3
line.long 0 "SSEG4"
hexfld.word 0 " SSSEL "
hexfld.word 0 " SSDEL "
;tree.end

base ad:0xa0362040
;tree "SCEG1"
group 0--3
line.long 0 "SCEG1"
hexfld.word 0 " SCSEL "
hexfld.word 0 " SCDEL "
;tree.end

base ad:0xa0362044
;tree "SCEG2"
group 0--3
line.long 0 "SCEG2"
hexfld.word 0 " SCSEL "
hexfld.word 0 " SCDEL "
;tree.end

base ad:0xa0362048
;tree "SCEG3"
group 0--3
line.long 0 "SCEG3"
hexfld.word 0 " SCSEL "
hexfld.word 0 " SCDEL "
;tree.end

base ad:0xa036204c
;tree "SCEG4"
group 0--3
line.long 0 "SCEG4"
hexfld.word 0 " SCSEL "
hexfld.word 0 " SCDEL "
;tree.end

base ad:0xa0362050
;tree "ACTIVE"
group 0--3
line.long 0 "ACTIVE"
bitfld.long 0 0.--1. " PR0AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR2S "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR4AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR6AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR8AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR10AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR12AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR14AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR16AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR18AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR20AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR22AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR24AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR26AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR28AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR30AS "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0362054
;tree "ACTIVO"
group 0--3
line.long 0 "ACTIVO"
bitfld.long 0 0.--1. " PR1AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR3S "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR5AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR7AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR9AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR11AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR13AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR15AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR17AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR19AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR21AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR23AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR25AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR27AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR29AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR31AS "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0362058
;tree "FSEBS1"
group 0--3
line.long 0 "FSEBS1"
hexfld.long 0 " FSEBS1 "
;tree.end

base ad:0xa036205c
;tree "FSEBS2"
group 0--3
line.long 0 "FSEBS2"
hexfld.long 0 " FSEBS2 "
;tree.end

base ad:0xa0362060
;tree "PCMIS"
group 0--3
line.long 0 "PCMIS"
hexfld.long 0 " PCMIS "
;tree.end

base ad:0xa0362064
;tree "PCICR"
group 0--3
line.long 0 "PCICR"
hexfld.long 0 " PCICR "
;tree.end

base ad:0xa0362068
;tree "PCTIS"
group 0--3
line.long 0 "PCTIS"
hexfld.long 0 " PCTIS "
;tree.end

base ad:0xa036206c
;tree "PCEIS"
group 0--3
line.long 0 "PCEIS"
hexfld.long 0 " PCEIS "
;tree.end

base ad:0xa0362070
;tree "SPCMIS"
wgroup 0--3
line.long 0 "SPCMIS"
hexfld.long 0 " SPCMIS "
;tree.end

base ad:0xa0362074
;tree "SPCICR"
wgroup 0--3
line.long 0 "SPCICR"
hexfld.long 0 " PCICR "
;tree.end

base ad:0xa0362078
;tree "SPCTIS"
wgroup 0--3
line.long 0 "SPCTIS"
hexfld.long 0 " SPCTIS "
;tree.end

base ad:0xa036207c
;tree "SPCEIS"
wgroup 0--3
line.long 0 "SPCEIS"
hexfld.long 0 " SPCEIS "
;tree.end

base ad:0xa0362080
;tree "LCMIS1"
group 0--3
line.long 0 "LCMIS1"
hexfld.long 0 " LCMIS "
;tree.end

base ad:0xa0362084
;tree "LCMIS2"
group 0--3
line.long 0 "LCMIS2"
hexfld.long 0 " LCMIS "
;tree.end

base ad:0xa0362088
;tree "LCMIS3"
group 0--3
line.long 0 "LCMIS3"
hexfld.long 0 " LCMIS "
;tree.end

base ad:0xa036208c
;tree "LCMIS4"
group 0--3
line.long 0 "LCMIS4"
hexfld.long 0 " LCMIS "
;tree.end

base ad:0xa0362090
;tree "LCICR1"
group 0--3
line.long 0 "LCICR1"
hexfld.long 0 " LCICR "
;tree.end

base ad:0xa0362094
;tree "LCICR2"
group 0--3
line.long 0 "LCICR2"
hexfld.long 0 " LCICR "
;tree.end

base ad:0xa0362098
;tree "LCICR3"
group 0--3
line.long 0 "LCICR3"
hexfld.long 0 " LCICR "
;tree.end

base ad:0xa036209c
;tree "LCICR4"
group 0--3
line.long 0 "LCICR4"
hexfld.long 0 " LCICR "
;tree.end

base ad:0xa03620a0
;tree "LCTIS1"
group 0--3
line.long 0 "LCTIS1"
hexfld.long 0 " LCTIS "
;tree.end

base ad:0xa03620a4
;tree "LCTIS2"
group 0--3
line.long 0 "LCTIS2"
hexfld.long 0 " LCTIS "
;tree.end

base ad:0xa03620a8
;tree "LCTIS3"
group 0--3
line.long 0 "LCTIS3"
hexfld.long 0 " LCTIS "
;tree.end

base ad:0xa03620ac
;tree "LCTIS4"
group 0--3
line.long 0 "LCTIS4"
hexfld.long 0 " LCTIS "
;tree.end

base ad:0xa03620b0
;tree "LCEIS1"
group 0--3
line.long 0 "LCEIS1"
hexfld.long 0 " LCEIS "
;tree.end

base ad:0xa03620b4
;tree "LCEIS2"
group 0--3
line.long 0 "LCEIS2"
hexfld.long 0 " LCEIS "
;tree.end

base ad:0xa03620b8
;tree "LCEIS3"
group 0--3
line.long 0 "LCEIS3"
hexfld.long 0 " LCEIS "
;tree.end

base ad:0xa03620bc
;tree "LCEIS4"
group 0--3
line.long 0 "LCEIS4"
hexfld.long 0 " LCEIS "
;tree.end

base ad:0xa03620c0
;tree "SLCMIS1"
wgroup 0--3
line.long 0 "SLCMIS1"
hexfld.long 0 " SLCMIS "
;tree.end

base ad:0xa03620c4
;tree "SLCMIS2"
wgroup 0--3
line.long 0 "SLCMIS2"
hexfld.long 0 " SLCMIS "
;tree.end

base ad:0xa03620c8
;tree "SLCMIS3"
wgroup 0--3
line.long 0 "SLCMIS3"
hexfld.long 0 " SLCMIS "
;tree.end

base ad:0xa03620cc
;tree "SLCMIS4"
wgroup 0--3
line.long 0 "SLCMIS4"
hexfld.long 0 " SLCMIS "
;tree.end

base ad:0xa03620d0
;tree "SLCICR1"
wgroup 0--3
line.long 0 "SLCICR1"
hexfld.long 0 " SLCICR "
;tree.end

base ad:0xa03620d4
;tree "SLCICR2"
wgroup 0--3
line.long 0 "SLCICR2"
hexfld.long 0 " SLCICR "
;tree.end

base ad:0xa03620d8
;tree "SLCICR3"
wgroup 0--3
line.long 0 "SLCICR3"
hexfld.long 0 " SLCICR "
;tree.end

base ad:0xa03620dc
;tree "SLCICR4"
wgroup 0--3
line.long 0 "SLCICR4"
hexfld.long 0 " SLCICR "
;tree.end

base ad:0xa03620e0
;tree "SLCTIS1"
wgroup 0--3
line.long 0 "SLCTIS1"
hexfld.long 0 " SLCTIS "
;tree.end

base ad:0xa03620e4
;tree "SLCTIS2"
wgroup 0--3
line.long 0 "SLCTIS2"
hexfld.long 0 " SLCTIS "
;tree.end

base ad:0xa03620e8
;tree "SLCTIS3"
wgroup 0--3
line.long 0 "SLCTIS3"
hexfld.long 0 " SLCTIS "
;tree.end

base ad:0xa03620ec
;tree "SLCTIS4"
wgroup 0--3
line.long 0 "SLCTIS4"
hexfld.long 0 " SLCTIS "
;tree.end

base ad:0xa03620f0
;tree "SLCEIS1"
wgroup 0--3
line.long 0 "SLCEIS1"
hexfld.long 0 " SLCEIS "
;tree.end

base ad:0xa03620f4
;tree "SLCEIS2"
wgroup 0--3
line.long 0 "SLCEIS2"
hexfld.long 0 " SLCEIS "
;tree.end

base ad:0xa03620f8
;tree "SLCEIS3"
wgroup 0--3
line.long 0 "SLCEIS3"
hexfld.long 0 " SLCEIS "
;tree.end

base ad:0xa03620fc
;tree "SLCEIS4"
wgroup 0--3
line.long 0 "SLCEIS4"
hexfld.long 0 " SLCEIS "
;tree.end

base ad:0xa0362400
;tree "SSCFG0"
group 0--3
line.long 0 "SSCFG0"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0xa0362404
;tree "SSELT0"
group 0--3
line.long 0 "SSELT0"
hexfld.word 0 " EIDX "
hexfld.word 0 " ECNT "
;tree.end

base ad:0xa0362408
;tree "SSPTR0"
group 0--3
line.long 0 "SSPTR0"
hexfld.long 0 " PTR "
;tree.end

base ad:0xa036240c
;tree "SSLNK0"
group 0--3
line.long 0 "SSLNK0"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0xa0362420
;tree "SSCFG1"
group 0--3
line.long 0 "SSCFG1"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0xa0362424
;tree "SSELT1"
group 0--3
line.long 0 "SSELT1"
hexfld.word 0 " EIDX "
hexfld.word 0 " ECNT "
;tree.end

base ad:0xa0362428
;tree "SSPTR1"
group 0--3
line.long 0 "SSPTR1"
hexfld.long 0 " PTR "
;tree.end

base ad:0xa036242c
;tree "SSLNK1"
group 0--3
line.long 0 "SSLNK1"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0xa0362440
;tree "SSCFG2"
group 0--3
line.long 0 "SSCFG2"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0xa0362444
;tree "SSELT2"
group 0--3
line.long 0 "SSELT2"
hexfld.word 0 " EIDX "
hexfld.word 0 " ECNT "
;tree.end

base ad:0xa0362448
;tree "SSPTR2"
group 0--3
line.long 0 "SSPTR2"
hexfld.long 0 " PTR "
;tree.end

base ad:0xa036244c
;tree "SSLNK2"
group 0--3
line.long 0 "SSLNK2"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0xa0362460
;tree "SSCFG3"
group 0--3
line.long 0 "SSCFG3"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0xa0362464
;tree "SSELT3"
group 0--3
line.long 0 "SSELT3"
hexfld.word 0 " EIDX "
hexfld.word 0 " ECNT "
;tree.end

base ad:0xa0362468
;tree "SSPTR3"
group 0--3
line.long 0 "SSPTR3"
hexfld.long 0 " PTR "
;tree.end

base ad:0xa036246c
;tree "SSLNK3"
group 0--3
line.long 0 "SSLNK3"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0xa0362480
;tree "SSCFG4"
group 0--3
line.long 0 "SSCFG4"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0xa0362484
;tree "SSELT4"
group 0--3
line.long 0 "SSELT4"
hexfld.word 0 " EIDX "
hexfld.word 0 " ECNT "
;tree.end

base ad:0xa0362488
;tree "SSPTR4"
group 0--3
line.long 0 "SSPTR4"
hexfld.long 0 " PTR "
;tree.end

base ad:0xa036248c
;tree "SSLNK4"
group 0--3
line.long 0 "SSLNK4"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0xa03624a0
;tree "SSCFG5"
group 0--3
line.long 0 "SSCFG5"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0xa03624a4
;tree "SSELT5"
group 0--3
line.long 0 "SSELT5"
hexfld.word 0 " EIDX "
hexfld.word 0 " ECNT "
;tree.end

base ad:0xa03624a8
;tree "SSPTR5"
group 0--3
line.long 0 "SSPTR5"
hexfld.long 0 " PTR "
;tree.end

base ad:0xa03624ac
;tree "SSLNK5"
group 0--3
line.long 0 "SSLNK5"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0xa03624c0
;tree "SSCFG6"
group 0--3
line.long 0 "SSCFG6"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0xa03624c4
;tree "SSELT6"
group 0--3
line.long 0 "SSELT6"
hexfld.word 0 " EIDX "
hexfld.word 0 " ECNT "
;tree.end

base ad:0xa03624c8
;tree "SSPTR6"
group 0--3
line.long 0 "SSPTR6"
hexfld.long 0 " PTR "
;tree.end

base ad:0xa03624cc
;tree "SSLNK6"
group 0--3
line.long 0 "SSLNK6"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0xa03624e0
;tree "SSCFG7"
wgroup 0--3
line.long 0 "SSCFG7"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0xa03624e4
;tree "SSELT7"
wgroup 0--3
line.long 0 "SSELT7"
hexfld.word 0 " EIDX "
hexfld.word 0 " ECNT "
;tree.end

base ad:0xa03624e8
;tree "SSPTR7"
wgroup 0--3
line.long 0 "SSPTR7"
hexfld.long 0 " PTR "
;tree.end

base ad:0xa03624ec
;tree "SSLNK7"
wgroup 0--3
line.long 0 "SSLNK7"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0xa0362fc8
;tree "STFU"
group 0--3
line.long 0 "STFU"
hexfld.word 0 " RESULT "
bitfld.long 0 16.--19. " LCELNB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20. " SD "  "0 ,1 "
bitfld.long 0 21.--25. " PRSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 26.--27. " MSTSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--30. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " ENA "  "0 ,1 "
;tree.end

base ad:0xa0362fcc
;tree "ICFG"
group 0--3
line.long 0 "ICFG"
bitfld.long 0 0.--2. " SCHNB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--4. " MNB "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " DBUFSZ "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " CPSZ "  "0 ,1 "
bitfld.long 0 8. " M1SZ "  "0 ,1 "
bitfld.long 0 9. " M2SZ "  "0 ,1 "
bitfld.long 0 10. " M3SZ "  "0 ,1 "
bitfld.long 0 11. " M4SZ "  "0 ,1 "
bitfld.long 0 12. " PTYP "  "0 ,1 "
bitfld.long 0 16.--19. " MODEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0362fd0
;tree "MPLUG0"
group 0--3
line.long 0 "MPLUG0"
hexfld.long 0 " MPLUG0 "
;tree.end

base ad:0xa0362fd4
;tree "MPLUG1"
group 0--3
line.long 0 "MPLUG1"
hexfld.long 0 " MPLUG1 "
;tree.end

base ad:0xa0362fd8
;tree "MPLUG2"
group 0--3
line.long 0 "MPLUG2"
hexfld.long 0 " MPLUG2 "
;tree.end

base ad:0xa0362fdc
;tree "MPLUG3"
group 0--3
line.long 0 "MPLUG3"
hexfld.long 0 " MPLUG3 "
;tree.end

base ad:0xa0362fe0
;tree "PeriphID0"
group 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PTNUM "
;tree.end

base ad:0xa0362fe4
;tree "PeriphID1"
group 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PTNUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " DES0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0362fe8
;tree "PeriphID2"
group 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " DES1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0362fec
;tree "PeriphID3"
group 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " CONFIG "
;tree.end

base ad:0xa0362ff0
;tree "CellID0"
group 0--3
line.long 0 "CellID0"
hexfld.byte 0 " ID0 "
;tree.end

base ad:0xa0362ff4
;tree "CellID1"
group 0--3
line.long 0 "CellID1"
hexfld.byte 0 " ID1 "
;tree.end

base ad:0xa0362ff8
;tree "CellID2"
group 0--3
line.long 0 "CellID2"
hexfld.byte 0 " ID2 "
;tree.end

base ad:0xa0362ffc
;tree "CellID3"
group 0--3
line.long 0 "CellID3"
hexfld.byte 0 " ID3 "
;tree.end

tree.end

;==============================================================
tree "DMC"
;==============================================================
base ad:0x80156000
;tree "CTL_00"
group 0--3
line.long 0 "CTL_00"
bitfld.long 0 0. " ACTIVE_AGING "  "0 ,1 "
bitfld.long 0 8. " ADDR_CMP_EN "  "0 ,1 "
bitfld.long 0 16. " AP "  "0 ,1 "
bitfld.long 0 24. " AREFRESH "  "0 ,1 "
;tree.end

base ad:0x80156001
;tree "CTL_01"
group 0--3
line.long 0 "CTL_01"
bitfld.long 0 0. " AUTO_REFRESH_MODE "  "0 ,1 "
bitfld.long 0 8. " AXI0_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 16. " AXI1_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 24. " AXI2_BDW_OVFLOW "  "0 ,1 "
;tree.end

base ad:0x80156002
;tree "CTL_02"
group 0--3
line.long 0 "CTL_02"
bitfld.long 0 0. " AXI3_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 8. " BANK_SPLIT_EN "  "0 ,1 "
bitfld.long 0 16. " CONCURRENTAP "  "0 ,1 "
;tree.end

base ad:0x80156003
;tree "CTL_03"
group 0--3
line.long 0 "CTL_03"
bitfld.long 0 8. " DRIVE_DQ_DQ "  "0 ,1 "
bitfld.long 0 16. " ENABLE_QUICK_SREFRESH "  "0 ,1 "
bitfld.long 0 24. " EN_LOWPOWER_MODE "  "0 ,1 "
;tree.end

base ad:0x80156004
;tree "CTL_04"
group 0--3
line.long 0 "CTL_04"
bitfld.long 0 0. " FAST_WRITE "  "0 ,1 "
bitfld.long 0 8. " INTRPTAPBURST "  "0 ,1 "
bitfld.long 0 16. " INTRPTREADA "  "0 ,1 "
bitfld.long 0 24. " INTRPTWRITEA "  "0 ,1 "
;tree.end

base ad:0x80156005
;tree "CTL_05"
group 0--3
line.long 0 "CTL_05"
bitfld.long 0 0. " NO_CMD_INIT "  "0 ,1 "
bitfld.long 0 8. " PLACEMENT_EN "  "0 ,1 "
bitfld.long 0 16. " POWER_DOWN "  "0 ,1 "
bitfld.long 0 24. " PRIORITY_EN "  "0 ,1 "
;tree.end

base ad:0x80156006
;tree "CTL_06"
group 0--3
line.long 0 "CTL_06"
bitfld.long 0 0. " PWRUP_SREFRESH_EXIT "  "0 ,1 "
bitfld.long 0 8. " RD2RD_TURN "  "0 ,1 "
bitfld.long 0 16. " REDUC "  "0 ,1 "
bitfld.long 0 24. " REG_DIMM_ENABLE "  "0 ,1 "
;tree.end

base ad:0x80156007
;tree "CTL_07"
group 0--3
line.long 0 "CTL_07"
bitfld.long 0 0. " RW_SAME_EN "  "0 ,1 "
bitfld.long 0 8. " SREFRESH "  "0 ,1 "
bitfld.long 0 16. " START "  "0 ,1 "
bitfld.long 0 24. " SWAP_EN "  "0 ,1 "
;tree.end

base ad:0x80156008
;tree "CTL_08"
group 0--3
line.long 0 "CTL_08"
bitfld.long 0 0. " TRAS_LOCKOUT "  "0 ,1 "
bitfld.long 0 8. " TREF_ENABLE "  "0 ,1 "
bitfld.long 0 16. " WRITEINTERP "  "0 ,1 "
bitfld.long 0 24. " WRITE_MODEREG "  "0 ,1 "
;tree.end

base ad:0x80156009
;tree "CTL_09"
group 0--3
line.long 0 "CTL_09"
bitfld.long 0 0. " WRLAT "  "0 ,1 "
bitfld.long 0 8.--9. " AXI0_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI0_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI0_W_PRIORITY "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8015600A
;tree "CTL_10"
group 0--3
line.long 0 "CTL_10"
bitfld.long 0 0.--1. " AXI1_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI1_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI1_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI2_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8015600B
;tree "CTL_11"
group 0--3
line.long 0 "CTL_11"
bitfld.long 0 0.--1. " AXI2_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI2_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI3_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI3_R_PRIORITY "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8015600C
;tree "CTL_12"
group 0--3
line.long 0 "CTL_12"
bitfld.long 0 0.--1. " AXI3_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " CS_MAP "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " LOWPOWER_REFRESH_ENABLE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8015600D
;tree "CTL_13"
group 0--3
line.long 0 "CTL_13"
bitfld.long 0 0.--1. " MAX_CS_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TEMRS "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " WRTPRCT_ENABLE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " ADDR_PINS "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8015600E
;tree "CTL_14"
group 0--3
line.long 0 "CTL_14"
bitfld.long 0 0.--2. " ARB_CMD_Q_THRESHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " BSTLEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " CASLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " CKE_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8015600F
;tree "CTL_15"
group 0--3
line.long 0 "CTL_15"
bitfld.long 0 0.--2. " COLUMN_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " PORT_DATA_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " Q_FULLNESS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TCKE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80156010
;tree "CTL_16"
group 0--3
line.long 0 "CTL_16"
bitfld.long 0 0.--2. " TDFI_CTRL_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDFI_DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " TDFI_DRAM_CLK_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TRRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80156011
;tree "CTL_17"
group 0--3
line.long 0 "CTL_17"
bitfld.long 0 0.--3. " TWTR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " APREBIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " CASLAT_LIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156012
;tree "CTL_18"
group 0--3
line.long 0 "CTL_18"
bitfld.long 0 0.--3. " CASLAT_LIN_GATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " COMMAND_AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " INITAREF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAX_COL_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156013
;tree "CTL_19"
group 0--3
line.long 0 "CTL_19"
bitfld.long 0 0.--3. " MAX_ROW_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " PORT_CMD_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_CTRLUPD_MIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156014
;tree "CTL_20"
group 0--3
line.long 0 "CTL_20"
bitfld.long 0 0.--3. " TDFI_PHY_RDLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TDFI_PHY_WRLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDFI_PHY_WRLAT_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_RDDATA_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156015
;tree "CTL_21"
group 0--3
line.long 0 "CTL_21"
bitfld.long 0 0.--3. " TDFI_RDDATA_EN_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TRP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TWR_INT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--28. " DLL_LOCK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x80156016
;tree "CTL_22"
group 0--3
line.long 0 "CTL_22"
bitfld.long 0 0.--4. " LOWPOWER_AUTO_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " LOWPOWER_CONTROL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " OUT_OF_RANGE_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--28. " TMRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x80156017
;tree "CTL_23"
group 0--3
line.long 0 "CTL_23"
bitfld.long 0 0.--4. " TRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--14. " AXI0_BDW "  " "
bitfld.long 0 16.--22. " AXI0_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI1_BDW "  " "
;tree.end

base ad:0x80156018
;tree "CTL_24"
group 0--3
line.long 0 "CTL_24"
bitfld.long 0 0.--6. " AXI1_CURRENT_BDW "  " "
bitfld.long 0 8.--14. " AXI2_BDW "  " "
bitfld.long 0 16.--22. " AXI2_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI3_BDW "  " "
;tree.end

base ad:0x80156019
;tree "CTL_25"
group 0--3
line.long 0 "CTL_25"
bitfld.long 0 0.--6. " AXI3_CURRENT_BDW "  " "
bitfld.long 0 8.--14. " INT_ACK "  " "
bitfld.long 0 16.--22. " OUT_OF_RANGE_LENGTH "  " "
bitfld.long 0 24.--30. " WRTPRCT_ERROR_LENGTH "  " "
;tree.end

base ad:0x8015601A
;tree "CTL_26"
group 0--3
line.long 0 "CTL_26"
hexfld.byte 0 " INT_MASK "
hexfld.byte 1 " INT_STATUS "
hexfld.byte 2 " TRAS_MIN "
hexfld.byte 3 " TRCD_INT "
;tree.end

base ad:0x8015601B
;tree "CTL_27"
group 0--3
line.long 0 "CTL_27"
hexfld.byte 0 " TRFC "
bitfld.long 0 8.--17. " OUT_OF_RANGE_SOURCE_ID "  " "
;tree.end

base ad:0x8015601C
;tree "CTL_28"
rgroup 0--3
line.long 0 "CTL_28"
bitfld.long 0 0.--9. " PORT_CMD_ERROR_ID "  " "
bitfld.long 0 16.--25. " PORT_DATA_ERROR_ID "  " "
;tree.end

base ad:0x8015601D
;tree "CTL_29"
rgroup 0--3
line.long 0 "CTL_29"
bitfld.long 0 0.--11. " TDFI_CTRLUPD_MAX "  " "
hexfld.word 0 " TDFI_PHYUPD_RESP "
;tree.end

base ad:0x8015601E
;tree "CTL_30"
group 0--3
line.long 0 "CTL_30"
bitfld.long 0 0.--11. " TDFI_PHYUPD_TYPE0 "  " "
bitfld.long 0 16.--27. " TRF "  " "
;tree.end

base ad:0x8015601F
;tree "CTL_31"
group 0--3
line.long 0 "CTL_31"
bitfld.long 0 0.--13. " EMRS1_DATA "  " "
bitfld.long 0 16.--29. " EMRS2_DATA_0 "  " "
;tree.end

base ad:0x80156020
;tree "CTL_32"
group 0--3
line.long 0 "CTL_32"
bitfld.long 0 0.--13. " EMRS2_DATA_1 "  " "
hexfld.word 0 " AXI0_EN_SIZE_LT_WIDTH_INSTR "
;tree.end

base ad:0x80156021
;tree "CTL_33"
group 0--3
line.long 0 "CTL_33"
hexfld.word 0 " AXI2_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 0 " AXI2_EN_SIZE_LT_WIDTH_INSTR "
;tree.end

base ad:0x80156022
;tree "CTL_34"
group 0--3
line.long 0 "CTL_34"
hexfld.word 0 " AXI3_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 0 " LOWPOWER_EXTERNAL_CNT "
;tree.end

base ad:0x80156023
;tree "CTL_35"
group 0--3
line.long 0 "CTL_35"
hexfld.word 0 " LOWPOWER_INTERNAL_CNT "
hexfld.word 0 " LOWPOWER_POWER_DOWN_CNT "
;tree.end

base ad:0x80156024
;tree "CTL_36"
group 0--3
line.long 0 "CTL_36"
hexfld.word 0 " LOWPOWER_REFRESH_HOLD "
hexfld.word 0 " LOWPOWER_SELF_REFRESH "
;tree.end

base ad:0x80156025
;tree "CTL_37"
group 0--3
line.long 0 "CTL_37"
hexfld.word 0 " TDLL "
hexfld.word 0 " TPDEX "
;tree.end

base ad:0x80156026
;tree "CTL_38"
group 0--3
line.long 0 "CTL_38"
hexfld.word 0 " TRAS_MAX "
hexfld.word 0 " TXSNR "
;tree.end

base ad:0x80156027
;tree "CTL_39"
group 0--3
line.long 0 "CTL_39"
hexfld.word 0 " TXSR "
hexfld.word 0 " VERSION "
;tree.end

base ad:0x80156028
;tree "CTL_40"
group 0--3
line.long 0 "CTL_40"
bitfld.long 0 0.--23. " TINIT "  " "
;tree.end

base ad:0x80156029
;tree "CTL_41"
rgroup 0--3
line.long 0 "CTL_41"
bitfld.long 0 0.--29. " OUT_OF_RANGE_ADDR "  " "
;tree.end

base ad:0x8015602A
;tree "CTL_42"
rgroup 0--3
line.long 0 "CTL_42"
bitfld.long 0 0.--29. " PORT_CMD-ERROR_ADDR "  " "
;tree.end

base ad:0x8015602B
;tree "CTL_43"
rgroup 0--3
line.long 0 "CTL_43"
bitfld.long 0 0.--29. " WRTPRCT_CMD-ERROR_ADDR "  " "
;tree.end

base ad:0x8015602C
;tree "CTL_44"
group 0--3
line.long 0 "CTL_44"
bitfld.long 0 0.--29. " WRTPRCT_LOWER_ADRESS_0 "  " "
;tree.end

base ad:0x8015602D
;tree "CTL_45"
group 0--3
line.long 0 "CTL_45"
bitfld.long 0 0.--29. " WRTPRCT_LOWER_ADRESS_1 "  " "
;tree.end

base ad:0x8015602E
;tree "CTL_46"
group 0--3
line.long 0 "CTL_46"
bitfld.long 0 0.--29. " WRTPRCT_UPPER_ADRESS_0 "  " "
;tree.end

base ad:0x8015602F
;tree "CTL_47"
group 0--3
line.long 0 "CTL_47"
bitfld.long 0 0.--29. " WRTPRCT_UPPER_ADRESS_1 "  " "
;tree.end

base ad:0x8015603B
;tree "CTL_59"
group 0--3
line.long 0 "CTL_59"
hexfld.long 0 " PHY_ADD "
;tree.end

base ad:0x8015603C
;tree "CTL_60"
group 0--3
line.long 0 "CTL_60"
hexfld.long 0 " PHY_CFG "
;tree.end

base ad:0x8015603D
;tree "CTL_61"
rgroup 0--3
line.long 0 "CTL_61"
hexfld.long 0 " PHY_STS "
;tree.end

base ad:0x8015603E
;tree "CTL_62"
rgroup 0--3
line.long 0 "CTL_62"
;tree.end

base ad:0x8015603F
;tree "CTL_63"
group 0--3
line.long 0 "CTL_63"
bitfld.long 0 0. " WRLAT_ADJ "  "0 ,1 "
bitfld.long 0 8.--9. " W2R_DIFFCS_DLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " W2R_SAMECS_DLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--27. " DRAM_CLASS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156040
;tree "CTL_64"
group 0--3
line.long 0 "CTL_64"
bitfld.long 0 0.--3. " RDLAT_ADJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DLL_RST_ADJ_DLY "
hexfld.byte 2 " TMOD "
;tree.end

base ad:0x80156041
;tree "CTL_65"
group 0--3
line.long 0 "CTL_65"
bitfld.long 0 0.--13. " EMRS1_DATA_0 "  " "
bitfld.long 0 16.--29. " EMRS1_DATA_1 "  " "
;tree.end

base ad:0x80156042
;tree "CTL_66"
group 0--3
line.long 0 "CTL_66"
bitfld.long 0 0.--13. " MRS1_DATA_0 "  " "
bitfld.long 0 16.--29. " MRS1_DATA_1 "  " "
;tree.end

base ad:0x80156043
;tree "CTL_67"
group 0--3
line.long 0 "CTL_67"
hexfld.word 0 " DLL_RST_DELAY "
;tree.end

base ad:0x80156048
;tree "CTL_72"
group 0--3
line.long 0 "CTL_72"
hexfld.long 0 " USER_DEF_REG_2 "
;tree.end

base ad:0x80156049
;tree "CTL_73"
group 0--3
line.long 0 "CTL_73"
bitfld.long 0 26. " DEBUG_DFI_TRIGGER_IS_WRITE "  "0 ,1 "
bitfld.long 0 27. " DBHAN_JTAG_CONTROL_ENABLE "  "0 ,1 "
bitfld.long 0 28. " DBHAN_JTAG_TRSTN "  "0 ,1 "
bitfld.long 0 29. " DBHAN_JTAG_TCK "  "0 ,1 "
bitfld.long 0 30. " DBHAN_JTAG_TMS "  "0 ,1 "
bitfld.long 0 31. " DBHAN_JTAG_TDI "  "0 ,1 "
;tree.end

base ad:0x8015604A
;tree "CTL_74"
group 0--3
line.long 0 "CTL_74"
hexfld.long 0 " USER_DEF_REG_RO_2 "
;tree.end

base ad:0x8015604B
;tree "CTL_75"
rgroup 0--3
line.long 0 "CTL_75"
bitfld.long 0 30. " DDR_PHY_DFI_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 31. " DBHAN_JTAG_TDO "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "DSI (3 instances)"
;==============================================================

base ad:0xa0353000
;********************************************
tree "DSI-2"
;********************************************
if (((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x801571ec)&0x20000000)!=0x20000000)||((data.long(ad:0x8015725c)&0x02)!=0x02))

base ad:0x80157064
;tree "prcm_mcdeclk_mgt_reg"
group 0--3
line.long 0 "prcm_mcdeclk_mgt_reg"
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 29. " SOC_mem_init_n "  "0 ,1 "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 29. " SOC_mem_init_n "  "0 ,1 "
;tree.end

base ad:0x8015725c
;tree "prcm_power_state_val"
group 0--3
line.long 0 "prcm_power_state_val"
bitfld.long 0 7. " B2R2_MCDE "  "0 ,1 "
;tree.end

else

base ad:0xa0353000
;tree "2MCTL_INTEGRATION_MODE"
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
;tree.end

base ad:0xa0353004
;tree "2MCTL_MAIN_DATA_CTL"
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF1_MODE "  "0 ,1 "
bitfld.long 0 2. " VID_EN "  "0 ,1 "
bitfld.long 0 3. " TVG_SEL "  "0 ,1 "
bitfld.long 0 4. " TBG_SEL "  "0 ,1 "
bitfld.long 0 5. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 6. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 7. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 8. " READ_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_EN "  "0 ,1 "
bitfld.long 0 10. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 11. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 12. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 13. " DISP_EOT_GEN "  "0 ,1 "
;tree.end

base ad:0xa0353008
;tree "2MCTL_MAIN_PHY_CTL"
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 2. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 3. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 6.--9. " WAIT_BURST_TIME "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa035300c
;tree "2MCTL_PLL_CTL"
group 0--3
line.long 0 "MCTL_PLL_CTL"
bitfld.long 0 0.--6. " PLL_MULT "  " "
bitfld.long 0 7.--9. " PLL_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " PLL_IN_SEL "  "0 ,1 "
bitfld.long 0 11. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 16. " PLL_MASTER "  "0 ,1 "
;tree.end

base ad:0xa0353010
;tree "2MCTL_LANE_STS"
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " DATLANE1_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " DATLANE2_STATE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0353014
;tree "2MCTL_DPHY_TIMEOUT"
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT"
bitfld.long 0 0.--3. " CLK_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--17. " HSTX_TO_VAL "  " "
bitfld.long 0 18.--31. " LPRX_TO_VAL "  " "
;tree.end

base ad:0xa0353018
;tree "2MCTL_ULPOUT_TIME"
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
;tree.end

base ad:0xa035301c
;tree "2MCTL_DPHY_STATIC"
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6.--11. " UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa0353020
;tree "2MCTL_MAIN_EN"
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 7. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 8. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " IF1_EN "  "0 ,1 "
bitfld.long 0 10. " IF2_EN "  "0 ,1 "
;tree.end

base ad:0xa0353024
;tree "2MCTL_MAIN_STS"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LOCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK "  "0 ,1 "
;tree.end

base ad:0xa0353028
;tree "2MCTL_DPHY_ERR"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 0. " ERR_SOT_HS_1 "  "0 ,1 "
bitfld.long 0 1. " ERR_SOT_HS_2 "  "0 ,1 "
bitfld.long 0 2. " ERR_SOTSYNC_1 "  "0 ,1 "
bitfld.long 0 3. " ERR_SOTSYNC_2 "  "0 ,1 "
bitfld.long 0 4. " ERR_EOTSYNC_1 "  "0 ,1 "
bitfld.long 0 5. " ERR_EOTSYNC_2 "  "0 ,1 "
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2 "  "0 ,1 "
;tree.end

base ad:0xa0353030
;tree "2INT_VID_RDDATA"
group 0--3
line.long 0 "INT_VID_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

base ad:0xa0353034
;tree "2INT_VID_GNT"
group 0--3
line.long 0 "INT_VID_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

base ad:0xa0353038
;tree "2INT_CMD_RDDATA"
group 0--3
line.long 0 "INT_CMD_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

base ad:0xa035303c
;tree "2INT_CMD_GNT"
group 0--3
line.long 0 "INT_CMD_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

base ad:0xa0353040
;tree "2INT_INTERRUPT_CTL"
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
;tree.end

base ad:0xa0353050
;tree "2CMD_MODE_CTL"
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " IF2_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 5. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 6. " ARB_MODE "  "0 ,1 "
bitfld.long 0 7. " ARB_PRI "  "0 ,1 "
hexfld.byte 1 " FIL_VALUE "
bitfld.long 0 16.--25. " TE_TIMEOUT "  " "
;tree.end

base ad:0xa0353054
;tree "2CMD_MODE_STS"
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING "  "0 ,1 "
;tree.end

base ad:0xa0353060
;tree "2DIRECT_CMD_SEND"
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
;tree.end

base ad:0xa0353064
;tree "2DIRECT_CMD_MAIN_SETTINGS"
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--15. " CMD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--20. " CMD_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 24.--27. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0353068
;tree "2DIRECT_CMD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 0 " ACK_VAL "
;tree.end

base ad:0xa035306c
;tree "2DIRECT_CMD_RD_INIT"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
hexfld.word 0 " CMD_RD_INIT "
;tree.end

base ad:0xa0353070
;tree "2DIRECT_CMD_WRDAT0"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT0"
bitfld.long 0 0. " WRDAT0 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT1 "  " "
bitfld.long 0 9.--16. " WRDAT2 "  " "
bitfld.long 0 17.--24. " WRDAT3 "  " "
;tree.end

base ad:0xa0353074
;tree "2DIRECT_CMD_WRDAT1"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT1"
bitfld.long 0 0. " WRDAT4 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT5 "  " "
bitfld.long 0 9.--16. " WRDAT6 "  " "
bitfld.long 0 17.--24. " WRDAT7 "  " "
;tree.end

base ad:0xa0353078
;tree "2DIRECT_CMD_WRDAT2"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT2"
bitfld.long 0 0. " WRDAT8 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT9 "  " "
bitfld.long 0 9.--16. " WRDAT10 "  " "
bitfld.long 0 17.--24. " WRDAT11 "  " "
;tree.end

base ad:0xa035307c
;tree "2DIRECT_CMD_WRDAT3"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT3"
bitfld.long 0 0. " WRDAT12 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT13 "  " "
bitfld.long 0 9.--16. " WRDAT14 "  " "
bitfld.long 0 17.--24. " WRDAT15 "  " "
;tree.end

base ad:0xa0353080
;tree "2DIRECT_CMD_RDDAT"
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
hexfld.byte 0 " RDDAT0 "
hexfld.byte 1 " RDDAT1 "
hexfld.byte 2 " RDDAT2 "
hexfld.byte 3 " RDDAT3 "
;tree.end

base ad:0xa0353084
;tree "2DIRECT_CMD_RD_PROPERTY"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
hexfld.word 0 " RD_SIZE "
bitfld.long 0 16.--17. " RD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
;tree.end

base ad:0xa0353088
;tree "2DIRECT_CMD_RD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
;tree.end

base ad:0xa0353090
;tree "2VID_MAIN_CTL"
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STOP_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " VID_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--11. " HEADER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--13. " VID_PIXEL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " BURST_MODE "  "0 ,1 "
bitfld.long 0 15. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 16. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 17.--18. " REG_BLKLINE_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 19.--20. " REG_BLKEOL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--22. " RECOVERY_MODE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0353094
;tree "2VID_VSIZE"
group 0--3
line.long 0 "VID_VSIZE"
bitfld.long 0 0.--3. " VSA_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " VBP_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " VFP_LENGTH "
bitfld.long 0 16.--26. " VACT_LENGTH "  " "
;tree.end

base ad:0xa0353098
;tree "2VID_HSIZE1"
group 0--3
line.long 0 "VID_HSIZE1"
hexfld.byte 0 " HSA_LENGTH "
hexfld.byte 1 " HBP_LENGTH "
bitfld.long 0 16.--26. " HFP_LENGTH "  " "
;tree.end

base ad:0xa035309c
;tree "2VID_HSIZE2"
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--12. " RGB_SIZE "  " "
;tree.end

base ad:0xa03530a0
;tree "2VID_BLKSIZE1"
group 0--3
line.long 0 "VID_BLKSIZE1"
bitfld.long 0 0.--12. " BLKLINE_EVENT_PCK "  " "
bitfld.long 0 13.--25. " BLKEOL_PCK "  " "
;tree.end

base ad:0xa03530a4
;tree "2VID_BLKSIZE2"
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
;tree.end

base ad:0xa03530a8
;tree "2VID_PCK_TIME"
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
;tree.end

base ad:0xa03530ac
;tree "2VID_DPHY_TIME"
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
;tree.end

base ad:0xa03530b0
;tree "2VID_ERR_COLOR"
group 0--3
line.long 0 "VID_ERR_COLOR"
hexfld.byte 0 " COL_RED "
hexfld.byte 1 " COL_GREEN "
hexfld.byte 2 " COL_BLUE "
hexfld.byte 3 " PAD_VAL "
;tree.end

base ad:0xa03530b4
;tree "2VID_VPOS"
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--12. " LINE_VAL "  " "
;tree.end

base ad:0xa03530b8
;tree "2VID_HPOS"
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
;tree.end

base ad:0xa03530bc
;tree "2VID_MODE_STS"
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
;tree.end

base ad:0xa03530c0
;tree "2VID_VCA_SETTING1"
group 0--3
line.long 0 "VID_VCA_SETTING1"
hexfld.word 0 " MAX_BURST_LIMIT "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
;tree.end

base ad:0xa03530c4
;tree "2VID_VCA_SETTING2"
group 0--3
line.long 0 "VID_VCA_SETTING2"
hexfld.word 0 " EXACT_BURST_LIMIT "
hexfld.word 0 " MAX_LINE_LIMIT "
;tree.end

base ad:0xa03530c8
;tree "2TVG_CTL"
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " TVG_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa03530cc
;tree "2TVG_IMG_SIZE"
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--12. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--26. " TVG_NBLINE "  " "
;tree.end

base ad:0xa03530d0
;tree "2TVG_COLOR1"
group 0--3
line.long 0 "TVG_COLOR1"
hexfld.byte 0 " COL1_RED "
hexfld.byte 1 " COL1_GREEN "
hexfld.byte 2 " COL1_BLUE "
;tree.end

base ad:0xa03530d4
;tree "2TVG_COLOR2"
group 0--3
line.long 0 "TVG_COLOR2"
hexfld.byte 0 " COL2_RED "
hexfld.byte 1 " COL2_GREEN "
hexfld.byte 2 " COL2_BLUE "
;tree.end

base ad:0xa03530d8
;tree "2TVG_STS"
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
;tree.end

base ad:0xa03530e0
;tree "2TBG_CTL"
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa03530e4
;tree "2TBG_SETTING"
group 0--3
line.long 0 "TBG_SETTING"
hexfld.word 0 " TBG_DATA "
bitfld.long 0 16.--27. " TBG_CPT "  " "
;tree.end

base ad:0xa03530e8
;tree "2TBG_STS"
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
;tree.end

base ad:0xa03530f0
;tree "2MCTL_MAIN_STS_CTL"
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 21. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " CRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " VRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03530f4
;tree "2CMD_MODE_STS_CTL"
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SDI1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SDI2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 21. " CSM_RUNNING_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03530f8
;tree "2DIRECT_CMD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03530fc
;tree "2DIRECT_CMD_RD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0353100
;tree "2VID_MODE_STS_CTL"
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGTH_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0353104
;tree "2TG_STS_CTL"
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0353108
;tree "2MCTL_DPHY_ERR_CTL"
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL"
bitfld.long 0 0. " ERR_SOT_HS_1_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_SOT_HS_2_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SOTSYNC_1_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SOTSYNC_2_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_EOTSYNC_1_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_EOTSYNC_2_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_SOT_HS_1_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_SOT_HS_2_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SOTSYNC_1_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SOTSYNC_2_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_EOTSYNC_1_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_EOTSYNC_2_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 26. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 27. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 28. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 29. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 30. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 31. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
;tree.end

base ad:0xa035310c
;tree "2DPHY_CLK_TRIM_RD_CTL"
group 0--3
line.long 0 "DPHY_CLK_TRIM_RD_CTL"
bitfld.long 0 0. " DPHY_Z_CALIB_OUT_VALID_EN "  "0 ,1 "
bitfld.long 0 16. " DPHY_Z_CALIB_OUT_VALID_ED "  "0 ,1 "
;tree.end

base ad:0xa0353110
;tree "2MCTL_MAIN_STS_CLR"
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa0353114
;tree "2CMD_MODE_STS_CLR"
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_CLR "  "0 ,1 "
;tree.end

base ad:0xa0353118
;tree "2DIRECT_CMD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa035311c
;tree "2DIRECT_CMD_RD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa0353120
;tree "2VID_MODE_STS_CLR"
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
;tree.end

base ad:0xa0353124
;tree "2TG_STS_CLR"
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
;tree.end

base ad:0xa0353128
;tree "2MCTL_DPHY_ERR_CLR"
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 0. " ERR_SOT_HS_1_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_SOT_HS_2_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SOTSYNC_1_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SOTSYNC_2_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_EOTSYNC_1_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_EOTSYNC_2_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
;tree.end

base ad:0xa035312c
;tree "2DPHY_CLK_TRIM_RD_CLR"
wgroup 0--3
line.long 0 "DPHY_CLK_TRIM_RD_CLR"
bitfld.long 0 0. " DPHY_Z_CALIB_OUT_VALID_CLR "  "0 ,1 "
;tree.end

base ad:0xa0353130
;tree "2MCTL_MAIN_STS_FLAG"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0353134
;tree "2CMD_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0353138
;tree "2DIRECT_CMD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa035313c
;tree "2DIRECT_CMD_RD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0353140
;tree "2VID_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0353144
;tree "2TG_STS_FLAG"
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0353148
;tree "2MCTL_DPHY_ERR_FLAG"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 0. " ERR_SOT_HS_1_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_SOT_HS_2_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SOTSYNC_1_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SOTSYNC_2_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_EOTSYNC_1_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_EOTSYNC_2_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
;tree.end

base ad:0xa035314c
;tree "2DPHY_CLK_TRIM_RD_FLAG"
rgroup 0--3
line.long 0 "DPHY_CLK_TRIM_RD_FLAG"
bitfld.long 0 0. " DPHY_Z_CALIB_OUT_VALID_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0353150
;tree "2DPHY_LANES_TRIM"
group 0--3
line.long 0 "DPHY_LANES_TRIM"
bitfld.long 0 0.--1. " DPHY_SKEW_DAT1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DPHY_CD_OFF_DAT1 "  "0 ,1 "
bitfld.long 0 3.--4. " DPHY_SKEW_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " DPHY_LP_RX_VIL_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 7.--8. " DPHY_LP_TX_SLEWRATE_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 9. " DPHY_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 10. " DPHY_Z_CALIB_BYPASS_CLK "  "0 ,1 "
bitfld.long 0 11.--13. " DPHY_Z_CALIB_IN_CLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 14.--16. " DPHY_ZH_CALIB_IN_CLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17. " DPHY_LPCD_BYPASS_CLK "  "0 ,1 "
bitfld.long 0 18. " DPHY_LPCD_345_E_CLK "  "0 ,1 "
bitfld.long 0 19. " DPHY_LPCD_375_E_CLK "  "0 ,1 "
bitfld.long 0 20. " DPHY_LPCD_400_E_CLK "  "0 ,1 "
bitfld.long 0 21.--22. " DPHY_SKEW_DAT2 "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0353154
;tree "2DPHY_CLK_TRIM_RD"
rgroup 0--3
line.long 0 "DPHY_CLK_TRIM_RD"
bitfld.long 0 0.--2. " DPHY_Z_CALIB_OUT_CLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " DPHY_ZH_CALIB_OUT_CLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6. " DPHY_Z_CALIB_OUT_VALID_CLK "  "0 ,1 "
;tree.end

base ad:0xa0353ff0
;tree "2ID_REG"
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--9. " H "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--17. " PRODUCT_ID "  " "
bitfld.long 0 18.--31. " VENDOR_ID "  " "
;tree.end

base ad:0xa0353ff4
;tree "2IP_CONF"
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " FIFO_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

endif

tree.end

base ad:0xa0352000
;********************************************
tree "DSI-1"
;********************************************
if (((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x801571ec)&0x20000000)!=0x20000000)||((data.long(ad:0x8015725c)&0x02)!=0x02))

base ad:0x80157064
;tree "prcm_mcdeclk_mgt_reg"
group 0--3
line.long 0 "prcm_mcdeclk_mgt_reg"
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 29. " SOC_mem_init_n "  "0 ,1 "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 29. " SOC_mem_init_n "  "0 ,1 "
;tree.end

base ad:0x8015725c
;tree "prcm_power_state_val"
group 0--3
line.long 0 "prcm_power_state_val"
bitfld.long 0 7. " B2R2_MCDE "  "0 ,1 "
;tree.end

else

base ad:0xa0352000
;tree "1MCTL_INTEGRATION_MODE"
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
;tree.end

base ad:0xa0352004
;tree "1MCTL_MAIN_DATA_CTL"
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF1_MODE "  "0 ,1 "
bitfld.long 0 2. " VID_EN "  "0 ,1 "
bitfld.long 0 3. " TVG_SEL "  "0 ,1 "
bitfld.long 0 4. " TBG_SEL "  "0 ,1 "
bitfld.long 0 5. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 6. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 7. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 8. " READ_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_EN "  "0 ,1 "
bitfld.long 0 10. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 11. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 12. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 13. " DISP_EOT_GEN "  "0 ,1 "
;tree.end

base ad:0xa0352008
;tree "1MCTL_MAIN_PHY_CTL"
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 2. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 3. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 6.--9. " WAIT_BURST_TIME "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa035200c
;tree "1MCTL_PLL_CTL"
group 0--3
line.long 0 "MCTL_PLL_CTL"
bitfld.long 0 0.--6. " PLL_MULT "  " "
bitfld.long 0 7.--9. " PLL_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " PLL_IN_SEL "  "0 ,1 "
bitfld.long 0 11. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 16. " PLL_MASTER "  "0 ,1 "
;tree.end

base ad:0xa0352010
;tree "1MCTL_LANE_STS"
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " DATLANE1_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " DATLANE2_STATE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0352014
;tree "1MCTL_DPHY_TIMEOUT"
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT"
bitfld.long 0 0.--3. " CLK_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--17. " HSTX_TO_VAL "  " "
bitfld.long 0 18.--31. " LPRX_TO_VAL "  " "
;tree.end

base ad:0xa0352018
;tree "1MCTL_ULPOUT_TIME"
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
;tree.end

base ad:0xa035201c
;tree "1MCTL_DPHY_STATIC"
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6.--11. " UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa0352020
;tree "1MCTL_MAIN_EN"
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 7. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 8. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " IF1_EN "  "0 ,1 "
bitfld.long 0 10. " IF2_EN "  "0 ,1 "
;tree.end

base ad:0xa0352024
;tree "1MCTL_MAIN_STS"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LOCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK "  "0 ,1 "
;tree.end

base ad:0xa0352028
;tree "1MCTL_DPHY_ERR"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 0. " ERR_SOT_HS_1 "  "0 ,1 "
bitfld.long 0 1. " ERR_SOT_HS_2 "  "0 ,1 "
bitfld.long 0 2. " ERR_SOTSYNC_1 "  "0 ,1 "
bitfld.long 0 3. " ERR_SOTSYNC_2 "  "0 ,1 "
bitfld.long 0 4. " ERR_EOTSYNC_1 "  "0 ,1 "
bitfld.long 0 5. " ERR_EOTSYNC_2 "  "0 ,1 "
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2 "  "0 ,1 "
;tree.end

base ad:0xa0352030
;tree "1INT_VID_RDDATA"
group 0--3
line.long 0 "INT_VID_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

base ad:0xa0352034
;tree "1INT_VID_GNT"
group 0--3
line.long 0 "INT_VID_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

base ad:0xa0352038
;tree "1INT_CMD_RDDATA"
group 0--3
line.long 0 "INT_CMD_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

base ad:0xa035203c
;tree "1INT_CMD_GNT"
group 0--3
line.long 0 "INT_CMD_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

base ad:0xa0352040
;tree "1INT_INTERRUPT_CTL"
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
;tree.end

base ad:0xa0352050
;tree "1CMD_MODE_CTL"
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " IF2_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 5. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 6. " ARB_MODE "  "0 ,1 "
bitfld.long 0 7. " ARB_PRI "  "0 ,1 "
hexfld.byte 1 " FIL_VALUE "
bitfld.long 0 16.--25. " TE_TIMEOUT "  " "
;tree.end

base ad:0xa0352054
;tree "1CMD_MODE_STS"
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING "  "0 ,1 "
;tree.end

base ad:0xa0352060
;tree "1DIRECT_CMD_SEND"
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
;tree.end

base ad:0xa0352064
;tree "1DIRECT_CMD_MAIN_SETTINGS"
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--15. " CMD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--20. " CMD_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 24.--27. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0352068
;tree "1DIRECT_CMD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 0 " ACK_VAL "
;tree.end

base ad:0xa035206c
;tree "1DIRECT_CMD_RD_INIT"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
hexfld.word 0 " CMD_RD_INIT "
;tree.end

base ad:0xa0352070
;tree "1DIRECT_CMD_WRDAT0"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT0"
bitfld.long 0 0. " WRDAT0 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT1 "  " "
bitfld.long 0 9.--16. " WRDAT2 "  " "
bitfld.long 0 17.--24. " WRDAT3 "  " "
;tree.end

base ad:0xa0352074
;tree "1DIRECT_CMD_WRDAT1"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT1"
bitfld.long 0 0. " WRDAT4 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT5 "  " "
bitfld.long 0 9.--16. " WRDAT6 "  " "
bitfld.long 0 17.--24. " WRDAT7 "  " "
;tree.end

base ad:0xa0352078
;tree "1DIRECT_CMD_WRDAT2"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT2"
bitfld.long 0 0. " WRDAT8 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT9 "  " "
bitfld.long 0 9.--16. " WRDAT10 "  " "
bitfld.long 0 17.--24. " WRDAT11 "  " "
;tree.end

base ad:0xa035207c
;tree "1DIRECT_CMD_WRDAT3"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT3"
bitfld.long 0 0. " WRDAT12 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT13 "  " "
bitfld.long 0 9.--16. " WRDAT14 "  " "
bitfld.long 0 17.--24. " WRDAT15 "  " "
;tree.end

base ad:0xa0352080
;tree "1DIRECT_CMD_RDDAT"
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
hexfld.byte 0 " RDDAT0 "
hexfld.byte 1 " RDDAT1 "
hexfld.byte 2 " RDDAT2 "
hexfld.byte 3 " RDDAT3 "
;tree.end

base ad:0xa0352084
;tree "1DIRECT_CMD_RD_PROPERTY"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
hexfld.word 0 " RD_SIZE "
bitfld.long 0 16.--17. " RD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
;tree.end

base ad:0xa0352088
;tree "1DIRECT_CMD_RD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
;tree.end

base ad:0xa0352090
;tree "1VID_MAIN_CTL"
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STOP_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " VID_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--11. " HEADER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--13. " VID_PIXEL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " BURST_MODE "  "0 ,1 "
bitfld.long 0 15. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 16. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 17.--18. " REG_BLKLINE_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 19.--20. " REG_BLKEOL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--22. " RECOVERY_MODE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0352094
;tree "1VID_VSIZE"
group 0--3
line.long 0 "VID_VSIZE"
bitfld.long 0 0.--3. " VSA_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " VBP_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " VFP_LENGTH "
bitfld.long 0 16.--26. " VACT_LENGTH "  " "
;tree.end

base ad:0xa0352098
;tree "1VID_HSIZE1"
group 0--3
line.long 0 "VID_HSIZE1"
hexfld.byte 0 " HSA_LENGTH "
hexfld.byte 1 " HBP_LENGTH "
bitfld.long 0 16.--26. " HFP_LENGTH "  " "
;tree.end

base ad:0xa035209c
;tree "1VID_HSIZE2"
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--12. " RGB_SIZE "  " "
;tree.end

base ad:0xa03520a0
;tree "1VID_BLKSIZE1"
group 0--3
line.long 0 "VID_BLKSIZE1"
bitfld.long 0 0.--12. " BLKLINE_EVENT_PCK "  " "
bitfld.long 0 13.--25. " BLKEOL_PCK "  " "
;tree.end

base ad:0xa03520a4
;tree "1VID_BLKSIZE2"
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
;tree.end

base ad:0xa03520a8
;tree "1VID_PCK_TIME"
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
;tree.end

base ad:0xa03520ac
;tree "1VID_DPHY_TIME"
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
;tree.end

base ad:0xa03520b0
;tree "1VID_ERR_COLOR"
group 0--3
line.long 0 "VID_ERR_COLOR"
hexfld.byte 0 " COL_RED "
hexfld.byte 1 " COL_GREEN "
hexfld.byte 2 " COL_BLUE "
hexfld.byte 3 " PAD_VAL "
;tree.end

base ad:0xa03520b4
;tree "1VID_VPOS"
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--12. " LINE_VAL "  " "
;tree.end

base ad:0xa03520b8
;tree "1VID_HPOS"
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
;tree.end

base ad:0xa03520bc
;tree "1VID_MODE_STS"
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
;tree.end

base ad:0xa03520c0
;tree "1VID_VCA_SETTING1"
group 0--3
line.long 0 "VID_VCA_SETTING1"
hexfld.word 0 " MAX_BURST_LIMIT "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
;tree.end

base ad:0xa03520c4
;tree "1VID_VCA_SETTING2"
group 0--3
line.long 0 "VID_VCA_SETTING2"
hexfld.word 0 " EXACT_BURST_LIMIT "
hexfld.word 0 " MAX_LINE_LIMIT "
;tree.end

base ad:0xa03520c8
;tree "1TVG_CTL"
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " TVG_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa03520cc
;tree "1TVG_IMG_SIZE"
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--12. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--26. " TVG_NBLINE "  " "
;tree.end

base ad:0xa03520d0
;tree "1TVG_COLOR1"
group 0--3
line.long 0 "TVG_COLOR1"
hexfld.byte 0 " COL1_RED "
hexfld.byte 1 " COL1_GREEN "
hexfld.byte 2 " COL1_BLUE "
;tree.end

base ad:0xa03520d4
;tree "1TVG_COLOR2"
group 0--3
line.long 0 "TVG_COLOR2"
hexfld.byte 0 " COL2_RED "
hexfld.byte 1 " COL2_GREEN "
hexfld.byte 2 " COL2_BLUE "
;tree.end

base ad:0xa03520d8
;tree "1TVG_STS"
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
;tree.end

base ad:0xa03520e0
;tree "1TBG_CTL"
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa03520e4
;tree "1TBG_SETTING"
group 0--3
line.long 0 "TBG_SETTING"
hexfld.word 0 " TBG_DATA "
bitfld.long 0 16.--27. " TBG_CPT "  " "
;tree.end

base ad:0xa03520e8
;tree "1TBG_STS"
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
;tree.end

base ad:0xa03520f0
;tree "1MCTL_MAIN_STS_CTL"
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 21. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " CRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " VRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03520f4
;tree "1CMD_MODE_STS_CTL"
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SDI1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SDI2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 21. " CSM_RUNNING_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03520f8
;tree "1DIRECT_CMD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03520fc
;tree "1DIRECT_CMD_RD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0352100
;tree "1VID_MODE_STS_CTL"
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGTH_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0352104
;tree "1TG_STS_CTL"
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0352108
;tree "1MCTL_DPHY_ERR_CTL"
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL"
bitfld.long 0 0. " ERR_SOT_HS_1_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_SOT_HS_2_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SOTSYNC_1_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SOTSYNC_2_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_EOTSYNC_1_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_EOTSYNC_2_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_SOT_HS_1_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_SOT_HS_2_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SOTSYNC_1_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SOTSYNC_2_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_EOTSYNC_1_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_EOTSYNC_2_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 26. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 27. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 28. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 29. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 30. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 31. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
;tree.end

base ad:0xa035210c
;tree "1DPHY_CLK_TRIM_RD_CTL"
group 0--3
line.long 0 "DPHY_CLK_TRIM_RD_CTL"
bitfld.long 0 0. " DPHY_Z_CALIB_OUT_VALID_EN "  "0 ,1 "
bitfld.long 0 16. " DPHY_Z_CALIB_OUT_VALID_ED "  "0 ,1 "
;tree.end

base ad:0xa0352110
;tree "1MCTL_MAIN_STS_CLR"
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa0352114
;tree "1CMD_MODE_STS_CLR"
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_CLR "  "0 ,1 "
;tree.end

base ad:0xa0352118
;tree "1DIRECT_CMD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa035211c
;tree "1DIRECT_CMD_RD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa0352120
;tree "1VID_MODE_STS_CLR"
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
;tree.end

base ad:0xa0352124
;tree "1TG_STS_CLR"
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
;tree.end

base ad:0xa0352128
;tree "1MCTL_DPHY_ERR_CLR"
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 0. " ERR_SOT_HS_1_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_SOT_HS_2_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SOTSYNC_1_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SOTSYNC_2_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_EOTSYNC_1_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_EOTSYNC_2_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
;tree.end

base ad:0xa035212c
;tree "1DPHY_CLK_TRIM_RD_CLR"
wgroup 0--3
line.long 0 "DPHY_CLK_TRIM_RD_CLR"
bitfld.long 0 0. " DPHY_Z_CALIB_OUT_VALID_CLR "  "0 ,1 "
;tree.end

base ad:0xa0352130
;tree "1MCTL_MAIN_STS_FLAG"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0352134
;tree "1CMD_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0352138
;tree "1DIRECT_CMD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa035213c
;tree "1DIRECT_CMD_RD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0352140
;tree "1VID_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0352144
;tree "1TG_STS_FLAG"
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0352148
;tree "1MCTL_DPHY_ERR_FLAG"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 0. " ERR_SOT_HS_1_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_SOT_HS_2_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SOTSYNC_1_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SOTSYNC_2_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_EOTSYNC_1_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_EOTSYNC_2_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
;tree.end

base ad:0xa035214c
;tree "1DPHY_CLK_TRIM_RD_FLAG"
rgroup 0--3
line.long 0 "DPHY_CLK_TRIM_RD_FLAG"
bitfld.long 0 0. " DPHY_Z_CALIB_OUT_VALID_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0352150
;tree "1DPHY_LANES_TRIM"
group 0--3
line.long 0 "DPHY_LANES_TRIM"
bitfld.long 0 0.--1. " DPHY_SKEW_DAT1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DPHY_CD_OFF_DAT1 "  "0 ,1 "
bitfld.long 0 3.--4. " DPHY_SKEW_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " DPHY_LP_RX_VIL_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 7.--8. " DPHY_LP_TX_SLEWRATE_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 9. " DPHY_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 10. " DPHY_Z_CALIB_BYPASS_CLK "  "0 ,1 "
bitfld.long 0 11.--13. " DPHY_Z_CALIB_IN_CLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 14.--16. " DPHY_ZH_CALIB_IN_CLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17. " DPHY_LPCD_BYPASS_CLK "  "0 ,1 "
bitfld.long 0 18. " DPHY_LPCD_345_E_CLK "  "0 ,1 "
bitfld.long 0 19. " DPHY_LPCD_375_E_CLK "  "0 ,1 "
bitfld.long 0 20. " DPHY_LPCD_400_E_CLK "  "0 ,1 "
bitfld.long 0 21.--22. " DPHY_SKEW_DAT2 "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0352154
;tree "1DPHY_CLK_TRIM_RD"
rgroup 0--3
line.long 0 "DPHY_CLK_TRIM_RD"
bitfld.long 0 0.--2. " DPHY_Z_CALIB_OUT_CLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " DPHY_ZH_CALIB_OUT_CLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6. " DPHY_Z_CALIB_OUT_VALID_CLK "  "0 ,1 "
;tree.end

base ad:0xa0352ff0
;tree "1ID_REG"
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--9. " H "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--17. " PRODUCT_ID "  " "
bitfld.long 0 18.--31. " VENDOR_ID "  " "
;tree.end

base ad:0xa0352ff4
;tree "1IP_CONF"
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " FIFO_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

endif

tree.end

base ad:0xa0351000
;********************************************
tree "DSI-0"
;********************************************
if (((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x801571ec)&0x20000000)!=0x20000000)||((data.long(ad:0x8015725c)&0x02)!=0x02))

base ad:0x80157064
;tree "prcm_mcdeclk_mgt_reg"
group 0--3
line.long 0 "prcm_mcdeclk_mgt_reg"
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 29. " SOC_mem_init_n "  "0 ,1 "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 29. " SOC_mem_init_n "  "0 ,1 "
;tree.end

base ad:0x8015725c
;tree "prcm_power_state_val"
group 0--3
line.long 0 "prcm_power_state_val"
bitfld.long 0 7. " B2R2_MCDE "  "0 ,1 "
;tree.end

else

base ad:0xa0351000
;tree "0MCTL_INTEGRATION_MODE"
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
;tree.end

base ad:0xa0351004
;tree "0MCTL_MAIN_DATA_CTL"
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF1_MODE "  "0 ,1 "
bitfld.long 0 2. " VID_EN "  "0 ,1 "
bitfld.long 0 3. " TVG_SEL "  "0 ,1 "
bitfld.long 0 4. " TBG_SEL "  "0 ,1 "
bitfld.long 0 5. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 6. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 7. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 8. " READ_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_EN "  "0 ,1 "
bitfld.long 0 10. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 11. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 12. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 13. " DISP_EOT_GEN "  "0 ,1 "
;tree.end

base ad:0xa0351008
;tree "0MCTL_MAIN_PHY_CTL"
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 2. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 3. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 6.--9. " WAIT_BURST_TIME "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa035100c
;tree "0MCTL_PLL_CTL"
group 0--3
line.long 0 "MCTL_PLL_CTL"
bitfld.long 0 0.--6. " PLL_MULT "  " "
bitfld.long 0 7.--9. " PLL_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " PLL_IN_SEL "  "0 ,1 "
bitfld.long 0 11. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 16. " PLL_MASTER "  "0 ,1 "
;tree.end

base ad:0xa0351010
;tree "0MCTL_LANE_STS"
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " DATLANE1_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " DATLANE2_STATE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0351014
;tree "0MCTL_DPHY_TIMEOUT"
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT"
bitfld.long 0 0.--3. " CLK_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--17. " HSTX_TO_VAL "  " "
bitfld.long 0 18.--31. " LPRX_TO_VAL "  " "
;tree.end

base ad:0xa0351018
;tree "0MCTL_ULPOUT_TIME"
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
;tree.end

base ad:0xa035101c
;tree "0MCTL_DPHY_STATIC"
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6.--11. " UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa0351020
;tree "0MCTL_MAIN_EN"
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 7. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 8. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " IF1_EN "  "0 ,1 "
bitfld.long 0 10. " IF2_EN "  "0 ,1 "
;tree.end

base ad:0xa0351024
;tree "0MCTL_MAIN_STS"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LOCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK "  "0 ,1 "
;tree.end

base ad:0xa0351028
;tree "0MCTL_DPHY_ERR"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 0. " ERR_SOT_HS_1 "  "0 ,1 "
bitfld.long 0 1. " ERR_SOT_HS_2 "  "0 ,1 "
bitfld.long 0 2. " ERR_SOTSYNC_1 "  "0 ,1 "
bitfld.long 0 3. " ERR_SOTSYNC_2 "  "0 ,1 "
bitfld.long 0 4. " ERR_EOTSYNC_1 "  "0 ,1 "
bitfld.long 0 5. " ERR_EOTSYNC_2 "  "0 ,1 "
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2 "  "0 ,1 "
;tree.end

base ad:0xa0351030
;tree "0INT_VID_RDDATA"
group 0--3
line.long 0 "INT_VID_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

base ad:0xa0351034
;tree "0INT_VID_GNT"
group 0--3
line.long 0 "INT_VID_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

base ad:0xa0351038
;tree "0INT_CMD_RDDATA"
group 0--3
line.long 0 "INT_CMD_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

base ad:0xa035103c
;tree "0INT_CMD_GNT"
group 0--3
line.long 0 "INT_CMD_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

base ad:0xa0351040
;tree "0INT_INTERRUPT_CTL"
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
;tree.end

base ad:0xa0351050
;tree "0CMD_MODE_CTL"
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " IF2_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 5. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 6. " ARB_MODE "  "0 ,1 "
bitfld.long 0 7. " ARB_PRI "  "0 ,1 "
hexfld.byte 1 " FIL_VALUE "
bitfld.long 0 16.--25. " TE_TIMEOUT "  " "
;tree.end

base ad:0xa0351054
;tree "0CMD_MODE_STS"
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING "  "0 ,1 "
;tree.end

base ad:0xa0351060
;tree "0DIRECT_CMD_SEND"
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
;tree.end

base ad:0xa0351064
;tree "0DIRECT_CMD_MAIN_SETTINGS"
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--15. " CMD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--20. " CMD_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 24.--27. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0351068
;tree "0DIRECT_CMD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 0 " ACK_VAL "
;tree.end

base ad:0xa035106c
;tree "0DIRECT_CMD_RD_INIT"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
hexfld.word 0 " CMD_RD_INIT "
;tree.end

base ad:0xa0351070
;tree "0DIRECT_CMD_WRDAT0"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT0"
bitfld.long 0 0. " WRDAT0 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT1 "  " "
bitfld.long 0 9.--16. " WRDAT2 "  " "
bitfld.long 0 17.--24. " WRDAT3 "  " "
;tree.end

base ad:0xa0351074
;tree "0DIRECT_CMD_WRDAT1"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT1"
bitfld.long 0 0. " WRDAT4 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT5 "  " "
bitfld.long 0 9.--16. " WRDAT6 "  " "
bitfld.long 0 17.--24. " WRDAT7 "  " "
;tree.end

base ad:0xa0351078
;tree "0DIRECT_CMD_WRDAT2"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT2"
bitfld.long 0 0. " WRDAT8 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT9 "  " "
bitfld.long 0 9.--16. " WRDAT10 "  " "
bitfld.long 0 17.--24. " WRDAT11 "  " "
;tree.end

base ad:0xa035107c
;tree "0DIRECT_CMD_WRDAT3"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT3"
bitfld.long 0 0. " WRDAT12 "  "0 ,1 "
bitfld.long 0 1.--8. " WRDAT13 "  " "
bitfld.long 0 9.--16. " WRDAT14 "  " "
bitfld.long 0 17.--24. " WRDAT15 "  " "
;tree.end

base ad:0xa0351080
;tree "0DIRECT_CMD_RDDAT"
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
hexfld.byte 0 " RDDAT0 "
hexfld.byte 1 " RDDAT1 "
hexfld.byte 2 " RDDAT2 "
hexfld.byte 3 " RDDAT3 "
;tree.end

base ad:0xa0351084
;tree "0DIRECT_CMD_RD_PROPERTY"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
hexfld.word 0 " RD_SIZE "
bitfld.long 0 16.--17. " RD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
;tree.end

base ad:0xa0351088
;tree "0DIRECT_CMD_RD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
;tree.end

base ad:0xa0351090
;tree "0VID_MAIN_CTL"
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STOP_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " VID_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--11. " HEADER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--13. " VID_PIXEL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " BURST_MODE "  "0 ,1 "
bitfld.long 0 15. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 16. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 17.--18. " REG_BLKLINE_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 19.--20. " REG_BLKEOL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--22. " RECOVERY_MODE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0351094
;tree "0VID_VSIZE"
group 0--3
line.long 0 "VID_VSIZE"
bitfld.long 0 0.--3. " VSA_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " VBP_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " VFP_LENGTH "
bitfld.long 0 16.--26. " VACT_LENGTH "  " "
;tree.end

base ad:0xa0351098
;tree "0VID_HSIZE1"
group 0--3
line.long 0 "VID_HSIZE1"
hexfld.byte 0 " HSA_LENGTH "
hexfld.byte 1 " HBP_LENGTH "
bitfld.long 0 16.--26. " HFP_LENGTH "  " "
;tree.end

base ad:0xa035109c
;tree "0VID_HSIZE2"
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--12. " RGB_SIZE "  " "
;tree.end

base ad:0xa03510a0
;tree "0VID_BLKSIZE1"
group 0--3
line.long 0 "VID_BLKSIZE1"
bitfld.long 0 0.--12. " BLKLINE_EVENT_PCK "  " "
bitfld.long 0 13.--25. " BLKEOL_PCK "  " "
;tree.end

base ad:0xa03510a4
;tree "0VID_BLKSIZE2"
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
;tree.end

base ad:0xa03510a8
;tree "0VID_PCK_TIME"
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
;tree.end

base ad:0xa03510ac
;tree "0VID_DPHY_TIME"
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
;tree.end

base ad:0xa03510b0
;tree "0VID_ERR_COLOR"
group 0--3
line.long 0 "VID_ERR_COLOR"
hexfld.byte 0 " COL_RED "
hexfld.byte 1 " COL_GREEN "
hexfld.byte 2 " COL_BLUE "
hexfld.byte 3 " PAD_VAL "
;tree.end

base ad:0xa03510b4
;tree "0VID_VPOS"
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--12. " LINE_VAL "  " "
;tree.end

base ad:0xa03510b8
;tree "0VID_HPOS"
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
;tree.end

base ad:0xa03510bc
;tree "0VID_MODE_STS"
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
;tree.end

base ad:0xa03510c0
;tree "0VID_VCA_SETTING1"
group 0--3
line.long 0 "VID_VCA_SETTING1"
hexfld.word 0 " MAX_BURST_LIMIT "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
;tree.end

base ad:0xa03510c4
;tree "0VID_VCA_SETTING2"
group 0--3
line.long 0 "VID_VCA_SETTING2"
hexfld.word 0 " EXACT_BURST_LIMIT "
hexfld.word 0 " MAX_LINE_LIMIT "
;tree.end

base ad:0xa03510c8
;tree "0TVG_CTL"
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " TVG_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa03510cc
;tree "0TVG_IMG_SIZE"
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--12. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--26. " TVG_NBLINE "  " "
;tree.end

base ad:0xa03510d0
;tree "0TVG_COLOR1"
group 0--3
line.long 0 "TVG_COLOR1"
hexfld.byte 0 " COL1_RED "
hexfld.byte 1 " COL1_GREEN "
hexfld.byte 2 " COL1_BLUE "
;tree.end

base ad:0xa03510d4
;tree "0TVG_COLOR2"
group 0--3
line.long 0 "TVG_COLOR2"
hexfld.byte 0 " COL2_RED "
hexfld.byte 1 " COL2_GREEN "
hexfld.byte 2 " COL2_BLUE "
;tree.end

base ad:0xa03510d8
;tree "0TVG_STS"
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
;tree.end

base ad:0xa03510e0
;tree "0TBG_CTL"
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa03510e4
;tree "0TBG_SETTING"
group 0--3
line.long 0 "TBG_SETTING"
hexfld.word 0 " TBG_DATA "
bitfld.long 0 16.--27. " TBG_CPT "  " "
;tree.end

base ad:0xa03510e8
;tree "0TBG_STS"
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
;tree.end

base ad:0xa03510f0
;tree "0MCTL_MAIN_STS_CTL"
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 21. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " CRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " VRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03510f4
;tree "0CMD_MODE_STS_CTL"
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SDI1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SDI2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 21. " CSM_RUNNING_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03510f8
;tree "0DIRECT_CMD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03510fc
;tree "0DIRECT_CMD_RD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0351100
;tree "0VID_MODE_STS_CTL"
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGTH_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0351104
;tree "0TG_STS_CTL"
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0351108
;tree "0MCTL_DPHY_ERR_CTL"
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL"
bitfld.long 0 0. " ERR_SOT_HS_1_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_SOT_HS_2_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SOTSYNC_1_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SOTSYNC_2_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_EOTSYNC_1_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_EOTSYNC_2_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_SOT_HS_1_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_SOT_HS_2_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SOTSYNC_1_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SOTSYNC_2_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_EOTSYNC_1_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_EOTSYNC_2_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 26. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 27. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 28. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 29. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 30. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 31. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
;tree.end

base ad:0xa035110c
;tree "0DPHY_CLK_TRIM_RD_CTL"
group 0--3
line.long 0 "DPHY_CLK_TRIM_RD_CTL"
bitfld.long 0 0. " DPHY_Z_CALIB_OUT_VALID_EN "  "0 ,1 "
bitfld.long 0 16. " DPHY_Z_CALIB_OUT_VALID_ED "  "0 ,1 "
;tree.end

base ad:0xa0351110
;tree "0MCTL_MAIN_STS_CLR"
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa0351114
;tree "0CMD_MODE_STS_CLR"
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_CLR "  "0 ,1 "
;tree.end

base ad:0xa0351118
;tree "0DIRECT_CMD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa035111c
;tree "0DIRECT_CMD_RD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa0351120
;tree "0VID_MODE_STS_CLR"
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
;tree.end

base ad:0xa0351124
;tree "0TG_STS_CLR"
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
;tree.end

base ad:0xa0351128
;tree "0MCTL_DPHY_ERR_CLR"
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 0. " ERR_SOT_HS_1_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_SOT_HS_2_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SOTSYNC_1_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SOTSYNC_2_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_EOTSYNC_1_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_EOTSYNC_2_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
;tree.end

base ad:0xa035112c
;tree "0DPHY_CLK_TRIM_RD_CLR"
wgroup 0--3
line.long 0 "DPHY_CLK_TRIM_RD_CLR"
bitfld.long 0 0. " DPHY_Z_CALIB_OUT_VALID_CLR "  "0 ,1 "
;tree.end

base ad:0xa0351130
;tree "0MCTL_MAIN_STS_FLAG"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0351134
;tree "0CMD_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0351138
;tree "0DIRECT_CMD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa035113c
;tree "0DIRECT_CMD_RD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0351140
;tree "0VID_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0351144
;tree "0TG_STS_FLAG"
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0351148
;tree "0MCTL_DPHY_ERR_FLAG"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 0. " ERR_SOT_HS_1_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_SOT_HS_2_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SOTSYNC_1_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SOTSYNC_2_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_EOTSYNC_1_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_EOTSYNC_2_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
;tree.end

base ad:0xa035114c
;tree "0DPHY_CLK_TRIM_RD_FLAG"
rgroup 0--3
line.long 0 "DPHY_CLK_TRIM_RD_FLAG"
bitfld.long 0 0. " DPHY_Z_CALIB_OUT_VALID_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0351150
;tree "0DPHY_LANES_TRIM"
group 0--3
line.long 0 "DPHY_LANES_TRIM"
bitfld.long 0 0.--1. " DPHY_SKEW_DAT1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DPHY_CD_OFF_DAT1 "  "0 ,1 "
bitfld.long 0 3.--4. " DPHY_SKEW_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " DPHY_LP_RX_VIL_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 7.--8. " DPHY_LP_TX_SLEWRATE_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 9. " DPHY_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 10. " DPHY_Z_CALIB_BYPASS_CLK "  "0 ,1 "
bitfld.long 0 11.--13. " DPHY_Z_CALIB_IN_CLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 14.--16. " DPHY_ZH_CALIB_IN_CLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17. " DPHY_LPCD_BYPASS_CLK "  "0 ,1 "
bitfld.long 0 18. " DPHY_LPCD_345_E_CLK "  "0 ,1 "
bitfld.long 0 19. " DPHY_LPCD_375_E_CLK "  "0 ,1 "
bitfld.long 0 20. " DPHY_LPCD_400_E_CLK "  "0 ,1 "
bitfld.long 0 21.--22. " DPHY_SKEW_DAT2 "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0351154
;tree "0DPHY_CLK_TRIM_RD"
rgroup 0--3
line.long 0 "DPHY_CLK_TRIM_RD"
bitfld.long 0 0.--2. " DPHY_Z_CALIB_OUT_CLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " DPHY_ZH_CALIB_OUT_CLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6. " DPHY_Z_CALIB_OUT_VALID_CLK "  "0 ,1 "
;tree.end

base ad:0xa0351ff0
;tree "0ID_REG"
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--9. " H "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--17. " PRODUCT_ID "  " "
bitfld.long 0 18.--31. " VENDOR_ID "  " "
;tree.end

base ad:0xa0351ff4
;tree "0IP_CONF"
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " FIFO_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

endif

tree.end

tree.end

;==============================================================
tree "ETB11"
;==============================================================
base eapb:0x801b4004
;tree "RAM_Depth"
rgroup 0--3
line.long 0 "RAM_Depth"
hexfld.long 0 " RDP "
;tree.end

base eapb:0x801b400c
;tree "Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " FULL "  "0 ,1 "
bitfld.long 0 1. " TRIGGERED "  "0 ,1 "
bitfld.long 0 2. " ACQCOMP "  "0 ,1 "
bitfld.long 0 3. " FTEMPTY "  "0 ,1 "
;tree.end

base eapb:0x801b4010
;tree "RAM_Data"
group 0--3
line.long 0 "RAM_Data"
hexfld.long 0 " RAM_READ_DATA "
;tree.end

base eapb:0x801b4014
;tree "RAM_Read_Pointer"
group 0--3
line.long 0 "RAM_Read_Pointer"
bitfld.long 0 0.--1. " RAM_Read_Pointer "  "0 ,1 ,2 ,3 "
;tree.end

base eapb:0x801b4018
;tree "RAM_Write_Pointer"
group 0--3
line.long 0 "RAM_Write_Pointer"
bitfld.long 0 0.--1. " RAM_Write_Pointer "  "0 ,1 ,2 ,3 "
;tree.end

base eapb:0x801b401c
;tree "Trigger_Counter"
group 0--3
line.long 0 "Trigger_Counter"
bitfld.long 0 0.--1. " Trigger_Counter "  "0 ,1 ,2 ,3 "
;tree.end

base eapb:0x801b4020
;tree "Control"
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " TRACECAPTEN "  "0 ,1 "
;tree.end

base eapb:0x801b4024
;tree "RAM_WRITE"
wgroup 0--3
line.long 0 "RAM_WRITE"
hexfld.long 0 " RAM_WRITE_DATA "
;tree.end

base eapb:0x801b4300
;tree "FFSR"
rgroup 0--3
line.long 0 "FFSR"
bitfld.long 0 0. " FLINPROG "  "0 ,1 "
bitfld.long 0 1. " FTSTOPPED "  "0 ,1 "
;tree.end

base eapb:0x801b4304
;tree "DESCRIPTION"
group 0--3
line.long 0 "DESCRIPTION"
bitfld.long 0 0. " ENFTC "  "0 ,1 "
bitfld.long 0 1. " ENFCONT "  "0 ,1 "
bitfld.long 0 4. " FONFLIN "  "0 ,1 "
bitfld.long 0 5. " FONTRIG "  "0 ,1 "
bitfld.long 0 6. " FONMAN "  "0 ,1 "
bitfld.long 0 8. " TRIGIN "  "0 ,1 "
bitfld.long 0 9. " TRIGEVT "  "0 ,1 "
bitfld.long 0 10. " TRGFL "  "0 ,1 "
bitfld.long 0 12. " STOPFL "  "0 ,1 "
bitfld.long 0 13. " STOPTRIG "  "0 ,1 "
;tree.end

base eapb:0x801b4ee0
;tree "ITMISCOP0"
group 0--3
line.long 0 "ITMISCOP0"
bitfld.long 0 0. " ACQCOMP "  "0 ,1 "
bitfld.long 0 1. " FULL "  "0 ,1 "
;tree.end

base eapb:0x801b4ee4
;tree "ITTRFLINACK"
group 0--3
line.long 0 "ITTRFLINACK"
bitfld.long 0 0. " TRIGNACK "  "0 ,1 "
bitfld.long 0 1. " FLUSHINACK "  "0 ,1 "
;tree.end

base eapb:0x801b4ee8
;tree "ITTRFLIN"
group 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0. " TRIGIN "  "0 ,1 "
bitfld.long 0 1. " FLUSHIN "  "0 ,1 "
;tree.end

base eapb:0x801b4eec
;tree "ITATBDATA0"
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ATDATA[0] "  "0 ,1 "
bitfld.long 0 1. " ATDATA[7] "  "0 ,1 "
bitfld.long 0 2. " ATDATA[15] "  "0 ,1 "
bitfld.long 0 3. " ATDATA[23] "  "0 ,1 "
bitfld.long 0 4. " ATDATA[31] "  "0 ,1 "
;tree.end

base eapb:0x801b4ef0
;tree "ITATBCTR2"
group 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ATREADYS "  "0 ,1 "
bitfld.long 0 1. " AFVALIDS "  "0 ,1 "
;tree.end

base eapb:0x801b4ef4
;tree "ITATBCTR1"
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0.--6. " ATID "  " "
;tree.end

base eapb:0x801b4ef8
;tree "ITATBCTR0"
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ATVALID "  "0 ,1 "
bitfld.long 0 1. " AFREADY "  "0 ,1 "
bitfld.long 0 8.--9. " ATBYTES "  "0 ,1 ,2 ,3 "
;tree.end

base eapb:0x801b4f00
;tree "IMCR"
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " IMCR "  "0 ,1 "
;tree.end

base eapb:0x801b4fa0
;tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0. " CTSR "  "0 ,1 "
;tree.end

base eapb:0x801b4fa4
;tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0. " CTCR "  "0 ,1 "
;tree.end

base eapb:0x801b4fb0
;tree "LAR"
group 0--3
line.long 0 "LAR"
bitfld.long 0 0. " LAR "  "0 ,1 "
;tree.end

base eapb:0x801b4fb4
;tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0. " LSR "  "0 ,1 "
;tree.end

base eapb:0x801b4fb8
;tree "ASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0. " ASR "  "0 ,1 "
;tree.end

base eapb:0x801b4fc8
;tree "DID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0. " DID "  "0 ,1 "
;tree.end

base eapb:0x801b4fcc
;tree "DTIR"
rgroup 0--3
line.long 0 "DTIR"
bitfld.long 0 0. " DTIR "  "0 ,1 "
;tree.end

base eapb:0x801b4fd0
;tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0. " PERIPHERAL_ID4 "  "0 ,1 "
;tree.end

base eapb:0x801b4fd4
;tree "PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

base eapb:0x801b4fd8
;tree "PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

base eapb:0x801b4fdc
;tree "PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

base eapb:0x801b4fe0
;tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0. " PERIPHERAL_ID0 "  "0 ,1 "
;tree.end

base eapb:0x801b4fe4
;tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0. " PERIPHERAL_ID1 "  "0 ,1 "
;tree.end

base eapb:0x801b4fe8
;tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0. " PERIPHERAL_ID2 "  "0 ,1 "
;tree.end

base eapb:0x801b4fec
;tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0. " PERIPHERAL_ID3 "  "0 ,1 "
;tree.end

base eapb:0x801b4ff0
;tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

base eapb:0x801b4ff4
;tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0. " COMPONENT_ID1 "  "0 ,1 "
;tree.end

base eapb:0x801b4ff8
;tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0. " COMPONENT_ID2 "  "0 ,1 "
;tree.end

base eapb:0x801b4ffc
;tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0. " COMPONENT_ID3 "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "FSMC"
;==============================================================
base ad:0x80000000
;tree "FSMC_BCR0"
group 0--3
line.long 0 "FSMC_BCR0"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
;tree.end

base ad:0x80000008
;tree "FSMC_BCR1"
group 0--3
line.long 0 "FSMC_BCR1"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
;tree.end

base ad:0x80000010
;tree "FSMC_BCR2"
group 0--3
line.long 0 "FSMC_BCR2"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
;tree.end

base ad:0x80000018
;tree "FSMC_BCR3"
group 0--3
line.long 0 "FSMC_BCR3"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
;tree.end

base ad:0x80000004
;tree "FSMC_BTR0"
group 0--3
line.long 0 "FSMC_BTR0"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8000000c
;tree "FSMC_BTR1"
group 0--3
line.long 0 "FSMC_BTR1"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80000014
;tree "FSMC_BTR2"
group 0--3
line.long 0 "FSMC_BTR2"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8000001c
;tree "FSMC_BTR3"
group 0--3
line.long 0 "FSMC_BTR3"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80000040
;tree "FSMC_PCR0"
group 0--3
line.long 0 "FSMC_PCR0"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80000060
;tree "FSMC_PCR1"
group 0--3
line.long 0 "FSMC_PCR1"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80000080
;tree "FSMC_PCR2"
group 0--3
line.long 0 "FSMC_PCR2"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x800000a0
;tree "FSMC_PCR3"
group 0--3
line.long 0 "FSMC_PCR3"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80000044
;tree "FSMC_SR0"
rgroup 0--3
line.long 0 "FSMC_SR0"
bitfld.long 0 6. " FEMPT "  "0 ,1 "
;tree.end

base ad:0x80000064
;tree "FSMC_SR1"
rgroup 0--3
line.long 0 "FSMC_SR1"
bitfld.long 0 6. " FEMPT "  "0 ,1 "
;tree.end

base ad:0x80000048
;tree "FSMC_PMEM0"
group 0--3
line.long 0 "FSMC_PMEM0"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x80000068
;tree "FSMC_PMEM1"
group 0--3
line.long 0 "FSMC_PMEM1"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x80000088
;tree "FSMC_PMEM2"
group 0--3
line.long 0 "FSMC_PMEM2"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x800000a8
;tree "FSMC_PMEM3"
group 0--3
line.long 0 "FSMC_PMEM3"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x8000004c
;tree "FSMC_PATT0"
group 0--3
line.long 0 "FSMC_PATT0"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x8000006c
;tree "FSMC_PATT1"
group 0--3
line.long 0 "FSMC_PATT1"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x8000008c
;tree "FSMC_PATT2"
group 0--3
line.long 0 "FSMC_PATT2"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x800000ac
;tree "FSMC_PATT3"
group 0--3
line.long 0 "FSMC_PATT3"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x80000050
;tree "FSMC_PIO0"
group 0--3
line.long 0 "FSMC_PIO0"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x80000070
;tree "FSMC_PIO1"
group 0--3
line.long 0 "FSMC_PIO1"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x80000054
;tree "FSMC_ECCR0"
rgroup 0--3
line.long 0 "FSMC_ECCR0"
bitfld.long 0 0.--23. " ECC "  " "
;tree.end

base ad:0x80000074
;tree "FSMC_ECCR1"
rgroup 0--3
line.long 0 "FSMC_ECCR1"
bitfld.long 0 0.--23. " ECC "  " "
;tree.end

base ad:0x800000c0
;tree "FSMC_ITCR"
group 0--3
line.long 0 "FSMC_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x800000c4
;tree "FSMC_ITIP0"
rgroup 0--3
line.long 0 "FSMC_ITIP0"
hexfld.long 0 " PCDAI "
;tree.end

base ad:0x800000c8
;tree "FSMC_ITIP1"
rgroup 0--3
line.long 0 "FSMC_ITIP1"
bitfld.long 0 0. " SMFBCLK "  "0 ,1 "
bitfld.long 0 1. " SMWAITn "  "0 ,1 "
bitfld.long 0 2.--3. " SMPCIRQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SMPIOIS16n "  "0 ,1 "
bitfld.long 0 7.--8. " SMPCD "  "0 ,1 ,2 ,3 "
bitfld.long 0 11.--12. " ExtDefWidth "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x800000cc
;tree "FSMC_ITOP0"
group 0--3
line.long 0 "FSMC_ITOP0"
hexfld.long 0 " PCDAO "
;tree.end

base ad:0x800000d0
;tree "FSMC_ITOP1"
group 0--3
line.long 0 "FSMC_ITOP1"
bitfld.long 0 0.--25. " SMAD "  " "
bitfld.long 0 26. " PC0INTR "  "0 ,1 "
bitfld.long 0 27. " PC1INTR "  "0 ,1 "
bitfld.long 0 30. " SMOEN "  "0 ,1 "
bitfld.long 0 31. " SWWEN "  "0 ,1 "
;tree.end

base ad:0x800000d4
;tree "FSMC_ITOP2"
group 0--3
line.long 0 "FSMC_ITOP2"
bitfld.long 0 0. " SMPREGN "  "0 ,1 "
bitfld.long 0 1. " SMPRST0N "  "0 ,1 "
bitfld.long 0 2. " SMPRST1N "  "0 ,1 "
bitfld.long 0 5. " SMPCDIRN "  "0 ,1 "
bitfld.long 0 6. " SMPC1EN "  "0 ,1 "
bitfld.long 0 7. " SMPC2EN "  "0 ,1 "
bitfld.long 0 8. " SMPIORN "  "0 ,1 "
bitfld.long 0 9. " SMPIOWN "  "0 ,1 "
bitfld.long 0 10. " SMADVN "  "0 ,1 "
bitfld.long 0 11. " SMCKO "  "0 ,1 "
bitfld.long 0 12. " SMBE0n "  "0 ,1 "
bitfld.long 0 13. " SMBE1n "  "0 ,1 "
bitfld.long 0 14. " SMBE2n "  "0 ,1 "
bitfld.long 0 15. " SMBE3n "  "0 ,1 "
bitfld.long 0 16. " SMPS0N "  "0 ,1 "
bitfld.long 0 17. " SMPS1N "  "0 ,1 "
;tree.end

base ad:0x800000d8
;tree "FSMC_ITOP3"
group 0--3
line.long 0 "FSMC_ITOP3"
bitfld.long 0 0. " SMCS0N "  "0 ,1 "
bitfld.long 0 1. " SMCS1N "  "0 ,1 "
bitfld.long 0 2. " SMCS2N "  "0 ,1 "
bitfld.long 0 3. " SMCS3N "  "0 ,1 "
bitfld.long 0 4. " SMFWP0N "  "0 ,1 "
bitfld.long 0 5. " SMFWP1N "  "0 ,1 "
bitfld.long 0 6. " SMFWP2N "  "0 ,1 "
bitfld.long 0 7. " SMFWP3N "  "0 ,1 "
bitfld.long 0 8. " SMFRST0N "  "0 ,1 "
bitfld.long 0 9. " SMFRST1N "  "0 ,1 "
bitfld.long 0 10. " SMFRST2N "  "0 ,1 "
bitfld.long 0 11. " SMFRST3N "  "0 ,1 "
;tree.end

base ad:0x80000100
;tree "FSMC_BWTR0"
group 0--3
line.long 0 "FSMC_BWTR0"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80000108
;tree "FSMC_BWTR1"
group 0--3
line.long 0 "FSMC_BWTR1"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80000110
;tree "FSMC_BWTR2"
group 0--3
line.long 0 "FSMC_BWTR2"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80000fe0
;tree "FSMC_PeriphID0"
rgroup 0--3
line.long 0 "FSMC_PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80000fe4
;tree "FSMC_PeriphID1"
rgroup 0--3
line.long 0 "FSMC_PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80000fe8
;tree "FSMC_PeriphID2"
rgroup 0--3
line.long 0 "FSMC_PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80000fec
;tree "FSMC_PeriphID3"
rgroup 0--3
line.long 0 "FSMC_PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80000ff0
;tree "FSMC_PCellID0"
rgroup 0--3
line.long 0 "FSMC_PCellID0"
hexfld.byte 0 " _PCellID0 "
;tree.end

base ad:0x80000ff4
;tree "FSMC_PCellID1"
rgroup 0--3
line.long 0 "FSMC_PCellID1"
hexfld.byte 0 " _BCRPCellID1 "
;tree.end

base ad:0x80000ff8
;tree "FSMC_PCellID2"
rgroup 0--3
line.long 0 "FSMC_PCellID2"
hexfld.byte 0 " _BCRPCellID2 "
;tree.end

base ad:0x80000ffc
;tree "FSMC_PCellID3"
rgroup 0--3
line.long 0 "FSMC_PCellID3"
hexfld.byte 0 " _BCRPCellID3 "
;tree.end

tree.end

;==============================================================
tree "GIC"
;==============================================================
base ad:0xa0410100
;tree "CPU_ICR"
group 0--3
line.long 0 "CPU_ICR"
bitfld.long 0 0. " CPUICREN "  "0 ,1 "
bitfld.long 0 1. " CPUICRENNS "  "0 ,1 "
bitfld.long 0 2. " CPUICRACKCTL "  "0 ,1 "
bitfld.long 0 3. " CPUICRFIQEN "  "0 ,1 "
bitfld.long 0 4. " CPUICRSBPR "  "0 ,1 "
;tree.end

base ad:0xa0410104
;tree "PMR"
group 0--3
line.long 0 "PMR"
bitfld.long 0 3.--7. " PMRPRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0410108
;tree "BPR"
group 0--3
line.long 0 "BPR"
bitfld.long 0 0.--2. " BPRBP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa041010c
;tree "IAR"
rgroup 0--3
line.long 0 "IAR"
bitfld.long 0 0.--9. " IARACKINTID "  " "
bitfld.long 0 10.--12. " IARSOURCECPUID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0410110
;tree "EOIR"
wgroup 0--3
line.long 0 "EOIR"
bitfld.long 0 0.--9. " EOIREOIINTID "  " "
bitfld.long 0 10.--12. " EOIRSOURCECPUID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0410114
;tree "RPR"
rgroup 0--3
line.long 0 "RPR"
hexfld.byte 0 " RPRPRIORITY "
;tree.end

base ad:0xa0410118
;tree "HPIR"
rgroup 0--3
line.long 0 "HPIR"
bitfld.long 0 0.--9. " HPIRPENDINTID "  " "
bitfld.long 0 10.--12. " HPIRSOURCECPUID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa041011c
;tree "ANSBPR"
group 0--3
line.long 0 "ANSBPR"
bitfld.long 0 0.--2. " ANSBPRBP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa04101fc
;tree "CPU_IIIR"
rgroup 0--3
line.long 0 "CPU_IIIR"
bitfld.long 0 0.--11. " CPUIIIRIMPLEMENTOR "  " "
bitfld.long 0 12.--15. " CPUIIIRRN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " CPUIIIRAV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--31. " CPUIIIRPN "  " "
;tree.end

base ad:0xa0411000
;tree "IDCR"
group 0--3
line.long 0 "IDCR"
bitfld.long 0 0. " IDCEN "  "0 ,1 "
;tree.end

base ad:0xa0411004
;tree "ICTR"
rgroup 0--3
line.long 0 "ICTR"
bitfld.long 0 0.--4. " ICTITLN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " ICTCPUN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " ICTDOM "  "0 ,1 "
bitfld.long 0 11.--15. " ICTLSPI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411008
;tree "DIIR"
rgroup 0--3
line.long 0 "DIIR"
bitfld.long 0 0.--11. " DIIIMPL "  " "
bitfld.long 0 12.--23. " DIIRN "  " "
hexfld.byte 3 " DIIIMPL_DEFINED "
;tree.end

base ad:0xa0411080
;tree "IS0R"
group 0--3
line.long 0 "IS0R"
hexfld.long 0 " IS0 "
;tree.end

base ad:0xa0411084
;tree "IS1R"
group 0--3
line.long 0 "IS1R"
hexfld.long 0 " IS1 "
;tree.end

base ad:0xa0411088
;tree "IS2R"
group 0--3
line.long 0 "IS2R"
hexfld.long 0 " IS2 "
;tree.end

base ad:0xa041108c
;tree "IS3R"
group 0--3
line.long 0 "IS3R"
hexfld.long 0 " IS3 "
;tree.end

base ad:0xa0411090
;tree "IS4R"
group 0--3
line.long 0 "IS4R"
hexfld.long 0 " IS4 "
;tree.end

base ad:0xa0411094
;tree "IS5R"
group 0--3
line.long 0 "IS5R"
hexfld.long 0 " IS5 "
;tree.end

base ad:0xa0411098
;tree "IS6R"
group 0--3
line.long 0 "IS6R"
hexfld.long 0 " IS6 "
;tree.end

base ad:0xa041109c
;tree "IS7R"
group 0--3
line.long 0 "IS7R"
hexfld.long 0 " IS7 "
;tree.end

base ad:0xa04110a0
;tree "IS8R"
group 0--3
line.long 0 "IS8R"
hexfld.long 0 " IS8 "
;tree.end

base ad:0xa04110a4
;tree "IS9R"
group 0--3
line.long 0 "IS9R"
hexfld.long 0 " IS9 "
;tree.end

base ad:0xa04110a8
;tree "IS10R"
group 0--3
line.long 0 "IS10R"
hexfld.long 0 " IS10 "
;tree.end

base ad:0xa04110ac
;tree "IS11R"
group 0--3
line.long 0 "IS11R"
hexfld.long 0 " IS11 "
;tree.end

base ad:0xa04110b0
;tree "IS12R"
group 0--3
line.long 0 "IS12R"
hexfld.long 0 " IS12 "
;tree.end

base ad:0xa04110b4
;tree "IS13R"
group 0--3
line.long 0 "IS13R"
hexfld.long 0 " IS13 "
;tree.end

base ad:0xa04110b8
;tree "IS14R"
group 0--3
line.long 0 "IS14R"
hexfld.long 0 " IS14 "
;tree.end

base ad:0xa04110bc
;tree "IS15R"
group 0--3
line.long 0 "IS15R"
hexfld.long 0 " IS15 "
;tree.end

base ad:0xa04110c0
;tree "IS16R"
group 0--3
line.long 0 "IS16R"
hexfld.long 0 " IS16 "
;tree.end

base ad:0xa04110c4
;tree "IS17R"
group 0--3
line.long 0 "IS17R"
hexfld.long 0 " IS17 "
;tree.end

base ad:0xa04110c8
;tree "IS18R"
group 0--3
line.long 0 "IS18R"
hexfld.long 0 " IS18 "
;tree.end

base ad:0xa04110cc
;tree "IS19R"
group 0--3
line.long 0 "IS19R"
hexfld.long 0 " IS19 "
;tree.end

base ad:0xa04110d0
;tree "IS20R"
group 0--3
line.long 0 "IS20R"
hexfld.long 0 " IS20 "
;tree.end

base ad:0xa04110d4
;tree "IS21R"
group 0--3
line.long 0 "IS21R"
hexfld.long 0 " IS21 "
;tree.end

base ad:0xa04110d8
;tree "IS22R"
group 0--3
line.long 0 "IS22R"
hexfld.long 0 " IS22 "
;tree.end

base ad:0xa04110dc
;tree "IS23R"
group 0--3
line.long 0 "IS23R"
hexfld.long 0 " IS23 "
;tree.end

base ad:0xa04110e0
;tree "IS24R"
group 0--3
line.long 0 "IS24R"
hexfld.long 0 " IS24 "
;tree.end

base ad:0xa04110e4
;tree "IS25R"
group 0--3
line.long 0 "IS25R"
hexfld.long 0 " IS25 "
;tree.end

base ad:0xa04110e8
;tree "IS26R"
group 0--3
line.long 0 "IS26R"
hexfld.long 0 " IS26 "
;tree.end

base ad:0xa04110ec
;tree "IS27R"
group 0--3
line.long 0 "IS27R"
hexfld.long 0 " IS27 "
;tree.end

base ad:0xa04110f0
;tree "IS28R"
group 0--3
line.long 0 "IS28R"
hexfld.long 0 " IS28 "
;tree.end

base ad:0xa04110f4
;tree "IS29R"
group 0--3
line.long 0 "IS29R"
hexfld.long 0 " IS29 "
;tree.end

base ad:0xa04110f8
;tree "IS30R"
group 0--3
line.long 0 "IS30R"
hexfld.long 0 " IS30 "
;tree.end

base ad:0xa04110fc
;tree "IS31R"
group 0--3
line.long 0 "IS31R"
hexfld.long 0 " IS31 "
;tree.end

base ad:0xa0411100
;tree "ES0R"
group 0--3
line.long 0 "ES0R"
hexfld.long 0 " ES0 "
;tree.end

base ad:0xa0411104
;tree "ES1R"
group 0--3
line.long 0 "ES1R"
hexfld.long 0 " ES1 "
;tree.end

base ad:0xa0411108
;tree "ES2R"
group 0--3
line.long 0 "ES2R"
hexfld.long 0 " ES2 "
;tree.end

base ad:0xa041110c
;tree "ES3R"
group 0--3
line.long 0 "ES3R"
hexfld.long 0 " ES3 "
;tree.end

base ad:0xa0411110
;tree "ES4R"
group 0--3
line.long 0 "ES4R"
hexfld.long 0 " ES4 "
;tree.end

base ad:0xa0411114
;tree "ES5R"
group 0--3
line.long 0 "ES5R"
hexfld.long 0 " ES5 "
;tree.end

base ad:0xa0411118
;tree "ES6R"
group 0--3
line.long 0 "ES6R"
hexfld.long 0 " ES6 "
;tree.end

base ad:0xa041111c
;tree "ES7R"
group 0--3
line.long 0 "ES7R"
hexfld.long 0 " ES7 "
;tree.end

base ad:0xa0411120
;tree "ES8R"
group 0--3
line.long 0 "ES8R"
hexfld.long 0 " ES8 "
;tree.end

base ad:0xa0411124
;tree "ES9R"
group 0--3
line.long 0 "ES9R"
hexfld.long 0 " ES9 "
;tree.end

base ad:0xa0411128
;tree "ES10R"
group 0--3
line.long 0 "ES10R"
hexfld.long 0 " ES10 "
;tree.end

base ad:0xa041112c
;tree "ES11R"
group 0--3
line.long 0 "ES11R"
hexfld.long 0 " ES11 "
;tree.end

base ad:0xa0411130
;tree "ES12R"
group 0--3
line.long 0 "ES12R"
hexfld.long 0 " ES12 "
;tree.end

base ad:0xa0411134
;tree "ES13R"
group 0--3
line.long 0 "ES13R"
hexfld.long 0 " ES13 "
;tree.end

base ad:0xa0411138
;tree "ES14R"
group 0--3
line.long 0 "ES14R"
hexfld.long 0 " ES14 "
;tree.end

base ad:0xa041113c
;tree "ES15R"
group 0--3
line.long 0 "ES15R"
hexfld.long 0 " ES15 "
;tree.end

base ad:0xa0411140
;tree "ES16R"
group 0--3
line.long 0 "ES16R"
hexfld.long 0 " ES16 "
;tree.end

base ad:0xa0411144
;tree "ES17R"
group 0--3
line.long 0 "ES17R"
hexfld.long 0 " ES17 "
;tree.end

base ad:0xa0411148
;tree "ES18R"
group 0--3
line.long 0 "ES18R"
hexfld.long 0 " ES18 "
;tree.end

base ad:0xa041114c
;tree "ES19R"
group 0--3
line.long 0 "ES19R"
hexfld.long 0 " ES19 "
;tree.end

base ad:0xa0411150
;tree "ES20R"
group 0--3
line.long 0 "ES20R"
hexfld.long 0 " ES20 "
;tree.end

base ad:0xa0411154
;tree "ES21R"
group 0--3
line.long 0 "ES21R"
hexfld.long 0 " ES21 "
;tree.end

base ad:0xa0411158
;tree "ES22R"
group 0--3
line.long 0 "ES22R"
hexfld.long 0 " ES22 "
;tree.end

base ad:0xa041115c
;tree "ES23R"
group 0--3
line.long 0 "ES23R"
hexfld.long 0 " ES23 "
;tree.end

base ad:0xa0411160
;tree "ES24R"
group 0--3
line.long 0 "ES24R"
hexfld.long 0 " ES24 "
;tree.end

base ad:0xa0411164
;tree "ES25R"
group 0--3
line.long 0 "ES25R"
hexfld.long 0 " ES25 "
;tree.end

base ad:0xa0411168
;tree "ES26R"
group 0--3
line.long 0 "ES26R"
hexfld.long 0 " ES26 "
;tree.end

base ad:0xa041116c
;tree "ES27R"
group 0--3
line.long 0 "ES27R"
hexfld.long 0 " ES27 "
;tree.end

base ad:0xa0411170
;tree "ES28R"
group 0--3
line.long 0 "ES28R"
hexfld.long 0 " ES28 "
;tree.end

base ad:0xa0411174
;tree "ES29R"
group 0--3
line.long 0 "ES29R"
hexfld.long 0 " ES29 "
;tree.end

base ad:0xa0411178
;tree "ES30R"
group 0--3
line.long 0 "ES30R"
hexfld.long 0 " ES30 "
;tree.end

base ad:0xa041117c
;tree "ES31R"
group 0--3
line.long 0 "ES31R"
hexfld.long 0 " ES31 "
;tree.end

base ad:0xa0411180
;tree "EC0R"
group 0--3
line.long 0 "EC0R"
hexfld.long 0 " EC0 "
;tree.end

base ad:0xa0411184
;tree "EC1R"
group 0--3
line.long 0 "EC1R"
hexfld.long 0 " EC1 "
;tree.end

base ad:0xa0411188
;tree "EC2R"
group 0--3
line.long 0 "EC2R"
hexfld.long 0 " EC2 "
;tree.end

base ad:0xa041118c
;tree "EC3R"
group 0--3
line.long 0 "EC3R"
hexfld.long 0 " EC3 "
;tree.end

base ad:0xa0411190
;tree "EC4R"
group 0--3
line.long 0 "EC4R"
hexfld.long 0 " EC4 "
;tree.end

base ad:0xa0411194
;tree "EC5R"
group 0--3
line.long 0 "EC5R"
hexfld.long 0 " EC5 "
;tree.end

base ad:0xa0411198
;tree "EC6R"
group 0--3
line.long 0 "EC6R"
hexfld.long 0 " EC6 "
;tree.end

base ad:0xa041119c
;tree "EC7R"
group 0--3
line.long 0 "EC7R"
hexfld.long 0 " EC7 "
;tree.end

base ad:0xa04111a0
;tree "EC8R"
group 0--3
line.long 0 "EC8R"
hexfld.long 0 " EC8 "
;tree.end

base ad:0xa04111a4
;tree "EC9R"
group 0--3
line.long 0 "EC9R"
hexfld.long 0 " EC9 "
;tree.end

base ad:0xa04111a8
;tree "EC10R"
group 0--3
line.long 0 "EC10R"
hexfld.long 0 " EC10 "
;tree.end

base ad:0xa04111ac
;tree "EC11R"
group 0--3
line.long 0 "EC11R"
hexfld.long 0 " EC11 "
;tree.end

base ad:0xa04111b0
;tree "EC12R"
group 0--3
line.long 0 "EC12R"
hexfld.long 0 " EC12 "
;tree.end

base ad:0xa04111b4
;tree "EC13R"
group 0--3
line.long 0 "EC13R"
hexfld.long 0 " EC13 "
;tree.end

base ad:0xa04111b8
;tree "EC14R"
group 0--3
line.long 0 "EC14R"
hexfld.long 0 " EC14 "
;tree.end

base ad:0xa04111bc
;tree "EC15R"
group 0--3
line.long 0 "EC15R"
hexfld.long 0 " EC15 "
;tree.end

base ad:0xa04111c0
;tree "EC16R"
group 0--3
line.long 0 "EC16R"
hexfld.long 0 " EC16 "
;tree.end

base ad:0xa04111c4
;tree "EC17R"
group 0--3
line.long 0 "EC17R"
hexfld.long 0 " EC17 "
;tree.end

base ad:0xa04111c8
;tree "EC18R"
group 0--3
line.long 0 "EC18R"
hexfld.long 0 " EC18 "
;tree.end

base ad:0xa04111cc
;tree "EC19R"
group 0--3
line.long 0 "EC19R"
hexfld.long 0 " EC19 "
;tree.end

base ad:0xa04111d0
;tree "EC20R"
group 0--3
line.long 0 "EC20R"
hexfld.long 0 " EC20 "
;tree.end

base ad:0xa04111d4
;tree "EC21R"
group 0--3
line.long 0 "EC21R"
hexfld.long 0 " EC21 "
;tree.end

base ad:0xa04111d8
;tree "EC22R"
group 0--3
line.long 0 "EC22R"
hexfld.long 0 " EC22 "
;tree.end

base ad:0xa04111dc
;tree "EC23R"
group 0--3
line.long 0 "EC23R"
hexfld.long 0 " EC23 "
;tree.end

base ad:0xa04111e0
;tree "EC24R"
group 0--3
line.long 0 "EC24R"
hexfld.long 0 " EC24 "
;tree.end

base ad:0xa04111e4
;tree "EC25R"
group 0--3
line.long 0 "EC25R"
hexfld.long 0 " EC25 "
;tree.end

base ad:0xa04111e8
;tree "EC26R"
group 0--3
line.long 0 "EC26R"
hexfld.long 0 " EC26 "
;tree.end

base ad:0xa04111ec
;tree "EC27R"
group 0--3
line.long 0 "EC27R"
hexfld.long 0 " EC27 "
;tree.end

base ad:0xa04111f0
;tree "EC28R"
group 0--3
line.long 0 "EC28R"
hexfld.long 0 " EC28 "
;tree.end

base ad:0xa04111f4
;tree "EC29R"
group 0--3
line.long 0 "EC29R"
hexfld.long 0 " EC29 "
;tree.end

base ad:0xa04111f8
;tree "EC30R"
group 0--3
line.long 0 "EC30R"
hexfld.long 0 " EC30 "
;tree.end

base ad:0xa04111fc
;tree "EC31R"
group 0--3
line.long 0 "EC31R"
hexfld.long 0 " EC31 "
;tree.end

base ad:0xa0411200
;tree "PS0R"
group 0--3
line.long 0 "PS0R"
hexfld.long 0 " PS0 "
;tree.end

base ad:0xa0411204
;tree "PS1R"
group 0--3
line.long 0 "PS1R"
hexfld.long 0 " PS1 "
;tree.end

base ad:0xa0411208
;tree "PS2R"
group 0--3
line.long 0 "PS2R"
hexfld.long 0 " PS2 "
;tree.end

base ad:0xa041120c
;tree "PS3R"
group 0--3
line.long 0 "PS3R"
hexfld.long 0 " PS3 "
;tree.end

base ad:0xa0411210
;tree "PS4R"
group 0--3
line.long 0 "PS4R"
hexfld.long 0 " PS4 "
;tree.end

base ad:0xa0411214
;tree "PS5R"
group 0--3
line.long 0 "PS5R"
hexfld.long 0 " PS5 "
;tree.end

base ad:0xa0411218
;tree "PS6R"
group 0--3
line.long 0 "PS6R"
hexfld.long 0 " PS6 "
;tree.end

base ad:0xa041121c
;tree "PS7R"
group 0--3
line.long 0 "PS7R"
hexfld.long 0 " PS7 "
;tree.end

base ad:0xa0411220
;tree "PS8R"
group 0--3
line.long 0 "PS8R"
hexfld.long 0 " PS8 "
;tree.end

base ad:0xa0411224
;tree "PS9R"
group 0--3
line.long 0 "PS9R"
hexfld.long 0 " PS9 "
;tree.end

base ad:0xa0411228
;tree "PS10R"
group 0--3
line.long 0 "PS10R"
hexfld.long 0 " PS10 "
;tree.end

base ad:0xa041122c
;tree "PS11R"
group 0--3
line.long 0 "PS11R"
hexfld.long 0 " PS11 "
;tree.end

base ad:0xa0411230
;tree "PS12R"
group 0--3
line.long 0 "PS12R"
hexfld.long 0 " PS12 "
;tree.end

base ad:0xa0411234
;tree "PS13R"
group 0--3
line.long 0 "PS13R"
hexfld.long 0 " PS13 "
;tree.end

base ad:0xa0411238
;tree "PS14R"
group 0--3
line.long 0 "PS14R"
hexfld.long 0 " PS14 "
;tree.end

base ad:0xa041123c
;tree "PS15R"
group 0--3
line.long 0 "PS15R"
hexfld.long 0 " PS15 "
;tree.end

base ad:0xa0411240
;tree "PS16R"
group 0--3
line.long 0 "PS16R"
hexfld.long 0 " PS16 "
;tree.end

base ad:0xa0411244
;tree "PS17R"
group 0--3
line.long 0 "PS17R"
hexfld.long 0 " PS17 "
;tree.end

base ad:0xa0411248
;tree "PS18R"
group 0--3
line.long 0 "PS18R"
hexfld.long 0 " PS18 "
;tree.end

base ad:0xa041124c
;tree "PS19R"
group 0--3
line.long 0 "PS19R"
hexfld.long 0 " PS19 "
;tree.end

base ad:0xa0411250
;tree "PS20R"
group 0--3
line.long 0 "PS20R"
hexfld.long 0 " PS20 "
;tree.end

base ad:0xa0411254
;tree "PS21R"
group 0--3
line.long 0 "PS21R"
hexfld.long 0 " PS21 "
;tree.end

base ad:0xa0411258
;tree "PS22R"
group 0--3
line.long 0 "PS22R"
hexfld.long 0 " PS22 "
;tree.end

base ad:0xa041125c
;tree "PS23R"
group 0--3
line.long 0 "PS23R"
hexfld.long 0 " PS23 "
;tree.end

base ad:0xa0411260
;tree "PS24R"
group 0--3
line.long 0 "PS24R"
hexfld.long 0 " PS24 "
;tree.end

base ad:0xa0411264
;tree "PS25R"
group 0--3
line.long 0 "PS25R"
hexfld.long 0 " PS25 "
;tree.end

base ad:0xa0411268
;tree "PS26R"
group 0--3
line.long 0 "PS26R"
hexfld.long 0 " PS26 "
;tree.end

base ad:0xa041126c
;tree "PS27R"
group 0--3
line.long 0 "PS27R"
hexfld.long 0 " PS27 "
;tree.end

base ad:0xa0411270
;tree "PS28R"
group 0--3
line.long 0 "PS28R"
hexfld.long 0 " PS28 "
;tree.end

base ad:0xa0411274
;tree "PS29R"
group 0--3
line.long 0 "PS29R"
hexfld.long 0 " PS29 "
;tree.end

base ad:0xa0411278
;tree "PS30R"
group 0--3
line.long 0 "PS30R"
hexfld.long 0 " PS30 "
;tree.end

base ad:0xa041127c
;tree "PS31R"
group 0--3
line.long 0 "PS31R"
hexfld.long 0 " PS31 "
;tree.end

base ad:0xa0411280
;tree "PC0R"
group 0--3
line.long 0 "PC0R"
hexfld.long 0 " PC0 "
;tree.end

base ad:0xa0411284
;tree "PC1R"
group 0--3
line.long 0 "PC1R"
hexfld.long 0 " PC1 "
;tree.end

base ad:0xa0411288
;tree "PC2R"
group 0--3
line.long 0 "PC2R"
hexfld.long 0 " PC2 "
;tree.end

base ad:0xa041128c
;tree "PC3R"
group 0--3
line.long 0 "PC3R"
hexfld.long 0 " PC3 "
;tree.end

base ad:0xa0411290
;tree "PC4R"
group 0--3
line.long 0 "PC4R"
hexfld.long 0 " PC4 "
;tree.end

base ad:0xa0411294
;tree "PC5R"
group 0--3
line.long 0 "PC5R"
hexfld.long 0 " PC5 "
;tree.end

base ad:0xa0411298
;tree "PC6R"
group 0--3
line.long 0 "PC6R"
hexfld.long 0 " PC6 "
;tree.end

base ad:0xa041129c
;tree "PC7R"
group 0--3
line.long 0 "PC7R"
hexfld.long 0 " PC7 "
;tree.end

base ad:0xa04112a0
;tree "PC8R"
group 0--3
line.long 0 "PC8R"
hexfld.long 0 " PC8 "
;tree.end

base ad:0xa04112a4
;tree "PC9R"
group 0--3
line.long 0 "PC9R"
hexfld.long 0 " PC9 "
;tree.end

base ad:0xa04112a8
;tree "PC10R"
group 0--3
line.long 0 "PC10R"
hexfld.long 0 " PC10 "
;tree.end

base ad:0xa04112ac
;tree "PC11R"
group 0--3
line.long 0 "PC11R"
hexfld.long 0 " PC11 "
;tree.end

base ad:0xa04112b0
;tree "PC12R"
group 0--3
line.long 0 "PC12R"
hexfld.long 0 " PC12 "
;tree.end

base ad:0xa04112b4
;tree "PC13R"
group 0--3
line.long 0 "PC13R"
hexfld.long 0 " PC13 "
;tree.end

base ad:0xa04112b8
;tree "PC14R"
group 0--3
line.long 0 "PC14R"
hexfld.long 0 " PC14 "
;tree.end

base ad:0xa04112bc
;tree "PC15R"
group 0--3
line.long 0 "PC15R"
hexfld.long 0 " PC15 "
;tree.end

base ad:0xa04112c0
;tree "PC16R"
group 0--3
line.long 0 "PC16R"
hexfld.long 0 " PC16 "
;tree.end

base ad:0xa04112c4
;tree "PC17R"
group 0--3
line.long 0 "PC17R"
hexfld.long 0 " PC17 "
;tree.end

base ad:0xa04112c8
;tree "PC18R"
group 0--3
line.long 0 "PC18R"
hexfld.long 0 " PC18 "
;tree.end

base ad:0xa04112cc
;tree "PC19R"
group 0--3
line.long 0 "PC19R"
hexfld.long 0 " PC19 "
;tree.end

base ad:0xa04112d0
;tree "PC20R"
group 0--3
line.long 0 "PC20R"
hexfld.long 0 " PC20 "
;tree.end

base ad:0xa04112d4
;tree "PC21R"
group 0--3
line.long 0 "PC21R"
hexfld.long 0 " PC21 "
;tree.end

base ad:0xa04112d8
;tree "PC22R"
group 0--3
line.long 0 "PC22R"
hexfld.long 0 " PC22 "
;tree.end

base ad:0xa04112dc
;tree "PC23R"
group 0--3
line.long 0 "PC23R"
hexfld.long 0 " PC23 "
;tree.end

base ad:0xa04112e0
;tree "PC24R"
group 0--3
line.long 0 "PC24R"
hexfld.long 0 " PC24 "
;tree.end

base ad:0xa04112e4
;tree "PC25R"
group 0--3
line.long 0 "PC25R"
hexfld.long 0 " PC25 "
;tree.end

base ad:0xa04112e8
;tree "PC26R"
group 0--3
line.long 0 "PC26R"
hexfld.long 0 " PC26 "
;tree.end

base ad:0xa04112ec
;tree "PC27R"
group 0--3
line.long 0 "PC27R"
hexfld.long 0 " PC27 "
;tree.end

base ad:0xa04112f0
;tree "PC28R"
group 0--3
line.long 0 "PC28R"
hexfld.long 0 " PC28 "
;tree.end

base ad:0xa04112f4
;tree "PC29R"
group 0--3
line.long 0 "PC29R"
hexfld.long 0 " PC29 "
;tree.end

base ad:0xa04112f8
;tree "PC30R"
group 0--3
line.long 0 "PC30R"
hexfld.long 0 " PC30 "
;tree.end

base ad:0xa04112fc
;tree "PC31R"
group 0--3
line.long 0 "PC31R"
hexfld.long 0 " PC31 "
;tree.end

base ad:0xa0411300
;tree "AS0R"
rgroup 0--3
line.long 0 "AS0R"
hexfld.long 0 " AS0 "
;tree.end

base ad:0xa0411304
;tree "AS1R"
rgroup 0--3
line.long 0 "AS1R"
hexfld.long 0 " AS1 "
;tree.end

base ad:0xa0411308
;tree "AS2R"
rgroup 0--3
line.long 0 "AS2R"
hexfld.long 0 " AS2 "
;tree.end

base ad:0xa041130c
;tree "AS3R"
rgroup 0--3
line.long 0 "AS3R"
hexfld.long 0 " AS3 "
;tree.end

base ad:0xa0411310
;tree "AS4R"
rgroup 0--3
line.long 0 "AS4R"
hexfld.long 0 " AS4 "
;tree.end

base ad:0xa0411314
;tree "AS5R"
rgroup 0--3
line.long 0 "AS5R"
hexfld.long 0 " AS5 "
;tree.end

base ad:0xa0411318
;tree "AS6R"
rgroup 0--3
line.long 0 "AS6R"
hexfld.long 0 " AS6 "
;tree.end

base ad:0xa041131c
;tree "AS7R"
rgroup 0--3
line.long 0 "AS7R"
hexfld.long 0 " AS7 "
;tree.end

base ad:0xa0411320
;tree "AS8R"
rgroup 0--3
line.long 0 "AS8R"
hexfld.long 0 " AS8 "
;tree.end

base ad:0xa0411324
;tree "AS9R"
rgroup 0--3
line.long 0 "AS9R"
hexfld.long 0 " AS9 "
;tree.end

base ad:0xa0411328
;tree "AS10R"
rgroup 0--3
line.long 0 "AS10R"
hexfld.long 0 " AS10 "
;tree.end

base ad:0xa041132c
;tree "AS11R"
rgroup 0--3
line.long 0 "AS11R"
hexfld.long 0 " AS11 "
;tree.end

base ad:0xa0411330
;tree "AS12R"
rgroup 0--3
line.long 0 "AS12R"
hexfld.long 0 " AS12 "
;tree.end

base ad:0xa0411334
;tree "AS13R"
rgroup 0--3
line.long 0 "AS13R"
hexfld.long 0 " AS13 "
;tree.end

base ad:0xa0411338
;tree "AS14R"
rgroup 0--3
line.long 0 "AS14R"
hexfld.long 0 " AS14 "
;tree.end

base ad:0xa041133c
;tree "AS15R"
rgroup 0--3
line.long 0 "AS15R"
hexfld.long 0 " AS15 "
;tree.end

base ad:0xa0411340
;tree "AS16R"
rgroup 0--3
line.long 0 "AS16R"
hexfld.long 0 " AS16 "
;tree.end

base ad:0xa0411344
;tree "AS17R"
rgroup 0--3
line.long 0 "AS17R"
hexfld.long 0 " AS17 "
;tree.end

base ad:0xa0411348
;tree "AS18R"
rgroup 0--3
line.long 0 "AS18R"
hexfld.long 0 " AS18 "
;tree.end

base ad:0xa041134c
;tree "AS19R"
rgroup 0--3
line.long 0 "AS19R"
hexfld.long 0 " AS19 "
;tree.end

base ad:0xa0411350
;tree "AS20R"
rgroup 0--3
line.long 0 "AS20R"
hexfld.long 0 " AS20 "
;tree.end

base ad:0xa0411354
;tree "AS21R"
rgroup 0--3
line.long 0 "AS21R"
hexfld.long 0 " AS21 "
;tree.end

base ad:0xa0411358
;tree "AS22R"
rgroup 0--3
line.long 0 "AS22R"
hexfld.long 0 " AS22 "
;tree.end

base ad:0xa041135c
;tree "AS23R"
rgroup 0--3
line.long 0 "AS23R"
hexfld.long 0 " AS23 "
;tree.end

base ad:0xa0411360
;tree "AS24R"
rgroup 0--3
line.long 0 "AS24R"
hexfld.long 0 " AS24 "
;tree.end

base ad:0xa0411364
;tree "AS25R"
rgroup 0--3
line.long 0 "AS25R"
hexfld.long 0 " AS25 "
;tree.end

base ad:0xa0411368
;tree "AS26R"
rgroup 0--3
line.long 0 "AS26R"
hexfld.long 0 " AS26 "
;tree.end

base ad:0xa041136c
;tree "AS27R"
rgroup 0--3
line.long 0 "AS27R"
hexfld.long 0 " AS27 "
;tree.end

base ad:0xa0411370
;tree "AS28R"
rgroup 0--3
line.long 0 "AS28R"
hexfld.long 0 " AS28 "
;tree.end

base ad:0xa0411374
;tree "AS29R"
rgroup 0--3
line.long 0 "AS29R"
hexfld.long 0 " AS29 "
;tree.end

base ad:0xa0411378
;tree "AS30R"
rgroup 0--3
line.long 0 "AS30R"
hexfld.long 0 " AS30 "
;tree.end

base ad:0xa041137c
;tree "AS31R"
rgroup 0--3
line.long 0 "AS31R"
hexfld.long 0 " AS31 "
;tree.end

base ad:0xa0411400
;tree "PL0R"
group 0--3
line.long 0 "PL0R"
bitfld.long 0 3.--7. " PL0IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL0IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL0IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL0IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411404
;tree "PL1R"
group 0--3
line.long 0 "PL1R"
bitfld.long 0 3.--7. " PL1IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL1IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL1IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL1IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411408
;tree "PL2R"
group 0--3
line.long 0 "PL2R"
bitfld.long 0 3.--7. " PL2IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL2IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL2IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL2IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041140c
;tree "PL3R"
group 0--3
line.long 0 "PL3R"
bitfld.long 0 3.--7. " PL3IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL3IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL3IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL3IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411410
;tree "PL4R"
group 0--3
line.long 0 "PL4R"
bitfld.long 0 3.--7. " PL4IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL4IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL4IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL4IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411414
;tree "PL5R"
group 0--3
line.long 0 "PL5R"
bitfld.long 0 3.--7. " PL5IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL5IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL5IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL5IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411418
;tree "PL6R"
group 0--3
line.long 0 "PL6R"
bitfld.long 0 3.--7. " PL6IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL6IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL6IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL6IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041141c
;tree "PL7R"
group 0--3
line.long 0 "PL7R"
bitfld.long 0 3.--7. " PL7IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL7IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL7IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL7IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411420
;tree "PL8R"
group 0--3
line.long 0 "PL8R"
bitfld.long 0 3.--7. " PL8IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL8IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL8IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL8IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411424
;tree "PL9R"
group 0--3
line.long 0 "PL9R"
bitfld.long 0 3.--7. " PL9IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL9IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL9IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL9IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411428
;tree "PL10R"
group 0--3
line.long 0 "PL10R"
bitfld.long 0 3.--7. " PL10IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL10IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL10IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL10IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041142c
;tree "PL11R"
group 0--3
line.long 0 "PL11R"
bitfld.long 0 3.--7. " PL11IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL11IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL11IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL11IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411430
;tree "PL12R"
group 0--3
line.long 0 "PL12R"
bitfld.long 0 3.--7. " PL12IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL12IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL12IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL12IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411434
;tree "PL13R"
group 0--3
line.long 0 "PL13R"
bitfld.long 0 3.--7. " PL13IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL13IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL13IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL13IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411438
;tree "PL14R"
group 0--3
line.long 0 "PL14R"
bitfld.long 0 3.--7. " PL14IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL14IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL14IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL14IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041143c
;tree "PL15R"
group 0--3
line.long 0 "PL15R"
bitfld.long 0 3.--7. " PL15IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL15IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL15IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL15IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411440
;tree "PL16R"
group 0--3
line.long 0 "PL16R"
bitfld.long 0 3.--7. " PL16IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL16IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL16IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL16IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411444
;tree "PL17R"
group 0--3
line.long 0 "PL17R"
bitfld.long 0 3.--7. " PL17IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL17IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL17IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL17IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411448
;tree "PL18R"
group 0--3
line.long 0 "PL18R"
bitfld.long 0 3.--7. " PL18IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL18IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL18IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL18IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041144c
;tree "PL19R"
group 0--3
line.long 0 "PL19R"
bitfld.long 0 3.--7. " PL19IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL19IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL19IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL19IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411450
;tree "PL20R"
group 0--3
line.long 0 "PL20R"
bitfld.long 0 3.--7. " PL20IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL20IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL20IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL20IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411454
;tree "PL21R"
group 0--3
line.long 0 "PL21R"
bitfld.long 0 3.--7. " PL21IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL21IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL21IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL21IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411458
;tree "PL22R"
group 0--3
line.long 0 "PL22R"
bitfld.long 0 3.--7. " PL22IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL22IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL22IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL22IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041145c
;tree "PL23R"
group 0--3
line.long 0 "PL23R"
bitfld.long 0 3.--7. " PL23IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL23IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL23IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL23IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411460
;tree "PL24R"
group 0--3
line.long 0 "PL24R"
bitfld.long 0 3.--7. " PL24IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL24IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL24IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL24IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411464
;tree "PL25R"
group 0--3
line.long 0 "PL25R"
bitfld.long 0 3.--7. " PL25IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL25IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL25IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL25IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411468
;tree "PL26R"
group 0--3
line.long 0 "PL26R"
bitfld.long 0 3.--7. " PL26IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL26IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL26IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL26IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041146c
;tree "PL27R"
group 0--3
line.long 0 "PL27R"
bitfld.long 0 3.--7. " PL27IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL27IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL27IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL27IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411470
;tree "PL28R"
group 0--3
line.long 0 "PL28R"
bitfld.long 0 3.--7. " PL28IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL28IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL28IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL28IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411474
;tree "PL29R"
group 0--3
line.long 0 "PL29R"
bitfld.long 0 3.--7. " PL29IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL29IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL29IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL29IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411478
;tree "PL30R"
group 0--3
line.long 0 "PL30R"
bitfld.long 0 3.--7. " PL30IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL30IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL30IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL30IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041147c
;tree "PL31R"
group 0--3
line.long 0 "PL31R"
bitfld.long 0 3.--7. " PL31IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL31IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL31IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL31IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411800
;tree "SPIT0R"
group 0--3
line.long 0 "SPIT0R"
hexfld.byte 0 " SPIT0INTIDNP0 "
hexfld.byte 1 " SPIT0INTIDNP1 "
hexfld.byte 2 " SPIT0INTIDNP2 "
hexfld.byte 3 " SPIT0INTIDNP3 "
;tree.end

base ad:0xa0411804
;tree "SPIT1R"
group 0--3
line.long 0 "SPIT1R"
hexfld.byte 0 " SPIT1INTIDNP0 "
hexfld.byte 1 " SPIT1INTIDNP1 "
hexfld.byte 2 " SPIT1INTIDNP2 "
hexfld.byte 3 " SPIT1INTIDNP3 "
;tree.end

base ad:0xa0411808
;tree "SPIT2R"
group 0--3
line.long 0 "SPIT2R"
hexfld.byte 0 " SPIT2INTIDNP0 "
hexfld.byte 1 " SPIT2INTIDNP1 "
hexfld.byte 2 " SPIT2INTIDNP2 "
hexfld.byte 3 " SPIT2INTIDNP3 "
;tree.end

base ad:0xa041180c
;tree "SPIT3R"
group 0--3
line.long 0 "SPIT3R"
hexfld.byte 0 " SPIT3INTIDNP0 "
hexfld.byte 1 " SPIT3INTIDNP1 "
hexfld.byte 2 " SPIT3INTIDNP2 "
hexfld.byte 3 " SPIT3INTIDNP3 "
;tree.end

base ad:0xa0411810
;tree "SPIT4R"
group 0--3
line.long 0 "SPIT4R"
hexfld.byte 0 " SPIT4INTIDNP0 "
hexfld.byte 1 " SPIT4INTIDNP1 "
hexfld.byte 2 " SPIT4INTIDNP2 "
hexfld.byte 3 " SPIT4INTIDNP3 "
;tree.end

base ad:0xa0411814
;tree "SPIT5R"
group 0--3
line.long 0 "SPIT5R"
hexfld.byte 0 " SPIT5INTIDNP0 "
hexfld.byte 1 " SPIT5INTIDNP1 "
hexfld.byte 2 " SPIT5INTIDNP2 "
hexfld.byte 3 " SPIT5INTIDNP3 "
;tree.end

base ad:0xa0411818
;tree "SPIT6R"
group 0--3
line.long 0 "SPIT6R"
hexfld.byte 0 " SPIT6INTIDNP0 "
hexfld.byte 1 " SPIT6INTIDNP1 "
hexfld.byte 2 " SPIT6INTIDNP2 "
hexfld.byte 3 " SPIT6INTIDNP3 "
;tree.end

base ad:0xa041181c
;tree "SPIT7R"
group 0--3
line.long 0 "SPIT7R"
hexfld.byte 0 " SPIT7INTIDNP0 "
hexfld.byte 1 " SPIT7INTIDNP1 "
hexfld.byte 2 " SPIT7INTIDNP2 "
hexfld.byte 3 " SPIT7INTIDNP3 "
;tree.end

base ad:0xa0411820
;tree "SPIT8R"
group 0--3
line.long 0 "SPIT8R"
hexfld.byte 0 " SPIT8INTIDNP0 "
hexfld.byte 1 " SPIT8INTIDNP1 "
hexfld.byte 2 " SPIT8INTIDNP2 "
hexfld.byte 3 " SPIT8INTIDNP3 "
;tree.end

base ad:0xa0411824
;tree "SPIT9R"
group 0--3
line.long 0 "SPIT9R"
hexfld.byte 0 " SPIT9INTIDNP0 "
hexfld.byte 1 " SPIT9INTIDNP1 "
hexfld.byte 2 " SPIT9INTIDNP2 "
hexfld.byte 3 " SPIT9INTIDNP3 "
;tree.end

base ad:0xa0411828
;tree "SPIT10R"
group 0--3
line.long 0 "SPIT10R"
hexfld.byte 0 " SPIT10INTIDNP0 "
hexfld.byte 1 " SPIT10INTIDNP1 "
hexfld.byte 2 " SPIT10INTIDNP2 "
hexfld.byte 3 " SPIT10INTIDNP3 "
;tree.end

base ad:0xa041182c
;tree "SPIT11R"
group 0--3
line.long 0 "SPIT11R"
hexfld.byte 0 " SPIT11INTIDNP0 "
hexfld.byte 1 " SPIT11INTIDNP1 "
hexfld.byte 2 " SPIT11INTIDNP2 "
hexfld.byte 3 " SPIT11INTIDNP3 "
;tree.end

base ad:0xa0411830
;tree "SPIT12R"
group 0--3
line.long 0 "SPIT12R"
hexfld.byte 0 " SPIT12INTIDNP0 "
hexfld.byte 1 " SPIT12INTIDNP1 "
hexfld.byte 2 " SPIT12INTIDNP2 "
hexfld.byte 3 " SPIT12INTIDNP3 "
;tree.end

base ad:0xa0411834
;tree "SPIT13R"
group 0--3
line.long 0 "SPIT13R"
hexfld.byte 0 " SPIT13INTIDNP0 "
hexfld.byte 1 " SPIT13INTIDNP1 "
hexfld.byte 2 " SPIT13INTIDNP2 "
hexfld.byte 3 " SPIT13INTIDNP3 "
;tree.end

base ad:0xa0411838
;tree "SPIT14R"
group 0--3
line.long 0 "SPIT14R"
hexfld.byte 0 " SPIT14INTIDNP0 "
hexfld.byte 1 " SPIT14INTIDNP1 "
hexfld.byte 2 " SPIT14INTIDNP2 "
hexfld.byte 3 " SPIT14INTIDNP3 "
;tree.end

base ad:0xa041183c
;tree "SPIT15R"
group 0--3
line.long 0 "SPIT15R"
hexfld.byte 0 " SPIT15INTIDNP0 "
hexfld.byte 1 " SPIT15INTIDNP1 "
hexfld.byte 2 " SPIT15INTIDNP2 "
hexfld.byte 3 " SPIT15INTIDNP3 "
;tree.end

base ad:0xa0411840
;tree "SPIT16R"
group 0--3
line.long 0 "SPIT16R"
hexfld.byte 0 " SPIT16INTIDNP0 "
hexfld.byte 1 " SPIT16INTIDNP1 "
hexfld.byte 2 " SPIT16INTIDNP2 "
hexfld.byte 3 " SPIT16INTIDNP3 "
;tree.end

base ad:0xa0411844
;tree "SPIT17R"
group 0--3
line.long 0 "SPIT17R"
hexfld.byte 0 " SPIT17INTIDNP0 "
hexfld.byte 1 " SPIT17INTIDNP1 "
hexfld.byte 2 " SPIT17INTIDNP2 "
hexfld.byte 3 " SPIT17INTIDNP3 "
;tree.end

base ad:0xa0411848
;tree "SPIT18R"
group 0--3
line.long 0 "SPIT18R"
hexfld.byte 0 " SPIT18INTIDNP0 "
hexfld.byte 1 " SPIT18INTIDNP1 "
hexfld.byte 2 " SPIT18INTIDNP2 "
hexfld.byte 3 " SPIT18INTIDNP3 "
;tree.end

base ad:0xa041184c
;tree "SPIT19R"
group 0--3
line.long 0 "SPIT19R"
hexfld.byte 0 " SPIT19INTIDNP0 "
hexfld.byte 1 " SPIT19INTIDNP1 "
hexfld.byte 2 " SPIT19INTIDNP2 "
hexfld.byte 3 " SPIT19INTIDNP3 "
;tree.end

base ad:0xa0411850
;tree "SPIT20R"
group 0--3
line.long 0 "SPIT20R"
hexfld.byte 0 " SPIT20INTIDNP0 "
hexfld.byte 1 " SPIT20INTIDNP1 "
hexfld.byte 2 " SPIT20INTIDNP2 "
hexfld.byte 3 " SPIT20INTIDNP3 "
;tree.end

base ad:0xa0411854
;tree "SPIT21R"
group 0--3
line.long 0 "SPIT21R"
hexfld.byte 0 " SPIT21INTIDNP0 "
hexfld.byte 1 " SPIT21INTIDNP1 "
hexfld.byte 2 " SPIT21INTIDNP2 "
hexfld.byte 3 " SPIT21INTIDNP3 "
;tree.end

base ad:0xa0411858
;tree "SPIT22R"
group 0--3
line.long 0 "SPIT22R"
hexfld.byte 0 " SPIT22INTIDNP0 "
hexfld.byte 1 " SPIT22INTIDNP1 "
hexfld.byte 2 " SPIT22INTIDNP2 "
hexfld.byte 3 " SPIT22INTIDNP3 "
;tree.end

base ad:0xa041185c
;tree "SPIT23R"
group 0--3
line.long 0 "SPIT23R"
hexfld.byte 0 " SPIT23INTIDNP0 "
hexfld.byte 1 " SPIT23INTIDNP1 "
hexfld.byte 2 " SPIT23INTIDNP2 "
hexfld.byte 3 " SPIT23INTIDNP3 "
;tree.end

base ad:0xa0411860
;tree "SPIT24R"
group 0--3
line.long 0 "SPIT24R"
hexfld.byte 0 " SPIT24INTIDNP0 "
hexfld.byte 1 " SPIT24INTIDNP1 "
hexfld.byte 2 " SPIT24INTIDNP2 "
hexfld.byte 3 " SPIT24INTIDNP3 "
;tree.end

base ad:0xa0411864
;tree "SPIT25R"
group 0--3
line.long 0 "SPIT25R"
hexfld.byte 0 " SPIT25INTIDNP0 "
hexfld.byte 1 " SPIT25INTIDNP1 "
hexfld.byte 2 " SPIT25INTIDNP2 "
hexfld.byte 3 " SPIT25INTIDNP3 "
;tree.end

base ad:0xa0411868
;tree "SPIT26R"
group 0--3
line.long 0 "SPIT26R"
hexfld.byte 0 " SPIT26INTIDNP0 "
hexfld.byte 1 " SPIT26INTIDNP1 "
hexfld.byte 2 " SPIT26INTIDNP2 "
hexfld.byte 3 " SPIT26INTIDNP3 "
;tree.end

base ad:0xa041186c
;tree "SPIT27R"
group 0--3
line.long 0 "SPIT27R"
hexfld.byte 0 " SPIT27INTIDNP0 "
hexfld.byte 1 " SPIT27INTIDNP1 "
hexfld.byte 2 " SPIT27INTIDNP2 "
hexfld.byte 3 " SPIT27INTIDNP3 "
;tree.end

base ad:0xa0411870
;tree "SPIT28R"
group 0--3
line.long 0 "SPIT28R"
hexfld.byte 0 " SPIT28INTIDNP0 "
hexfld.byte 1 " SPIT28INTIDNP1 "
hexfld.byte 2 " SPIT28INTIDNP2 "
hexfld.byte 3 " SPIT28INTIDNP3 "
;tree.end

base ad:0xa0411874
;tree "SPIT29R"
group 0--3
line.long 0 "SPIT29R"
hexfld.byte 0 " SPIT29INTIDNP0 "
hexfld.byte 1 " SPIT29INTIDNP1 "
hexfld.byte 2 " SPIT29INTIDNP2 "
hexfld.byte 3 " SPIT29INTIDNP3 "
;tree.end

base ad:0xa0411878
;tree "SPIT30R"
group 0--3
line.long 0 "SPIT30R"
hexfld.byte 0 " SPIT30INTIDNP0 "
hexfld.byte 1 " SPIT30INTIDNP1 "
hexfld.byte 2 " SPIT30INTIDNP2 "
hexfld.byte 3 " SPIT30INTIDNP3 "
;tree.end

base ad:0xa041187c
;tree "SPIT31R"
group 0--3
line.long 0 "SPIT31R"
hexfld.byte 0 " SPIT31INTIDNP0 "
hexfld.byte 1 " SPIT31INTIDNP1 "
hexfld.byte 2 " SPIT31INTIDNP2 "
hexfld.byte 3 " SPIT31INTIDNP3 "
;tree.end

base ad:0xa0411880
;tree "SPIT32R"
group 0--3
line.long 0 "SPIT32R"
hexfld.byte 0 " SPIT32INTIDNP0 "
hexfld.byte 1 " SPIT32INTIDNP1 "
hexfld.byte 2 " SPIT32INTIDNP2 "
hexfld.byte 3 " SPIT32INTIDNP3 "
;tree.end

base ad:0xa0411884
;tree "SPIT33R"
group 0--3
line.long 0 "SPIT33R"
hexfld.byte 0 " SPIT33INTIDNP0 "
hexfld.byte 1 " SPIT33INTIDNP1 "
hexfld.byte 2 " SPIT33INTIDNP2 "
hexfld.byte 3 " SPIT33INTIDNP3 "
;tree.end

base ad:0xa0411888
;tree "SPIT34R"
group 0--3
line.long 0 "SPIT34R"
hexfld.byte 0 " SPIT34INTIDNP0 "
hexfld.byte 1 " SPIT34INTIDNP1 "
hexfld.byte 2 " SPIT34INTIDNP2 "
hexfld.byte 3 " SPIT34INTIDNP3 "
;tree.end

base ad:0xa041188c
;tree "SPIT35R"
group 0--3
line.long 0 "SPIT35R"
hexfld.byte 0 " SPIT35INTIDNP0 "
hexfld.byte 1 " SPIT35INTIDNP1 "
hexfld.byte 2 " SPIT35INTIDNP2 "
hexfld.byte 3 " SPIT35INTIDNP3 "
;tree.end

base ad:0xa0411890
;tree "SPIT36R"
group 0--3
line.long 0 "SPIT36R"
hexfld.byte 0 " SPIT36INTIDNP0 "
hexfld.byte 1 " SPIT36INTIDNP1 "
hexfld.byte 2 " SPIT36INTIDNP2 "
hexfld.byte 3 " SPIT36INTIDNP3 "
;tree.end

base ad:0xa0411894
;tree "SPIT37R"
group 0--3
line.long 0 "SPIT37R"
hexfld.byte 0 " SPIT37INTIDNP0 "
hexfld.byte 1 " SPIT37INTIDNP1 "
hexfld.byte 2 " SPIT37INTIDNP2 "
hexfld.byte 3 " SPIT37INTIDNP3 "
;tree.end

base ad:0xa0411898
;tree "SPIT38R"
group 0--3
line.long 0 "SPIT38R"
hexfld.byte 0 " SPIT38INTIDNP0 "
hexfld.byte 1 " SPIT38INTIDNP1 "
hexfld.byte 2 " SPIT38INTIDNP2 "
hexfld.byte 3 " SPIT38INTIDNP3 "
;tree.end

base ad:0xa041189c
;tree "SPIT39R"
group 0--3
line.long 0 "SPIT39R"
hexfld.byte 0 " SPIT39INTIDNP0 "
hexfld.byte 1 " SPIT39INTIDNP1 "
hexfld.byte 2 " SPIT39INTIDNP2 "
hexfld.byte 3 " SPIT39INTIDNP3 "
;tree.end

base ad:0xa04118a0
;tree "SPIT40R"
group 0--3
line.long 0 "SPIT40R"
hexfld.byte 0 " SPIT40INTIDNP0 "
hexfld.byte 1 " SPIT40INTIDNP1 "
hexfld.byte 2 " SPIT40INTIDNP2 "
hexfld.byte 3 " SPIT40INTIDNP3 "
;tree.end

base ad:0xa04118a4
;tree "SPIT41R"
group 0--3
line.long 0 "SPIT41R"
hexfld.byte 0 " SPIT41INTIDNP0 "
hexfld.byte 1 " SPIT41INTIDNP1 "
hexfld.byte 2 " SPIT41INTIDNP2 "
hexfld.byte 3 " SPIT41INTIDNP3 "
;tree.end

base ad:0xa04118a8
;tree "SPIT42R"
group 0--3
line.long 0 "SPIT42R"
hexfld.byte 0 " SPIT42INTIDNP0 "
hexfld.byte 1 " SPIT42INTIDNP1 "
hexfld.byte 2 " SPIT42INTIDNP2 "
hexfld.byte 3 " SPIT42INTIDNP3 "
;tree.end

base ad:0xa04118ac
;tree "SPIT43R"
group 0--3
line.long 0 "SPIT43R"
hexfld.byte 0 " SPIT43INTIDNP0 "
hexfld.byte 1 " SPIT43INTIDNP1 "
hexfld.byte 2 " SPIT43INTIDNP2 "
hexfld.byte 3 " SPIT43INTIDNP3 "
;tree.end

base ad:0xa04118b0
;tree "SPIT44R"
group 0--3
line.long 0 "SPIT44R"
hexfld.byte 0 " SPIT44INTIDNP0 "
hexfld.byte 1 " SPIT44INTIDNP1 "
hexfld.byte 2 " SPIT44INTIDNP2 "
hexfld.byte 3 " SPIT44INTIDNP3 "
;tree.end

base ad:0xa04118b4
;tree "SPIT45R"
group 0--3
line.long 0 "SPIT45R"
hexfld.byte 0 " SPIT45INTIDNP0 "
hexfld.byte 1 " SPIT45INTIDNP1 "
hexfld.byte 2 " SPIT45INTIDNP2 "
hexfld.byte 3 " SPIT45INTIDNP3 "
;tree.end

base ad:0xa04118b8
;tree "SPIT46R"
group 0--3
line.long 0 "SPIT46R"
hexfld.byte 0 " SPIT46INTIDNP0 "
hexfld.byte 1 " SPIT46INTIDNP1 "
hexfld.byte 2 " SPIT46INTIDNP2 "
hexfld.byte 3 " SPIT46INTIDNP3 "
;tree.end

base ad:0xa04118bc
;tree "SPIT47R"
group 0--3
line.long 0 "SPIT47R"
hexfld.byte 0 " SPIT47INTIDNP0 "
hexfld.byte 1 " SPIT47INTIDNP1 "
hexfld.byte 2 " SPIT47INTIDNP2 "
hexfld.byte 3 " SPIT47INTIDNP3 "
;tree.end

base ad:0xa04118c0
;tree "SPIT48R"
group 0--3
line.long 0 "SPIT48R"
hexfld.byte 0 " SPIT48INTIDNP0 "
hexfld.byte 1 " SPIT48INTIDNP1 "
hexfld.byte 2 " SPIT48INTIDNP2 "
hexfld.byte 3 " SPIT48INTIDNP3 "
;tree.end

base ad:0xa04118c4
;tree "SPIT49R"
group 0--3
line.long 0 "SPIT49R"
hexfld.byte 0 " SPIT49INTIDNP0 "
hexfld.byte 1 " SPIT49INTIDNP1 "
hexfld.byte 2 " SPIT49INTIDNP2 "
hexfld.byte 3 " SPIT49INTIDNP3 "
;tree.end

base ad:0xa04118c8
;tree "SPIT50R"
group 0--3
line.long 0 "SPIT50R"
hexfld.byte 0 " SPIT50INTIDNP0 "
hexfld.byte 1 " SPIT50INTIDNP1 "
hexfld.byte 2 " SPIT50INTIDNP2 "
hexfld.byte 3 " SPIT50INTIDNP3 "
;tree.end

base ad:0xa04118cc
;tree "SPIT51R"
group 0--3
line.long 0 "SPIT51R"
hexfld.byte 0 " SPIT51INTIDNP0 "
hexfld.byte 1 " SPIT51INTIDNP1 "
hexfld.byte 2 " SPIT51INTIDNP2 "
hexfld.byte 3 " SPIT51INTIDNP3 "
;tree.end

base ad:0xa04118d0
;tree "SPIT52R"
group 0--3
line.long 0 "SPIT52R"
hexfld.byte 0 " SPIT52INTIDNP0 "
hexfld.byte 1 " SPIT52INTIDNP1 "
hexfld.byte 2 " SPIT52INTIDNP2 "
hexfld.byte 3 " SPIT52INTIDNP3 "
;tree.end

base ad:0xa04118d4
;tree "SPIT53R"
group 0--3
line.long 0 "SPIT53R"
hexfld.byte 0 " SPIT53INTIDNP0 "
hexfld.byte 1 " SPIT53INTIDNP1 "
hexfld.byte 2 " SPIT53INTIDNP2 "
hexfld.byte 3 " SPIT53INTIDNP3 "
;tree.end

base ad:0xa04118d8
;tree "SPIT54R"
group 0--3
line.long 0 "SPIT54R"
hexfld.byte 0 " SPIT54INTIDNP0 "
hexfld.byte 1 " SPIT54INTIDNP1 "
hexfld.byte 2 " SPIT54INTIDNP2 "
hexfld.byte 3 " SPIT54INTIDNP3 "
;tree.end

base ad:0xa04118dc
;tree "SPIT55R"
group 0--3
line.long 0 "SPIT55R"
hexfld.byte 0 " SPIT55INTIDNP0 "
hexfld.byte 1 " SPIT55INTIDNP1 "
hexfld.byte 2 " SPIT55INTIDNP2 "
hexfld.byte 3 " SPIT55INTIDNP3 "
;tree.end

base ad:0xa04118e0
;tree "SPIT56R"
group 0--3
line.long 0 "SPIT56R"
hexfld.byte 0 " SPIT56INTIDNP0 "
hexfld.byte 1 " SPIT56INTIDNP1 "
hexfld.byte 2 " SPIT56INTIDNP2 "
hexfld.byte 3 " SPIT56INTIDNP3 "
;tree.end

base ad:0xa04118e4
;tree "SPIT57R"
group 0--3
line.long 0 "SPIT57R"
hexfld.byte 0 " SPIT57INTIDNP0 "
hexfld.byte 1 " SPIT57INTIDNP1 "
hexfld.byte 2 " SPIT57INTIDNP2 "
hexfld.byte 3 " SPIT57INTIDNP3 "
;tree.end

base ad:0xa04118e8
;tree "SPIT58R"
group 0--3
line.long 0 "SPIT58R"
hexfld.byte 0 " SPIT58INTIDNP0 "
hexfld.byte 1 " SPIT58INTIDNP1 "
hexfld.byte 2 " SPIT58INTIDNP2 "
hexfld.byte 3 " SPIT58INTIDNP3 "
;tree.end

base ad:0xa04118ec
;tree "SPIT59R"
group 0--3
line.long 0 "SPIT59R"
hexfld.byte 0 " SPIT59INTIDNP0 "
hexfld.byte 1 " SPIT59INTIDNP1 "
hexfld.byte 2 " SPIT59INTIDNP2 "
hexfld.byte 3 " SPIT59INTIDNP3 "
;tree.end

base ad:0xa04118f0
;tree "SPIT60R"
group 0--3
line.long 0 "SPIT60R"
hexfld.byte 0 " SPIT60INTIDNP0 "
hexfld.byte 1 " SPIT60INTIDNP1 "
hexfld.byte 2 " SPIT60INTIDNP2 "
hexfld.byte 3 " SPIT60INTIDNP3 "
;tree.end

base ad:0xa04118f4
;tree "SPIT61R"
group 0--3
line.long 0 "SPIT61R"
hexfld.byte 0 " SPIT61INTIDNP0 "
hexfld.byte 1 " SPIT61INTIDNP1 "
hexfld.byte 2 " SPIT61INTIDNP2 "
hexfld.byte 3 " SPIT61INTIDNP3 "
;tree.end

base ad:0xa04118f8
;tree "SPIT62R"
group 0--3
line.long 0 "SPIT62R"
hexfld.byte 0 " SPIT62INTIDNP0 "
hexfld.byte 1 " SPIT62INTIDNP1 "
hexfld.byte 2 " SPIT62INTIDNP2 "
hexfld.byte 3 " SPIT62INTIDNP3 "
;tree.end

base ad:0xa04118fc
;tree "SPIT63R"
group 0--3
line.long 0 "SPIT63R"
hexfld.byte 0 " SPIT63INTIDNP0 "
hexfld.byte 1 " SPIT63INTIDNP1 "
hexfld.byte 2 " SPIT63INTIDNP2 "
hexfld.byte 3 " SPIT63INTIDNP3 "
;tree.end

base ad:0xa0411c00
;tree "IC0R"
group 0--3
line.long 0 "IC0R"
hexfld.long 0 " IC0 "
;tree.end

base ad:0xa0411c04
;tree "IC1R"
group 0--3
line.long 0 "IC1R"
hexfld.long 0 " IC1 "
;tree.end

base ad:0xa0411c08
;tree "IC2R"
group 0--3
line.long 0 "IC2R"
hexfld.long 0 " IC2 "
;tree.end

base ad:0xa0411c0c
;tree "IC3R"
group 0--3
line.long 0 "IC3R"
hexfld.long 0 " IC3 "
;tree.end

base ad:0xa0411c10
;tree "IC4R"
group 0--3
line.long 0 "IC4R"
hexfld.long 0 " IC4 "
;tree.end

base ad:0xa0411c14
;tree "IC5R"
group 0--3
line.long 0 "IC5R"
hexfld.long 0 " IC5 "
;tree.end

base ad:0xa0411c18
;tree "IC6R"
group 0--3
line.long 0 "IC6R"
hexfld.long 0 " IC6 "
;tree.end

base ad:0xa0411c1c
;tree "IC7R"
group 0--3
line.long 0 "IC7R"
hexfld.long 0 " IC7 "
;tree.end

base ad:0xa0411c20
;tree "IC8R"
group 0--3
line.long 0 "IC8R"
hexfld.long 0 " IC8 "
;tree.end

base ad:0xa0411c24
;tree "IC9R"
group 0--3
line.long 0 "IC9R"
hexfld.long 0 " IC9 "
;tree.end

base ad:0xa0411c28
;tree "IC10R"
group 0--3
line.long 0 "IC10R"
hexfld.long 0 " IC10 "
;tree.end

base ad:0xa0411c2c
;tree "IC11R"
group 0--3
line.long 0 "IC11R"
hexfld.long 0 " IC11 "
;tree.end

base ad:0xa0411c30
;tree "IC12R"
group 0--3
line.long 0 "IC12R"
hexfld.long 0 " IC12 "
;tree.end

base ad:0xa0411c34
;tree "IC13R"
group 0--3
line.long 0 "IC13R"
hexfld.long 0 " IC13 "
;tree.end

base ad:0xa0411c38
;tree "IC14R"
group 0--3
line.long 0 "IC14R"
hexfld.long 0 " IC14 "
;tree.end

base ad:0xa0411c3c
;tree "IC15R"
group 0--3
line.long 0 "IC15R"
hexfld.long 0 " IC15 "
;tree.end

base ad:0xa0411c40
;tree "IC16R"
group 0--3
line.long 0 "IC16R"
hexfld.long 0 " IC16 "
;tree.end

base ad:0xa0411c44
;tree "IC17R"
group 0--3
line.long 0 "IC17R"
hexfld.long 0 " IC17 "
;tree.end

base ad:0xa0411c48
;tree "IC18R"
group 0--3
line.long 0 "IC18R"
hexfld.long 0 " IC18 "
;tree.end

base ad:0xa0411c4c
;tree "IC19R"
group 0--3
line.long 0 "IC19R"
hexfld.long 0 " IC19 "
;tree.end

base ad:0xa0411c50
;tree "IC20R"
group 0--3
line.long 0 "IC20R"
hexfld.long 0 " IC20 "
;tree.end

base ad:0xa0411c54
;tree "IC21R"
group 0--3
line.long 0 "IC21R"
hexfld.long 0 " IC21 "
;tree.end

base ad:0xa0411c58
;tree "IC22R"
group 0--3
line.long 0 "IC22R"
hexfld.long 0 " IC22 "
;tree.end

base ad:0xa0411c5c
;tree "IC23R"
group 0--3
line.long 0 "IC23R"
hexfld.long 0 " IC23 "
;tree.end

base ad:0xa0411c60
;tree "IC24R"
group 0--3
line.long 0 "IC24R"
hexfld.long 0 " IC24 "
;tree.end

base ad:0xa0411c64
;tree "IC25R"
group 0--3
line.long 0 "IC25R"
hexfld.long 0 " IC25 "
;tree.end

base ad:0xa0411c68
;tree "IC26R"
group 0--3
line.long 0 "IC26R"
hexfld.long 0 " IC26 "
;tree.end

base ad:0xa0411c6c
;tree "IC27R"
group 0--3
line.long 0 "IC27R"
hexfld.long 0 " IC27 "
;tree.end

base ad:0xa0411c70
;tree "IC28R"
group 0--3
line.long 0 "IC28R"
hexfld.long 0 " IC28 "
;tree.end

base ad:0xa0411c74
;tree "IC29R"
group 0--3
line.long 0 "IC29R"
hexfld.long 0 " IC29 "
;tree.end

base ad:0xa0411c78
;tree "IC30R"
group 0--3
line.long 0 "IC30R"
hexfld.long 0 " IC30 "
;tree.end

base ad:0xa0411c7c
;tree "IC31R"
group 0--3
line.long 0 "IC31R"
hexfld.long 0 " IC31 "
;tree.end

base ad:0xa0411c80
;tree "IC32R"
group 0--3
line.long 0 "IC32R"
hexfld.long 0 " IC32 "
;tree.end

base ad:0xa0411c84
;tree "IC33R"
group 0--3
line.long 0 "IC33R"
hexfld.long 0 " IC33 "
;tree.end

base ad:0xa0411c88
;tree "IC34R"
group 0--3
line.long 0 "IC34R"
hexfld.long 0 " IC34 "
;tree.end

base ad:0xa0411c8c
;tree "IC35R"
group 0--3
line.long 0 "IC35R"
hexfld.long 0 " IC35 "
;tree.end

base ad:0xa0411c90
;tree "IC36R"
group 0--3
line.long 0 "IC36R"
hexfld.long 0 " IC36 "
;tree.end

base ad:0xa0411c94
;tree "IC37R"
group 0--3
line.long 0 "IC37R"
hexfld.long 0 " IC37 "
;tree.end

base ad:0xa0411c98
;tree "IC38R"
group 0--3
line.long 0 "IC38R"
hexfld.long 0 " IC38 "
;tree.end

base ad:0xa0411c9c
;tree "IC39R"
group 0--3
line.long 0 "IC39R"
hexfld.long 0 " IC39 "
;tree.end

base ad:0xa0411ca0
;tree "IC40R"
group 0--3
line.long 0 "IC40R"
hexfld.long 0 " IC40 "
;tree.end

base ad:0xa0411ca4
;tree "IC41R"
group 0--3
line.long 0 "IC41R"
hexfld.long 0 " IC41 "
;tree.end

base ad:0xa0411ca8
;tree "IC42R"
group 0--3
line.long 0 "IC42R"
hexfld.long 0 " IC42 "
;tree.end

base ad:0xa0411cac
;tree "IC43R"
group 0--3
line.long 0 "IC43R"
hexfld.long 0 " IC43 "
;tree.end

base ad:0xa0411cb0
;tree "IC44R"
group 0--3
line.long 0 "IC44R"
hexfld.long 0 " IC44 "
;tree.end

base ad:0xa0411cb4
;tree "IC45R"
group 0--3
line.long 0 "IC45R"
hexfld.long 0 " IC45 "
;tree.end

base ad:0xa0411cb8
;tree "IC46R"
group 0--3
line.long 0 "IC46R"
hexfld.long 0 " IC46 "
;tree.end

base ad:0xa0411cbc
;tree "IC47R"
group 0--3
line.long 0 "IC47R"
hexfld.long 0 " IC47 "
;tree.end

base ad:0xa0411cc0
;tree "IC48R"
group 0--3
line.long 0 "IC48R"
hexfld.long 0 " IC48 "
;tree.end

base ad:0xa0411cc4
;tree "IC49R"
group 0--3
line.long 0 "IC49R"
hexfld.long 0 " IC49 "
;tree.end

base ad:0xa0411cc8
;tree "IC50R"
group 0--3
line.long 0 "IC50R"
hexfld.long 0 " IC50 "
;tree.end

base ad:0xa0411ccc
;tree "IC51R"
group 0--3
line.long 0 "IC51R"
hexfld.long 0 " IC51 "
;tree.end

base ad:0xa0411cd0
;tree "IC52R"
group 0--3
line.long 0 "IC52R"
hexfld.long 0 " IC52 "
;tree.end

base ad:0xa0411cd4
;tree "IC53R"
group 0--3
line.long 0 "IC53R"
hexfld.long 0 " IC53 "
;tree.end

base ad:0xa0411cd8
;tree "IC54R"
group 0--3
line.long 0 "IC54R"
hexfld.long 0 " IC54 "
;tree.end

base ad:0xa0411cdc
;tree "IC55R"
group 0--3
line.long 0 "IC55R"
hexfld.long 0 " IC55 "
;tree.end

base ad:0xa0411ce0
;tree "IC56R"
group 0--3
line.long 0 "IC56R"
hexfld.long 0 " IC56 "
;tree.end

base ad:0xa0411ce4
;tree "IC57R"
group 0--3
line.long 0 "IC57R"
hexfld.long 0 " IC57 "
;tree.end

base ad:0xa0411ce8
;tree "IC58R"
group 0--3
line.long 0 "IC58R"
hexfld.long 0 " IC58 "
;tree.end

base ad:0xa0411cec
;tree "IC59R"
group 0--3
line.long 0 "IC59R"
hexfld.long 0 " IC59 "
;tree.end

base ad:0xa0411cf0
;tree "IC60R"
group 0--3
line.long 0 "IC60R"
hexfld.long 0 " IC60 "
;tree.end

base ad:0xa0411cf4
;tree "IC61R"
group 0--3
line.long 0 "IC61R"
hexfld.long 0 " IC61 "
;tree.end

base ad:0xa0411cf8
;tree "IC62R"
group 0--3
line.long 0 "IC62R"
hexfld.long 0 " IC62 "
;tree.end

base ad:0xa0411cfc
;tree "IC63R"
group 0--3
line.long 0 "IC63R"
hexfld.long 0 " IC63 "
;tree.end

base ad:0xa0411d00
;tree "PPISR"
rgroup 0--3
line.long 0 "PPISR"
bitfld.long 0 12.--15. " PPISS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0411d04
;tree "SPIS0R"
rgroup 0--3
line.long 0 "SPIS0R"
hexfld.long 0 " SPIS0 "
;tree.end

base ad:0xa0411d08
;tree "SPIS1R"
rgroup 0--3
line.long 0 "SPIS1R"
hexfld.long 0 " SPIS1 "
;tree.end

base ad:0xa0411d0c
;tree "SPIS2R"
rgroup 0--3
line.long 0 "SPIS2R"
hexfld.long 0 " SPIS2 "
;tree.end

base ad:0xa0411d10
;tree "SPIS3R"
rgroup 0--3
line.long 0 "SPIS3R"
hexfld.long 0 " SPIS3 "
;tree.end

base ad:0xa0411d14
;tree "SPIS4R"
rgroup 0--3
line.long 0 "SPIS4R"
hexfld.long 0 " SPIS4 "
;tree.end

base ad:0xa0411d18
;tree "SPIS5R"
rgroup 0--3
line.long 0 "SPIS5R"
hexfld.long 0 " SPIS5 "
;tree.end

base ad:0xa0411d1c
;tree "SPIS6R"
rgroup 0--3
line.long 0 "SPIS6R"
hexfld.long 0 " SPIS6 "
;tree.end

base ad:0xa0411d20
;tree "SPIS7R"
rgroup 0--3
line.long 0 "SPIS7R"
hexfld.long 0 " SPIS7 "
;tree.end

base ad:0xa0411d24
;tree "SPIS8R"
rgroup 0--3
line.long 0 "SPIS8R"
hexfld.long 0 " SPIS8 "
;tree.end

base ad:0xa0411d28
;tree "SPIS9R"
rgroup 0--3
line.long 0 "SPIS9R"
hexfld.long 0 " SPIS9 "
;tree.end

base ad:0xa0411d2c
;tree "SPIS10R"
rgroup 0--3
line.long 0 "SPIS10R"
hexfld.long 0 " SPIS10 "
;tree.end

base ad:0xa0411d30
;tree "SPIS11R"
rgroup 0--3
line.long 0 "SPIS11R"
hexfld.long 0 " SPIS11 "
;tree.end

base ad:0xa0411d34
;tree "SPIS12R"
rgroup 0--3
line.long 0 "SPIS12R"
hexfld.long 0 " SPIS12 "
;tree.end

base ad:0xa0411d38
;tree "SPIS13R"
rgroup 0--3
line.long 0 "SPIS13R"
hexfld.long 0 " SPIS13 "
;tree.end

base ad:0xa0411d3c
;tree "SPIS14R"
rgroup 0--3
line.long 0 "SPIS14R"
hexfld.long 0 " SPIS14 "
;tree.end

base ad:0xa0411d40
;tree "SPIS15R"
rgroup 0--3
line.long 0 "SPIS15R"
hexfld.long 0 " SPIS15 "
;tree.end

base ad:0xa0411d44
;tree "SPIS16R"
rgroup 0--3
line.long 0 "SPIS16R"
hexfld.long 0 " SPIS16 "
;tree.end

base ad:0xa0411d48
;tree "SPIS17R"
rgroup 0--3
line.long 0 "SPIS17R"
hexfld.long 0 " SPIS17 "
;tree.end

base ad:0xa0411d4c
;tree "SPIS18R"
rgroup 0--3
line.long 0 "SPIS18R"
hexfld.long 0 " SPIS18 "
;tree.end

base ad:0xa0411d50
;tree "SPIS19R"
rgroup 0--3
line.long 0 "SPIS19R"
hexfld.long 0 " SPIS19 "
;tree.end

base ad:0xa0411d54
;tree "SPIS20R"
rgroup 0--3
line.long 0 "SPIS20R"
hexfld.long 0 " SPIS20 "
;tree.end

base ad:0xa0411d58
;tree "SPIS21R"
rgroup 0--3
line.long 0 "SPIS21R"
hexfld.long 0 " SPIS21 "
;tree.end

base ad:0xa0411d5c
;tree "SPIS22R"
rgroup 0--3
line.long 0 "SPIS22R"
hexfld.long 0 " SPIS22 "
;tree.end

base ad:0xa0411d60
;tree "SPIS23R"
rgroup 0--3
line.long 0 "SPIS23R"
hexfld.long 0 " SPIS23 "
;tree.end

base ad:0xa0411d64
;tree "SPIS24R"
rgroup 0--3
line.long 0 "SPIS24R"
hexfld.long 0 " SPIS24 "
;tree.end

base ad:0xa0411d68
;tree "SPIS25R"
rgroup 0--3
line.long 0 "SPIS25R"
hexfld.long 0 " SPIS25 "
;tree.end

base ad:0xa0411d6c
;tree "SPIS26R"
rgroup 0--3
line.long 0 "SPIS26R"
hexfld.long 0 " SPIS26 "
;tree.end

base ad:0xa0411d70
;tree "SPIS27R"
rgroup 0--3
line.long 0 "SPIS27R"
hexfld.long 0 " SPIS27 "
;tree.end

base ad:0xa0411d74
;tree "SPIS28R"
rgroup 0--3
line.long 0 "SPIS28R"
hexfld.long 0 " SPIS28 "
;tree.end

base ad:0xa0411d78
;tree "SPIS29R"
rgroup 0--3
line.long 0 "SPIS29R"
hexfld.long 0 " SPIS29 "
;tree.end

base ad:0xa0411d7c
;tree "SPIS30R"
rgroup 0--3
line.long 0 "SPIS30R"
hexfld.long 0 " SPIS30 "
;tree.end

base ad:0xa0411f00
;tree "STIR"
wgroup 0--3
line.long 0 "STIR"
bitfld.long 0 0.--3. " STIINTID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 15. " STISATT "  "0 ,1 "
hexfld.byte 2 " STICPUTL "
bitfld.long 0 24.--25. " STITLF "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0411fe0
;tree "PPLI0R"
rgroup 0--3
line.long 0 "PPLI0R"
bitfld.long 0 0.--11. " PPLI0PN "  " "
bitfld.long 0 12.--18. " PPLI0JEP106 "  " "
bitfld.long 0 19. " PPLI0JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI0REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI0MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI0REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0411fe4
;tree "PPLI1R"
rgroup 0--3
line.long 0 "PPLI1R"
bitfld.long 0 0.--11. " PPLI1PN "  " "
bitfld.long 0 12.--18. " PPLI1JEP106 "  " "
bitfld.long 0 19. " PPLI1JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI1REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI1MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI1REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0411fe8
;tree "PPLI2R"
rgroup 0--3
line.long 0 "PPLI2R"
bitfld.long 0 0.--11. " PPLI2PN "  " "
bitfld.long 0 12.--18. " PPLI2JEP106 "  " "
bitfld.long 0 19. " PPLI2JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI2REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI2MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI2REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0411fec
;tree "PPLI3R"
rgroup 0--3
line.long 0 "PPLI3R"
bitfld.long 0 0.--11. " PPLI3PN "  " "
bitfld.long 0 12.--18. " PPLI3JEP106 "  " "
bitfld.long 0 19. " PPLI3JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI3REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI3MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI3REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0411ff0
;tree "PCI0R"
rgroup 0--3
line.long 0 "PCI0R"
hexfld.byte 0 " PCI0CID0 "
hexfld.byte 1 " PCI0CID1 "
hexfld.byte 2 " PCI0CID2 "
hexfld.byte 3 " PCI0CID3 "
;tree.end

base ad:0xa0411ff4
;tree "PCI1R"
rgroup 0--3
line.long 0 "PCI1R"
hexfld.byte 0 " PCI1CID0 "
hexfld.byte 1 " PCI1CID1 "
hexfld.byte 2 " PCI1CID2 "
hexfld.byte 3 " PCI1CID3 "
;tree.end

base ad:0xa0411ff8
;tree "PCI2R"
rgroup 0--3
line.long 0 "PCI2R"
hexfld.byte 0 " PCI2CID0 "
hexfld.byte 1 " PCI2CID1 "
hexfld.byte 2 " PCI2CID2 "
hexfld.byte 3 " PCI2CID3 "
;tree.end

base ad:0xa0411ffc
;tree "PCI3R"
rgroup 0--3
line.long 0 "PCI3R"
hexfld.byte 0 " PCI3CID0 "
hexfld.byte 1 " PCI3CID1 "
hexfld.byte 2 " PCI3CID2 "
hexfld.byte 3 " PCI3CID3 "
;tree.end

tree.end

;==============================================================
tree "GPIO0"
;==============================================================
base ad:0x8012e000
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8012e004
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8012e008
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8012e00c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8012e010
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8012e014
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8012e018
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8012e01c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8012e020
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8012e024
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8012e040
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8012e044
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8012e048
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8012e04c
;tree "IC"
rgroup 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8012e050
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8012e054
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8012e058
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

base ad:0x8012e7e0
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
hexfld.long 0 " ITCR "
;tree.end

base ad:0x8012e7e4
;tree "ITOP"
rgroup 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8012e7e8
;tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012efe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8012efe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8012eff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " _PCellID0 "
;tree.end

base ad:0x8012eff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " _PCellID1 "
;tree.end

base ad:0x8012eff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " _PCellID2 "
;tree.end

base ad:0x8012effc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " _PCellID3 "
;tree.end

tree.end

;==============================================================
tree "GPIO1"
;==============================================================
base ad:0x8012e080
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8012e084
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8012e088
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8012e08c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8012e090
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8012e094
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8012e098
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8012e09c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8012e0a0
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8012e0a4
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8012e0c0
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8012e0c4
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8012e0c8
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8012e0cc
;tree "IC"
rgroup 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8012e0d0
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8012e0d4
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8012e0d8
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

base ad:0x8012e7e0
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
hexfld.long 0 " ITCR "
;tree.end

base ad:0x8012e7e4
;tree "ITOP"
rgroup 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8012e7e8
;tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012efe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8012efe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8012eff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " _PCellID0 "
;tree.end

base ad:0x8012eff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " _PCellID1 "
;tree.end

base ad:0x8012eff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " _PCellID2 "
;tree.end

base ad:0x8012effc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " _PCellID3 "
;tree.end

tree.end

;==============================================================
tree "GPIO2"
;==============================================================
base ad:0x8000e000
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8000e004
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8000e008
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8000e00c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8000e010
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8000e014
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8000e018
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8000e01c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8000e020
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8000e024
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8000e040
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8000e044
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8000e048
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8000e04c
;tree "IC"
rgroup 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8000e050
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8000e054
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8000e058
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

base ad:0x8012e7e0
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
hexfld.long 0 " ITCR "
;tree.end

base ad:0x8012e7e4
;tree "ITOP"
rgroup 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8012e7e8
;tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012efe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8012efe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8012eff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " _PCellID0 "
;tree.end

base ad:0x8012eff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " _PCellID1 "
;tree.end

base ad:0x8012eff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " _PCellID2 "
;tree.end

base ad:0x8012effc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " _PCellID3 "
;tree.end

tree.end

;==============================================================
tree "GPIO3"
;==============================================================
base ad:0x8000e080
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8000e084
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8000e088
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8000e08c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8000e090
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8000e094
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8000e098
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8000e09c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8000e0a0
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8000e0a4
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8000e0c0
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8000e0c4
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8000e0c8
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8000e0cc
;tree "IC"
rgroup 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8000e0d0
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8000e0d4
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8000e0d8
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

base ad:0x8012e7e0
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
hexfld.long 0 " ITCR "
;tree.end

base ad:0x8012e7e4
;tree "ITOP"
rgroup 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8012e7e8
;tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012efe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8012efe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8012eff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " _PCellID0 "
;tree.end

base ad:0x8012eff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " _PCellID1 "
;tree.end

base ad:0x8012eff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " _PCellID2 "
;tree.end

base ad:0x8012effc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " _PCellID3 "
;tree.end

tree.end

;==============================================================
tree "GPIO4"
;==============================================================
base ad:0x8000e100
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8000e104
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8000e108
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8000e10c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8000e110
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8000e114
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8000e118
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8000e11c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8000e120
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8000e124
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8000e140
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8000e144
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8000e148
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8000e14c
;tree "IC"
rgroup 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8000e150
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8000e154
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8000e158
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

base ad:0x8012e7e0
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
hexfld.long 0 " ITCR "
;tree.end

base ad:0x8012e7e4
;tree "ITOP"
rgroup 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8012e7e8
;tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012efe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8012efe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8012eff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " _PCellID0 "
;tree.end

base ad:0x8012eff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " _PCellID1 "
;tree.end

base ad:0x8012eff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " _PCellID2 "
;tree.end

base ad:0x8012effc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " _PCellID3 "
;tree.end

tree.end

;==============================================================
tree "GPIO5"
;==============================================================
base ad:0x8000e180
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8000e184
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8000e188
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8000e18c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8000e190
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8000e194
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8000e198
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8000e19c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8000e1a0
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8000e1a4
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8000e1c0
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8000e1c4
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8000e1c8
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8000e1cc
;tree "IC"
rgroup 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8000e1d0
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8000e1d4
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8000e1d8
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

base ad:0x8012e7e0
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
hexfld.long 0 " ITCR "
;tree.end

base ad:0x8012e7e4
;tree "ITOP"
rgroup 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8012e7e8
;tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012efe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8012efe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8012eff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " _PCellID0 "
;tree.end

base ad:0x8012eff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " _PCellID1 "
;tree.end

base ad:0x8012eff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " _PCellID2 "
;tree.end

base ad:0x8012effc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " _PCellID3 "
;tree.end

tree.end

;==============================================================
tree "GPIO6"
;==============================================================
base ad:0x8011e000
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8011e004
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8011e008
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8011e00c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8011e010
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8011e014
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8011e018
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8011e01c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8011e020
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8011e024
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8011e040
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8011e044
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8011e048
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8011e04c
;tree "IC"
rgroup 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8011e050
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8011e054
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8011e058
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

base ad:0x8012e7e0
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
hexfld.long 0 " ITCR "
;tree.end

base ad:0x8012e7e4
;tree "ITOP"
rgroup 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8012e7e8
;tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012efe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8012efe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8012eff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " _PCellID0 "
;tree.end

base ad:0x8012eff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " _PCellID1 "
;tree.end

base ad:0x8012eff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " _PCellID2 "
;tree.end

base ad:0x8012effc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " _PCellID3 "
;tree.end

tree.end

;==============================================================
tree "GPIO7"
;==============================================================
base ad:0x8011e080
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8011e084
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8011e088
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8011e08c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8011e090
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8011e094
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8011e098
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8011e09c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8011e0a0
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8011e0a4
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8011e0c0
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8011e0c4
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8011e0c8
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8011e0cc
;tree "IC"
rgroup 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8011e0d0
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8011e0d4
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8011e0d8
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

base ad:0x8012e7e0
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
hexfld.long 0 " ITCR "
;tree.end

base ad:0x8012e7e4
;tree "ITOP"
rgroup 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8012e7e8
;tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012efe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8012efe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8012eff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " _PCellID0 "
;tree.end

base ad:0x8012eff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " _PCellID1 "
;tree.end

base ad:0x8012eff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " _PCellID2 "
;tree.end

base ad:0x8012effc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " _PCellID3 "
;tree.end

tree.end

;==============================================================
tree "GPIO8"
;==============================================================
base ad:0xa03fe000
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0xa03fe004
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0xa03fe008
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0xa03fe00c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0xa03fe010
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0xa03fe014
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0xa03fe018
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0xa03fe01c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0xa03fe020
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0xa03fe024
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0xa03fe040
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0xa03fe044
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0xa03fe048
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0xa03fe04c
;tree "IC"
rgroup 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0xa03fe050
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0xa03fe054
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0xa03fe058
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

base ad:0x8012e7e0
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
hexfld.long 0 " ITCR "
;tree.end

base ad:0x8012e7e4
;tree "ITOP"
rgroup 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8012e7e8
;tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012efe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8012efe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8012eff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " _PCellID0 "
;tree.end

base ad:0x8012eff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " _PCellID1 "
;tree.end

base ad:0x8012eff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " _PCellID2 "
;tree.end

base ad:0x8012effc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " _PCellID3 "
;tree.end

tree.end

;==============================================================
tree "HASH (2 instances)"
;==============================================================
base ad:0xa03c1000
;********************************************
tree "HASH-0"
;********************************************
base ad:0xa03c1000
;tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SECn "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " INIT "  "0 ,1 "
bitfld.long 0 3. " DMAE "  "0 ,1 "
bitfld.long 0 4.--5. " DATAFORM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " MODE "  "0 ,1 "
bitfld.long 0 7. " ALGO "  "0 ,1 "
bitfld.long 0 8.--11. " NBW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " DINF "  "0 ,1 "
bitfld.long 0 16. " LKEY "  "0 ,1 "
;tree.end

base ad:0xa03c1004
;tree "0DIN"
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa03c1008
;tree "0STR"
group 0--3
line.long 0 "STR"
bitfld.long 0 0.--4. " NBLW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " DCAL "  "0 ,1 "
;tree.end

base ad:0xa03c100c
;tree "0H0"
rgroup 0--3
line.long 0 "H0"
hexfld.long 0 " H0 "
;tree.end

base ad:0xa03c1010
;tree "0H1"
rgroup 0--3
line.long 0 "H1"
hexfld.long 0 " H1 "
;tree.end

base ad:0xa03c1014
;tree "0H2"
rgroup 0--3
line.long 0 "H2"
hexfld.long 0 " H2 "
;tree.end

base ad:0xa03c1018
;tree "0H3"
rgroup 0--3
line.long 0 "H3"
hexfld.long 0 " H3 "
;tree.end

base ad:0xa03c101c
;tree "0H4"
rgroup 0--3
line.long 0 "H4"
hexfld.long 0 " H4 "
;tree.end

base ad:0xa03c1020
;tree "0H5"
rgroup 0--3
line.long 0 "H5"
hexfld.long 0 " H5 "
;tree.end

base ad:0xa03c1024
;tree "0H6"
rgroup 0--3
line.long 0 "H6"
hexfld.long 0 " H6 "
;tree.end

base ad:0xa03c1028
;tree "0H7"
rgroup 0--3
line.long 0 "H7"
hexfld.long 0 " H7 "
;tree.end

base ad:0xa03c1100
;tree "0CSR0"
rgroup 0--3
line.long 0 "CSR0"
hexfld.long 0 " W0 "
;tree.end

base ad:0xa03c1104
;tree "0CSR1"
group 0--3
line.long 0 "CSR1"
hexfld.long 0 " W1 "
;tree.end

base ad:0xa03c1108
;tree "0CSR2"
group 0--3
line.long 0 "CSR2"
hexfld.long 0 " W2 "
;tree.end

base ad:0xa03c110c
;tree "0CSR3"
group 0--3
line.long 0 "CSR3"
hexfld.long 0 " W3 "
;tree.end

base ad:0xa03c1110
;tree "0CSR4"
group 0--3
line.long 0 "CSR4"
hexfld.long 0 " W4 "
;tree.end

base ad:0xa03c1114
;tree "0CSR5"
group 0--3
line.long 0 "CSR5"
hexfld.long 0 " W5 "
;tree.end

base ad:0xa03c1118
;tree "0CSR6"
group 0--3
line.long 0 "CSR6"
hexfld.long 0 " W6 "
;tree.end

base ad:0xa03c111c
;tree "0CSR7"
group 0--3
line.long 0 "CSR7"
hexfld.long 0 " W7 "
;tree.end

base ad:0xa03c1120
;tree "0CSR8"
group 0--3
line.long 0 "CSR8"
hexfld.long 0 " W8 "
;tree.end

base ad:0xa03c1124
;tree "0CSR9"
group 0--3
line.long 0 "CSR9"
hexfld.long 0 " W9 "
;tree.end

base ad:0xa03c1128
;tree "0CSR10"
group 0--3
line.long 0 "CSR10"
hexfld.long 0 " W10 "
;tree.end

base ad:0xa03c112c
;tree "0CSR11"
group 0--3
line.long 0 "CSR11"
hexfld.long 0 " W11 "
;tree.end

base ad:0xa03c1130
;tree "0CSR12"
group 0--3
line.long 0 "CSR12"
hexfld.long 0 " W12 "
;tree.end

base ad:0xa03c1134
;tree "0CSR13"
group 0--3
line.long 0 "CSR13"
hexfld.long 0 " W13 "
;tree.end

base ad:0xa03c1138
;tree "0CSR14"
group 0--3
line.long 0 "CSR14"
hexfld.long 0 " W14 "
;tree.end

base ad:0xa03c113c
;tree "0CSR15"
group 0--3
line.long 0 "CSR15"
hexfld.long 0 " W15 "
;tree.end

base ad:0xa03c1140
;tree "0CSR16"
group 0--3
line.long 0 "CSR16"
hexfld.long 0 " W16 "
;tree.end

base ad:0xa03c1144
;tree "0CSR17"
group 0--3
line.long 0 "CSR17"
hexfld.long 0 " W17 "
;tree.end

base ad:0xa03c1148
;tree "0CSR18"
group 0--3
line.long 0 "CSR18"
hexfld.long 0 " W18 "
;tree.end

base ad:0xa03c114c
;tree "0CSR19"
group 0--3
line.long 0 "CSR19"
hexfld.long 0 " W19 "
;tree.end

base ad:0xa03c1150
;tree "0CSR20"
group 0--3
line.long 0 "CSR20"
hexfld.long 0 " W20 "
;tree.end

base ad:0xa03c1154
;tree "0CSR21"
group 0--3
line.long 0 "CSR21"
hexfld.long 0 " W21 "
;tree.end

base ad:0xa03c1158
;tree "0CSR22"
group 0--3
line.long 0 "CSR22"
hexfld.long 0 " W22 "
;tree.end

base ad:0xa03c115c
;tree "0CSR23"
group 0--3
line.long 0 "CSR23"
hexfld.long 0 " W23 "
;tree.end

base ad:0xa03c1160
;tree "0CSR24"
group 0--3
line.long 0 "CSR24"
hexfld.long 0 " W24 "
;tree.end

base ad:0xa03c1164
;tree "0CSR25"
group 0--3
line.long 0 "CSR25"
hexfld.long 0 " W25 "
;tree.end

base ad:0xa03c1168
;tree "0CSR26"
group 0--3
line.long 0 "CSR26"
hexfld.long 0 " W26 "
;tree.end

base ad:0xa03c116c
;tree "0CSR27"
group 0--3
line.long 0 "CSR27"
hexfld.long 0 " W27 "
;tree.end

base ad:0xa03c1170
;tree "0CSR28"
group 0--3
line.long 0 "CSR28"
hexfld.long 0 " W28 "
;tree.end

base ad:0xa03c1174
;tree "0CSR29"
group 0--3
line.long 0 "CSR29"
hexfld.long 0 " W29 "
;tree.end

base ad:0xa03c1178
;tree "0CSR30"
group 0--3
line.long 0 "CSR30"
hexfld.long 0 " W30 "
;tree.end

base ad:0xa03c117c
;tree "0CSR31"
group 0--3
line.long 0 "CSR31"
hexfld.long 0 " W31 "
;tree.end

base ad:0xa03c1180
;tree "0CSR32"
group 0--3
line.long 0 "CSR32"
hexfld.long 0 " W32 "
;tree.end

base ad:0xa03c1184
;tree "0CSR33"
group 0--3
line.long 0 "CSR33"
hexfld.long 0 " W33 "
;tree.end

base ad:0xa03c1188
;tree "0CSR34"
group 0--3
line.long 0 "CSR34"
hexfld.long 0 " W34 "
;tree.end

base ad:0xa03c118c
;tree "0CSR35"
group 0--3
line.long 0 "CSR35"
hexfld.long 0 " W35 "
;tree.end

base ad:0xa03c1190
;tree "0CSR36"
group 0--3
line.long 0 "CSR36"
hexfld.long 0 " W36 "
;tree.end

base ad:0xa03c1194
;tree "0CSR37"
group 0--3
line.long 0 "CSR37"
hexfld.long 0 " W37 "
;tree.end

base ad:0xa03c1198
;tree "0CSR38"
group 0--3
line.long 0 "CSR38"
hexfld.long 0 " W38 "
;tree.end

base ad:0xa03c119c
;tree "0CSR39"
group 0--3
line.long 0 "CSR39"
hexfld.long 0 " W39 "
;tree.end

base ad:0xa03c11a0
;tree "0CSR40"
group 0--3
line.long 0 "CSR40"
hexfld.long 0 " W40 "
;tree.end

base ad:0xa03c11a4
;tree "0CSR41"
group 0--3
line.long 0 "CSR41"
hexfld.long 0 " W41 "
;tree.end

base ad:0xa03c11a8
;tree "0CSR42"
group 0--3
line.long 0 "CSR42"
hexfld.long 0 " W42 "
;tree.end

base ad:0xa03c11ac
;tree "0CSR43"
group 0--3
line.long 0 "CSR43"
hexfld.long 0 " W43 "
;tree.end

base ad:0xa03c11b0
;tree "0CSR44"
group 0--3
line.long 0 "CSR44"
hexfld.long 0 " W44 "
;tree.end

base ad:0xa03c11b4
;tree "0CSR45"
group 0--3
line.long 0 "CSR45"
hexfld.long 0 " W45 "
;tree.end

base ad:0xa03c11b8
;tree "0CSR46"
group 0--3
line.long 0 "CSR46"
hexfld.long 0 " W46 "
;tree.end

base ad:0xa03c11bc
;tree "0CSR47"
group 0--3
line.long 0 "CSR47"
hexfld.long 0 " W47 "
;tree.end

base ad:0xa03c11c0
;tree "0CSR48"
group 0--3
line.long 0 "CSR48"
hexfld.long 0 " W48 "
;tree.end

base ad:0xa03c11c4
;tree "0CSR49"
group 0--3
line.long 0 "CSR49"
hexfld.long 0 " W49 "
;tree.end

base ad:0xa03c11c8
;tree "0CSR50"
group 0--3
line.long 0 "CSR50"
hexfld.long 0 " W50 "
;tree.end

base ad:0xa03c11cc
;tree "0CSR51"
group 0--3
line.long 0 "CSR51"
hexfld.long 0 " W51 "
;tree.end

base ad:0xa03c10f8
;tree "0CSFULL"
group 0--3
line.long 0 "CSFULL"
hexfld.long 0 " W40 "
;tree.end

base ad:0xa03c10fc
;tree "0CSDATAIN"
group 0--3
line.long 0 "CSDATAIN"
hexfld.long 0 " W41 "
;tree.end

base ad:0xa03c1080
;tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0xa03c1084
;tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR "  "0 ,1 "
bitfld.long 0 1. " DMATC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
;tree.end

base ad:0xa03c1088
;tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMABREQ "  "0 ,1 "
;tree.end

base ad:0xa03c1fe0
;tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03c1fe4
;tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c1fe8
;tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c1fec
;tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03c1ff0
;tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

base ad:0xa03c1ff4
;tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

base ad:0xa03c1ff8
;tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

base ad:0xa03c1ffc
;tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

base ad:0xa03c2000
;********************************************
tree "HASH-1"
;********************************************
base ad:0xa03c2000
;tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SECn "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " INIT "  "0 ,1 "
bitfld.long 0 3. " DMAE "  "0 ,1 "
bitfld.long 0 4.--5. " DATAFORM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " MODE "  "0 ,1 "
bitfld.long 0 7. " ALGO "  "0 ,1 "
bitfld.long 0 8.--11. " NBW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " DINF "  "0 ,1 "
bitfld.long 0 16. " LKEY "  "0 ,1 "
;tree.end

base ad:0xa03c2004
;tree "1DIN"
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa03c2008
;tree "1STR"
group 0--3
line.long 0 "STR"
bitfld.long 0 0.--4. " NBLW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " DCAL "  "0 ,1 "
;tree.end

base ad:0xa03c200c
;tree "1H0"
rgroup 0--3
line.long 0 "H0"
hexfld.long 0 " H0 "
;tree.end

base ad:0xa03c2010
;tree "1H1"
rgroup 0--3
line.long 0 "H1"
hexfld.long 0 " H1 "
;tree.end

base ad:0xa03c2014
;tree "1H2"
rgroup 0--3
line.long 0 "H2"
hexfld.long 0 " H2 "
;tree.end

base ad:0xa03c2018
;tree "1H3"
rgroup 0--3
line.long 0 "H3"
hexfld.long 0 " H3 "
;tree.end

base ad:0xa03c201c
;tree "1H4"
rgroup 0--3
line.long 0 "H4"
hexfld.long 0 " H4 "
;tree.end

base ad:0xa03c2020
;tree "1H5"
rgroup 0--3
line.long 0 "H5"
hexfld.long 0 " H5 "
;tree.end

base ad:0xa03c2024
;tree "1H6"
rgroup 0--3
line.long 0 "H6"
hexfld.long 0 " H6 "
;tree.end

base ad:0xa03c2028
;tree "1H7"
rgroup 0--3
line.long 0 "H7"
hexfld.long 0 " H7 "
;tree.end

base ad:0xa03c2100
;tree "1CSR0"
rgroup 0--3
line.long 0 "CSR0"
hexfld.long 0 " W0 "
;tree.end

base ad:0xa03c2104
;tree "1CSR1"
group 0--3
line.long 0 "CSR1"
hexfld.long 0 " W1 "
;tree.end

base ad:0xa03c2108
;tree "1CSR2"
group 0--3
line.long 0 "CSR2"
hexfld.long 0 " W2 "
;tree.end

base ad:0xa03c210c
;tree "1CSR3"
group 0--3
line.long 0 "CSR3"
hexfld.long 0 " W3 "
;tree.end

base ad:0xa03c2110
;tree "1CSR4"
group 0--3
line.long 0 "CSR4"
hexfld.long 0 " W4 "
;tree.end

base ad:0xa03c2114
;tree "1CSR5"
group 0--3
line.long 0 "CSR5"
hexfld.long 0 " W5 "
;tree.end

base ad:0xa03c2118
;tree "1CSR6"
group 0--3
line.long 0 "CSR6"
hexfld.long 0 " W6 "
;tree.end

base ad:0xa03c211c
;tree "1CSR7"
group 0--3
line.long 0 "CSR7"
hexfld.long 0 " W7 "
;tree.end

base ad:0xa03c2120
;tree "1CSR8"
group 0--3
line.long 0 "CSR8"
hexfld.long 0 " W8 "
;tree.end

base ad:0xa03c2124
;tree "1CSR9"
group 0--3
line.long 0 "CSR9"
hexfld.long 0 " W9 "
;tree.end

base ad:0xa03c2128
;tree "1CSR10"
group 0--3
line.long 0 "CSR10"
hexfld.long 0 " W10 "
;tree.end

base ad:0xa03c212c
;tree "1CSR11"
group 0--3
line.long 0 "CSR11"
hexfld.long 0 " W11 "
;tree.end

base ad:0xa03c2130
;tree "1CSR12"
group 0--3
line.long 0 "CSR12"
hexfld.long 0 " W12 "
;tree.end

base ad:0xa03c2134
;tree "1CSR13"
group 0--3
line.long 0 "CSR13"
hexfld.long 0 " W13 "
;tree.end

base ad:0xa03c2138
;tree "1CSR14"
group 0--3
line.long 0 "CSR14"
hexfld.long 0 " W14 "
;tree.end

base ad:0xa03c213c
;tree "1CSR15"
group 0--3
line.long 0 "CSR15"
hexfld.long 0 " W15 "
;tree.end

base ad:0xa03c2140
;tree "1CSR16"
group 0--3
line.long 0 "CSR16"
hexfld.long 0 " W16 "
;tree.end

base ad:0xa03c2144
;tree "1CSR17"
group 0--3
line.long 0 "CSR17"
hexfld.long 0 " W17 "
;tree.end

base ad:0xa03c2148
;tree "1CSR18"
group 0--3
line.long 0 "CSR18"
hexfld.long 0 " W18 "
;tree.end

base ad:0xa03c214c
;tree "1CSR19"
group 0--3
line.long 0 "CSR19"
hexfld.long 0 " W19 "
;tree.end

base ad:0xa03c2150
;tree "1CSR20"
group 0--3
line.long 0 "CSR20"
hexfld.long 0 " W20 "
;tree.end

base ad:0xa03c2154
;tree "1CSR21"
group 0--3
line.long 0 "CSR21"
hexfld.long 0 " W21 "
;tree.end

base ad:0xa03c2158
;tree "1CSR22"
group 0--3
line.long 0 "CSR22"
hexfld.long 0 " W22 "
;tree.end

base ad:0xa03c215c
;tree "1CSR23"
group 0--3
line.long 0 "CSR23"
hexfld.long 0 " W23 "
;tree.end

base ad:0xa03c2160
;tree "1CSR24"
group 0--3
line.long 0 "CSR24"
hexfld.long 0 " W24 "
;tree.end

base ad:0xa03c2164
;tree "1CSR25"
group 0--3
line.long 0 "CSR25"
hexfld.long 0 " W25 "
;tree.end

base ad:0xa03c2168
;tree "1CSR26"
group 0--3
line.long 0 "CSR26"
hexfld.long 0 " W26 "
;tree.end

base ad:0xa03c216c
;tree "1CSR27"
group 0--3
line.long 0 "CSR27"
hexfld.long 0 " W27 "
;tree.end

base ad:0xa03c2170
;tree "1CSR28"
group 0--3
line.long 0 "CSR28"
hexfld.long 0 " W28 "
;tree.end

base ad:0xa03c2174
;tree "1CSR29"
group 0--3
line.long 0 "CSR29"
hexfld.long 0 " W29 "
;tree.end

base ad:0xa03c2178
;tree "1CSR30"
group 0--3
line.long 0 "CSR30"
hexfld.long 0 " W30 "
;tree.end

base ad:0xa03c217c
;tree "1CSR31"
group 0--3
line.long 0 "CSR31"
hexfld.long 0 " W31 "
;tree.end

base ad:0xa03c2180
;tree "1CSR32"
group 0--3
line.long 0 "CSR32"
hexfld.long 0 " W32 "
;tree.end

base ad:0xa03c2184
;tree "1CSR33"
group 0--3
line.long 0 "CSR33"
hexfld.long 0 " W33 "
;tree.end

base ad:0xa03c2188
;tree "1CSR34"
group 0--3
line.long 0 "CSR34"
hexfld.long 0 " W34 "
;tree.end

base ad:0xa03c218c
;tree "1CSR35"
group 0--3
line.long 0 "CSR35"
hexfld.long 0 " W35 "
;tree.end

base ad:0xa03c2190
;tree "1CSR36"
group 0--3
line.long 0 "CSR36"
hexfld.long 0 " W36 "
;tree.end

base ad:0xa03c2194
;tree "1CSR37"
group 0--3
line.long 0 "CSR37"
hexfld.long 0 " W37 "
;tree.end

base ad:0xa03c2198
;tree "1CSR38"
group 0--3
line.long 0 "CSR38"
hexfld.long 0 " W38 "
;tree.end

base ad:0xa03c219c
;tree "1CSR39"
group 0--3
line.long 0 "CSR39"
hexfld.long 0 " W39 "
;tree.end

base ad:0xa03c21a0
;tree "1CSR40"
group 0--3
line.long 0 "CSR40"
hexfld.long 0 " W40 "
;tree.end

base ad:0xa03c21a4
;tree "1CSR41"
group 0--3
line.long 0 "CSR41"
hexfld.long 0 " W41 "
;tree.end

base ad:0xa03c21a8
;tree "1CSR42"
group 0--3
line.long 0 "CSR42"
hexfld.long 0 " W42 "
;tree.end

base ad:0xa03c21ac
;tree "1CSR43"
group 0--3
line.long 0 "CSR43"
hexfld.long 0 " W43 "
;tree.end

base ad:0xa03c21b0
;tree "1CSR44"
group 0--3
line.long 0 "CSR44"
hexfld.long 0 " W44 "
;tree.end

base ad:0xa03c21b4
;tree "1CSR45"
group 0--3
line.long 0 "CSR45"
hexfld.long 0 " W45 "
;tree.end

base ad:0xa03c21b8
;tree "1CSR46"
group 0--3
line.long 0 "CSR46"
hexfld.long 0 " W46 "
;tree.end

base ad:0xa03c21bc
;tree "1CSR47"
group 0--3
line.long 0 "CSR47"
hexfld.long 0 " W47 "
;tree.end

base ad:0xa03c21c0
;tree "1CSR48"
group 0--3
line.long 0 "CSR48"
hexfld.long 0 " W48 "
;tree.end

base ad:0xa03c21c4
;tree "1CSR49"
group 0--3
line.long 0 "CSR49"
hexfld.long 0 " W49 "
;tree.end

base ad:0xa03c21c8
;tree "1CSR50"
group 0--3
line.long 0 "CSR50"
hexfld.long 0 " W50 "
;tree.end

base ad:0xa03c21cc
;tree "1CSR51"
group 0--3
line.long 0 "CSR51"
hexfld.long 0 " W51 "
;tree.end

base ad:0xa03c20f8
;tree "1CSFULL"
group 0--3
line.long 0 "CSFULL"
hexfld.long 0 " W40 "
;tree.end

base ad:0xa03c20fc
;tree "1CSDATAIN"
group 0--3
line.long 0 "CSDATAIN"
hexfld.long 0 " W41 "
;tree.end

base ad:0xa03c2080
;tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0xa03c2084
;tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR "  "0 ,1 "
bitfld.long 0 1. " DMATC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
;tree.end

base ad:0xa03c2088
;tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMABREQ "  "0 ,1 "
;tree.end

base ad:0xa03c2fe0
;tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03c2fe4
;tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c2fe8
;tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c2fec
;tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03c2ff0
;tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

base ad:0xa03c2ff4
;tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

base ad:0xa03c2ff8
;tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

base ad:0xa03c2ffc
;tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "HSEM"
;==============================================================
base ad:0x80140000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PROT2 "  "0 ,1 "
;tree.end

base ad:0x80140008
;tree "R0"
group 0--3
line.long 0 "R0"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014000c
;tree "R1"
group 0--3
line.long 0 "R1"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140010
;tree "R2"
group 0--3
line.long 0 "R2"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140014
;tree "R3"
group 0--3
line.long 0 "R3"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140018
;tree "R4"
group 0--3
line.long 0 "R4"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014001c
;tree "R5"
group 0--3
line.long 0 "R5"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140020
;tree "R6"
group 0--3
line.long 0 "R6"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140024
;tree "R7"
group 0--3
line.long 0 "R7"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140028
;tree "R8"
group 0--3
line.long 0 "R8"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014002c
;tree "R9"
group 0--3
line.long 0 "R9"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140030
;tree "R10"
group 0--3
line.long 0 "R10"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140034
;tree "R11"
group 0--3
line.long 0 "R11"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140038
;tree "R12"
group 0--3
line.long 0 "R12"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014003c
;tree "R13"
group 0--3
line.long 0 "R13"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140040
;tree "R14"
group 0--3
line.long 0 "R14"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140044
;tree "R15"
group 0--3
line.long 0 "R15"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140048
;tree "R16"
group 0--3
line.long 0 "R16"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014004c
;tree "R17"
group 0--3
line.long 0 "R17"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140050
;tree "R18"
group 0--3
line.long 0 "R18"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140054
;tree "R19"
group 0--3
line.long 0 "R19"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140058
;tree "R20"
group 0--3
line.long 0 "R20"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014005c
;tree "R21"
group 0--3
line.long 0 "R21"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140060
;tree "R22"
group 0--3
line.long 0 "R22"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140064
;tree "R23"
group 0--3
line.long 0 "R23"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140068
;tree "R24"
group 0--3
line.long 0 "R24"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014006c
;tree "R25"
group 0--3
line.long 0 "R25"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140070
;tree "R26"
group 0--3
line.long 0 "R26"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140074
;tree "R27"
group 0--3
line.long 0 "R27"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140078
;tree "R28"
group 0--3
line.long 0 "R28"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014007c
;tree "R29"
group 0--3
line.long 0 "R29"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140080
;tree "R30"
group 0--3
line.long 0 "R30"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140084
;tree "R31"
group 0--3
line.long 0 "R31"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140090
;tree "ICRALL"
wgroup 0--3
line.long 0 "ICRALL"
bitfld.long 0 0. " HSEMICALL0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICALL1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICALL2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICALL3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICALL4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICALL5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICALL6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICALL7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICALL8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICALL9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICALL10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICALL11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICALL12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICALL13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICALL14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICALL15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICALL16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICALL17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICALL18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICALL19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICALL20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICALL21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICALL22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICALL23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICALL24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICALL25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICALL26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICALL27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICALL28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICALL29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICALL30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICALL31 "  "0 ,1 "
;tree.end

base ad:0x801400a0
;tree "IMSCA"
group 0--3
line.long 0 "IMSCA"
bitfld.long 0 0. " HSEMIMA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMA31 "  "0 ,1 "
;tree.end

base ad:0x801400a4
;tree "RISA"
rgroup 0--3
line.long 0 "RISA"
bitfld.long 0 0. " HSEMRISA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISA31 "  "0 ,1 "
;tree.end

base ad:0x801400a8
;tree "MISA"
rgroup 0--3
line.long 0 "MISA"
bitfld.long 0 0. " HSEMMISA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISA31 "  "0 ,1 "
;tree.end

base ad:0x801400ac
;tree "ICRA"
wgroup 0--3
line.long 0 "ICRA"
bitfld.long 0 0. " HSEMICA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICA31 "  "0 ,1 "
;tree.end

base ad:0x801400b0
;tree "IMSCB"
group 0--3
line.long 0 "IMSCB"
bitfld.long 0 0. " HSEMIMB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMB31 "  "0 ,1 "
;tree.end

base ad:0x801400b4
;tree "RISB"
rgroup 0--3
line.long 0 "RISB"
bitfld.long 0 0. " HSEMRISB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISB31 "  "0 ,1 "
;tree.end

base ad:0x801400b8
;tree "MISB"
rgroup 0--3
line.long 0 "MISB"
bitfld.long 0 0. " HSEMMISB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISB31 "  "0 ,1 "
;tree.end

base ad:0x801400bc
;tree "ICRB"
wgroup 0--3
line.long 0 "ICRB"
bitfld.long 0 0. " HSEMICB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICB31 "  "0 ,1 "
;tree.end

base ad:0x801400c0
;tree "IMSCC"
group 0--3
line.long 0 "IMSCC"
bitfld.long 0 0. " HSEMIMC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMC31 "  "0 ,1 "
;tree.end

base ad:0x801400c4
;tree "RISC"
rgroup 0--3
line.long 0 "RISC"
bitfld.long 0 0. " HSEMRISC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISC31 "  "0 ,1 "
;tree.end

base ad:0x801400c8
;tree "MISC"
rgroup 0--3
line.long 0 "MISC"
bitfld.long 0 0. " HSEMMISC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISC31 "  "0 ,1 "
;tree.end

base ad:0x801400cc
;tree "ICRC"
wgroup 0--3
line.long 0 "ICRC"
bitfld.long 0 0. " HSEMICC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICC31 "  "0 ,1 "
;tree.end

base ad:0x801400d0
;tree "IMSCD"
group 0--3
line.long 0 "IMSCD"
bitfld.long 0 0. " HSEMIMD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMD31 "  "0 ,1 "
;tree.end

base ad:0x801400d4
;tree "RISD"
rgroup 0--3
line.long 0 "RISD"
bitfld.long 0 0. " HSEMRISD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISD31 "  "0 ,1 "
;tree.end

base ad:0x801400d8
;tree "MISD"
rgroup 0--3
line.long 0 "MISD"
bitfld.long 0 0. " HSEMMISD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISD31 "  "0 ,1 "
;tree.end

base ad:0x801400dc
;tree "ICRD"
wgroup 0--3
line.long 0 "ICRD"
bitfld.long 0 0. " HSEMICD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMID20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICD31 "  "0 ,1 "
;tree.end

base ad:0x801400e0
;tree "IMSCE"
group 0--3
line.long 0 "IMSCE"
bitfld.long 0 0. " HSEMIME0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIME1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIME2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIME3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIME4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIME5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIME6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIME7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIME8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIME9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIME10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIME11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIME12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIME13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIME14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIME15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIME16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIME17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIME18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIME19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIME20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIME21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIME22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIME23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIME24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIME25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIME26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIME27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIME28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIME29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIME30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIME31 "  "0 ,1 "
;tree.end

base ad:0x801400e4
;tree "RISE"
rgroup 0--3
line.long 0 "RISE"
bitfld.long 0 0. " HSEMRISE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISE31 "  "0 ,1 "
;tree.end

base ad:0x801400e8
;tree "MISE"
rgroup 0--3
line.long 0 "MISE"
bitfld.long 0 0. " HSEMMISE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISE31 "  "0 ,1 "
;tree.end

base ad:0x801400ec
;tree "ICRE"
wgroup 0--3
line.long 0 "ICRE"
bitfld.long 0 0. " HSEMICE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICE31 "  "0 ,1 "
;tree.end

base ad:0x80140100
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80140108
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " HSEMINTRA "  "0 ,1 "
bitfld.long 0 1. " HSEMINTRB "  "0 ,1 "
bitfld.long 0 2. " HSEMINTRC "  "0 ,1 "
bitfld.long 0 3. " HSEMINTRD "  "0 ,1 "
bitfld.long 0 4. " HSEMINTRE "  "0 ,1 "
;tree.end

base ad:0x80140fe0
;tree "HSEMPeriphID0"
rgroup 0--3
line.long 0 "HSEMPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80140fe4
;tree "HSEMPeriphID1"
rgroup 0--3
line.long 0 "HSEMPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80140fe8
;tree "HSEMPeriphID2"
rgroup 0--3
line.long 0 "HSEMPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80140fec
;tree "HSEMPeriphID3"
rgroup 0--3
line.long 0 "HSEMPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80140ff0
;tree "HSEMPCellID0"
rgroup 0--3
line.long 0 "HSEMPCellID0"
hexfld.byte 0 " HSEMPCellID0 "
;tree.end

base ad:0x80140ff4
;tree "HSEMPCellID1"
rgroup 0--3
line.long 0 "HSEMPCellID1"
hexfld.byte 0 " HSEMPCellID1 "
;tree.end

base ad:0x80140ff8
;tree "HSEMPCellID2"
rgroup 0--3
line.long 0 "HSEMPCellID2"
hexfld.byte 0 " HSEMPCellID2 "
;tree.end

base ad:0x80140ffc
;tree "HSEMPCellID3"
rgroup 0--3
line.long 0 "HSEMPCellID3"
hexfld.byte 0 " HSEMPCellID3 "
;tree.end

tree.end

;==============================================================
tree "HSI2C (5 instances)"
;==============================================================
base ad:0x80122000
;********************************************
tree "HSI2C-1"
;********************************************
base ad:0x80122000
;tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80122004
;tree "1SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 0 " SLSU "
;tree.end

base ad:0x80122008
;tree "1HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8012200c
;tree "1MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

base ad:0x80122010
;tree "1TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

base ad:0x80122014
;tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

base ad:0x80122018
;tree "1RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

base ad:0x8012201c
;tree "1TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80122020
;tree "1RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80122024
;tree "1DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

base ad:0x80122028
;tree "1BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 0 " BRCNT1 "
;tree.end

base ad:0x8012202c
;tree "1IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

base ad:0x80122030
;tree "1RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

base ad:0x80122034
;tree "1MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

base ad:0x80122038
;tree "1ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

base ad:0x8012203c
;tree "1I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

base ad:0x80122040
;tree "1I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

base ad:0x80122044
;tree "1I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

base ad:0x80122048
;tree "1I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

base ad:0x8012204c
;tree "1I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

base ad:0x80122050
;tree "1I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x80122054
;tree "1I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80122058
;tree "1I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x8012205c
;tree "1I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80122fe0
;tree "1PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80122fe4
;tree "1PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80122fe8
;tree "1PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80122fec
;tree "1PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80122ff0
;tree "1PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

base ad:0x80122ff4
;tree "1PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

base ad:0x80122ff8
;tree "1PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

base ad:0x80122ffc
;tree "1PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

base ad:0x80128000
;********************************************
tree "HSI2C-2"
;********************************************
base ad:0x80128000
;tree "2CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80128004
;tree "2SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 0 " SLSU "
;tree.end

base ad:0x80128008
;tree "2HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8012800c
;tree "2MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

base ad:0x80128010
;tree "2TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

base ad:0x80128014
;tree "2SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

base ad:0x80128018
;tree "2RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

base ad:0x8012801c
;tree "2TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80128020
;tree "2RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80128024
;tree "2DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

base ad:0x80128028
;tree "2BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 0 " BRCNT1 "
;tree.end

base ad:0x8012802c
;tree "2IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

base ad:0x80128030
;tree "2RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

base ad:0x80128034
;tree "2MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

base ad:0x80128038
;tree "2ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

base ad:0x8012803c
;tree "2I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

base ad:0x80128040
;tree "2I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

base ad:0x80128044
;tree "2I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

base ad:0x80128048
;tree "2I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

base ad:0x8012804c
;tree "2I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

base ad:0x80128050
;tree "2I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x80128054
;tree "2I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80128058
;tree "2I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x8012805c
;tree "2I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80128fe0
;tree "2PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80128fe4
;tree "2PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80128fe8
;tree "2PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80128fec
;tree "2PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80128ff0
;tree "2PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

base ad:0x80128ff4
;tree "2PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

base ad:0x80128ff8
;tree "2PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

base ad:0x80128ffc
;tree "2PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

base ad:0x80110000
;********************************************
tree "HSI2C-3"
;********************************************
base ad:0x80110000
;tree "3CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80110004
;tree "3SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 0 " SLSU "
;tree.end

base ad:0x80110008
;tree "3HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8011000c
;tree "3MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

base ad:0x80110010
;tree "3TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

base ad:0x80110014
;tree "3SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

base ad:0x80110018
;tree "3RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

base ad:0x8011001c
;tree "3TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80110020
;tree "3RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80110024
;tree "3DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

base ad:0x80110028
;tree "3BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 0 " BRCNT1 "
;tree.end

base ad:0x8011002c
;tree "3IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

base ad:0x80110030
;tree "3RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

base ad:0x80110034
;tree "3MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

base ad:0x80110038
;tree "3ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

base ad:0x8011003c
;tree "3I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

base ad:0x80110040
;tree "3I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

base ad:0x80110044
;tree "3I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

base ad:0x80110048
;tree "3I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

base ad:0x8011004c
;tree "3I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

base ad:0x80110050
;tree "3I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x80110054
;tree "3I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80110058
;tree "3I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x8011005c
;tree "3I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80110fe0
;tree "3PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80110fe4
;tree "3PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80110fe8
;tree "3PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80110fec
;tree "3PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80110ff0
;tree "3PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

base ad:0x80110ff4
;tree "3PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

base ad:0x80110ff8
;tree "3PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

base ad:0x80110ffc
;tree "3PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

base ad:0x80004000
;********************************************
tree "HSI2C-0"
;********************************************
base ad:0x80004000
;tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80004004
;tree "0SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 0 " SLSU "
;tree.end

base ad:0x80004008
;tree "0HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8000400c
;tree "0MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

base ad:0x80004010
;tree "0TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

base ad:0x80004014
;tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

base ad:0x80004018
;tree "0RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

base ad:0x8000401c
;tree "0TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80004020
;tree "0RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80004024
;tree "0DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

base ad:0x80004028
;tree "0BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 0 " BRCNT1 "
;tree.end

base ad:0x8000402c
;tree "0IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

base ad:0x80004030
;tree "0RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

base ad:0x80004034
;tree "0MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

base ad:0x80004038
;tree "0ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

base ad:0x8000403c
;tree "0I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

base ad:0x80004040
;tree "0I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

base ad:0x80004044
;tree "0I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

base ad:0x80004048
;tree "0I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

base ad:0x8000404c
;tree "0I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

base ad:0x80004050
;tree "0I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x80004054
;tree "0I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80004058
;tree "0I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x8000405c
;tree "0I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80004fe0
;tree "0PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80004fe4
;tree "0PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80004fe8
;tree "0PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80004fec
;tree "0PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80004ff0
;tree "0PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

base ad:0x80004ff4
;tree "0PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

base ad:0x80004ff8
;tree "0PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

base ad:0x80004ffc
;tree "0PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

base ad:0xb7e02000
;********************************************
tree "HSI2C-MODEM"
;********************************************
base ad:0xb7e02000
;tree "MODEMCR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7e02004
;tree "MODEMSCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 0 " SLSU "
;tree.end

base ad:0xb7e02008
;tree "MODEMHSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xb7e0200c
;tree "MODEMMCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

base ad:0xb7e02010
;tree "MODEMTFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

base ad:0xb7e02014
;tree "MODEMSR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

base ad:0xb7e02018
;tree "MODEMRFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

base ad:0xb7e0201c
;tree "MODEMTFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7e02020
;tree "MODEMRFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7e02024
;tree "MODEMDMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

base ad:0xb7e02028
;tree "MODEMBRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 0 " BRCNT1 "
;tree.end

base ad:0xb7e0202c
;tree "MODEMIMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

base ad:0xb7e02030
;tree "MODEMRISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

base ad:0xb7e02034
;tree "MODEMMISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

base ad:0xb7e02038
;tree "MODEMICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

base ad:0xb7e0203c
;tree "MODEMI2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

base ad:0xb7e02040
;tree "MODEMI2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

base ad:0xb7e02044
;tree "MODEMI2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

base ad:0xb7e02048
;tree "MODEMI2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

base ad:0xb7e0204c
;tree "MODEMI2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

base ad:0xb7e02050
;tree "MODEMI2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0xb7e02054
;tree "MODEMI2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0xb7e02058
;tree "MODEMI2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0xb7e0205c
;tree "MODEMI2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0xb7e02fe0
;tree "MODEMPERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0xb7e02fe4
;tree "MODEMPERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7e02fe8
;tree "MODEMPERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7e02fec
;tree "MODEMPERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xb7e02ff0
;tree "MODEMPCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

base ad:0xb7e02ff4
;tree "MODEMPCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

base ad:0xb7e02ff8
;tree "MODEMPCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

base ad:0xb7e02ffc
;tree "MODEMPCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "HSIR"
;==============================================================

base ad:0x80002008
sgroup ""
constx 0 %l 0x00c20000
setx 0x0 %l 0
line.long 0 ""

if (data.long(ad:0x80002008)!=0x00c20000)

base ad:0x80002008
;tree "0DR"
group 0--3
line.long 0 "DR"
;tree.end

else

base ad:0x8011b000
;tree "ID"
group 0--3
line.long 0 "ID"
hexfld.long 0 " ID "
;tree.end

bitfld.long 0 2. " FAILSAFE "  "0 ,1 "
bitfld.long 0 0.--1. " PIPELINED "  "0 ,1 ,2 ,3 "
bitfld.long 0 1. " FRAME "  "0 ,1 "
bitfld.long 0 0. " STREAM "  "0 ,1 "
base ad:0x8011b004
;tree "MODE"
group 0--3
line.long 0 "MODE"
bitfld.long 0 0.--2. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

bitfld.long 0 0.--1. " SYNC "  "0 ,1 ,2 ,3 "
bitfld.long 0 1. " FLUSH "  "0 ,1 "
bitfld.long 0 0. " RECEIVING "  "0 ,1 "
base ad:0x8011b008
;tree "RXSTATE"
group 0--3
line.long 0 "RXSTATE"
bitfld.long 0 0.--1. " RXSTATE "  "0 ,1 ,2 ,3 "
;tree.end

bitfld.long 0 0. " NOTEMPTY "  "0 ,1 "
base ad:0x8011b00c
;tree "BUFSTATE"
group 0--3
line.long 0 "BUFSTATE"
bitfld.long 0 0. " BUFSTATE0 "  "0 ,1 "
bitfld.long 0 1. " BUFSTATE1 "  "0 ,1 "
bitfld.long 0 2. " BUFSTATE2 "  "0 ,1 "
bitfld.long 0 3. " BUFSTATE3 "  "0 ,1 "
bitfld.long 0 4. " BUFSTATE4 "  "0 ,1 "
bitfld.long 0 5. " BUFSTATE5 "  "0 ,1 "
bitfld.long 0 6. " BUFSTATE6 "  "0 ,1 "
bitfld.long 0 7. " BUFSTATE7 "  "0 ,1 "
;tree.end

base ad:0x8011b010
;tree "THRESHOLD"
group 0--3
line.long 0 "THRESHOLD"
bitfld.long 0 0.--5. " THRESHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

bitfld.long 0 1. " EVEN "  "0 ,1 "
bitfld.long 0 0. " ODD "  "0 ,1 "
base ad:0x8011b014
;tree "PARITY"
group 0--3
line.long 0 "PARITY"
bitfld.long 0 0.--1. " PARITY "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8011b018
;tree "DETECTOR"
group 0--3
line.long 0 "DETECTOR"
bitfld.long 0 0. " DETECTOR "  "0 ,1 "
;tree.end

base ad:0x8011b01c
;tree "EXCEPTION"
group 0--3
line.long 0 "EXCEPTION"
bitfld.long 0 0. " TIMEOUT "  "0 ,1 "
bitfld.long 0 1. " OVERRUN "  "0 ,1 "
bitfld.long 0 2. " BREAK "  "0 ,1 "
bitfld.long 0 3. " PARITY "  "0 ,1 "
;tree.end

base ad:0x8011b020
;tree "ACKNOWLEDGE"
wgroup 0--3
line.long 0 "ACKNOWLEDGE"
bitfld.long 0 0. " ACKTIMEOUT "  "0 ,1 "
bitfld.long 0 1. " ACKOVERRUN "  "0 ,1 "
bitfld.long 0 2. " ACKBREAK "  "0 ,1 "
bitfld.long 0 3. " ACKPARITY "  "0 ,1 "
;tree.end

base ad:0x8011b024
;tree "CHANNELS"
group 0--3
line.long 0 "CHANNELS"
bitfld.long 0 0.--3. " CHANNELS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011b028
;tree "REALTIME"
group 0--3
line.long 0 "REALTIME"
bitfld.long 0 0. " REALTIME0 "  "0 ,1 "
bitfld.long 0 1. " REALTIME1 "  "0 ,1 "
bitfld.long 0 2. " REALTIME2 "  "0 ,1 "
bitfld.long 0 3. " REALTIME3 "  "0 ,1 "
bitfld.long 0 4. " REALTIME4 "  "0 ,1 "
bitfld.long 0 5. " REALTIME5 "  "0 ,1 "
bitfld.long 0 6. " REALTIME6 "  "0 ,1 "
bitfld.long 0 7. " REALTIME7 "  "0 ,1 "
;tree.end

base ad:0x8011b02c
;tree "OVERRUN"
group 0--3
line.long 0 "OVERRUN"
bitfld.long 0 0. " OVERRUN0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUN1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUN2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUN3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUN4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUN5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUN6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUN7 "  "0 ,1 "
;tree.end

base ad:0x8011b030
;tree "OVERRUNACK"
rgroup 0--3
line.long 0 "OVERRUNACK"
bitfld.long 0 0. " OVERRUNACK0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUNACK1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUNACK2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUNACK3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUNACK4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUNACK5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUNACK6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUNACK7 "  "0 ,1 "
;tree.end

base ad:0x8011b034
;tree "PREAMBLE"
group 0--3
line.long 0 "PREAMBLE"
bitfld.long 0 0.--23. " PREAMBLE "  " "
;tree.end

base ad:0x8011b038
;tree "PIPEGAUGE"
group 0--3
line.long 0 "PIPEGAUGE"
bitfld.long 0 0.--1. " PIPEGAUGE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8011b03c
;tree "TIMEOUT"
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0.--23. " TIMEOUT "  " "
;tree.end

base ad:0x8011b080
;tree "BUFFER0"
group 0--3
line.long 0 "BUFFER0"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b084
;tree "BUFFER1"
group 0--3
line.long 0 "BUFFER1"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b088
;tree "BUFFER2"
group 0--3
line.long 0 "BUFFER2"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b08c
;tree "BUFFER3"
group 0--3
line.long 0 "BUFFER3"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b090
;tree "BUFFER4"
group 0--3
line.long 0 "BUFFER4"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b094
;tree "BUFFER5"
group 0--3
line.long 0 "BUFFER5"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b098
;tree "BUFFER6"
group 0--3
line.long 0 "BUFFER6"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b09c
;tree "BUFFER7"
group 0--3
line.long 0 "BUFFER7"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b0c0
;tree "FRAMELEN0"
group 0--3
line.long 0 "FRAMELEN0"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0c4
;tree "FRAMELEN1"
group 0--3
line.long 0 "FRAMELEN1"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0c8
;tree "FRAMELEN2"
group 0--3
line.long 0 "FRAMELEN2"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0cc
;tree "FRAMELEN3"
group 0--3
line.long 0 "FRAMELEN3"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0d0
;tree "FRAMELEN4"
group 0--3
line.long 0 "FRAMELEN4"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0d4
;tree "FRAMELEN5"
group 0--3
line.long 0 "FRAMELEN5"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0d8
;tree "FRAMELEN6"
group 0--3
line.long 0 "FRAMELEN6"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0dc
;tree "FRAMELEN7"
group 0--3
line.long 0 "FRAMELEN7"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b100
;tree "BASE0"
group 0--3
line.long 0 "BASE0"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b104
;tree "BASE1"
group 0--3
line.long 0 "BASE1"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b108
;tree "BASE2"
group 0--3
line.long 0 "BASE2"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b10c
;tree "BASE3"
group 0--3
line.long 0 "BASE3"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b110
;tree "BASE4"
group 0--3
line.long 0 "BASE4"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b114
;tree "BASE5"
group 0--3
line.long 0 "BASE5"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b118
;tree "BASE6"
group 0--3
line.long 0 "BASE6"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b11c
;tree "BASE7"
group 0--3
line.long 0 "BASE7"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b140
;tree "SPAN0"
group 0--3
line.long 0 "SPAN0"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b144
;tree "SPAN1"
group 0--3
line.long 0 "SPAN1"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b148
;tree "SPAN2"
group 0--3
line.long 0 "SPAN2"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b14c
;tree "SPAN3"
group 0--3
line.long 0 "SPAN3"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b150
;tree "SPAN4"
group 0--3
line.long 0 "SPAN4"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b154
;tree "SPAN5"
group 0--3
line.long 0 "SPAN5"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b158
;tree "SPAN6"
group 0--3
line.long 0 "SPAN6"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b15c
;tree "SPAN7"
group 0--3
line.long 0 "SPAN7"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b180
;tree "GAUGE0"
group 0--3
line.long 0 "GAUGE0"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b184
;tree "GAUGE1"
group 0--3
line.long 0 "GAUGE1"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b188
;tree "GAUGE2"
group 0--3
line.long 0 "GAUGE2"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b18c
;tree "GAUGE3"
group 0--3
line.long 0 "GAUGE3"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b190
;tree "GAUGE4"
group 0--3
line.long 0 "GAUGE4"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b194
;tree "GAUGE5"
group 0--3
line.long 0 "GAUGE5"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b198
;tree "GAUGE6"
group 0--3
line.long 0 "GAUGE6"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b19c
;tree "GAUGE7"
group 0--3
line.long 0 "GAUGE7"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1c0
;tree "WATERMARK0"
group 0--3
line.long 0 "WATERMARK0"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1c4
;tree "WATERMARK1"
group 0--3
line.long 0 "WATERMARK1"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1c8
;tree "WATERMARK2"
group 0--3
line.long 0 "WATERMARK2"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1cc
;tree "WATERMARK3"
group 0--3
line.long 0 "WATERMARK3"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1d0
;tree "WATERMARK4"
group 0--3
line.long 0 "WATERMARK4"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1d4
;tree "WATERMARK5"
group 0--3
line.long 0 "WATERMARK5"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1d8
;tree "WATERMARK6"
group 0--3
line.long 0 "WATERMARK6"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1dc
;tree "WATERMARK7"
group 0--3
line.long 0 "WATERMARK7"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b200
;tree "DMAEN"
group 0--3
line.long 0 "DMAEN"
bitfld.long 0 0. " DMAEN0 "  "0 ,1 "
bitfld.long 0 1. " DMAEN1 "  "0 ,1 "
bitfld.long 0 2. " DMAEN2 "  "0 ,1 "
bitfld.long 0 3. " DMAEN3 "  "0 ,1 "
bitfld.long 0 4. " DMAEN4 "  "0 ,1 "
bitfld.long 0 5. " DMAEN5 "  "0 ,1 "
bitfld.long 0 6. " DMAEN6 "  "0 ,1 "
bitfld.long 0 7. " DMAEN7 "  "0 ,1 "
;tree.end

base ad:0x8011b204
;tree "WMARKMIS"
rgroup 0--3
line.long 0 "WMARKMIS"
bitfld.long 0 0. " WATERMIS0 "  "0 ,1 "
bitfld.long 0 1. " WATERMIS1 "  "0 ,1 "
bitfld.long 0 2. " WATERMIS2 "  "0 ,1 "
bitfld.long 0 3. " WATERMIS3 "  "0 ,1 "
bitfld.long 0 4. " WATERMIS4 "  "0 ,1 "
bitfld.long 0 5. " WATERMIS5 "  "0 ,1 "
bitfld.long 0 6. " WATERMIS6 "  "0 ,1 "
bitfld.long 0 7. " WATERMIS7 "  "0 ,1 "
;tree.end

base ad:0x8011b208
;tree "WMARKIM"
group 0--3
line.long 0 "WMARKIM"
bitfld.long 0 0. " WMARKIM0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIM1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIM2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIM3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIM4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIM5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIM6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIM7 "  "0 ,1 "
;tree.end

base ad:0x8011b20c
;tree "WMARKIC"
wgroup 0--3
line.long 0 "WMARKIC"
bitfld.long 0 0. " WMARKIC0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIC1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIC2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIC3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIC4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIC5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIC6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIC7 "  "0 ,1 "
;tree.end

base ad:0x8011b210
;tree "WMARKID"
group 0--3
line.long 0 "WMARKID"
bitfld.long 0 0. " WMARKID0 "  "0 ,1 "
bitfld.long 0 1. " WMARKID1 "  "0 ,1 "
bitfld.long 0 2. " WMARKID2 "  "0 ,1 "
bitfld.long 0 3. " WMARKID3 "  "0 ,1 "
bitfld.long 0 4. " WMARKID4 "  "0 ,1 "
bitfld.long 0 5. " WMARKID5 "  "0 ,1 "
bitfld.long 0 6. " WMARKID6 "  "0 ,1 "
bitfld.long 0 7. " WMARKID7 "  "0 ,1 "
;tree.end

base ad:0x8011b214
;tree "OVERRUNMIS"
rgroup 0--3
line.long 0 "OVERRUNMIS"
bitfld.long 0 0. " OVERRUNMIS0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUNMIS1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUNMIS2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUNMIS3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUNMIS4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUNMIS5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUNMIS6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUNMIS7 "  "0 ,1 "
;tree.end

base ad:0x8011b218
;tree "OVERRUNIM"
group 0--3
line.long 0 "OVERRUNIM"
bitfld.long 0 0. " OVERRUNIM0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUNIM1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUNIM2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUNIM3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUNIM4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUNIM5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUNIM6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUNIM7 "  "0 ,1 "
;tree.end

base ad:0x8011b21c
;tree "EXCEPMIS"
rgroup 0--3
line.long 0 "EXCEPMIS"
bitfld.long 0 0. " TIMEOUTMIS "  "0 ,1 "
bitfld.long 0 1. " OVERRUNMIS "  "0 ,1 "
bitfld.long 0 2. " BREAKMIS "  "0 ,1 "
bitfld.long 0 3. " PARITYMIS "  "0 ,1 "
;tree.end

base ad:0x8011b220
;tree "EXCEPIM"
group 0--3
line.long 0 "EXCEPIM"
bitfld.long 0 0. " TIMEOUTIM "  "0 ,1 "
bitfld.long 0 1. " OVERRUNIM "  "0 ,1 "
bitfld.long 0 2. " BREAKIM "  "0 ,1 "
bitfld.long 0 3. " PARITYIM "  "0 ,1 "
;tree.end

base ad:0x8011bd00
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8011bd04
;tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR0 "  "0 ,1 "
bitfld.long 0 1. " DMACLR1 "  "0 ,1 "
bitfld.long 0 2. " DMACLR2 "  "0 ,1 "
bitfld.long 0 3. " DMACLR3 "  "0 ,1 "
bitfld.long 0 4. " DMACLR4 "  "0 ,1 "
bitfld.long 0 5. " DMACLR5 "  "0 ,1 "
bitfld.long 0 6. " DMACLR6 "  "0 ,1 "
bitfld.long 0 7. " DMACLR7 "  "0 ,1 "
bitfld.long 0 16. " DATA "  "0 ,1 "
bitfld.long 0 17. " FLAG "  "0 ,1 "
;tree.end

base ad:0x8011bd08
;tree "ITOP1"
group 0--3
line.long 0 "ITOP1"
hexfld.byte 0 " DMABREQ "
hexfld.byte 2 " DMASREQ "
;tree.end

base ad:0x8011bd0c
;tree "ITOP2"
group 0--3
line.long 0 "ITOP2"
bitfld.long 0 0. " WMARKD0INT "  "0 ,1 "
bitfld.long 0 1. " WMARKD1INT "  "0 ,1 "
bitfld.long 0 2. " EXCEPINT "  "0 ,1 "
bitfld.long 0 16. " READY "  "0 ,1 "
;tree.end

base ad:0x8011bd10
;tree "ITOP3"
group 0--3
line.long 0 "ITOP3"
hexfld.byte 0 " OVERRUNINT "
;tree.end

base ad:0x8011bfe0
;tree "PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " PARTMUMBER0 "
;tree.end

base ad:0x8011bfe4
;tree "PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " PARTNUMBER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " DESIGNER0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011bfe8
;tree "PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " DESIGNER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " REVISION "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011bfec
;tree "PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " CONFIGURATION "
;tree.end

base ad:0x8011bff0
;tree "PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " PCELLID0 "
;tree.end

base ad:0x8011bff4
;tree "PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " PCELLID1 "
;tree.end

base ad:0x8011bff8
;tree "PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " PCELLID2 "
;tree.end

base ad:0x8011bffc
;tree "PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " PCELLID3 "
;tree.end

endif

tree.end

;==============================================================
tree "HSIT"
;==============================================================

base ad:0x80002008
sgroup ""
constx 0 %l 0x00c20000
setx 0x0 %l 0
line.long 0 ""

if (data.long(ad:0x80002008)!=0x00c20000)

base ad:0x80002008
;tree "0DR"
group 0--3
line.long 0 "DR"
;tree.end

else

base ad:0x8011c000
;tree "ID"
group 0--3
line.long 0 "ID"
hexfld.long 0 " ID "
;tree.end

bitfld.long 0 1. " FRAME "  "0 ,1 "
bitfld.long 0 0. " STREAM "  "0 ,1 "
base ad:0x8011c004
;tree "MODE"
group 0--3
line.long 0 "MODE"
bitfld.long 0 0.--1. " MODE "  "0 ,1 ,2 ,3 "
;tree.end

bitfld.long 0 0.--2. " HALT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 2. " FLUSH "  "0 ,1 "
bitfld.long 0 0.--2. " BREAK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 1. " TRANSMIT "  "0 ,1 "
bitfld.long 0 0. " START "  "0 ,1 "
base ad:0x8011c008
;tree "TXSTATE"
group 0--3
line.long 0 "TXSTATE"
bitfld.long 0 0.--2. " TXSTATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

bitfld.long 0 2. " READY "  "0 ,1 "
bitfld.long 0 1. " FLAG "  "0 ,1 "
bitfld.long 0 0. " DATA "  "0 ,1 "
base ad:0x8011c00c
;tree "IOSTATE"
group 0--3
line.long 0 "IOSTATE"
bitfld.long 0 0. " DSTATE "  "0 ,1 "
bitfld.long 0 1. " FSTATE "  "0 ,1 "
bitfld.long 0 2. " RSTATE "  "0 ,1 "
;tree.end

bitfld.long 0 0. " FULL "  "0 ,1 "
base ad:0x8011c010
;tree "BUFSTATE"
group 0--3
line.long 0 "BUFSTATE"
bitfld.long 0 0. " BUFSTATE0 "  "0 ,1 "
bitfld.long 0 1. " BUFSTATE1 "  "0 ,1 "
bitfld.long 0 2. " BUFSTATE2 "  "0 ,1 "
bitfld.long 0 3. " BUFSTATE3 "  "0 ,1 "
bitfld.long 0 4. " BUFSTATE4 "  "0 ,1 "
bitfld.long 0 5. " BUFSTATE5 "  "0 ,1 "
bitfld.long 0 6. " BUFSTATE6 "  "0 ,1 "
bitfld.long 0 7. " BUFSTATE7 "  "0 ,1 "
;tree.end

base ad:0x8011c014
;tree "DIVISOR"
group 0--3
line.long 0 "DIVISOR"
bitfld.long 0 0.--23. " DIVISOR "  " "
;tree.end

bitfld.long 0 1. " EVEN "  "0 ,1 "
bitfld.long 0 0. " ODD "  "0 ,1 "
base ad:0x8011c018
;tree "PARITY"
group 0--3
line.long 0 "PARITY"
bitfld.long 0 0.--1. " PARITY "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8011c01c
;tree "BREAK"
group 0--3
line.long 0 "BREAK"
bitfld.long 0 0. " BREAK "  "0 ,1 "
;tree.end

base ad:0x8011c020
;tree "CHANNELS"
group 0--3
line.long 0 "CHANNELS"
bitfld.long 0 0.--3. " CHANNELS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011c024
;tree "FLUSHBITS"
group 0--3
line.long 0 "FLUSHBITS"
bitfld.long 0 0.--5. " FLUSHBITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8011c028
;tree "PRIORITY"
group 0--3
line.long 0 "PRIORITY"
bitfld.long 0 0. " PRIORITY0 "  "0 ,1 "
bitfld.long 0 1. " PRIORITY1 "  "0 ,1 "
bitfld.long 0 2. " PRIORITY2 "  "0 ,1 "
bitfld.long 0 3. " PRIORITY3 "  "0 ,1 "
bitfld.long 0 4. " PRIORITY4 "  "0 ,1 "
bitfld.long 0 5. " PRIORITY5 "  "0 ,1 "
bitfld.long 0 6. " PRIORITY6 "  "0 ,1 "
bitfld.long 0 7. " PRIORITY7 "  "0 ,1 "
;tree.end

base ad:0x8011c02c
;tree "BURSTLEN"
group 0--3
line.long 0 "BURSTLEN"
bitfld.long 0 0.--23. " BURSTLEN "  " "
;tree.end

base ad:0x8011c030
;tree "PREAMBLE"
group 0--3
line.long 0 "PREAMBLE"
bitfld.long 0 0.--23. " PREAMBLE "  " "
;tree.end

base ad:0x8011c080
;tree "FRAMELEN0"
group 0--3
line.long 0 "FRAMELEN0"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c084
;tree "FRAMELEN1"
group 0--3
line.long 0 "FRAMELEN1"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c088
;tree "FRAMELEN2"
group 0--3
line.long 0 "FRAMELEN2"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c08c
;tree "FRAMELEN3"
group 0--3
line.long 0 "FRAMELEN3"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c090
;tree "FRAMELEN4"
group 0--3
line.long 0 "FRAMELEN4"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c094
;tree "FRAMELEN5"
group 0--3
line.long 0 "FRAMELEN5"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c098
;tree "FRAMELEN6"
group 0--3
line.long 0 "FRAMELEN6"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c09c
;tree "FRAMELEN7"
group 0--3
line.long 0 "FRAMELEN7"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c0c0
;tree "BUFFER0"
group 0--3
line.long 0 "BUFFER0"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0c4
;tree "BUFFER1"
group 0--3
line.long 0 "BUFFER1"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0c8
;tree "BUFFER2"
group 0--3
line.long 0 "BUFFER2"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0cc
;tree "BUFFER3"
group 0--3
line.long 0 "BUFFER3"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0d0
;tree "BUFFER4"
group 0--3
line.long 0 "BUFFER4"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0d4
;tree "BUFFER5"
group 0--3
line.long 0 "BUFFER5"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0d8
;tree "BUFFER6"
group 0--3
line.long 0 "BUFFER6"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0dc
;tree "BUFFER7"
group 0--3
line.long 0 "BUFFER7"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c100
;tree "BASE0"
group 0--3
line.long 0 "BASE0"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c104
;tree "BASE1"
group 0--3
line.long 0 "BASE1"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c108
;tree "BASE2"
group 0--3
line.long 0 "BASE2"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c10c
;tree "BASE3"
group 0--3
line.long 0 "BASE3"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c110
;tree "BASE4"
group 0--3
line.long 0 "BASE4"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c114
;tree "BASE5"
group 0--3
line.long 0 "BASE5"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c118
;tree "BASE6"
group 0--3
line.long 0 "BASE6"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c11c
;tree "BASE7"
group 0--3
line.long 0 "BASE7"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c140
;tree "SPAN0"
group 0--3
line.long 0 "SPAN0"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c144
;tree "SPAN1"
group 0--3
line.long 0 "SPAN1"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c148
;tree "SPAN2"
group 0--3
line.long 0 "SPAN2"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c14c
;tree "SPAN3"
group 0--3
line.long 0 "SPAN3"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c150
;tree "SPAN4"
group 0--3
line.long 0 "SPAN4"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c154
;tree "SPAN5"
group 0--3
line.long 0 "SPAN5"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c158
;tree "SPAN6"
group 0--3
line.long 0 "SPAN6"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c15c
;tree "SPAN7"
group 0--3
line.long 0 "SPAN7"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c180
;tree "GAUGE0"
group 0--3
line.long 0 "GAUGE0"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c184
;tree "GAUGE1"
group 0--3
line.long 0 "GAUGE1"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c188
;tree "GAUGE2"
group 0--3
line.long 0 "GAUGE2"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c18c
;tree "GAUGE3"
group 0--3
line.long 0 "GAUGE3"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c190
;tree "GAUGE4"
group 0--3
line.long 0 "GAUGE4"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c194
;tree "GAUGE5"
group 0--3
line.long 0 "GAUGE5"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c198
;tree "GAUGE6"
group 0--3
line.long 0 "GAUGE6"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c19c
;tree "GAUGE7"
group 0--3
line.long 0 "GAUGE7"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1c0
;tree "WATERMARK0"
group 0--3
line.long 0 "WATERMARK0"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1c4
;tree "WATERMARK1"
group 0--3
line.long 0 "WATERMARK1"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1c8
;tree "WATERMARK2"
group 0--3
line.long 0 "WATERMARK2"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1cc
;tree "WATERMARK3"
group 0--3
line.long 0 "WATERMARK3"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1d0
;tree "WATERMARK4"
group 0--3
line.long 0 "WATERMARK4"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1d4
;tree "WATERMARK5"
group 0--3
line.long 0 "WATERMARK5"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1d8
;tree "WATERMARK6"
group 0--3
line.long 0 "WATERMARK6"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1dc
;tree "WATERMARK7"
group 0--3
line.long 0 "WATERMARK7"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c200
;tree "DMAEN"
group 0--3
line.long 0 "DMAEN"
bitfld.long 0 0. " DMAEN0 "  "0 ,1 "
bitfld.long 0 1. " DMAEN1 "  "0 ,1 "
bitfld.long 0 2. " DMAEN2 "  "0 ,1 "
bitfld.long 0 3. " DMAEN3 "  "0 ,1 "
bitfld.long 0 4. " DMAEN4 "  "0 ,1 "
bitfld.long 0 5. " DMAEN5 "  "0 ,1 "
bitfld.long 0 6. " DMAEN6 "  "0 ,1 "
bitfld.long 0 7. " DMAEN7 "  "0 ,1 "
;tree.end

base ad:0x8011c204
;tree "WMARKMIS"
rgroup 0--3
line.long 0 "WMARKMIS"
bitfld.long 0 0. " WMARKMIS0 "  "0 ,1 "
bitfld.long 0 1. " WMARKMIS1 "  "0 ,1 "
bitfld.long 0 2. " WMARKMIS2 "  "0 ,1 "
bitfld.long 0 3. " WMARKMIS3 "  "0 ,1 "
bitfld.long 0 4. " WMARKMIS4 "  "0 ,1 "
bitfld.long 0 5. " WMARKMIS5 "  "0 ,1 "
bitfld.long 0 6. " WMARKMIS6 "  "0 ,1 "
bitfld.long 0 7. " WMARKMIS7 "  "0 ,1 "
;tree.end

base ad:0x8011c208
;tree "WMARKIM"
group 0--3
line.long 0 "WMARKIM"
bitfld.long 0 0. " WMARKIM0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIM1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIM2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIM3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIM4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIM5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIM6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIM7 "  "0 ,1 "
;tree.end

base ad:0x8011c20c
;tree "WMARKIC"
wgroup 0--3
line.long 0 "WMARKIC"
bitfld.long 0 0. " WMARKIC0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIC1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIC2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIC3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIC4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIC5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIC6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIC7 "  "0 ,1 "
;tree.end

base ad:0x8011c210
;tree "WMARKID"
group 0--3
line.long 0 "WMARKID"
bitfld.long 0 0. " WMARKID0 "  "0 ,1 "
bitfld.long 0 1. " WMARKID1 "  "0 ,1 "
bitfld.long 0 2. " WMARKID2 "  "0 ,1 "
bitfld.long 0 3. " WMARKID3 "  "0 ,1 "
bitfld.long 0 4. " WMARKID4 "  "0 ,1 "
bitfld.long 0 5. " WMARKID5 "  "0 ,1 "
bitfld.long 0 6. " WMARKID6 "  "0 ,1 "
bitfld.long 0 7. " WMARKID7 "  "0 ,1 "
;tree.end

base ad:0x8011cd00
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8011cd04
;tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR0 "  "0 ,1 "
bitfld.long 0 1. " DMACLR1 "  "0 ,1 "
bitfld.long 0 2. " DMACLR2 "  "0 ,1 "
bitfld.long 0 3. " DMACLR3 "  "0 ,1 "
bitfld.long 0 4. " DMACLR4 "  "0 ,1 "
bitfld.long 0 5. " DMACLR5 "  "0 ,1 "
bitfld.long 0 6. " DMACLR6 "  "0 ,1 "
bitfld.long 0 7. " DMACLR7 "  "0 ,1 "
bitfld.long 0 16. " READY "  "0 ,1 "
;tree.end

base ad:0x8011cd08
;tree "ITOP1"
group 0--3
line.long 0 "ITOP1"
hexfld.byte 0 " DMABREQ "
hexfld.byte 2 " DMASREQ "
;tree.end

base ad:0x8011cd0c
;tree "ITOP2"
group 0--3
line.long 0 "ITOP2"
bitfld.long 0 0. " WMARKD0INT "  "0 ,1 "
bitfld.long 0 1. " WMARKD1INT "  "0 ,1 "
bitfld.long 0 16. " DATA "  "0 ,1 "
bitfld.long 0 17. " FLAG "  "0 ,1 "
;tree.end

base ad:0x8011cfe0
;tree "PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " PARTNUMBER0 "
;tree.end

base ad:0x8011cfe4
;tree "PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " PARTNUMBER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " DESIGNER0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011cfe8
;tree "PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " DESIGNER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " REVISION "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011cfec
;tree "PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " CONFIGURATION "
;tree.end

base ad:0x8011cff0
;tree "PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " PCELLID0 "
;tree.end

base ad:0x8011cff4
;tree "PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " PCELLID1 "
;tree.end

base ad:0x8011cff8
;tree "PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " PCELLID2 "
;tree.end

base ad:0x8011cffc
;tree "PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " PCELLID3 "
;tree.end

endif

tree.end

;==============================================================
tree "ICN"
;==============================================================
base ad:0x81000400
;tree "Node_HiBw1_Esram_in_0_priority_reg"
group 0--3
line.long 0 "Node_HiBw1_Esram_in_0_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000404
;tree "Node_HiBw1_Esram_in_1_priority_reg"
group 0--3
line.long 0 "Node_HiBw1_Esram_in_1_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000c00
;tree "Node_HiBw2_Esram_in_0_priority_reg"
group 0--3
line.long 0 "Node_HiBw2_Esram_in_0_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000c04
;tree "Node_HiBw2_Esram_in_1_priority_reg"
group 0--3
line.long 0 "Node_HiBw2_Esram_in_1_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000c08
;tree "Node_HiBw2_Esram_in_2_priority_reg"
group 0--3
line.long 0 "Node_HiBw2_Esram_in_2_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001400
;tree "Node_Esram4_5_in_0_priority_reg"
group 0--3
line.long 0 "Node_Esram4_5_in_0_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001404
;tree "Node_Esram4_5_in_1_priority_reg"
group 0--3
line.long 0 "Node_Esram4_5_in_1_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001408
;tree "Node_Esram4_5_in_2_priority_reg"
group 0--3
line.long 0 "Node_Esram4_5_in_2_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x8100140c
;tree "Node_Esram4_5_in_3_priority_reg"
group 0--3
line.long 0 "Node_Esram4_5_in_3_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001430
;tree "Node_Esram4_5_in_0_limit_reg"
group 0--3
line.long 0 "Node_Esram4_5_in_0_limit_reg"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8100143c
;tree "Node_Esram4_5_in_3_limit_reg"
group 0--3
line.long 0 "Node_Esram4_5_in_3_limit_reg"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001800
;tree "Node_Esram0_1_in_0_priority_reg"
group 0--3
line.long 0 "Node_Esram0_1_in_0_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001804
;tree "Node_Esram0_1_in_1_priority_reg"
group 0--3
line.long 0 "Node_Esram0_1_in_1_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001808
;tree "Node_Esram0_1_in_2_priority_reg"
group 0--3
line.long 0 "Node_Esram0_1_in_2_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x8100180c
;tree "Node_Esram0_1_in_3_priority_reg"
group 0--3
line.long 0 "Node_Esram0_1_in_3_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001830
;tree "Node_Esram0_1_in_0_limit_reg"
group 0--3
line.long 0 "Node_Esram0_1_in_0_limit_reg"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8100183c
;tree "Node_Esram0_1_in_3_limit_reg"
group 0--3
line.long 0 "Node_Esram0_1_in_3_limit_reg"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001c00
;tree "Node_Esram2_3_in_0_priority_reg"
group 0--3
line.long 0 "Node_Esram2_3_in_0_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001c04
;tree "Node_Esram2_3_in_1_priority_reg"
group 0--3
line.long 0 "Node_Esram2_3_in_1_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001c08
;tree "Node_Esram2_3_in_2_priority_reg"
group 0--3
line.long 0 "Node_Esram2_3_in_2_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001c0c
;tree "Node_Esram2_3_in_3_priority_reg"
group 0--3
line.long 0 "Node_Esram2_3_in_3_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001c30
;tree "Node_Esram2_3_in_0_limit_reg"
group 0--3
line.long 0 "Node_Esram2_3_in_0_limit_reg"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001c3c
;tree "Node_Esram2_3_in_3_limit_reg"
group 0--3
line.long 0 "Node_Esram2_3_in_3_limit_reg"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000800
;tree "Node_HiBw1_DDR_in_0_priority_reg"
group 0--3
line.long 0 "Node_HiBw1_DDR_in_0_priority_reg"
bitfld.long 0 0.--3. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x81000804
;tree "Node_HiBw1_DDR_in_1_priority_reg"
group 0--3
line.long 0 "Node_HiBw1_DDR_in_1_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000808
;tree "Node_HiBw1_DDR_in_2_priority_reg"
group 0--3
line.long 0 "Node_HiBw1_DDR_in_2_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000824
;tree "Node_HiBw1_DDR_in_0_limit_reg"
group 0--3
line.long 0 "Node_HiBw1_DDR_in_0_limit_reg"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000830
;tree "Node_HiBw1_DDR_out_0_priority_reg"
group 0--3
line.long 0 "Node_HiBw1_DDR_out_0_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001000
;tree "Node_HiBw2_DDR_in_0_priority_reg"
group 0--3
line.long 0 "Node_HiBw2_DDR_in_0_priority_reg"
bitfld.long 0 0.--3. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x81001004
;tree "Node_HiBw2_DDR_in_1_priority_reg"
group 0--3
line.long 0 "Node_HiBw2_DDR_in_1_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001008
;tree "Node_HiBw2_DDR_in_2_priority_reg"
group 0--3
line.long 0 "Node_HiBw2_DDR_in_2_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001024
;tree "Node_HiBw2_DDR_in_0_limit_reg"
group 0--3
line.long 0 "Node_HiBw2_DDR_in_0_limit_reg"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001030
;tree "Node_HiBw2_DDR_out_0_priority_reg"
group 0--3
line.long 0 "Node_HiBw2_DDR_out_0_priority_reg"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "MCDE"
;==============================================================
if (((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x801571ec)&0x20000000)!=0x20000000)||((data.long(ad:0x8015725c)&0x02)!=0x02))

base ad:0x80157064
;tree "prcm_mcdeclk_mgt_reg"
group 0--3
line.long 0 "prcm_mcdeclk_mgt_reg"
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 29. " SOC_mem_init_n "  "0 ,1 "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 29. " SOC_mem_init_n "  "0 ,1 "
;tree.end

base ad:0x8015725c
;tree "prcm_power_state_val"
group 0--3
line.long 0 "prcm_power_state_val"
bitfld.long 0 7. " B2R2_MCDE "  "0 ,1 "
;tree.end

else

base ad:0xa0350000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " DSICMD2_EN "  "0 ,1 "
bitfld.long 0 1. " DSICMD1_EN "  "0 ,1 "
bitfld.long 0 2. " DSICMD0_EN "  "0 ,1 "
bitfld.long 0 3. " DSIVID2_END "  "0 ,1 "
bitfld.long 0 4. " DSIVID1_EN "  "0 ,1 "
bitfld.long 0 5. " DSIVID0_EN "  "0 ,1 "
bitfld.long 0 6. " DBIC1_EN "  "0 ,1 "
bitfld.long 0 7. " DBIC0_EN "  "0 ,1 "
bitfld.long 0 8. " DPIB_EN "  "0 ,1 "
bitfld.long 0 9. " DPIA_EN "  "0 ,1 "
bitfld.long 0 15. " IFIF0CTRLEN "  "0 ,1 "
bitfld.long 0 16. " F01MUX "  "0 ,1 "
bitfld.long 0 17. " FABMUX "  "0 ,1 "
bitfld.long 0 31. " MCDEEN "  "0 ,1 "
;tree.end

base ad:0xa0350004
;tree "CONF0"
group 0--3
line.long 0 "CONF0"
bitfld.long 0 0. " SYNCMUX0 "  "0 ,1 "
bitfld.long 0 1. " SYNCMUX1 "  "0 ,1 "
bitfld.long 0 2. " SYNCMUX2 "  "0 ,1 "
bitfld.long 0 3. " SYNCMUX3 "  "0 ,1 "
bitfld.long 0 4. " SYNCMUX4 "  "0 ,1 "
bitfld.long 0 5. " SYNCMUX5 "  "0 ,1 "
bitfld.long 0 6. " SYNCMUX6 "  "0 ,1 "
bitfld.long 0 7. " SYNCMUX7 "  "0 ,1 "
bitfld.long 0 8. " swapA_C0 "  "0 ,1 "
bitfld.long 0 9. " swapB_C1 "  "0 ,1 "
bitfld.long 0 10. " FSYNCCTRLA "  "0 ,1 "
bitfld.long 0 11. " FSYNCCTRLB "  "0 ,1 "
bitfld.long 0 12.--14. " IFIFOCTRLWTRMRKLVL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " OUTMUX0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--21. " OUTMUX1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 22.--24. " OUTMUX2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 25.--27. " OUTMUX3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 28.--30. " OUTMUX4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350104
;tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " FUAIM "  "0 ,1 "
bitfld.long 0 1. " FUBIM "  "0 ,1 "
bitfld.long 0 2. " VCMPAIM "  "0 ,1 "
bitfld.long 0 3. " VCMPBIM "  "0 ,1 "
bitfld.long 0 4. " VSCC0IM "  "0 ,1 "
bitfld.long 0 5. " VSCC1IM "  "0 ,1 "
bitfld.long 0 6. " VCMPC0IM "  "0 ,1 "
bitfld.long 0 7. " VCMPC1IM "  "0 ,1 "
bitfld.long 0 9. " SCHBLCKDIM "  "0 ,1 "
bitfld.long 0 10.--11. " ROTFDIM "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " CHNLRDIM "  "0 ,1 "
bitfld.long 0 13. " CHNLAIM "  "0 ,1 "
bitfld.long 0 14. " OVLRDIM "  "0 ,1 "
bitfld.long 0 15. " OVLWRIM "  "0 ,1 "
bitfld.long 0 16.--20. " OVLFERIM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0350108
;tree "RIS"
group 0--3
line.long 0 "RIS"
bitfld.long 0 0. " FURARIS "  "0 ,1 "
bitfld.long 0 1. " FURBRIS "  "0 ,1 "
bitfld.long 0 2. " VCMPARIS "  "0 ,1 "
bitfld.long 0 3. " VCMPBRIS "  "0 ,1 "
bitfld.long 0 4. " VSCC0RIS "  "0 ,1 "
bitfld.long 0 5. " VSCC1RIS "  "0 ,1 "
bitfld.long 0 6. " VCMPC0RIS "  "0 ,1 "
bitfld.long 0 7. " VCMPC1RIS "  "0 ,1 "
bitfld.long 0 9. " SCHBLCKDRIS "  "0 ,1 "
bitfld.long 0 10.--11. " ROTFDRIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " CHNLRDRIS "  "0 ,1 "
bitfld.long 0 13. " CHNLARIS "  "0 ,1 "
bitfld.long 0 14. " OVLRDRIS "  "0 ,1 "
bitfld.long 0 15. " OVLWRRIS "  "0 ,1 "
bitfld.long 0 16.--20. " OVLFERRIS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa035010c
;tree "MIS"
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " FUAMIS "  "0 ,1 "
bitfld.long 0 1. " FUBMIS "  "0 ,1 "
bitfld.long 0 2. " VCMPAMIS "  "0 ,1 "
bitfld.long 0 3. " VCMPBMIS "  "0 ,1 "
bitfld.long 0 4. " VSCC0MIS "  "0 ,1 "
bitfld.long 0 5. " VSCC1MIS "  "0 ,1 "
bitfld.long 0 6. " VCMPC0MIS "  "0 ,1 "
bitfld.long 0 7. " VCMPC1MIS "  "0 ,1 "
bitfld.long 0 9. " SCHBLCKDMIS "  "0 ,1 "
bitfld.long 0 10.--11. " ROTFDMIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " CHNLRDMIS "  "0 ,1 "
bitfld.long 0 13. " CHNLAMIS "  "0 ,1 "
bitfld.long 0 14. " OVLRDMIS "  "0 ,1 "
bitfld.long 0 15. " OVLWRMIS "  "0 ,1 "
bitfld.long 0 16.--20. " OVLFERMIS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0350110
;tree "SIS"
group 0--3
line.long 0 "SIS"
bitfld.long 0 0. " FUAIS "  "0 ,1 "
bitfld.long 0 1. " FUBIS "  "0 ,1 "
bitfld.long 0 2. " VCMPAIS "  "0 ,1 "
bitfld.long 0 3. " VCMPBIS "  "0 ,1 "
bitfld.long 0 4. " VSCC0IS "  "0 ,1 "
bitfld.long 0 5. " VSCC1IS "  "0 ,1 "
bitfld.long 0 6. " VCMPC0IS "  "0 ,1 "
bitfld.long 0 7. " VCMPC1IS "  "0 ,1 "
bitfld.long 0 9. " SCHBLCKDSIS "  "0 ,1 "
bitfld.long 0 10.--11. " ROTFDIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " CHNLRDIS "  "0 ,1 "
bitfld.long 0 13. " CHNLAIS "  "0 ,1 "
bitfld.long 0 14. " OVLRDIS "  "0 ,1 "
bitfld.long 0 15. " OVLWRIS "  "0 ,1 "
bitfld.long 0 16.--20. " OVLFERIS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0350114
;tree "SSP"
group 0--3
line.long 0 "SSP"
hexfld.byte 0 " DATAREAD "
bitfld.long 0 8. " CMDREAD "  "0 ,1 "
bitfld.long 0 16. " SSPEN "  "0 ,1 "
;tree.end

base ad:0xa03501fc
;tree "PID"
group 0--3
line.long 0 "PID"
hexfld.long 0 " PID "
;tree.end

base ad:0xa0350200
;tree "EXTSRC0A0"
group 0--3
line.long 0 "EXTSRC0A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa0350220
;tree "EXTSRC1A0"
group 0--3
line.long 0 "EXTSRC1A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa0350240
;tree "EXTSRC2A0"
group 0--3
line.long 0 "EXTSRC2A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa0350260
;tree "EXTSRC3A0"
group 0--3
line.long 0 "EXTSRC3A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa0350280
;tree "EXTSRC4A0"
group 0--3
line.long 0 "EXTSRC4A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa03502a0
;tree "EXTSRC5A0"
group 0--3
line.long 0 "EXTSRC5A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa03502c0
;tree "EXTSRC6A0"
group 0--3
line.long 0 "EXTSRC6A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa03502e0
;tree "EXTSRC7A0"
group 0--3
line.long 0 "EXTSRC7A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa0350300
;tree "EXTSRC8A0"
group 0--3
line.long 0 "EXTSRC8A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa0350320
;tree "EXTSRC9A0"
group 0--3
line.long 0 "EXTSRC9A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa0350340
;tree "EXTSRC10A0"
group 0--3
line.long 0 "EXTSRC10A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa0350360
;tree "EXTSRC11A0"
group 0--3
line.long 0 "EXTSRC11A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa0350380
;tree "EXTSRC12A0"
group 0--3
line.long 0 "EXTSRC12A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa03503a0
;tree "EXTSRC13A0"
group 0--3
line.long 0 "EXTSRC13A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa03503c0
;tree "EXTSRC14A0"
group 0--3
line.long 0 "EXTSRC14A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa03503e0
;tree "EXTSRC15A0"
group 0--3
line.long 0 "EXTSRC15A0"
bitfld.long 0 3.--31. " BaseAddress0 "  " "
;tree.end

base ad:0xa0350204
;tree "EXTSRC0A1"
group 0--3
line.long 0 "EXTSRC0A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa0350224
;tree "EXTSRC1A1"
group 0--3
line.long 0 "EXTSRC1A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa0350244
;tree "EXTSRC2A1"
group 0--3
line.long 0 "EXTSRC2A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa0350264
;tree "EXTSRC3A1"
group 0--3
line.long 0 "EXTSRC3A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa0350284
;tree "EXTSRC4A1"
group 0--3
line.long 0 "EXTSRC4A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa03502a4
;tree "EXTSRC5A1"
group 0--3
line.long 0 "EXTSRC5A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa03502c4
;tree "EXTSRC6A1"
group 0--3
line.long 0 "EXTSRC6A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa03502e4
;tree "EXTSRC7A1"
group 0--3
line.long 0 "EXTSRC7A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa0350304
;tree "EXTSRC8A1"
group 0--3
line.long 0 "EXTSRC8A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa0350324
;tree "EXTSRC9A1"
group 0--3
line.long 0 "EXTSRC9A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa0350344
;tree "EXTSRC10A1"
group 0--3
line.long 0 "EXTSRC10A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa0350364
;tree "EXTSRC11A1"
group 0--3
line.long 0 "EXTSRC11A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa0350384
;tree "EXTSRC12A1"
group 0--3
line.long 0 "EXTSRC12A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa03503a4
;tree "EXTSRC13A1"
group 0--3
line.long 0 "EXTSRC13A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa03503c4
;tree "EXTSRC14A1"
group 0--3
line.long 0 "EXTSRC14A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa03503e4
;tree "EXTSRC15A1"
group 0--3
line.long 0 "EXTSRC15A1"
bitfld.long 0 3.--31. " BaseAddress1 "  " "
;tree.end

base ad:0xa0350208
;tree "EXTSRC0A2"
group 0--3
line.long 0 "EXTSRC0A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa0350228
;tree "EXTSRC1A2"
group 0--3
line.long 0 "EXTSRC1A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa0350248
;tree "EXTSRC2A2"
group 0--3
line.long 0 "EXTSRC2A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa0350268
;tree "EXTSRC3A2"
group 0--3
line.long 0 "EXTSRC3A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa0350288
;tree "EXTSRC4A2"
group 0--3
line.long 0 "EXTSRC4A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa03502a8
;tree "EXTSRC5A2"
group 0--3
line.long 0 "EXTSRC5A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa03502c8
;tree "EXTSRC6A2"
group 0--3
line.long 0 "EXTSRC6A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa03502e8
;tree "EXTSRC7A2"
group 0--3
line.long 0 "EXTSRC7A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa0350308
;tree "EXTSRC8A2"
group 0--3
line.long 0 "EXTSRC8A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa0350328
;tree "EXTSRC9A2"
group 0--3
line.long 0 "EXTSRC9A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa0350348
;tree "EXTSRC10A2"
group 0--3
line.long 0 "EXTSRC10A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa0350368
;tree "EXTSRC11A2"
group 0--3
line.long 0 "EXTSRC11A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa0350388
;tree "EXTSRC12A2"
group 0--3
line.long 0 "EXTSRC12A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa03503a8
;tree "EXTSRC13A2"
group 0--3
line.long 0 "EXTSRC13A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa03503c8
;tree "EXTSRC14A2"
group 0--3
line.long 0 "EXTSRC14A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa03503e8
;tree "EXTSRC15A2"
group 0--3
line.long 0 "EXTSRC15A2"
bitfld.long 0 3.--31. " BaseAddress2 "  " "
;tree.end

base ad:0xa035020c
;tree "EXTSRC0CONF"
group 0--3
line.long 0 "EXTSRC0CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa035022c
;tree "EXTSRC1CONF"
group 0--3
line.long 0 "EXTSRC1CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa035024c
;tree "EXTSRC2CONF"
group 0--3
line.long 0 "EXTSRC2CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa035026c
;tree "EXTSRC3CONF"
group 0--3
line.long 0 "EXTSRC3CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa035028c
;tree "EXTSRC4CONF"
group 0--3
line.long 0 "EXTSRC4CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa03502ac
;tree "EXTSRC5CONF"
group 0--3
line.long 0 "EXTSRC5CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa03502cc
;tree "EXTSRC6CONF"
group 0--3
line.long 0 "EXTSRC6CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa03502ec
;tree "EXTSRC7CONF"
group 0--3
line.long 0 "EXTSRC7CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa035030c
;tree "EXTSRC8CONF"
group 0--3
line.long 0 "EXTSRC8CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa035032c
;tree "EXTSRC9CONF"
group 0--3
line.long 0 "EXTSRC9CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa035034c
;tree "EXTSRC10CONF"
group 0--3
line.long 0 "EXTSRC10CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa035036c
;tree "EXTSRC11CONF"
group 0--3
line.long 0 "EXTSRC11CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa035038c
;tree "EXTSRC12CONF"
group 0--3
line.long 0 "EXTSRC12CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa03503ac
;tree "EXTSRC13CONF"
group 0--3
line.long 0 "EXTSRC13CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa03503cc
;tree "EXTSRC14CONF"
group 0--3
line.long 0 "EXTSRC14CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa03503ec
;tree "EXTSRC15CONF"
group 0--3
line.long 0 "EXTSRC15CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEPO "  "0 ,1 "
bitfld.long 0 14. " BEBO "  "0 ,1 "
;tree.end

base ad:0xa0350210
;tree "EXTSRC0CR"
group 0--3
line.long 0 "EXTSRC0CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350230
;tree "EXTSRC1CR"
group 0--3
line.long 0 "EXTSRC1CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350250
;tree "EXTSRC2CR"
group 0--3
line.long 0 "EXTSRC2CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350270
;tree "EXTSRC3CR"
group 0--3
line.long 0 "EXTSRC3CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350290
;tree "EXTSRC4CR"
group 0--3
line.long 0 "EXTSRC4CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa03502b0
;tree "EXTSRC5CR"
group 0--3
line.long 0 "EXTSRC5CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa03502d0
;tree "EXTSRC6CR"
group 0--3
line.long 0 "EXTSRC6CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa03502f0
;tree "EXTSRC7CR"
group 0--3
line.long 0 "EXTSRC7CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350310
;tree "EXTSRC8CR"
group 0--3
line.long 0 "EXTSRC8CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350330
;tree "EXTSRC9CR"
group 0--3
line.long 0 "EXTSRC9CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350350
;tree "EXTSRC10CR"
group 0--3
line.long 0 "EXTSRC10CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350370
;tree "EXTSRC11CR"
group 0--3
line.long 0 "EXTSRC11CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350390
;tree "EXTSRC12CR"
group 0--3
line.long 0 "EXTSRC12CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa03503b0
;tree "EXTSRC13CR"
group 0--3
line.long 0 "EXTSRC13CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa03503d0
;tree "EXTSRC14CR"
group 0--3
line.long 0 "EXTSRC14CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa03503f0
;tree "EXTSRC15CR"
group 0--3
line.long 0 "EXTSRC15CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350400
;tree "OVL0CR"
group 0--3
line.long 0 "OVL0CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " PALCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " CKEYEN "  "0 ,1 "
bitfld.long 0 6. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 7. " CLIPEN "  "0 ,1 "
bitfld.long 0 8. " OVLF "  "0 ,1 "
bitfld.long 0 9. " OVLR "  "0 ,1 "
bitfld.long 0 10. " OVLB "  "0 ,1 "
bitfld.long 0 16.--19. " STBPrio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350420
;tree "OVL1CR"
group 0--3
line.long 0 "OVL1CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " PALCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " CKEYEN "  "0 ,1 "
bitfld.long 0 6. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 7. " CLIPEN "  "0 ,1 "
bitfld.long 0 8. " OVLF "  "0 ,1 "
bitfld.long 0 9. " OVLR "  "0 ,1 "
bitfld.long 0 10. " OVLB "  "0 ,1 "
bitfld.long 0 16.--19. " STBPrio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350440
;tree "OVL2CR"
group 0--3
line.long 0 "OVL2CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " PALCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " CKEYEN "  "0 ,1 "
bitfld.long 0 6. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 7. " CLIPEN "  "0 ,1 "
bitfld.long 0 8. " OVLF "  "0 ,1 "
bitfld.long 0 9. " OVLR "  "0 ,1 "
bitfld.long 0 10. " OVLB "  "0 ,1 "
bitfld.long 0 16.--19. " STBPrio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350460
;tree "OVL3CR"
group 0--3
line.long 0 "OVL3CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " PALCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " CKEYEN "  "0 ,1 "
bitfld.long 0 6. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 7. " CLIPEN "  "0 ,1 "
bitfld.long 0 8. " OVLF "  "0 ,1 "
bitfld.long 0 9. " OVLR "  "0 ,1 "
bitfld.long 0 10. " OVLB "  "0 ,1 "
bitfld.long 0 16.--19. " STBPrio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350480
;tree "OVL4CR"
group 0--3
line.long 0 "OVL4CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " PALCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " CKEYEN "  "0 ,1 "
bitfld.long 0 6. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 7. " CLIPEN "  "0 ,1 "
bitfld.long 0 8. " OVLF "  "0 ,1 "
bitfld.long 0 9. " OVLR "  "0 ,1 "
bitfld.long 0 10. " OVLB "  "0 ,1 "
bitfld.long 0 16.--19. " STBPrio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350404
;tree "OVL0CONF"
group 0--3
line.long 0 "OVL0CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350424
;tree "OVL1CONF"
group 0--3
line.long 0 "OVL1CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350444
;tree "OVL2CONF"
group 0--3
line.long 0 "OVL2CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350464
;tree "OVL3CONF"
group 0--3
line.long 0 "OVL3CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350484
;tree "OVL4CONF"
group 0--3
line.long 0 "OVL4CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350408
;tree "OVL0CONF2"
group 0--3
line.long 0 "OVL0CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHA_VALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PFWML "  " "
;tree.end

base ad:0xa0350428
;tree "OVL1CONF2"
group 0--3
line.long 0 "OVL1CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHA_VALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PFWML "  " "
;tree.end

base ad:0xa0350448
;tree "OVL2CONF2"
group 0--3
line.long 0 "OVL2CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHA_VALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PFWML "  " "
;tree.end

base ad:0xa0350468
;tree "OVL3CONF2"
group 0--3
line.long 0 "OVL3CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHA_VALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PFWML "  " "
;tree.end

base ad:0xa0350488
;tree "OVL4CONF2"
group 0--3
line.long 0 "OVL4CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHA_VALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PFWML "  " "
;tree.end

base ad:0xa035040c
;tree "OVL0JINC"
group 0--3
line.long 0 "OVL0JINC"
bitfld.long 0 3.--31. " LJINC "  " "
;tree.end

base ad:0xa035042c
;tree "OVL1JINC"
group 0--3
line.long 0 "OVL1JINC"
bitfld.long 0 3.--31. " LJINC "  " "
;tree.end

base ad:0xa035044c
;tree "OVL2JINC"
group 0--3
line.long 0 "OVL2JINC"
bitfld.long 0 3.--31. " LJINC "  " "
;tree.end

base ad:0xa035046c
;tree "OVL3JINC"
group 0--3
line.long 0 "OVL3JINC"
bitfld.long 0 3.--31. " LJINC "  " "
;tree.end

base ad:0xa035048c
;tree "OVL4JINC"
group 0--3
line.long 0 "OVL4JINC"
bitfld.long 0 3.--31. " LJINC "  " "
;tree.end

base ad:0xa0350410
;tree "OVL0CROP"
group 0--3
line.long 0 "OVL0CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

base ad:0xa0350430
;tree "OVL1CROP"
group 0--3
line.long 0 "OVL1CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

base ad:0xa0350450
;tree "OVL2CROP"
group 0--3
line.long 0 "OVL2CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

base ad:0xa0350470
;tree "OVL3CROP"
group 0--3
line.long 0 "OVL3CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

base ad:0xa0350490
;tree "OVL4CROP"
group 0--3
line.long 0 "OVL4CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

base ad:0xa0350414
;tree "OVL0TLCLIP"
group 0--3
line.long 0 "OVL0TLCLIP"
bitfld.long 0 0.--10. " XTLCOOR "  " "
bitfld.long 0 16.--26. " YTLCOOR "  " "
;tree.end

base ad:0xa0350434
;tree "OVL1TLCLIP"
group 0--3
line.long 0 "OVL1TLCLIP"
bitfld.long 0 0.--10. " XTLCOOR "  " "
bitfld.long 0 16.--26. " YTLCOOR "  " "
;tree.end

base ad:0xa0350454
;tree "OVL2TLCLIP"
group 0--3
line.long 0 "OVL2TLCLIP"
bitfld.long 0 0.--10. " XTLCOOR "  " "
bitfld.long 0 16.--26. " YTLCOOR "  " "
;tree.end

base ad:0xa0350474
;tree "OVL3TLCLIP"
group 0--3
line.long 0 "OVL3TLCLIP"
bitfld.long 0 0.--10. " XTLCOOR "  " "
bitfld.long 0 16.--26. " YTLCOOR "  " "
;tree.end

base ad:0xa0350494
;tree "OVL4TLCLIP"
group 0--3
line.long 0 "OVL4TLCLIP"
bitfld.long 0 0.--10. " XTLCOOR "  " "
bitfld.long 0 16.--26. " YTLCOOR "  " "
;tree.end

base ad:0xa0350418
;tree "OVL0BRCLIP"
group 0--3
line.long 0 "OVL0BRCLIP"
bitfld.long 0 0.--10. " XBRCOOR "  " "
bitfld.long 0 16.--26. " YBRCOOR "  " "
;tree.end

base ad:0xa0350438
;tree "OVL1BRCLIP"
group 0--3
line.long 0 "OVL1BRCLIP"
bitfld.long 0 0.--10. " XBRCOOR "  " "
bitfld.long 0 16.--26. " YBRCOOR "  " "
;tree.end

base ad:0xa0350458
;tree "OVL2BRCLIP"
group 0--3
line.long 0 "OVL2BRCLIP"
bitfld.long 0 0.--10. " XBRCOOR "  " "
bitfld.long 0 16.--26. " YBRCOOR "  " "
;tree.end

base ad:0xa0350478
;tree "OVL3BRCLIP"
group 0--3
line.long 0 "OVL3BRCLIP"
bitfld.long 0 0.--10. " XBRCOOR "  " "
bitfld.long 0 16.--26. " YBRCOOR "  " "
;tree.end

base ad:0xa0350498
;tree "OVL4BRCLIP"
group 0--3
line.long 0 "OVL4BRCLIP"
bitfld.long 0 0.--10. " XBRCOOR "  " "
bitfld.long 0 16.--26. " YBRCOOR "  " "
;tree.end

base ad:0xa035041c
;tree "OVL0COMP"
group 0--3
line.long 0 "OVL0COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa035043c
;tree "OVL1COMP"
group 0--3
line.long 0 "OVL1COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa035045c
;tree "OVL2COMP"
group 0--3
line.long 0 "OVL2COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa035047c
;tree "OVL3COMP"
group 0--3
line.long 0 "OVL3COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa035049c
;tree "OVL4COMP"
group 0--3
line.long 0 "OVL4COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350600
;tree "CHNL0CONF"
group 0--3
line.long 0 "CHNL0CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350620
;tree "CHNL1CONF"
group 0--3
line.long 0 "CHNL1CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350640
;tree "CHNL2CONF"
group 0--3
line.long 0 "CHNL2CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350660
;tree "CHNL3CONF"
group 0--3
line.long 0 "CHNL3CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350680
;tree "CHNL4CONF"
group 0--3
line.long 0 "CHNL4CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa03506a0
;tree "CHNL5CONF"
group 0--3
line.long 0 "CHNL5CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa03506c0
;tree "CHNL6CONF"
group 0--3
line.long 0 "CHNL6CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa03506e0
;tree "CHNL7CONF"
group 0--3
line.long 0 "CHNL7CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350700
;tree "CHNL8CONF"
group 0--3
line.long 0 "CHNL8CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350720
;tree "CHNL9CONF"
group 0--3
line.long 0 "CHNL9CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350740
;tree "CHNL10CONF"
group 0--3
line.long 0 "CHNL10CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350760
;tree "CHNL11CONF"
group 0--3
line.long 0 "CHNL11CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350780
;tree "CHNL12CONF"
group 0--3
line.long 0 "CHNL12CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa03507a0
;tree "CHNL13CONF"
group 0--3
line.long 0 "CHNL13CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa03507c0
;tree "CHNL14CONF"
group 0--3
line.long 0 "CHNL14CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa03507e0
;tree "CHNL15CONF"
group 0--3
line.long 0 "CHNL15CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa035087c
;tree "SYNCONFA"
group 0--3
line.long 0 "SYNCONFA"
bitfld.long 0 0.--1. " HwReqVEvent "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--15. " HwReqVCnt "  " "
bitfld.long 0 16.--17. " SwInVEvent "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--31. " SwIntVCnt "  " "
;tree.end

base ad:0xa0350a7c
;tree "SYNCONFB"
group 0--3
line.long 0 "SYNCONFB"
bitfld.long 0 0.--1. " HwReqVEvent "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--15. " HwReqVCnt "  " "
bitfld.long 0 16.--17. " SwInVEvent "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--31. " SwIntVCnt "  " "
;tree.end

base ad:0xa0350608
;tree "CHNL0SYNCMOD"
group 0--3
line.long 0 "CHNL0SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350628
;tree "CHNL1SYNCMOD"
group 0--3
line.long 0 "CHNL1SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350648
;tree "CHNL2SYNCMOD"
group 0--3
line.long 0 "CHNL2SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350668
;tree "CHNL3SYNCMOD"
group 0--3
line.long 0 "CHNL3SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350688
;tree "CHNL4SYNCMOD"
group 0--3
line.long 0 "CHNL4SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa03506a8
;tree "CHNL5SYNCMOD"
group 0--3
line.long 0 "CHNL5SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa03506c8
;tree "CHNL6SYNCMOD"
group 0--3
line.long 0 "CHNL6SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa03506e8
;tree "CHNL7SYNCMOD"
group 0--3
line.long 0 "CHNL7SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350708
;tree "CHNL8SYNCMOD"
group 0--3
line.long 0 "CHNL8SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350728
;tree "CHNL9SYNCMOD"
group 0--3
line.long 0 "CHNL9SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350748
;tree "CHNL10SYNCMOD"
group 0--3
line.long 0 "CHNL10SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350768
;tree "CHNL11SYNCMOD"
group 0--3
line.long 0 "CHNL11SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350788
;tree "CHNL12SYNCMOD"
group 0--3
line.long 0 "CHNL12SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa03507a8
;tree "CHNL13SYNCMOD"
group 0--3
line.long 0 "CHNL13SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa03507c8
;tree "CHNL14SYNCMOD"
group 0--3
line.long 0 "CHNL14SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa03507e8
;tree "CHNL15SYNCMOD"
group 0--3
line.long 0 "CHNL15SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa035060c
;tree "CHNL0SYNCHSW"
wgroup 0--3
line.long 0 "CHNL0SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa035062c
;tree "CHNL1SYNCHSW"
wgroup 0--3
line.long 0 "CHNL1SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa035064c
;tree "CHNL2SYNCHSW"
wgroup 0--3
line.long 0 "CHNL2SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa035066c
;tree "CHNL3SYNCHSW"
wgroup 0--3
line.long 0 "CHNL3SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa035068c
;tree "CHNL4SYNCHSW"
group 0--3
line.long 0 "CHNL4SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa03506ac
;tree "CHNL5SYNCHSW"
group 0--3
line.long 0 "CHNL5SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa03506cc
;tree "CHNL6SYNCHSW"
group 0--3
line.long 0 "CHNL6SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa03506ec
;tree "CHNL7SYNCHSW"
group 0--3
line.long 0 "CHNL7SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa035070c
;tree "CHNL8SYNCHSW"
group 0--3
line.long 0 "CHNL8SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa035072c
;tree "CHNL9SYNCHSW"
group 0--3
line.long 0 "CHNL9SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa035074c
;tree "CHNL10SYNCHSW"
group 0--3
line.long 0 "CHNL10SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa035076c
;tree "CHNL11SYNCHSW"
group 0--3
line.long 0 "CHNL11SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa035078c
;tree "CHNL12SYNCHSW"
group 0--3
line.long 0 "CHNL12SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa03507ac
;tree "CHNL13SYNCHSW"
group 0--3
line.long 0 "CHNL13SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa03507cc
;tree "CHNL14SYNCHSW"
group 0--3
line.long 0 "CHNL14SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa03507ec
;tree "CHNL15SYNCHSW"
group 0--3
line.long 0 "CHNL15SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa0350610
;tree "CHNL0BCKCL"
group 0--3
line.long 0 "CHNL0BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350630
;tree "CHNL1BCKCL"
group 0--3
line.long 0 "CHNL1BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350650
;tree "CHNL2BCKCL"
group 0--3
line.long 0 "CHNL2BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350670
;tree "CHNL3BCKCL"
group 0--3
line.long 0 "CHNL3BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350690
;tree "CHNL4BCKCL"
group 0--3
line.long 0 "CHNL4BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa03506b0
;tree "CHNL5BCKCL"
group 0--3
line.long 0 "CHNL5BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa03506d0
;tree "CHNL6BCKCL"
group 0--3
line.long 0 "CHNL6BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa03506f0
;tree "CHNL7BCKCL"
group 0--3
line.long 0 "CHNL7BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350710
;tree "CHNL8BCKCL"
group 0--3
line.long 0 "CHNL8BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350730
;tree "CHNL9BCKCL"
group 0--3
line.long 0 "CHNL9BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350750
;tree "CHNL10BCKCL"
group 0--3
line.long 0 "CHNL10BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350770
;tree "CHNL11BCKCL"
group 0--3
line.long 0 "CHNL11BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350790
;tree "CHNL12BCKCL"
group 0--3
line.long 0 "CHNL12BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa03507b0
;tree "CHNL13BCKCL"
group 0--3
line.long 0 "CHNL13BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa03507d0
;tree "CHNL14BCKCL"
group 0--3
line.long 0 "CHNL14BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa03507f0
;tree "CHNL15BCKCL"
group 0--3
line.long 0 "CHNL15BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350614
;tree "CHNL0PRIO"
group 0--3
line.long 0 "CHNL0PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350634
;tree "CHNL1PRIO"
group 0--3
line.long 0 "CHNL1PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350654
;tree "CHNL2PRIO"
group 0--3
line.long 0 "CHNL2PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350674
;tree "CHNL3PRIO"
group 0--3
line.long 0 "CHNL3PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350694
;tree "CHNL4PRIO"
group 0--3
line.long 0 "CHNL4PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03506b4
;tree "CHNL5PRIO"
group 0--3
line.long 0 "CHNL5PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03506d4
;tree "CHNL6PRIO"
group 0--3
line.long 0 "CHNL6PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03506f4
;tree "CHNL7PRIO"
group 0--3
line.long 0 "CHNL7PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350714
;tree "CHNL8PRIO"
group 0--3
line.long 0 "CHNL8PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350734
;tree "CHNL9PRIO"
group 0--3
line.long 0 "CHNL9PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350754
;tree "CHNL10PRIO"
group 0--3
line.long 0 "CHNL10PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350774
;tree "CHNL11PRIO"
group 0--3
line.long 0 "CHNL11PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350794
;tree "CHNL12PRIO"
group 0--3
line.long 0 "CHNL12PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03507b4
;tree "CHNL13PRIO"
group 0--3
line.long 0 "CHNL13PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03507d4
;tree "CHNL14PRIO"
group 0--3
line.long 0 "CHNL14PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03507f4
;tree "CHNL15PRIO"
group 0--3
line.long 0 "CHNL15PRIO"
bitfld.long 0 0.--3. " CHNLPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350800
;tree "CRA0"
group 0--3
line.long 0 "CRA0"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 1. " POWEREN "  "0 ,1 "
bitfld.long 0 2. " BLENDEN "  "0 ,1 "
bitfld.long 0 3. " AFLICKEN "  "0 ,1 "
bitfld.long 0 4. " CEAEN "  "0 ,1 "
bitfld.long 0 5. " DITHEN "  "0 ,1 "
bitfld.long 0 6. " ROTEN "  "0 ,1 "
bitfld.long 0 7.--9. " KEYCTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " BLENDCTRL "  "0 ,1 "
bitfld.long 0 11.--12. " FLICKMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " FLICKFORMAT "  "0 ,1 "
bitfld.long 0 14. " GAMEN "  "0 ,1 "
bitfld.long 0 15. " ROTDIR "  "0 ,1 "
hexfld.byte 2 " ALPHABLEND "
bitfld.long 0 24. " ROTSTRIPNB "  "0 ,1 "
;tree.end

base ad:0xa0350804
;tree "CRA1"
group 0--3
line.long 0 "CRA1"
bitfld.long 0 0.--9. " PCD "  " "
bitfld.long 0 10.--12. " CLKSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--15. " CDWIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--25. " CLP "  " "
bitfld.long 0 26.--28. " OUTBPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 29. " BCD "  "0 ,1 "
bitfld.long 0 30. " CLKTYPE "  "0 ,1 "
;tree.end

base ad:0xa0350808
;tree "COLKEYA"
group 0--3
line.long 0 "COLKEYA"
hexfld.byte 0 " KEYB "
hexfld.byte 1 " KEYG "
hexfld.byte 2 " KEYR "
hexfld.byte 3 " KEYA "
;tree.end

base ad:0xa035080c
;tree "FCOLKEYA"
group 0--3
line.long 0 "FCOLKEYA"
hexfld.byte 0 " FKEYB "
hexfld.byte 1 " FKEYG "
hexfld.byte 2 " FKEYR "
hexfld.byte 3 " FKEYA "
;tree.end

base ad:0xa0350810
;tree "RGBCONV1A"
group 0--3
line.long 0 "RGBCONV1A"
bitfld.long 0 0.--9. " Yr_green "  " "
bitfld.long 0 16.--25. " Yr_red "  " "
;tree.end

base ad:0xa0350814
;tree "RGBCONV2A"
group 0--3
line.long 0 "RGBCONV2A"
bitfld.long 0 0.--9. " Cr_red "  " "
bitfld.long 0 16.--25. " Yr_blue "  " "
;tree.end

base ad:0xa0350818
;tree "RGBCONV3A"
group 0--3
line.long 0 "RGBCONV3A"
bitfld.long 0 0.--9. " Cr_blue "  " "
bitfld.long 0 16.--25. " Cr_green "  " "
;tree.end

base ad:0xa035081c
;tree "RGBCONV4A"
group 0--3
line.long 0 "RGBCONV4A"
bitfld.long 0 0.--9. " Cb_green "  " "
bitfld.long 0 16.--25. " Cb_red "  " "
;tree.end

base ad:0xa0350820
;tree "RGBCONV5A"
group 0--3
line.long 0 "RGBCONV5A"
bitfld.long 0 0.--9. " Off_red "  " "
bitfld.long 0 16.--25. " Cb_blue "  " "
;tree.end

base ad:0xa0350824
;tree "RGBCONV6A"
group 0--3
line.long 0 "RGBCONV6A"
bitfld.long 0 0.--9. " Off_blue "  " "
bitfld.long 0 16.--25. " Off_green "  " "
;tree.end

base ad:0xa0350828
;tree "FFCOEF0A"
group 0--3
line.long 0 "FFCOEF0A"
hexfld.byte 0 " COEFF0_N1 "
hexfld.byte 1 " COEFF0_N2 "
hexfld.byte 2 " COEFF0_N3 "
bitfld.long 0 24.--27. " T0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa035082c
;tree "FFCOEF1A"
group 0--3
line.long 0 "FFCOEF1A"
hexfld.byte 0 " COEFF1_N1 "
hexfld.byte 1 " COEFF1_N2 "
hexfld.byte 2 " COEFF1_N3 "
bitfld.long 0 24.--27. " T1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350830
;tree "FFCOEF2A"
group 0--3
line.long 0 "FFCOEF2A"
hexfld.byte 0 " COEFF2_N1 "
hexfld.byte 1 " COEFF2_N2 "
hexfld.byte 2 " COEFF2_N3 "
bitfld.long 0 24.--27. " T2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350838
;tree "TVCRA"
group 0--3
line.long 0 "TVCRA"
bitfld.long 0 0. " SELMOD "  "0 ,1 "
bitfld.long 0 1. " INTEREN "  "0 ,1 "
bitfld.long 0 2. " IFIELD "  "0 ,1 "
bitfld.long 0 3.--4. " TVCRA "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--26. " LINES "  " "
;tree.end

base ad:0xa035083c
;tree "TVBL1A"
group 0--3
line.long 0 "TVBL1A"
bitfld.long 0 0.--10. " BEL1 "  " "
bitfld.long 0 16.--26. " BSL1 "  " "
;tree.end

base ad:0xa0350840
;tree "TVISLA"
group 0--3
line.long 0 "TVISLA"
bitfld.long 0 0.--10. " FSL1 "  " "
bitfld.long 0 16.--26. " FSL2 "  " "
;tree.end

base ad:0xa0350844
;tree "TVDVOA"
group 0--3
line.long 0 "TVDVOA"
bitfld.long 0 0.--10. " DVO1 "  " "
bitfld.long 0 16.--26. " DVO2 "  " "
;tree.end

base ad:0xa0350848
;tree "TVSWHA"
group 0--3
line.long 0 "TVSWHA"
bitfld.long 0 0.--10. " SWH1 "  " "
bitfld.long 0 16.--26. " SWH2 "  " "
;tree.end

base ad:0xa035084c
;tree "TVTIM1A"
group 0--3
line.long 0 "TVTIM1A"
bitfld.long 0 0.--10. " DHO "  " "
bitfld.long 0 16.--26. " SWW "  " "
;tree.end

base ad:0xa0350850
;tree "TVLBALWA"
group 0--3
line.long 0 "TVLBALWA"
bitfld.long 0 0.--10. " LBW "  " "
bitfld.long 0 16.--26. " ALW "  " "
;tree.end

base ad:0xa0350854
;tree "TVBL2A"
group 0--3
line.long 0 "TVBL2A"
bitfld.long 0 0.--10. " BEL2 "  " "
bitfld.long 0 16.--26. " BSL2 "  " "
;tree.end

base ad:0xa0350858
;tree "TVBLUA"
group 0--3
line.long 0 "TVBLUA"
hexfld.byte 0 " TVBLU "
hexfld.byte 1 " TVBCB "
hexfld.byte 2 " TVBCR "
;tree.end

base ad:0xa035085c
;tree "LCDTIM0A"
group 0--3
line.long 0 "LCDTIM0A"
hexfld.byte 0 " PSDEL0 "
bitfld.long 0 8.--11. " PSDEL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--13. " PSLOADSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " PSTGEN "  "0 ,1 "
bitfld.long 0 15. " PSVAEN "  "0 ,1 "
hexfld.byte 2 " REVDEL0 "
bitfld.long 0 24.--27. " REVDEL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " REVLOADSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 30. " REVTGEN "  "0 ,1 "
bitfld.long 0 31. " REVVAEN "  "0 ,1 "
;tree.end

base ad:0xa0350860
;tree "LCDTIM1A"
group 0--3
line.long 0 "LCDTIM1A"
hexfld.byte 0 " SPLDEL0 "
bitfld.long 0 8.--11. " SPLDEL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--13. " SPLLOADSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " SPLTGEN "  "0 ,1 "
bitfld.long 0 15. " SPLVAEN "  "0 ,1 "
bitfld.long 0 16. " ICLPS "  "0 ,1 "
bitfld.long 0 17. " ICLREV "  "0 ,1 "
bitfld.long 0 18. " ICLSPL "  "0 ,1 "
bitfld.long 0 19. " IVP "  "0 ,1 "
bitfld.long 0 20. " IVS "  "0 ,1 "
bitfld.long 0 21. " IHS "  "0 ,1 "
bitfld.long 0 22. " IPC "  "0 ,1 "
bitfld.long 0 23. " IOE "  "0 ,1 "
;tree.end

base ad:0xa0350864
;tree "DITCTRLA"
group 0--3
line.long 0 "DITCTRLA"
bitfld.long 0 0. " TEMP "  "0 ,1 "
bitfld.long 0 1. " COMP "  "0 ,1 "
bitfld.long 0 2.--3. " MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MASK "  "0 ,1 "
bitfld.long 0 5.--9. " FOFFX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--14. " FOFFY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0350868
;tree "DITOFFA"
group 0--3
line.long 0 "DITOFFA"
bitfld.long 0 0.--4. " XG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " YG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " XB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--28. " YB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa035086c
;tree "PAL0A"
group 0--3
line.long 0 "PAL0A"
hexfld.byte 0 " BLUE "
hexfld.byte 1 " GREEN "
bitfld.long 0 16.--25. " ALRED "  " "
;tree.end

base ad:0xa0350870
;tree "GAMA"
group 0--3
line.long 0 "GAMA"
hexfld.byte 0 " BLUE "
hexfld.byte 1 " GREEN "
hexfld.byte 2 " RED "
;tree.end

base ad:0xa0350874
;tree "ROTADD0A"
group 0--3
line.long 0 "ROTADD0A"
bitfld.long 0 3.--31. " BASEADDRESS0 "  " "
;tree.end

base ad:0xa0350878
;tree "ROTADD1A"
group 0--3
line.long 0 "ROTADD1A"
bitfld.long 0 3.--31. " BASEADDRESS1 "  " "
;tree.end

base ad:0xa0350a00
;tree "CRB0"
group 0--3
line.long 0 "CRB0"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 1. " POWEREN "  "0 ,1 "
bitfld.long 0 2. " BLENDEN "  "0 ,1 "
bitfld.long 0 3. " AFLICKEN "  "0 ,1 "
bitfld.long 0 4. " CEAEN "  "0 ,1 "
bitfld.long 0 5. " DITHEN "  "0 ,1 "
bitfld.long 0 6. " ROTEN "  "0 ,1 "
bitfld.long 0 7.--9. " KEYCTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " BLENDCTRL "  "0 ,1 "
bitfld.long 0 11.--12. " FLICKMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " FLICKFORMAT "  "0 ,1 "
bitfld.long 0 14. " GAMEN "  "0 ,1 "
bitfld.long 0 15. " ROTDIR "  "0 ,1 "
hexfld.byte 2 " ALPHABLEND "
hexfld.byte 3 " ROTSTRIPNB "
;tree.end

base ad:0xa0350a04
;tree "CRB1"
group 0--3
line.long 0 "CRB1"
bitfld.long 0 0.--9. " PCD "  " "
bitfld.long 0 10.--12. " CLKSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--15. " CDWIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--25. " CLP "  " "
bitfld.long 0 26.--28. " OUTBPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 29. " BCD "  "0 ,1 "
bitfld.long 0 30. " CLKTYPE "  "0 ,1 "
;tree.end

base ad:0xa0350a08
;tree "COLKEYB"
group 0--3
line.long 0 "COLKEYB"
hexfld.byte 0 " KEYB "
hexfld.byte 1 " KEYG "
hexfld.byte 2 " KEYR "
hexfld.byte 3 " KEYA "
;tree.end

base ad:0xa0350a0c
;tree "FCOLKEYB"
group 0--3
line.long 0 "FCOLKEYB"
hexfld.byte 0 " FKEYB "
hexfld.byte 1 " FKEYG "
hexfld.byte 2 " FKEYR "
hexfld.byte 3 " FKEYA "
;tree.end

base ad:0xa0350a10
;tree "RGBCONV1B"
group 0--3
line.long 0 "RGBCONV1B"
bitfld.long 0 0.--9. " Yr_green "  " "
bitfld.long 0 16.--25. " Yr_red "  " "
;tree.end

base ad:0xa0350a14
;tree "RGBCONV2B"
group 0--3
line.long 0 "RGBCONV2B"
bitfld.long 0 0.--9. " Cr_red "  " "
bitfld.long 0 16.--25. " Yr_blue "  " "
;tree.end

base ad:0xa0350a18
;tree "RGBCONV3B"
group 0--3
line.long 0 "RGBCONV3B"
bitfld.long 0 0.--9. " Cr_blue "  " "
bitfld.long 0 16.--25. " Cr_green "  " "
;tree.end

base ad:0xa0350a1c
;tree "RGBCONV4B"
group 0--3
line.long 0 "RGBCONV4B"
bitfld.long 0 0.--9. " Cb_green "  " "
bitfld.long 0 16.--25. " Cb_red "  " "
;tree.end

base ad:0xa0350a20
;tree "RGBCONV5B"
group 0--3
line.long 0 "RGBCONV5B"
bitfld.long 0 0.--9. " Off_red "  " "
bitfld.long 0 16.--25. " Cb_blue "  " "
;tree.end

base ad:0xa0350a24
;tree "RGBCONV6B"
group 0--3
line.long 0 "RGBCONV6B"
bitfld.long 0 0.--9. " Off_blue "  " "
bitfld.long 0 16.--25. " Off_green "  " "
;tree.end

base ad:0xa0350a28
;tree "FFCOEF0B"
group 0--3
line.long 0 "FFCOEF0B"
hexfld.byte 0 " COEFF0_N1 "
hexfld.byte 1 " COEFF0_N2 "
hexfld.byte 2 " COEFF0_N3 "
bitfld.long 0 24.--27. " T0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350a2c
;tree "FFCOEF1B"
group 0--3
line.long 0 "FFCOEF1B"
hexfld.byte 0 " COEFF1_N1 "
hexfld.byte 1 " COEFF1_N2 "
hexfld.byte 2 " COEFF1_N3 "
bitfld.long 0 24.--27. " T1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350a30
;tree "FFCOEF2B"
group 0--3
line.long 0 "FFCOEF2B"
hexfld.byte 0 " COEFF2_N1 "
hexfld.byte 1 " COEFF2_N2 "
hexfld.byte 2 " COEFF2_N3 "
bitfld.long 0 24.--27. " T2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350a38
;tree "TVCRB"
group 0--3
line.long 0 "TVCRB"
bitfld.long 0 0. " SELMOD "  "0 ,1 "
bitfld.long 0 1. " INTEREN "  "0 ,1 "
bitfld.long 0 2. " IFIELD "  "0 ,1 "
bitfld.long 0 3.--4. " TVMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--26. " LINES "  " "
;tree.end

base ad:0xa0350a3c
;tree "TVBL1B"
group 0--3
line.long 0 "TVBL1B"
bitfld.long 0 0.--10. " BEL1 "  " "
bitfld.long 0 16.--26. " BSL1 "  " "
;tree.end

base ad:0xa0350a40
;tree "TVISLB"
group 0--3
line.long 0 "TVISLB"
bitfld.long 0 0.--10. " FSL1 "  " "
bitfld.long 0 16.--26. " FSL2 "  " "
;tree.end

base ad:0xa0350a44
;tree "TVDVOB"
group 0--3
line.long 0 "TVDVOB"
bitfld.long 0 0.--10. " DVO1 "  " "
bitfld.long 0 16.--26. " DVO2 "  " "
;tree.end

base ad:0xa0350a48
;tree "TVSWHB"
group 0--3
line.long 0 "TVSWHB"
bitfld.long 0 0.--10. " SWH1 "  " "
bitfld.long 0 16.--26. " SWH2 "  " "
;tree.end

base ad:0xa0350a4c
;tree "TVTIM1B"
group 0--3
line.long 0 "TVTIM1B"
bitfld.long 0 0.--10. " DHO "  " "
bitfld.long 0 16.--26. " SWW "  " "
;tree.end

base ad:0xa0350a50
;tree "TVLBALWB"
group 0--3
line.long 0 "TVLBALWB"
bitfld.long 0 0.--10. " LBW "  " "
bitfld.long 0 16.--26. " ALW "  " "
;tree.end

base ad:0xa0350a54
;tree "TVBL2B"
group 0--3
line.long 0 "TVBL2B"
bitfld.long 0 0.--10. " BEL2 "  " "
bitfld.long 0 16.--26. " BSL2 "  " "
;tree.end

base ad:0xa0350a58
;tree "TVBLUB"
group 0--3
line.long 0 "TVBLUB"
hexfld.byte 0 " TVBLU "
hexfld.byte 1 " TVBCB "
hexfld.byte 2 " TVBCR "
;tree.end

base ad:0xa0350a5c
;tree "LCDTIM0B"
group 0--3
line.long 0 "LCDTIM0B"
hexfld.byte 0 " PSDEL0 "
bitfld.long 0 8.--11. " PSDEL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--13. " PSLOADSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " PSTGEN "  "0 ,1 "
bitfld.long 0 15. " PSVAEN "  "0 ,1 "
hexfld.byte 2 " REVDEL0 "
bitfld.long 0 24.--27. " REVDEL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " REVLOADSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 30. " REVTGEN "  "0 ,1 "
bitfld.long 0 31. " REVVAEN "  "0 ,1 "
;tree.end

base ad:0xa0350a60
;tree "LCDTIM1B"
group 0--3
line.long 0 "LCDTIM1B"
hexfld.byte 0 " SPLDEL0 "
bitfld.long 0 8.--11. " SPLDEL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--13. " SPLLOADSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " SPLTGEN "  "0 ,1 "
bitfld.long 0 15. " SPLVAEN "  "0 ,1 "
bitfld.long 0 16. " ICLPS "  "0 ,1 "
bitfld.long 0 17. " ICLREV "  "0 ,1 "
bitfld.long 0 18. " ICLSPL "  "0 ,1 "
bitfld.long 0 19. " IVP "  "0 ,1 "
bitfld.long 0 20. " IVS "  "0 ,1 "
bitfld.long 0 21. " IHS "  "0 ,1 "
bitfld.long 0 22. " IPC "  "0 ,1 "
bitfld.long 0 23. " IOE "  "0 ,1 "
;tree.end

base ad:0xa0350a64
;tree "DITHCTRLB"
group 0--3
line.long 0 "DITHCTRLB"
bitfld.long 0 0. " TEMP "  "0 ,1 "
bitfld.long 0 1. " COMP "  "0 ,1 "
bitfld.long 0 2.--3. " MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MASK "  "0 ,1 "
bitfld.long 0 5.--9. " FOFFX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--14. " FOFFY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0350a68
;tree "DITOFFB"
group 0--3
line.long 0 "DITOFFB"
bitfld.long 0 0.--4. " XG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " YG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " XB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--28. " YB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0350a6c
;tree "PAL0B"
group 0--3
line.long 0 "PAL0B"
hexfld.byte 0 " BLUE "
hexfld.byte 1 " GREEN "
bitfld.long 0 16.--25. " ALRED "  " "
;tree.end

base ad:0xa0350a70
;tree "GAMB"
group 0--3
line.long 0 "GAMB"
hexfld.byte 0 " BLUE "
hexfld.byte 1 " GREEN "
hexfld.byte 2 " RED "
;tree.end

base ad:0xa0350a74
;tree "ROTADD0B"
group 0--3
line.long 0 "ROTADD0B"
bitfld.long 0 3.--31. " BASEADDRESS0 "  " "
;tree.end

base ad:0xa0350a78
;tree "ROTADD1B"
group 0--3
line.long 0 "ROTADD1B"
bitfld.long 0 3.--31. " BASEADDRESS1 "  " "
;tree.end

base ad:0xa0350c00
;tree "CRC"
group 0--3
line.long 0 "CRC"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 1. " POWEREN "  "0 ,1 "
bitfld.long 0 2. " C1En "  "0 ,1 "
bitfld.long 0 3. " C2EN "  "0 ,1 "
bitfld.long 0 4. " WMLVL1 "  "0 ,1 "
bitfld.long 0 5. " WMLVL2 "  "0 ,1 "
bitfld.long 0 6. " SYNCSEL "  "0 ,1 "
bitfld.long 0 7. " SYCEN0 "  "0 ,1 "
bitfld.long 0 8. " SYCEN1 "  "0 ,1 "
bitfld.long 0 9. " SIZE1 "  "0 ,1 "
bitfld.long 0 10. " SIZE2 "  "0 ,1 "
bitfld.long 0 11. " INBAND1 "  "0 ,1 "
bitfld.long 0 12. " INBAND2 "  "0 ,1 "
bitfld.long 0 13.--14. " CLKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " CS1EN "  "0 ,1 "
bitfld.long 0 16. " CS2EN "  "0 ,1 "
bitfld.long 0 17. " RESEN "  "0 ,1 "
bitfld.long 0 18. " CS1POL "  "0 ,1 "
bitfld.long 0 19. " CS2POL "  "0 ,1 "
bitfld.long 0 20. " CD2POL "  "0 ,1 "
bitfld.long 0 21. " CD1POL "  "0 ,1 "
bitfld.long 0 22. " WR2POL "  "0 ,1 "
bitfld.long 0 23. " WR1POL "  "0 ,1 "
bitfld.long 0 24. " RD2POL "  "0 ,1 "
bitfld.long 0 25. " RD1POL "  "0 ,1 "
bitfld.long 0 26. " RES1POL "  "0 ,1 "
bitfld.long 0 27. " RES2POL "  "0 ,1 "
bitfld.long 0 28.--29. " SYNCCTRL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0350c04
;tree "PBCCRC0"
group 0--3
line.long 0 "PBCCRC0"
bitfld.long 0 0.--2. " BSCM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " BSDM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " PDM "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PDCTRL "  "0 ,1 "
;tree.end

base ad:0xa0350c08
;tree "PBCCRC1"
group 0--3
line.long 0 "PBCCRC1"
bitfld.long 0 0.--2. " BSCM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " BSDM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " PDM "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PDCTRL "  "0 ,1 "
;tree.end

base ad:0xa0350c0c
;tree "PBCBMRC00"
group 0--3
line.long 0 "PBCBMRC00"
bitfld.long 0 0. " MUX00 "  "0 ,1 "
bitfld.long 0 1. " MUX01 "  "0 ,1 "
bitfld.long 0 2. " MUX02 "  "0 ,1 "
bitfld.long 0 3. " MUX03 "  "0 ,1 "
bitfld.long 0 4. " MUX04 "  "0 ,1 "
bitfld.long 0 5. " MUX05 "  "0 ,1 "
bitfld.long 0 6. " MUX06 "  "0 ,1 "
bitfld.long 0 7. " MUX07 "  "0 ,1 "
bitfld.long 0 8. " MUX08 "  "0 ,1 "
bitfld.long 0 9. " MUX09 "  "0 ,1 "
bitfld.long 0 10. " MUX10 "  "0 ,1 "
bitfld.long 0 11. " MUX11 "  "0 ,1 "
bitfld.long 0 12. " MUX12 "  "0 ,1 "
bitfld.long 0 13. " MUX13 "  "0 ,1 "
bitfld.long 0 14. " MUX14 "  "0 ,1 "
bitfld.long 0 15. " MUX15 "  "0 ,1 "
bitfld.long 0 16. " MUX16 "  "0 ,1 "
bitfld.long 0 17. " MUX17 "  "0 ,1 "
bitfld.long 0 18. " MUX18 "  "0 ,1 "
bitfld.long 0 19. " MUX19 "  "0 ,1 "
bitfld.long 0 20. " MUX20 "  "0 ,1 "
bitfld.long 0 21. " MUX21 "  "0 ,1 "
bitfld.long 0 22. " MUX22 "  "0 ,1 "
bitfld.long 0 23. " MUX23 "  "0 ,1 "
bitfld.long 0 24. " MUX24 "  "0 ,1 "
bitfld.long 0 25. " MUX25 "  "0 ,1 "
bitfld.long 0 26. " MUX26 "  "0 ,1 "
bitfld.long 0 27. " MUX27 "  "0 ,1 "
bitfld.long 0 28. " MUX28 "  "0 ,1 "
bitfld.long 0 29. " MUX29 "  "0 ,1 "
bitfld.long 0 30. " MUX30 "  "0 ,1 "
bitfld.long 0 31. " MUX31 "  "0 ,1 "
;tree.end

base ad:0xa0350c10
;tree "PBCBMRC01"
group 0--3
line.long 0 "PBCBMRC01"
bitfld.long 0 0. " MUX00 "  "0 ,1 "
bitfld.long 0 1. " MUX01 "  "0 ,1 "
bitfld.long 0 2. " MUX02 "  "0 ,1 "
bitfld.long 0 3. " MUX03 "  "0 ,1 "
bitfld.long 0 4. " MUX04 "  "0 ,1 "
bitfld.long 0 5. " MUX05 "  "0 ,1 "
bitfld.long 0 6. " MUX06 "  "0 ,1 "
bitfld.long 0 7. " MUX07 "  "0 ,1 "
bitfld.long 0 8. " MUX08 "  "0 ,1 "
bitfld.long 0 9. " MUX09 "  "0 ,1 "
bitfld.long 0 10. " MUX10 "  "0 ,1 "
bitfld.long 0 11. " MUX11 "  "0 ,1 "
bitfld.long 0 12. " MUX12 "  "0 ,1 "
bitfld.long 0 13. " MUX13 "  "0 ,1 "
bitfld.long 0 14. " MUX14 "  "0 ,1 "
bitfld.long 0 15. " MUX15 "  "0 ,1 "
bitfld.long 0 16. " MUX16 "  "0 ,1 "
bitfld.long 0 17. " MUX17 "  "0 ,1 "
bitfld.long 0 18. " MUX18 "  "0 ,1 "
bitfld.long 0 19. " MUX19 "  "0 ,1 "
bitfld.long 0 20. " MUX20 "  "0 ,1 "
bitfld.long 0 21. " MUX21 "  "0 ,1 "
bitfld.long 0 22. " MUX22 "  "0 ,1 "
bitfld.long 0 23. " MUX23 "  "0 ,1 "
bitfld.long 0 24. " MUX24 "  "0 ,1 "
bitfld.long 0 25. " MUX25 "  "0 ,1 "
bitfld.long 0 26. " MUX26 "  "0 ,1 "
bitfld.long 0 27. " MUX27 "  "0 ,1 "
bitfld.long 0 28. " MUX28 "  "0 ,1 "
bitfld.long 0 29. " MUX29 "  "0 ,1 "
bitfld.long 0 30. " MUX30 "  "0 ,1 "
bitfld.long 0 31. " MUX31 "  "0 ,1 "
;tree.end

base ad:0xa0350c14
;tree "PBCBMRC02"
group 0--3
line.long 0 "PBCBMRC02"
bitfld.long 0 0. " MUX00 "  "0 ,1 "
bitfld.long 0 1. " MUX01 "  "0 ,1 "
bitfld.long 0 2. " MUX02 "  "0 ,1 "
bitfld.long 0 3. " MUX03 "  "0 ,1 "
bitfld.long 0 4. " MUX04 "  "0 ,1 "
bitfld.long 0 5. " MUX05 "  "0 ,1 "
bitfld.long 0 6. " MUX06 "  "0 ,1 "
bitfld.long 0 7. " MUX07 "  "0 ,1 "
bitfld.long 0 8. " MUX08 "  "0 ,1 "
bitfld.long 0 9. " MUX09 "  "0 ,1 "
bitfld.long 0 10. " MUX10 "  "0 ,1 "
bitfld.long 0 11. " MUX11 "  "0 ,1 "
bitfld.long 0 12. " MUX12 "  "0 ,1 "
bitfld.long 0 13. " MUX13 "  "0 ,1 "
bitfld.long 0 14. " MUX14 "  "0 ,1 "
bitfld.long 0 15. " MUX15 "  "0 ,1 "
bitfld.long 0 16. " MUX16 "  "0 ,1 "
bitfld.long 0 17. " MUX17 "  "0 ,1 "
bitfld.long 0 18. " MUX18 "  "0 ,1 "
bitfld.long 0 19. " MUX19 "  "0 ,1 "
bitfld.long 0 20. " MUX20 "  "0 ,1 "
bitfld.long 0 21. " MUX21 "  "0 ,1 "
bitfld.long 0 22. " MUX22 "  "0 ,1 "
bitfld.long 0 23. " MUX23 "  "0 ,1 "
bitfld.long 0 24. " MUX24 "  "0 ,1 "
bitfld.long 0 25. " MUX25 "  "0 ,1 "
bitfld.long 0 26. " MUX26 "  "0 ,1 "
bitfld.long 0 27. " MUX27 "  "0 ,1 "
bitfld.long 0 28. " MUX28 "  "0 ,1 "
bitfld.long 0 29. " MUX29 "  "0 ,1 "
bitfld.long 0 30. " MUX30 "  "0 ,1 "
bitfld.long 0 31. " MUX31 "  "0 ,1 "
;tree.end

base ad:0xa0350c18
;tree "PBCBMRC03"
group 0--3
line.long 0 "PBCBMRC03"
bitfld.long 0 0. " MUX00 "  "0 ,1 "
bitfld.long 0 1. " MUX01 "  "0 ,1 "
bitfld.long 0 2. " MUX02 "  "0 ,1 "
bitfld.long 0 3. " MUX03 "  "0 ,1 "
bitfld.long 0 4. " MUX04 "  "0 ,1 "
bitfld.long 0 5. " MUX05 "  "0 ,1 "
bitfld.long 0 6. " MUX06 "  "0 ,1 "
bitfld.long 0 7. " MUX07 "  "0 ,1 "
bitfld.long 0 8. " MUX08 "  "0 ,1 "
bitfld.long 0 9. " MUX09 "  "0 ,1 "
bitfld.long 0 10. " MUX10 "  "0 ,1 "
bitfld.long 0 11. " MUX11 "  "0 ,1 "
bitfld.long 0 12. " MUX12 "  "0 ,1 "
bitfld.long 0 13. " MUX13 "  "0 ,1 "
bitfld.long 0 14. " MUX14 "  "0 ,1 "
bitfld.long 0 15. " MUX15 "  "0 ,1 "
bitfld.long 0 16. " MUX16 "  "0 ,1 "
bitfld.long 0 17. " MUX17 "  "0 ,1 "
bitfld.long 0 18. " MUX18 "  "0 ,1 "
bitfld.long 0 19. " MUX19 "  "0 ,1 "
bitfld.long 0 20. " MUX20 "  "0 ,1 "
bitfld.long 0 21. " MUX21 "  "0 ,1 "
bitfld.long 0 22. " MUX22 "  "0 ,1 "
bitfld.long 0 23. " MUX23 "  "0 ,1 "
bitfld.long 0 24. " MUX24 "  "0 ,1 "
bitfld.long 0 25. " MUX25 "  "0 ,1 "
bitfld.long 0 26. " MUX26 "  "0 ,1 "
bitfld.long 0 27. " MUX27 "  "0 ,1 "
bitfld.long 0 28. " MUX28 "  "0 ,1 "
bitfld.long 0 29. " MUX29 "  "0 ,1 "
bitfld.long 0 30. " MUX30 "  "0 ,1 "
bitfld.long 0 31. " MUX31 "  "0 ,1 "
;tree.end

base ad:0xa0350c1c
;tree "PBCBMRC04"
group 0--3
line.long 0 "PBCBMRC04"
bitfld.long 0 0. " MUX00 "  "0 ,1 "
bitfld.long 0 1. " MUX01 "  "0 ,1 "
bitfld.long 0 2. " MUX02 "  "0 ,1 "
bitfld.long 0 3. " MUX03 "  "0 ,1 "
bitfld.long 0 4. " MUX04 "  "0 ,1 "
bitfld.long 0 5. " MUX05 "  "0 ,1 "
bitfld.long 0 6. " MUX06 "  "0 ,1 "
bitfld.long 0 7. " MUX07 "  "0 ,1 "
bitfld.long 0 8. " MUX08 "  "0 ,1 "
bitfld.long 0 9. " MUX09 "  "0 ,1 "
bitfld.long 0 10. " MUX10 "  "0 ,1 "
bitfld.long 0 11. " MUX11 "  "0 ,1 "
bitfld.long 0 12. " MUX12 "  "0 ,1 "
bitfld.long 0 13. " MUX13 "  "0 ,1 "
bitfld.long 0 14. " MUX14 "  "0 ,1 "
bitfld.long 0 15. " MUX15 "  "0 ,1 "
bitfld.long 0 16. " MUX16 "  "0 ,1 "
bitfld.long 0 17. " MUX17 "  "0 ,1 "
bitfld.long 0 18. " MUX18 "  "0 ,1 "
bitfld.long 0 19. " MUX19 "  "0 ,1 "
bitfld.long 0 20. " MUX20 "  "0 ,1 "
bitfld.long 0 21. " MUX21 "  "0 ,1 "
bitfld.long 0 22. " MUX22 "  "0 ,1 "
bitfld.long 0 23. " MUX23 "  "0 ,1 "
bitfld.long 0 24. " MUX24 "  "0 ,1 "
bitfld.long 0 25. " MUX25 "  "0 ,1 "
bitfld.long 0 26. " MUX26 "  "0 ,1 "
bitfld.long 0 27. " MUX27 "  "0 ,1 "
bitfld.long 0 28. " MUX28 "  "0 ,1 "
bitfld.long 0 29. " MUX29 "  "0 ,1 "
bitfld.long 0 30. " MUX30 "  "0 ,1 "
bitfld.long 0 31. " MUX31 "  "0 ,1 "
;tree.end

base ad:0xa0350c20
;tree "PBCBMRC10"
group 0--3
line.long 0 "PBCBMRC10"
bitfld.long 0 0. " MUX00 "  "0 ,1 "
bitfld.long 0 1. " MUX01 "  "0 ,1 "
bitfld.long 0 2. " MUX02 "  "0 ,1 "
bitfld.long 0 3. " MUX03 "  "0 ,1 "
bitfld.long 0 4. " MUX04 "  "0 ,1 "
bitfld.long 0 5. " MUX05 "  "0 ,1 "
bitfld.long 0 6. " MUX06 "  "0 ,1 "
bitfld.long 0 7. " MUX07 "  "0 ,1 "
bitfld.long 0 8. " MUX08 "  "0 ,1 "
bitfld.long 0 9. " MUX09 "  "0 ,1 "
bitfld.long 0 10. " MUX10 "  "0 ,1 "
bitfld.long 0 11. " MUX11 "  "0 ,1 "
bitfld.long 0 12. " MUX12 "  "0 ,1 "
bitfld.long 0 13. " MUX13 "  "0 ,1 "
bitfld.long 0 14. " MUX14 "  "0 ,1 "
bitfld.long 0 15. " MUX15 "  "0 ,1 "
bitfld.long 0 16. " MUX16 "  "0 ,1 "
bitfld.long 0 17. " MUX17 "  "0 ,1 "
bitfld.long 0 18. " MUX18 "  "0 ,1 "
bitfld.long 0 19. " MUX19 "  "0 ,1 "
bitfld.long 0 20. " MUX20 "  "0 ,1 "
bitfld.long 0 21. " MUX21 "  "0 ,1 "
bitfld.long 0 22. " MUX22 "  "0 ,1 "
bitfld.long 0 23. " MUX23 "  "0 ,1 "
bitfld.long 0 24. " MUX24 "  "0 ,1 "
bitfld.long 0 25. " MUX25 "  "0 ,1 "
bitfld.long 0 26. " MUX26 "  "0 ,1 "
bitfld.long 0 27. " MUX27 "  "0 ,1 "
bitfld.long 0 28. " MUX28 "  "0 ,1 "
bitfld.long 0 29. " MUX29 "  "0 ,1 "
bitfld.long 0 30. " MUX30 "  "0 ,1 "
bitfld.long 0 31. " MUX31 "  "0 ,1 "
;tree.end

base ad:0xa0350c24
;tree "PBCBMRC11"
group 0--3
line.long 0 "PBCBMRC11"
bitfld.long 0 0. " MUX00 "  "0 ,1 "
bitfld.long 0 1. " MUX01 "  "0 ,1 "
bitfld.long 0 2. " MUX02 "  "0 ,1 "
bitfld.long 0 3. " MUX03 "  "0 ,1 "
bitfld.long 0 4. " MUX04 "  "0 ,1 "
bitfld.long 0 5. " MUX05 "  "0 ,1 "
bitfld.long 0 6. " MUX06 "  "0 ,1 "
bitfld.long 0 7. " MUX07 "  "0 ,1 "
bitfld.long 0 8. " MUX08 "  "0 ,1 "
bitfld.long 0 9. " MUX09 "  "0 ,1 "
bitfld.long 0 10. " MUX10 "  "0 ,1 "
bitfld.long 0 11. " MUX11 "  "0 ,1 "
bitfld.long 0 12. " MUX12 "  "0 ,1 "
bitfld.long 0 13. " MUX13 "  "0 ,1 "
bitfld.long 0 14. " MUX14 "  "0 ,1 "
bitfld.long 0 15. " MUX15 "  "0 ,1 "
bitfld.long 0 16. " MUX16 "  "0 ,1 "
bitfld.long 0 17. " MUX17 "  "0 ,1 "
bitfld.long 0 18. " MUX18 "  "0 ,1 "
bitfld.long 0 19. " MUX19 "  "0 ,1 "
bitfld.long 0 20. " MUX20 "  "0 ,1 "
bitfld.long 0 21. " MUX21 "  "0 ,1 "
bitfld.long 0 22. " MUX22 "  "0 ,1 "
bitfld.long 0 23. " MUX23 "  "0 ,1 "
bitfld.long 0 24. " MUX24 "  "0 ,1 "
bitfld.long 0 25. " MUX25 "  "0 ,1 "
bitfld.long 0 26. " MUX26 "  "0 ,1 "
bitfld.long 0 27. " MUX27 "  "0 ,1 "
bitfld.long 0 28. " MUX28 "  "0 ,1 "
bitfld.long 0 29. " MUX29 "  "0 ,1 "
bitfld.long 0 30. " MUX30 "  "0 ,1 "
bitfld.long 0 31. " MUX31 "  "0 ,1 "
;tree.end

base ad:0xa0350c28
;tree "PBCBMRC12"
group 0--3
line.long 0 "PBCBMRC12"
bitfld.long 0 0. " MUX00 "  "0 ,1 "
bitfld.long 0 1. " MUX01 "  "0 ,1 "
bitfld.long 0 2. " MUX02 "  "0 ,1 "
bitfld.long 0 3. " MUX03 "  "0 ,1 "
bitfld.long 0 4. " MUX04 "  "0 ,1 "
bitfld.long 0 5. " MUX05 "  "0 ,1 "
bitfld.long 0 6. " MUX06 "  "0 ,1 "
bitfld.long 0 7. " MUX07 "  "0 ,1 "
bitfld.long 0 8. " MUX08 "  "0 ,1 "
bitfld.long 0 9. " MUX09 "  "0 ,1 "
bitfld.long 0 10. " MUX10 "  "0 ,1 "
bitfld.long 0 11. " MUX11 "  "0 ,1 "
bitfld.long 0 12. " MUX12 "  "0 ,1 "
bitfld.long 0 13. " MUX13 "  "0 ,1 "
bitfld.long 0 14. " MUX14 "  "0 ,1 "
bitfld.long 0 15. " MUX15 "  "0 ,1 "
bitfld.long 0 16. " MUX16 "  "0 ,1 "
bitfld.long 0 17. " MUX17 "  "0 ,1 "
bitfld.long 0 18. " MUX18 "  "0 ,1 "
bitfld.long 0 19. " MUX19 "  "0 ,1 "
bitfld.long 0 20. " MUX20 "  "0 ,1 "
bitfld.long 0 21. " MUX21 "  "0 ,1 "
bitfld.long 0 22. " MUX22 "  "0 ,1 "
bitfld.long 0 23. " MUX23 "  "0 ,1 "
bitfld.long 0 24. " MUX24 "  "0 ,1 "
bitfld.long 0 25. " MUX25 "  "0 ,1 "
bitfld.long 0 26. " MUX26 "  "0 ,1 "
bitfld.long 0 27. " MUX27 "  "0 ,1 "
bitfld.long 0 28. " MUX28 "  "0 ,1 "
bitfld.long 0 29. " MUX29 "  "0 ,1 "
bitfld.long 0 30. " MUX30 "  "0 ,1 "
bitfld.long 0 31. " MUX31 "  "0 ,1 "
;tree.end

base ad:0xa0350c2c
;tree "PBCBMRC13"
group 0--3
line.long 0 "PBCBMRC13"
bitfld.long 0 0. " MUX00 "  "0 ,1 "
bitfld.long 0 1. " MUX01 "  "0 ,1 "
bitfld.long 0 2. " MUX02 "  "0 ,1 "
bitfld.long 0 3. " MUX03 "  "0 ,1 "
bitfld.long 0 4. " MUX04 "  "0 ,1 "
bitfld.long 0 5. " MUX05 "  "0 ,1 "
bitfld.long 0 6. " MUX06 "  "0 ,1 "
bitfld.long 0 7. " MUX07 "  "0 ,1 "
bitfld.long 0 8. " MUX08 "  "0 ,1 "
bitfld.long 0 9. " MUX09 "  "0 ,1 "
bitfld.long 0 10. " MUX10 "  "0 ,1 "
bitfld.long 0 11. " MUX11 "  "0 ,1 "
bitfld.long 0 12. " MUX12 "  "0 ,1 "
bitfld.long 0 13. " MUX13 "  "0 ,1 "
bitfld.long 0 14. " MUX14 "  "0 ,1 "
bitfld.long 0 15. " MUX15 "  "0 ,1 "
bitfld.long 0 16. " MUX16 "  "0 ,1 "
bitfld.long 0 17. " MUX17 "  "0 ,1 "
bitfld.long 0 18. " MUX18 "  "0 ,1 "
bitfld.long 0 19. " MUX19 "  "0 ,1 "
bitfld.long 0 20. " MUX20 "  "0 ,1 "
bitfld.long 0 21. " MUX21 "  "0 ,1 "
bitfld.long 0 22. " MUX22 "  "0 ,1 "
bitfld.long 0 23. " MUX23 "  "0 ,1 "
bitfld.long 0 24. " MUX24 "  "0 ,1 "
bitfld.long 0 25. " MUX25 "  "0 ,1 "
bitfld.long 0 26. " MUX26 "  "0 ,1 "
bitfld.long 0 27. " MUX27 "  "0 ,1 "
bitfld.long 0 28. " MUX28 "  "0 ,1 "
bitfld.long 0 29. " MUX29 "  "0 ,1 "
bitfld.long 0 30. " MUX30 "  "0 ,1 "
bitfld.long 0 31. " MUX31 "  "0 ,1 "
;tree.end

base ad:0xa0350c30
;tree "PBCBMRC14"
group 0--3
line.long 0 "PBCBMRC14"
bitfld.long 0 0. " MUX00 "  "0 ,1 "
bitfld.long 0 1. " MUX01 "  "0 ,1 "
bitfld.long 0 2. " MUX02 "  "0 ,1 "
bitfld.long 0 3. " MUX03 "  "0 ,1 "
bitfld.long 0 4. " MUX04 "  "0 ,1 "
bitfld.long 0 5. " MUX05 "  "0 ,1 "
bitfld.long 0 6. " MUX06 "  "0 ,1 "
bitfld.long 0 7. " MUX07 "  "0 ,1 "
bitfld.long 0 8. " MUX08 "  "0 ,1 "
bitfld.long 0 9. " MUX09 "  "0 ,1 "
bitfld.long 0 10. " MUX10 "  "0 ,1 "
bitfld.long 0 11. " MUX11 "  "0 ,1 "
bitfld.long 0 12. " MUX12 "  "0 ,1 "
bitfld.long 0 13. " MUX13 "  "0 ,1 "
bitfld.long 0 14. " MUX14 "  "0 ,1 "
bitfld.long 0 15. " MUX15 "  "0 ,1 "
bitfld.long 0 16. " MUX16 "  "0 ,1 "
bitfld.long 0 17. " MUX17 "  "0 ,1 "
bitfld.long 0 18. " MUX18 "  "0 ,1 "
bitfld.long 0 19. " MUX19 "  "0 ,1 "
bitfld.long 0 20. " MUX20 "  "0 ,1 "
bitfld.long 0 21. " MUX21 "  "0 ,1 "
bitfld.long 0 22. " MUX22 "  "0 ,1 "
bitfld.long 0 23. " MUX23 "  "0 ,1 "
bitfld.long 0 24. " MUX24 "  "0 ,1 "
bitfld.long 0 25. " MUX25 "  "0 ,1 "
bitfld.long 0 26. " MUX26 "  "0 ,1 "
bitfld.long 0 27. " MUX27 "  "0 ,1 "
bitfld.long 0 28. " MUX28 "  "0 ,1 "
bitfld.long 0 29. " MUX29 "  "0 ,1 "
bitfld.long 0 30. " MUX30 "  "0 ,1 "
bitfld.long 0 31. " MUX31 "  "0 ,1 "
;tree.end

base ad:0xa0350c34
;tree "PBCBCR00"
group 0--3
line.long 0 "PBCBCR00"
bitfld.long 0 0. " CTL00 "  "0 ,1 "
bitfld.long 0 1. " CTL01 "  "0 ,1 "
bitfld.long 0 2. " CTL02 "  "0 ,1 "
bitfld.long 0 3. " CTL03 "  "0 ,1 "
bitfld.long 0 4. " CTL04 "  "0 ,1 "
bitfld.long 0 5. " CTL05 "  "0 ,1 "
bitfld.long 0 6. " CTL06 "  "0 ,1 "
bitfld.long 0 7. " CTL07 "  "0 ,1 "
bitfld.long 0 8. " CTL08 "  "0 ,1 "
bitfld.long 0 9. " CTL09 "  "0 ,1 "
bitfld.long 0 10. " CTL10 "  "0 ,1 "
bitfld.long 0 11. " CTL11 "  "0 ,1 "
bitfld.long 0 12. " CTL12 "  "0 ,1 "
bitfld.long 0 13. " CTL13 "  "0 ,1 "
bitfld.long 0 14. " CTL14 "  "0 ,1 "
bitfld.long 0 15. " CTL15 "  "0 ,1 "
bitfld.long 0 16. " CTL16 "  "0 ,1 "
bitfld.long 0 17. " CTL17 "  "0 ,1 "
bitfld.long 0 18. " CTL18 "  "0 ,1 "
bitfld.long 0 19. " CTL19 "  "0 ,1 "
bitfld.long 0 20. " CTL20 "  "0 ,1 "
bitfld.long 0 21. " CTL21 "  "0 ,1 "
bitfld.long 0 22. " CTL22 "  "0 ,1 "
bitfld.long 0 23. " CTL23 "  "0 ,1 "
bitfld.long 0 24. " CTL24 "  "0 ,1 "
bitfld.long 0 25. " CTL25 "  "0 ,1 "
bitfld.long 0 26. " CTL26 "  "0 ,1 "
bitfld.long 0 27. " CTL27 "  "0 ,1 "
bitfld.long 0 28. " CTL28 "  "0 ,1 "
bitfld.long 0 29. " CTL29 "  "0 ,1 "
bitfld.long 0 30. " CTL30 "  "0 ,1 "
bitfld.long 0 31. " CTL31 "  "0 ,1 "
;tree.end

base ad:0xa0350c38
;tree "PBCBCR01"
group 0--3
line.long 0 "PBCBCR01"
bitfld.long 0 0. " CTL00 "  "0 ,1 "
bitfld.long 0 1. " CTL01 "  "0 ,1 "
bitfld.long 0 2. " CTL02 "  "0 ,1 "
bitfld.long 0 3. " CTL03 "  "0 ,1 "
bitfld.long 0 4. " CTL04 "  "0 ,1 "
bitfld.long 0 5. " CTL05 "  "0 ,1 "
bitfld.long 0 6. " CTL06 "  "0 ,1 "
bitfld.long 0 7. " CTL07 "  "0 ,1 "
bitfld.long 0 8. " CTL08 "  "0 ,1 "
bitfld.long 0 9. " CTL09 "  "0 ,1 "
bitfld.long 0 10. " CTL10 "  "0 ,1 "
bitfld.long 0 11. " CTL11 "  "0 ,1 "
bitfld.long 0 12. " CTL12 "  "0 ,1 "
bitfld.long 0 13. " CTL13 "  "0 ,1 "
bitfld.long 0 14. " CTL14 "  "0 ,1 "
bitfld.long 0 15. " CTL15 "  "0 ,1 "
bitfld.long 0 16. " CTL16 "  "0 ,1 "
bitfld.long 0 17. " CTL17 "  "0 ,1 "
bitfld.long 0 18. " CTL18 "  "0 ,1 "
bitfld.long 0 19. " CTL19 "  "0 ,1 "
bitfld.long 0 20. " CTL20 "  "0 ,1 "
bitfld.long 0 21. " CTL21 "  "0 ,1 "
bitfld.long 0 22. " CTL22 "  "0 ,1 "
bitfld.long 0 23. " CTL23 "  "0 ,1 "
bitfld.long 0 24. " CTL24 "  "0 ,1 "
bitfld.long 0 25. " CTL25 "  "0 ,1 "
bitfld.long 0 26. " CTL26 "  "0 ,1 "
bitfld.long 0 27. " CTL27 "  "0 ,1 "
bitfld.long 0 28. " CTL28 "  "0 ,1 "
bitfld.long 0 29. " CTL29 "  "0 ,1 "
bitfld.long 0 30. " CTL30 "  "0 ,1 "
bitfld.long 0 31. " CTL31 "  "0 ,1 "
;tree.end

base ad:0xa0350c48
;tree "PBCBCR10"
group 0--3
line.long 0 "PBCBCR10"
bitfld.long 0 0. " CTL00 "  "0 ,1 "
bitfld.long 0 1. " CTL01 "  "0 ,1 "
bitfld.long 0 2. " CTL02 "  "0 ,1 "
bitfld.long 0 3. " CTL03 "  "0 ,1 "
bitfld.long 0 4. " CTL04 "  "0 ,1 "
bitfld.long 0 5. " CTL05 "  "0 ,1 "
bitfld.long 0 6. " CTL06 "  "0 ,1 "
bitfld.long 0 7. " CTL07 "  "0 ,1 "
bitfld.long 0 8. " CTL08 "  "0 ,1 "
bitfld.long 0 9. " CTL09 "  "0 ,1 "
bitfld.long 0 10. " CTL10 "  "0 ,1 "
bitfld.long 0 11. " CTL11 "  "0 ,1 "
bitfld.long 0 12. " CTL12 "  "0 ,1 "
bitfld.long 0 13. " CTL13 "  "0 ,1 "
bitfld.long 0 14. " CTL14 "  "0 ,1 "
bitfld.long 0 15. " CTL15 "  "0 ,1 "
bitfld.long 0 16. " CTL16 "  "0 ,1 "
bitfld.long 0 17. " CTL17 "  "0 ,1 "
bitfld.long 0 18. " CTL18 "  "0 ,1 "
bitfld.long 0 19. " CTL19 "  "0 ,1 "
bitfld.long 0 20. " CTL20 "  "0 ,1 "
bitfld.long 0 21. " CTL21 "  "0 ,1 "
bitfld.long 0 22. " CTL22 "  "0 ,1 "
bitfld.long 0 23. " CTL23 "  "0 ,1 "
bitfld.long 0 24. " CTL24 "  "0 ,1 "
bitfld.long 0 25. " CTL25 "  "0 ,1 "
bitfld.long 0 26. " CTL26 "  "0 ,1 "
bitfld.long 0 27. " CTL27 "  "0 ,1 "
bitfld.long 0 28. " CTL28 "  "0 ,1 "
bitfld.long 0 29. " CTL29 "  "0 ,1 "
bitfld.long 0 30. " CTL30 "  "0 ,1 "
bitfld.long 0 31. " CTL31 "  "0 ,1 "
;tree.end

base ad:0xa0350c4c
;tree "PBCBCR11"
group 0--3
line.long 0 "PBCBCR11"
bitfld.long 0 0. " CTL00 "  "0 ,1 "
bitfld.long 0 1. " CTL01 "  "0 ,1 "
bitfld.long 0 2. " CTL02 "  "0 ,1 "
bitfld.long 0 3. " CTL03 "  "0 ,1 "
bitfld.long 0 4. " CTL04 "  "0 ,1 "
bitfld.long 0 5. " CTL05 "  "0 ,1 "
bitfld.long 0 6. " CTL06 "  "0 ,1 "
bitfld.long 0 7. " CTL07 "  "0 ,1 "
bitfld.long 0 8. " CTL08 "  "0 ,1 "
bitfld.long 0 9. " CTL09 "  "0 ,1 "
bitfld.long 0 10. " CTL10 "  "0 ,1 "
bitfld.long 0 11. " CTL11 "  "0 ,1 "
bitfld.long 0 12. " CTL12 "  "0 ,1 "
bitfld.long 0 13. " CTL13 "  "0 ,1 "
bitfld.long 0 14. " CTL14 "  "0 ,1 "
bitfld.long 0 15. " CTL15 "  "0 ,1 "
bitfld.long 0 16. " CTL16 "  "0 ,1 "
bitfld.long 0 17. " CTL17 "  "0 ,1 "
bitfld.long 0 18. " CTL18 "  "0 ,1 "
bitfld.long 0 19. " CTL19 "  "0 ,1 "
bitfld.long 0 20. " CTL20 "  "0 ,1 "
bitfld.long 0 21. " CTL21 "  "0 ,1 "
bitfld.long 0 22. " CTL22 "  "0 ,1 "
bitfld.long 0 23. " CTL23 "  "0 ,1 "
bitfld.long 0 24. " CTL24 "  "0 ,1 "
bitfld.long 0 25. " CTL25 "  "0 ,1 "
bitfld.long 0 26. " CTL26 "  "0 ,1 "
bitfld.long 0 27. " CTL27 "  "0 ,1 "
bitfld.long 0 28. " CTL28 "  "0 ,1 "
bitfld.long 0 29. " CTL29 "  "0 ,1 "
bitfld.long 0 30. " CTL30 "  "0 ,1 "
bitfld.long 0 31. " CTL31 "  "0 ,1 "
;tree.end

base ad:0xa0350c5c
;tree "VSCRC0"
group 0--3
line.long 0 "VSCRC0"
bitfld.long 0 0.--11. " VSPMIN "  " "
bitfld.long 0 12.--23. " VSPMAX "  " "
bitfld.long 0 24.--26. " VSPDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 27. " VSPOL "  "0 ,1 "
bitfld.long 0 28. " VSSEL "  "0 ,1 "
bitfld.long 0 29.--31. " VSDBAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350c60
;tree "VSCRC1"
group 0--3
line.long 0 "VSCRC1"
bitfld.long 0 0.--11. " VSPMIN "  " "
bitfld.long 0 12.--23. " VSPMAX "  " "
bitfld.long 0 24.--26. " VSPDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 27. " VSPOL "  "0 ,1 "
bitfld.long 0 28. " VSSEL "  "0 ,1 "
bitfld.long 0 29.--31. " VSDBAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350c64
;tree "SCTRC"
group 0--3
line.long 0 "SCTRC"
hexfld.byte 0 " SYNCDELC0 "
hexfld.byte 1 " SYNCDELC1 "
bitfld.long 0 16.--27. " TRDELC "  " "
;tree.end

base ad:0xa0350c68
;tree "SCSRC"
rgroup 0--3
line.long 0 "SCSRC"
bitfld.long 0 0. " VSTAC0 "  "0 ,1 "
bitfld.long 0 1. " VSTAC1 "  "0 ,1 "
;tree.end

base ad:0xa0350c6c
;tree "BCNR0"
group 0--3
line.long 0 "BCNR0"
hexfld.byte 0 " BCN "
;tree.end

base ad:0xa0350c70
;tree "BCNR1"
group 0--3
line.long 0 "BCNR1"
hexfld.byte 0 " BCN "
;tree.end

base ad:0xa0350c74
;tree "CSCDTRC0"
group 0--3
line.long 0 "CSCDTRC0"
hexfld.byte 0 " CSCDACT "
hexfld.byte 1 " CSCDDEACT "
;tree.end

base ad:0xa0350c78
;tree "CSCDTRC1"
group 0--3
line.long 0 "CSCDTRC1"
hexfld.byte 0 " CSCDACT "
hexfld.byte 1 " CSCDDEACT "
;tree.end

base ad:0xa0350c7c
;tree "RDWRTRC0"
group 0--3
line.long 0 "RDWRTRC0"
hexfld.byte 0 " RWACT "
hexfld.byte 1 " RWDEACT "
bitfld.long 0 16. " MOTINT "  "0 ,1 "
;tree.end

base ad:0xa0350c80
;tree "RDWRTRC1"
group 0--3
line.long 0 "RDWRTRC1"
hexfld.byte 0 " RWACT "
hexfld.byte 1 " RWDEACT "
bitfld.long 0 16. " MOTINT "  "0 ,1 "
;tree.end

base ad:0xa0350c84
;tree "DOTRC0"
group 0--3
line.long 0 "DOTRC0"
hexfld.byte 0 " DOACT "
hexfld.byte 1 " DODEACT "
;tree.end

base ad:0xa0350c88
;tree "DOTRC1"
group 0--3
line.long 0 "DOTRC1"
hexfld.byte 0 " DOACT "
hexfld.byte 1 " DODEACT "
;tree.end

base ad:0xa0350c8c
;tree "WCMDC0"
wgroup 0--3
line.long 0 "WCMDC0"
hexfld.long 0 " DCMDVAL "
;tree.end

base ad:0xa0350c90
;tree "WCMDC1"
wgroup 0--3
line.long 0 "WCMDC1"
hexfld.long 0 " DCMDVAL "
;tree.end

base ad:0xa0350c94
;tree "WDC0"
wgroup 0--3
line.long 0 "WDC0"
hexfld.long 0 " DCMDVAL "
;tree.end

base ad:0xa0350c98
;tree "WDC1"
wgroup 0--3
line.long 0 "WDC1"
hexfld.long 0 " DCMDVAL "
;tree.end

base ad:0xa0350c9c
;tree "RDATADC0"
rgroup 0--3
line.long 0 "RDATADC0"
hexfld.word 0 " RDATAVAL "
;tree.end

base ad:0xa0350ca0
;tree "RDATADC1"
rgroup 0--3
line.long 0 "RDATADC1"
hexfld.word 0 " RDATAVAL "
;tree.end

base ad:0xa0350ca4
;tree "STATC"
group 0--3
line.long 0 "STATC"
bitfld.long 0 0.--9. " RSTAT "  " "
;tree.end

base ad:0xa0350e00
;tree "DSI0CONF0"
group 0--3
line.long 0 "DSI0CONF0"
bitfld.long 0 0.--3. " BLANKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e04
;tree "DSI0FRAME"
group 0--3
line.long 0 "DSI0FRAME"
bitfld.long 0 0.--3. " BLANKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSCMD_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e08
;tree "DSI0PKT"
group 0--3
line.long 0 "DSI0PKT"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e0c
;tree "DSI0SYNC"
group 0--3
line.long 0 "DSI0SYNC"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e10
;tree "DSI0CMDW"
group 0--3
line.long 0 "DSI0CMDW"
hexfld.word 0 " PACKET "
;tree.end

base ad:0xa0350e20
;tree "DSI1CONF0"
group 0--3
line.long 0 "DSI1CONF0"
bitfld.long 0 0.--3. " BLANKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e24
;tree "DSI1FRAME"
group 0--3
line.long 0 "DSI1FRAME"
bitfld.long 0 0.--3. " BLANKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSCMD_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e28
;tree "DSI1PKT"
group 0--3
line.long 0 "DSI1PKT"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e2c
;tree "DSI1SYNC"
group 0--3
line.long 0 "DSI1SYNC"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e30
;tree "DSI1CMDW"
group 0--3
line.long 0 "DSI1CMDW"
hexfld.word 0 " PACKET "
;tree.end

base ad:0xa0350e40
;tree "DSI2CONF0"
group 0--3
line.long 0 "DSI2CONF0"
bitfld.long 0 0.--3. " BLANKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e44
;tree "DSI2FRAME"
group 0--3
line.long 0 "DSI2FRAME"
bitfld.long 0 0.--3. " BLANKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSCMD_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e48
;tree "DSI2PKT"
group 0--3
line.long 0 "DSI2PKT"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e4c
;tree "DSI2SYNC"
group 0--3
line.long 0 "DSI2SYNC"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e50
;tree "DSI2CMDW"
group 0--3
line.long 0 "DSI2CMDW"
hexfld.word 0 " PACKET "
;tree.end

base ad:0xa0350e60
;tree "DSI3CONF0"
group 0--3
line.long 0 "DSI3CONF0"
bitfld.long 0 0.--3. " BLANKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e64
;tree "DSI3FRAME"
group 0--3
line.long 0 "DSI3FRAME"
bitfld.long 0 0.--3. " BLANKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSCMD_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e68
;tree "DSI3PKT"
group 0--3
line.long 0 "DSI3PKT"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e6c
;tree "DSI3SYNC"
group 0--3
line.long 0 "DSI3SYNC"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e70
;tree "DSI3CMDW"
group 0--3
line.long 0 "DSI3CMDW"
hexfld.word 0 " PACKET "
;tree.end

base ad:0xa0350e80
;tree "DSI4CONF0"
group 0--3
line.long 0 "DSI4CONF0"
bitfld.long 0 0.--3. " BLANKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e84
;tree "DSI4FRAME"
group 0--3
line.long 0 "DSI4FRAME"
bitfld.long 0 0.--3. " BLANKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSCMD_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e88
;tree "DSI4PKT"
group 0--3
line.long 0 "DSI4PKT"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e8c
;tree "DSI4SYNC"
group 0--3
line.long 0 "DSI4SYNC"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e90
;tree "DSI4CMDW"
group 0--3
line.long 0 "DSI4CMDW"
hexfld.word 0 " PACKET "
;tree.end

base ad:0xa0350ea0
;tree "DSI5CONF0"
group 0--3
line.long 0 "DSI5CONF0"
bitfld.long 0 0.--3. " BLANKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350ea4
;tree "DSI5FRAME"
group 0--3
line.long 0 "DSI5FRAME"
bitfld.long 0 0.--3. " BLANKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSCMD_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350ea8
;tree "DSI5PKT"
group 0--3
line.long 0 "DSI5PKT"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350eac
;tree "DSI5SYNC"
group 0--3
line.long 0 "DSI5SYNC"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350eb0
;tree "DSI5CMDW"
group 0--3
line.long 0 "DSI5CMDW"
hexfld.word 0 " PACKET "
;tree.end

base ad:0xa0350ef0
;tree "CLKDSI"
group 0--3
line.long 0 "CLKDSI"
hexfld.word 0 " PACKET "
;tree.end

endif

tree.end

;==============================================================
tree "MMCI (6 instances)"
;==============================================================
base ad:0x80126000
;********************************************
tree "MMCI-0"
;********************************************
base ad:0x80126000
;tree "0Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
;tree.end

base ad:0x80126004
;tree "0Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
;tree.end

base ad:0x80126008
;tree "0Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

base ad:0x8012600c
;tree "0Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

base ad:0x80126010
;tree "0RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80126014
;tree "0Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

base ad:0x80126018
;tree "0Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

base ad:0x8012601c
;tree "0Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

base ad:0x80126020
;tree "0Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

base ad:0x80126024
;tree "0Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

base ad:0x80126028
;tree "0DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

base ad:0x8012602c
;tree "0DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 4.--7. " BlockSize "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
;tree.end

base ad:0x80126030
;tree "0DataCnt"
rgroup 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

base ad:0x80126034
;tree "0Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
;tree.end

base ad:0x80126038
;tree "0Clear"
wgroup 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 25. " BOOTACKTIMEOUTC "  "0 ,1 "
;tree.end

base ad:0x8012603c
;tree "0Mask"
group 0--3
line.long 0 "Mask"
;tree.end

base ad:0x80126040
;tree "0Mask1"
group 0--3
line.long 0 "Mask1"
;tree.end

base ad:0x80126044
;tree "0CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80126048
;tree "0FifoCnt"
rgroup 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

base ad:0x80126080
;tree "0Fifo_0"
group 0--3
line.long 0 "Fifo_0"
hexfld.long 0 " Data "
;tree.end

base ad:0x80126084
;tree "0Fifo_1"
group 0--3
line.long 0 "Fifo_1"
hexfld.long 0 " Data "
;tree.end

base ad:0x80126088
;tree "0Fifo_2"
group 0--3
line.long 0 "Fifo_2"
hexfld.long 0 " Data "
;tree.end

base ad:0x8012608c
;tree "0Fifo_3"
group 0--3
line.long 0 "Fifo_3"
hexfld.long 0 " Data "
;tree.end

base ad:0x80126090
;tree "0Fifo_4"
group 0--3
line.long 0 "Fifo_4"
hexfld.long 0 " Data "
;tree.end

base ad:0x80126094
;tree "0Fifo_5"
group 0--3
line.long 0 "Fifo_5"
hexfld.long 0 " Data "
;tree.end

base ad:0x80126098
;tree "0Fifo_6"
group 0--3
line.long 0 "Fifo_6"
hexfld.long 0 " Data "
;tree.end

base ad:0x8012609c
;tree "0Fifo_7"
group 0--3
line.long 0 "Fifo_7"
hexfld.long 0 " Data "
;tree.end

base ad:0x801260a0
;tree "0Fifo_8"
group 0--3
line.long 0 "Fifo_8"
hexfld.long 0 " Data "
;tree.end

base ad:0x801260a4
;tree "0Fifo_9"
group 0--3
line.long 0 "Fifo_9"
hexfld.long 0 " Data "
;tree.end

base ad:0x801260a8
;tree "0Fifo_10"
group 0--3
line.long 0 "Fifo_10"
hexfld.long 0 " Data "
;tree.end

base ad:0x801260ac
;tree "0Fifo_11"
group 0--3
line.long 0 "Fifo_11"
hexfld.long 0 " Data "
;tree.end

base ad:0x801260b0
;tree "0Fifo_12"
group 0--3
line.long 0 "Fifo_12"
hexfld.long 0 " Data "
;tree.end

base ad:0x801260b4
;tree "0Fifo_13"
group 0--3
line.long 0 "Fifo_13"
hexfld.long 0 " Data "
;tree.end

base ad:0x801260b8
;tree "0Fifo_14"
group 0--3
line.long 0 "Fifo_14"
hexfld.long 0 " Data "
;tree.end

base ad:0x801260bc
;tree "0Fifo_15"
group 0--3
line.long 0 "Fifo_15"
hexfld.long 0 " Data "
;tree.end

base ad:0x801260c0
;tree "0DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

base ad:0x80126fe0
;tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80126fe4
;tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80126fe8
;tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80126fec
;tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80126ff0
;tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

base ad:0x80126ff4
;tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

base ad:0x80126ff8
;tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

base ad:0x80126ffc
;tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

base ad:0x80114000
;********************************************
tree "MMCI-4"
;********************************************
base ad:0x80114000
;tree "4Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
;tree.end

base ad:0x80114004
;tree "4Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
;tree.end

base ad:0x80114008
;tree "4Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

base ad:0x8011400c
;tree "4Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

base ad:0x80114010
;tree "4RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80114014
;tree "4Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

base ad:0x80114018
;tree "4Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

base ad:0x8011401c
;tree "4Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

base ad:0x80114020
;tree "4Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

base ad:0x80114024
;tree "4Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

base ad:0x80114028
;tree "4DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

base ad:0x8011402c
;tree "4DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 4.--7. " BlockSize "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
;tree.end

base ad:0x80114030
;tree "4DataCnt"
rgroup 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

base ad:0x80114034
;tree "4Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
;tree.end

base ad:0x80114038
;tree "4Clear"
wgroup 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 25. " BOOTACKTIMEOUTC "  "0 ,1 "
;tree.end

base ad:0x8011403c
;tree "4Mask"
group 0--3
line.long 0 "Mask"
;tree.end

base ad:0x80114040
;tree "4Mask1"
group 0--3
line.long 0 "Mask1"
;tree.end

base ad:0x80114044
;tree "4CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80114048
;tree "4FifoCnt"
rgroup 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

base ad:0x80114080
;tree "4Fifo_0"
group 0--3
line.long 0 "Fifo_0"
hexfld.long 0 " Data "
;tree.end

base ad:0x80114084
;tree "4Fifo_1"
group 0--3
line.long 0 "Fifo_1"
hexfld.long 0 " Data "
;tree.end

base ad:0x80114088
;tree "4Fifo_2"
group 0--3
line.long 0 "Fifo_2"
hexfld.long 0 " Data "
;tree.end

base ad:0x8011408c
;tree "4Fifo_3"
group 0--3
line.long 0 "Fifo_3"
hexfld.long 0 " Data "
;tree.end

base ad:0x80114090
;tree "4Fifo_4"
group 0--3
line.long 0 "Fifo_4"
hexfld.long 0 " Data "
;tree.end

base ad:0x80114094
;tree "4Fifo_5"
group 0--3
line.long 0 "Fifo_5"
hexfld.long 0 " Data "
;tree.end

base ad:0x80114098
;tree "4Fifo_6"
group 0--3
line.long 0 "Fifo_6"
hexfld.long 0 " Data "
;tree.end

base ad:0x8011409c
;tree "4Fifo_7"
group 0--3
line.long 0 "Fifo_7"
hexfld.long 0 " Data "
;tree.end

base ad:0x801140a0
;tree "4Fifo_8"
group 0--3
line.long 0 "Fifo_8"
hexfld.long 0 " Data "
;tree.end

base ad:0x801140a4
;tree "4Fifo_9"
group 0--3
line.long 0 "Fifo_9"
hexfld.long 0 " Data "
;tree.end

base ad:0x801140a8
;tree "4Fifo_10"
group 0--3
line.long 0 "Fifo_10"
hexfld.long 0 " Data "
;tree.end

base ad:0x801140ac
;tree "4Fifo_11"
group 0--3
line.long 0 "Fifo_11"
hexfld.long 0 " Data "
;tree.end

base ad:0x801140b0
;tree "4Fifo_12"
group 0--3
line.long 0 "Fifo_12"
hexfld.long 0 " Data "
;tree.end

base ad:0x801140b4
;tree "4Fifo_13"
group 0--3
line.long 0 "Fifo_13"
hexfld.long 0 " Data "
;tree.end

base ad:0x801140b8
;tree "4Fifo_14"
group 0--3
line.long 0 "Fifo_14"
hexfld.long 0 " Data "
;tree.end

base ad:0x801140bc
;tree "4Fifo_15"
group 0--3
line.long 0 "Fifo_15"
hexfld.long 0 " Data "
;tree.end

base ad:0x801140c0
;tree "4DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

base ad:0x80114fe0
;tree "4PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80114fe4
;tree "4PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80114fe8
;tree "4PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80114fec
;tree "4PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80114ff0
;tree "4PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

base ad:0x80114ff4
;tree "4PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

base ad:0x80114ff8
;tree "4PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

base ad:0x80114ffc
;tree "4PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

base ad:0x80118000
;********************************************
tree "MMCI-1"
;********************************************
base ad:0x80118000
;tree "1Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
;tree.end

base ad:0x80118004
;tree "1Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
;tree.end

base ad:0x80118008
;tree "1Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

base ad:0x8011800c
;tree "1Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

base ad:0x80118010
;tree "1RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80118014
;tree "1Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

base ad:0x80118018
;tree "1Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

base ad:0x8011801c
;tree "1Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

base ad:0x80118020
;tree "1Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

base ad:0x80118024
;tree "1Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

base ad:0x80118028
;tree "1DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

base ad:0x8011802c
;tree "1DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 4.--7. " BlockSize "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
;tree.end

base ad:0x80118030
;tree "1DataCnt"
rgroup 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

base ad:0x80118034
;tree "1Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
;tree.end

base ad:0x80118038
;tree "1Clear"
wgroup 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 25. " BOOTACKTIMEOUTC "  "0 ,1 "
;tree.end

base ad:0x8011803c
;tree "1Mask"
group 0--3
line.long 0 "Mask"
;tree.end

base ad:0x80118040
;tree "1Mask1"
group 0--3
line.long 0 "Mask1"
;tree.end

base ad:0x80118044
;tree "1CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80118048
;tree "1FifoCnt"
rgroup 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

base ad:0x80118080
;tree "1Fifo_0"
group 0--3
line.long 0 "Fifo_0"
hexfld.long 0 " Data "
;tree.end

base ad:0x80118084
;tree "1Fifo_1"
group 0--3
line.long 0 "Fifo_1"
hexfld.long 0 " Data "
;tree.end

base ad:0x80118088
;tree "1Fifo_2"
group 0--3
line.long 0 "Fifo_2"
hexfld.long 0 " Data "
;tree.end

base ad:0x8011808c
;tree "1Fifo_3"
group 0--3
line.long 0 "Fifo_3"
hexfld.long 0 " Data "
;tree.end

base ad:0x80118090
;tree "1Fifo_4"
group 0--3
line.long 0 "Fifo_4"
hexfld.long 0 " Data "
;tree.end

base ad:0x80118094
;tree "1Fifo_5"
group 0--3
line.long 0 "Fifo_5"
hexfld.long 0 " Data "
;tree.end

base ad:0x80118098
;tree "1Fifo_6"
group 0--3
line.long 0 "Fifo_6"
hexfld.long 0 " Data "
;tree.end

base ad:0x8011809c
;tree "1Fifo_7"
group 0--3
line.long 0 "Fifo_7"
hexfld.long 0 " Data "
;tree.end

base ad:0x801180a0
;tree "1Fifo_8"
group 0--3
line.long 0 "Fifo_8"
hexfld.long 0 " Data "
;tree.end

base ad:0x801180a4
;tree "1Fifo_9"
group 0--3
line.long 0 "Fifo_9"
hexfld.long 0 " Data "
;tree.end

base ad:0x801180a8
;tree "1Fifo_10"
group 0--3
line.long 0 "Fifo_10"
hexfld.long 0 " Data "
;tree.end

base ad:0x801180ac
;tree "1Fifo_11"
group 0--3
line.long 0 "Fifo_11"
hexfld.long 0 " Data "
;tree.end

base ad:0x801180b0
;tree "1Fifo_12"
group 0--3
line.long 0 "Fifo_12"
hexfld.long 0 " Data "
;tree.end

base ad:0x801180b4
;tree "1Fifo_13"
group 0--3
line.long 0 "Fifo_13"
hexfld.long 0 " Data "
;tree.end

base ad:0x801180b8
;tree "1Fifo_14"
group 0--3
line.long 0 "Fifo_14"
hexfld.long 0 " Data "
;tree.end

base ad:0x801180bc
;tree "1Fifo_15"
group 0--3
line.long 0 "Fifo_15"
hexfld.long 0 " Data "
;tree.end

base ad:0x801180c0
;tree "1DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

base ad:0x80118fe0
;tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80118fe4
;tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80118fe8
;tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80118fec
;tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80118ff0
;tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

base ad:0x80118ff4
;tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

base ad:0x80118ff8
;tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

base ad:0x80118ffc
;tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

base ad:0x80119000
;********************************************
tree "MMCI-3"
;********************************************
base ad:0x80119000
;tree "3Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
;tree.end

base ad:0x80119004
;tree "3Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
;tree.end

base ad:0x80119008
;tree "3Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

base ad:0x8011900c
;tree "3Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

base ad:0x80119010
;tree "3RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80119014
;tree "3Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

base ad:0x80119018
;tree "3Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

base ad:0x8011901c
;tree "3Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

base ad:0x80119020
;tree "3Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

base ad:0x80119024
;tree "3Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

base ad:0x80119028
;tree "3DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

base ad:0x8011902c
;tree "3DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 4.--7. " BlockSize "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
;tree.end

base ad:0x80119030
;tree "3DataCnt"
rgroup 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

base ad:0x80119034
;tree "3Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
;tree.end

base ad:0x80119038
;tree "3Clear"
wgroup 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 25. " BOOTACKTIMEOUTC "  "0 ,1 "
;tree.end

base ad:0x8011903c
;tree "3Mask"
group 0--3
line.long 0 "Mask"
;tree.end

base ad:0x80119040
;tree "3Mask1"
group 0--3
line.long 0 "Mask1"
;tree.end

base ad:0x80119044
;tree "3CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80119048
;tree "3FifoCnt"
rgroup 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

base ad:0x80119080
;tree "3Fifo_0"
group 0--3
line.long 0 "Fifo_0"
hexfld.long 0 " Data "
;tree.end

base ad:0x80119084
;tree "3Fifo_1"
group 0--3
line.long 0 "Fifo_1"
hexfld.long 0 " Data "
;tree.end

base ad:0x80119088
;tree "3Fifo_2"
group 0--3
line.long 0 "Fifo_2"
hexfld.long 0 " Data "
;tree.end

base ad:0x8011908c
;tree "3Fifo_3"
group 0--3
line.long 0 "Fifo_3"
hexfld.long 0 " Data "
;tree.end

base ad:0x80119090
;tree "3Fifo_4"
group 0--3
line.long 0 "Fifo_4"
hexfld.long 0 " Data "
;tree.end

base ad:0x80119094
;tree "3Fifo_5"
group 0--3
line.long 0 "Fifo_5"
hexfld.long 0 " Data "
;tree.end

base ad:0x80119098
;tree "3Fifo_6"
group 0--3
line.long 0 "Fifo_6"
hexfld.long 0 " Data "
;tree.end

base ad:0x8011909c
;tree "3Fifo_7"
group 0--3
line.long 0 "Fifo_7"
hexfld.long 0 " Data "
;tree.end

base ad:0x801190a0
;tree "3Fifo_8"
group 0--3
line.long 0 "Fifo_8"
hexfld.long 0 " Data "
;tree.end

base ad:0x801190a4
;tree "3Fifo_9"
group 0--3
line.long 0 "Fifo_9"
hexfld.long 0 " Data "
;tree.end

base ad:0x801190a8
;tree "3Fifo_10"
group 0--3
line.long 0 "Fifo_10"
hexfld.long 0 " Data "
;tree.end

base ad:0x801190ac
;tree "3Fifo_11"
group 0--3
line.long 0 "Fifo_11"
hexfld.long 0 " Data "
;tree.end

base ad:0x801190b0
;tree "3Fifo_12"
group 0--3
line.long 0 "Fifo_12"
hexfld.long 0 " Data "
;tree.end

base ad:0x801190b4
;tree "3Fifo_13"
group 0--3
line.long 0 "Fifo_13"
hexfld.long 0 " Data "
;tree.end

base ad:0x801190b8
;tree "3Fifo_14"
group 0--3
line.long 0 "Fifo_14"
hexfld.long 0 " Data "
;tree.end

base ad:0x801190bc
;tree "3Fifo_15"
group 0--3
line.long 0 "Fifo_15"
hexfld.long 0 " Data "
;tree.end

base ad:0x801190c0
;tree "3DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

base ad:0x80119fe0
;tree "3PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80119fe4
;tree "3PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80119fe8
;tree "3PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80119fec
;tree "3PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80119ff0
;tree "3PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

base ad:0x80119ff4
;tree "3PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

base ad:0x80119ff8
;tree "3PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

base ad:0x80119ffc
;tree "3PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

base ad:0x80005000
;********************************************
tree "MMCI-2"
;********************************************
base ad:0x80005000
;tree "2Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
;tree.end

base ad:0x80005004
;tree "2Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
;tree.end

base ad:0x80005008
;tree "2Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

base ad:0x8000500c
;tree "2Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

base ad:0x80005010
;tree "2RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80005014
;tree "2Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

base ad:0x80005018
;tree "2Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

base ad:0x8000501c
;tree "2Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

base ad:0x80005020
;tree "2Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

base ad:0x80005024
;tree "2Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

base ad:0x80005028
;tree "2DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

base ad:0x8000502c
;tree "2DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 4.--7. " BlockSize "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
;tree.end

base ad:0x80005030
;tree "2DataCnt"
rgroup 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

base ad:0x80005034
;tree "2Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
;tree.end

base ad:0x80005038
;tree "2Clear"
wgroup 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 25. " BOOTACKTIMEOUTC "  "0 ,1 "
;tree.end

base ad:0x8000503c
;tree "2Mask"
group 0--3
line.long 0 "Mask"
;tree.end

base ad:0x80005040
;tree "2Mask1"
group 0--3
line.long 0 "Mask1"
;tree.end

base ad:0x80005044
;tree "2CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80005048
;tree "2FifoCnt"
rgroup 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

base ad:0x80005080
;tree "2Fifo_0"
group 0--3
line.long 0 "Fifo_0"
hexfld.long 0 " Data "
;tree.end

base ad:0x80005084
;tree "2Fifo_1"
group 0--3
line.long 0 "Fifo_1"
hexfld.long 0 " Data "
;tree.end

base ad:0x80005088
;tree "2Fifo_2"
group 0--3
line.long 0 "Fifo_2"
hexfld.long 0 " Data "
;tree.end

base ad:0x8000508c
;tree "2Fifo_3"
group 0--3
line.long 0 "Fifo_3"
hexfld.long 0 " Data "
;tree.end

base ad:0x80005090
;tree "2Fifo_4"
group 0--3
line.long 0 "Fifo_4"
hexfld.long 0 " Data "
;tree.end

base ad:0x80005094
;tree "2Fifo_5"
group 0--3
line.long 0 "Fifo_5"
hexfld.long 0 " Data "
;tree.end

base ad:0x80005098
;tree "2Fifo_6"
group 0--3
line.long 0 "Fifo_6"
hexfld.long 0 " Data "
;tree.end

base ad:0x8000509c
;tree "2Fifo_7"
group 0--3
line.long 0 "Fifo_7"
hexfld.long 0 " Data "
;tree.end

base ad:0x800050a0
;tree "2Fifo_8"
group 0--3
line.long 0 "Fifo_8"
hexfld.long 0 " Data "
;tree.end

base ad:0x800050a4
;tree "2Fifo_9"
group 0--3
line.long 0 "Fifo_9"
hexfld.long 0 " Data "
;tree.end

base ad:0x800050a8
;tree "2Fifo_10"
group 0--3
line.long 0 "Fifo_10"
hexfld.long 0 " Data "
;tree.end

base ad:0x800050ac
;tree "2Fifo_11"
group 0--3
line.long 0 "Fifo_11"
hexfld.long 0 " Data "
;tree.end

base ad:0x800050b0
;tree "2Fifo_12"
group 0--3
line.long 0 "Fifo_12"
hexfld.long 0 " Data "
;tree.end

base ad:0x800050b4
;tree "2Fifo_13"
group 0--3
line.long 0 "Fifo_13"
hexfld.long 0 " Data "
;tree.end

base ad:0x800050b8
;tree "2Fifo_14"
group 0--3
line.long 0 "Fifo_14"
hexfld.long 0 " Data "
;tree.end

base ad:0x800050bc
;tree "2Fifo_15"
group 0--3
line.long 0 "Fifo_15"
hexfld.long 0 " Data "
;tree.end

base ad:0x800050c0
;tree "2DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

base ad:0x80005fe0
;tree "2PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80005fe4
;tree "2PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80005fe8
;tree "2PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80005fec
;tree "2PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80005ff0
;tree "2PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

base ad:0x80005ff4
;tree "2PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

base ad:0x80005ff8
;tree "2PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

base ad:0x80005ffc
;tree "2PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

base ad:0x80008000
;********************************************
tree "MMCI-5"
;********************************************
base ad:0x80008000
;tree "5Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
;tree.end

base ad:0x80008004
;tree "5Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
;tree.end

base ad:0x80008008
;tree "5Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

base ad:0x8000800c
;tree "5Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

base ad:0x80008010
;tree "5RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80008014
;tree "5Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

base ad:0x80008018
;tree "5Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

base ad:0x8000801c
;tree "5Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

base ad:0x80008020
;tree "5Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

base ad:0x80008024
;tree "5Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

base ad:0x80008028
;tree "5DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

base ad:0x8000802c
;tree "5DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 4.--7. " BlockSize "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
;tree.end

base ad:0x80008030
;tree "5DataCnt"
rgroup 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

base ad:0x80008034
;tree "5Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
;tree.end

base ad:0x80008038
;tree "5Clear"
wgroup 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 25. " BOOTACKTIMEOUTC "  "0 ,1 "
;tree.end

base ad:0x8000803c
;tree "5Mask"
group 0--3
line.long 0 "Mask"
;tree.end

base ad:0x80008040
;tree "5Mask1"
group 0--3
line.long 0 "Mask1"
;tree.end

base ad:0x80008044
;tree "5CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80008048
;tree "5FifoCnt"
rgroup 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

base ad:0x80008080
;tree "5Fifo_0"
group 0--3
line.long 0 "Fifo_0"
hexfld.long 0 " Data "
;tree.end

base ad:0x80008084
;tree "5Fifo_1"
group 0--3
line.long 0 "Fifo_1"
hexfld.long 0 " Data "
;tree.end

base ad:0x80008088
;tree "5Fifo_2"
group 0--3
line.long 0 "Fifo_2"
hexfld.long 0 " Data "
;tree.end

base ad:0x8000808c
;tree "5Fifo_3"
group 0--3
line.long 0 "Fifo_3"
hexfld.long 0 " Data "
;tree.end

base ad:0x80008090
;tree "5Fifo_4"
group 0--3
line.long 0 "Fifo_4"
hexfld.long 0 " Data "
;tree.end

base ad:0x80008094
;tree "5Fifo_5"
group 0--3
line.long 0 "Fifo_5"
hexfld.long 0 " Data "
;tree.end

base ad:0x80008098
;tree "5Fifo_6"
group 0--3
line.long 0 "Fifo_6"
hexfld.long 0 " Data "
;tree.end

base ad:0x8000809c
;tree "5Fifo_7"
group 0--3
line.long 0 "Fifo_7"
hexfld.long 0 " Data "
;tree.end

base ad:0x800080a0
;tree "5Fifo_8"
group 0--3
line.long 0 "Fifo_8"
hexfld.long 0 " Data "
;tree.end

base ad:0x800080a4
;tree "5Fifo_9"
group 0--3
line.long 0 "Fifo_9"
hexfld.long 0 " Data "
;tree.end

base ad:0x800080a8
;tree "5Fifo_10"
group 0--3
line.long 0 "Fifo_10"
hexfld.long 0 " Data "
;tree.end

base ad:0x800080ac
;tree "5Fifo_11"
group 0--3
line.long 0 "Fifo_11"
hexfld.long 0 " Data "
;tree.end

base ad:0x800080b0
;tree "5Fifo_12"
group 0--3
line.long 0 "Fifo_12"
hexfld.long 0 " Data "
;tree.end

base ad:0x800080b4
;tree "5Fifo_13"
group 0--3
line.long 0 "Fifo_13"
hexfld.long 0 " Data "
;tree.end

base ad:0x800080b8
;tree "5Fifo_14"
group 0--3
line.long 0 "Fifo_14"
hexfld.long 0 " Data "
;tree.end

base ad:0x800080bc
;tree "5Fifo_15"
group 0--3
line.long 0 "Fifo_15"
hexfld.long 0 " Data "
;tree.end

base ad:0x800080c0
;tree "5DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

base ad:0x80008fe0
;tree "5PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80008fe4
;tree "5PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80008fe8
;tree "5PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80008fec
;tree "5PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80008ff0
;tree "5PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

base ad:0x80008ff4
;tree "5PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

base ad:0x80008ff8
;tree "5PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

base ad:0x80008ffc
;tree "5PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "MSP (3 instances)"
;==============================================================
base ad:0x80123000
;********************************************
tree "MSP-0"
;********************************************
base ad:0x80123000
;tree "0DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123004
;tree "0GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
;tree.end

base ad:0x80123008
;tree "0TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012300c
;tree "0RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80123010
;tree "0SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
;tree.end

base ad:0x80123014
;tree "0FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
;tree.end

base ad:0x80123018
;tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
;tree.end

base ad:0x80123020
;tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
;tree.end

base ad:0x80123024
;tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
;tree.end

base ad:0x80123028
;tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
;tree.end

base ad:0x8012302c
;tree "0ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
;tree.end

base ad:0x80123030
;tree "0MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80123034
;tree "0RCV"
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
;tree.end

base ad:0x80123038
;tree "0RCM"
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
;tree.end

base ad:0x80123040
;tree "0TCE0"
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
;tree.end

base ad:0x80123044
;tree "0TCE1"
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
;tree.end

base ad:0x80123048
;tree "0TCE2"
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
;tree.end

base ad:0x8012304c
;tree "0TCE3"
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
;tree.end

base ad:0x80123060
;tree "0RCE0"
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
;tree.end

base ad:0x80123064
;tree "0RCE1"
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
;tree.end

base ad:0x80123068
;tree "0RCE2"
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
;tree.end

base ad:0x8012306c
;tree "0RCE3"
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
;tree.end

base ad:0x80123070
;tree "0IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80123080
;tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

base ad:0x80123084
;tree "0ITIP"
rgroup 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123088
;tree "0ITOP"
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8012308c
;tree "0TSTDR"
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123fe0
;tree "0PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123fe4
;tree "0PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123fe8
;tree "0PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123fec
;tree "0PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123ff0
;tree "0PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123ff4
;tree "0PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123ff8
;tree "0PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123ffc
;tree "0PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
;tree.end

tree.end

base ad:0x80124000
;********************************************
tree "MSP-1"
;********************************************
base ad:0x80124000
;tree "1DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124004
;tree "1GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
;tree.end

base ad:0x80124008
;tree "1TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012400c
;tree "1RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80124010
;tree "1SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
;tree.end

base ad:0x80124014
;tree "1FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
;tree.end

base ad:0x80124018
;tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
;tree.end

base ad:0x80124020
;tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
;tree.end

base ad:0x80124024
;tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
;tree.end

base ad:0x80124028
;tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
;tree.end

base ad:0x8012402c
;tree "1ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
;tree.end

base ad:0x80124030
;tree "1MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80124034
;tree "1RCV"
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
;tree.end

base ad:0x80124038
;tree "1RCM"
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
;tree.end

base ad:0x80124040
;tree "1TCE0"
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
;tree.end

base ad:0x80124044
;tree "1TCE1"
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
;tree.end

base ad:0x80124048
;tree "1TCE2"
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
;tree.end

base ad:0x8012404c
;tree "1TCE3"
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
;tree.end

base ad:0x80124060
;tree "1RCE0"
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
;tree.end

base ad:0x80124064
;tree "1RCE1"
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
;tree.end

base ad:0x80124068
;tree "1RCE2"
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
;tree.end

base ad:0x8012406c
;tree "1RCE3"
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
;tree.end

base ad:0x80124070
;tree "1IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80124080
;tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

base ad:0x80124084
;tree "1ITIP"
rgroup 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124088
;tree "1ITOP"
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8012408c
;tree "1TSTDR"
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124fe0
;tree "1PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124fe4
;tree "1PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124fe8
;tree "1PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124fec
;tree "1PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124ff0
;tree "1PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124ff4
;tree "1PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124ff8
;tree "1PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124ffc
;tree "1PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
;tree.end

tree.end

base ad:0x80117000
;********************************************
tree "MSP-2"
;********************************************
base ad:0x80117000
;tree "2DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117004
;tree "2GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
;tree.end

base ad:0x80117008
;tree "2TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8011700c
;tree "2RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80117010
;tree "2SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
;tree.end

base ad:0x80117014
;tree "2FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
;tree.end

base ad:0x80117018
;tree "2DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
;tree.end

base ad:0x80117020
;tree "2IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
;tree.end

base ad:0x80117024
;tree "2RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
;tree.end

base ad:0x80117028
;tree "2MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
;tree.end

base ad:0x8011702c
;tree "2ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
;tree.end

base ad:0x80117030
;tree "2MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80117034
;tree "2RCV"
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
;tree.end

base ad:0x80117038
;tree "2RCM"
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
;tree.end

base ad:0x80117040
;tree "2TCE0"
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
;tree.end

base ad:0x80117044
;tree "2TCE1"
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
;tree.end

base ad:0x80117048
;tree "2TCE2"
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
;tree.end

base ad:0x8011704c
;tree "2TCE3"
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
;tree.end

base ad:0x80117060
;tree "2RCE0"
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
;tree.end

base ad:0x80117064
;tree "2RCE1"
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
;tree.end

base ad:0x80117068
;tree "2RCE2"
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
;tree.end

base ad:0x8011706c
;tree "2RCE3"
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
;tree.end

base ad:0x80117070
;tree "2IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80117080
;tree "2ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

base ad:0x80117084
;tree "2ITIP"
rgroup 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117088
;tree "2ITOP"
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8011708c
;tree "2TSTDR"
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117fe0
;tree "2PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117fe4
;tree "2PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117fe8
;tree "2PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117fec
;tree "2PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117ff0
;tree "2PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117ff4
;tree "2PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117ff8
;tree "2PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117ffc
;tree "2PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
;tree.end

tree.end

tree.end

;==============================================================
tree "PKA"
;==============================================================
base ad:0xa03c4000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PKAGO "  "0 ,1 "
bitfld.long 0 1. " PKASTOP "  "0 ,1 "
bitfld.long 0 2. " PKARESTORE "  "0 ,1 "
;tree.end

base ad:0xa03c4004
;tree "CFG"
group 0--3
line.long 0 "CFG"
bitfld.long 0 0. " SEC "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGOMODE "  "0 ,1 "
bitfld.long 0 3.--4. " ALGOCALC "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " SECLVL "  "0 ,1 ,2 ,3 "
bitfld.long 0 7.--8. " DATASWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa03c4008
;tree "SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " BUSY "  "0 ,1 "
bitfld.long 0 1. " STATUSSTOP "  "0 ,1 "
bitfld.long 0 2. " STATUSRESTORE "  "0 ,1 "
;tree.end

base ad:0xa03c400c
;tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " PKAIM "  "0 ,1 "
;tree.end

base ad:0xa03c4010
;tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " PKARIS "  "0 ,1 "
;tree.end

base ad:0xa03c4014
;tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " PKAMIS "  "0 ,1 "
;tree.end

base ad:0xa03c4018
;tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " PKAIC "  "0 ,1 "
;tree.end

base ad:0xa03c4800
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0xa03c4804
;tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
;tree.end

base ad:0xa03c4808
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " PKAINTR "  "0 ,1 "
;tree.end

base ad:0xa03c4fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03c4fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c4fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c4fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03c4ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PKAPCellID0 "
;tree.end

base ad:0xa03c4ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PKAPCellID1 "
;tree.end

base ad:0xa03c4ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PKAPCellID2 "
;tree.end

base ad:0xa03c4ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PKA0PCellID3 "
;tree.end

tree.end

;==============================================================
tree "PL310"
;==============================================================
base ad:0xa0412000
;tree "ID"
rgroup 0--3
line.long 0 "ID"
bitfld.long 0 0.--5. " REL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--9. " PART "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10.--15. " ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
hexfld.byte 3 " IMPL "
;tree.end

base ad:0xa0412004
;tree "Type"
rgroup 0--3
line.long 0 "Type"
bitfld.long 0 0. " ILINELEN "  "0 ,1 "
bitfld.long 0 5. " IASSOC "  "0 ,1 "
bitfld.long 0 6.--10. " ISIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--12. " DLINELEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 17. " DASSOC "  "0 ,1 "
bitfld.long 0 18.--22. " DSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 23. " H "  "0 ,1 "
bitfld.long 0 24.--27. " CTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0412100
;tree "Control"
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " EN "  "0 ,1 "
;tree.end

base ad:0xa0412104
;tree "AuxControl"
group 0--3
line.long 0 "AuxControl"
bitfld.long 0 12. " EXCONF "  "0 ,1 "
bitfld.long 0 16. " ASSOC "  "0 ,1 "
bitfld.long 0 17.--19. " WAYSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " EMBEN "  "0 ,1 "
bitfld.long 0 21. " PAREN "  "0 ,1 "
bitfld.long 0 22. " SAOEN "  "0 ,1 "
bitfld.long 0 23.--24. " FWALLOC "  "0 ,1 ,2 ,3 "
bitfld.long 0 26. " NSLCKEN "  "0 ,1 "
bitfld.long 0 27. " NSIAC "  "0 ,1 "
bitfld.long 0 28. " DPFEN "  "0 ,1 "
bitfld.long 0 29. " IPFEN "  "0 ,1 "
;tree.end

base ad:0xa0412108
;tree "TagLatControl"
group 0--3
line.long 0 "TagLatControl"
bitfld.long 0 0.--2. " SLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " RLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " WLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa041210c
;tree "DataLatControl"
group 0--3
line.long 0 "DataLatControl"
bitfld.long 0 0.--2. " SLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " RLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " WLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0412200
;tree "EventCountControl"
group 0--3
line.long 0 "EventCountControl"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 1.--2. " RES "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0412204
;tree "EventCount1Conf"
group 0--3
line.long 0 "EventCount1Conf"
bitfld.long 0 0.--1. " EVINTGEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--5. " EVSRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0412208
;tree "EventCount0Conf"
group 0--3
line.long 0 "EventCount0Conf"
bitfld.long 0 0.--1. " EVINTGEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--5. " EVSRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa041220c
;tree "EventCount1Value"
group 0--3
line.long 0 "EventCount1Value"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa0412210
;tree "EventCount0Value"
group 0--3
line.long 0 "EventCount0Value"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa0412214
;tree "IntMask"
group 0--3
line.long 0 "IntMask"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
;tree.end

base ad:0xa0412218
;tree "MaskedIntStatus"
rgroup 0--3
line.long 0 "MaskedIntStatus"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
;tree.end

base ad:0xa041221c
;tree "RawIntStatus"
rgroup 0--3
line.long 0 "RawIntStatus"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
;tree.end

base ad:0xa0412220
;tree "IntClear"
wgroup 0--3
line.long 0 "IntClear"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
;tree.end

base ad:0xa0412730
;tree "CacheSync"
group 0--3
line.long 0 "CacheSync"
hexfld.long 0 " SYNC "
;tree.end

base ad:0xa0412770
;tree "InvalidateLine"
group 0--3
line.long 0 "InvalidateLine"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
;tree.end

base ad:0xa041277c
;tree "InvalidateByWay"
group 0--3
line.long 0 "InvalidateByWay"
hexfld.word 0 " WAYBITS "
;tree.end

base ad:0xa04127b0
;tree "CleanLine"
group 0--3
line.long 0 "CleanLine"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
;tree.end

base ad:0xa04127b8
;tree "CleanLineByWay"
group 0--3
line.long 0 "CleanLineByWay"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 28.--31. " WAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa04127bc
;tree "CleanByWay"
group 0--3
line.long 0 "CleanByWay"
hexfld.word 0 " WAYBITS "
;tree.end

base ad:0xa04127f0
;tree "CleanInvLine"
group 0--3
line.long 0 "CleanInvLine"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
;tree.end

base ad:0xa04127f8
;tree "CleanInvLineByWay"
group 0--3
line.long 0 "CleanInvLineByWay"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 28.--31. " WAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa04127fc
;tree "CleanInvByWay"
group 0--3
line.long 0 "CleanInvByWay"
hexfld.word 0 " WAYBITS "
;tree.end

base ad:0xa0412900
;tree "DataLockdownByWay_0"
group 0--3
line.long 0 "DataLockdownByWay_0"
hexfld.word 0 " DATALOCK000 "
;tree.end

base ad:0xa0412904
;tree "InstLockdownByWay_0"
group 0--3
line.long 0 "InstLockdownByWay_0"
hexfld.word 0 " INSTRLOCK000 "
;tree.end

base ad:0xa0412908
;tree "DataLockdownByWay_1"
group 0--3
line.long 0 "DataLockdownByWay_1"
hexfld.word 0 " DATALOCK001 "
;tree.end

base ad:0xa041290c
;tree "InstLockdownByWay_1"
group 0--3
line.long 0 "InstLockdownByWay_1"
hexfld.word 0 " INSTRLOCK001 "
;tree.end

base ad:0xa0412910
;tree "DataLockdownByWay_2"
group 0--3
line.long 0 "DataLockdownByWay_2"
hexfld.word 0 " DATALOCK010 "
;tree.end

base ad:0xa0412914
;tree "InstLockdownByWay_2"
group 0--3
line.long 0 "InstLockdownByWay_2"
hexfld.word 0 " INSTRLOCK010 "
;tree.end

base ad:0xa0412918
;tree "DataLockdownByWay_3"
group 0--3
line.long 0 "DataLockdownByWay_3"
hexfld.word 0 " DATALOCK011 "
;tree.end

base ad:0xa041291c
;tree "InstLockdownByWay_3"
group 0--3
line.long 0 "InstLockdownByWay_3"
hexfld.word 0 " INSTRLOCK011 "
;tree.end

base ad:0xa0412920
;tree "DataLockdownByWay_4"
group 0--3
line.long 0 "DataLockdownByWay_4"
hexfld.word 0 " DATALOCK100 "
;tree.end

base ad:0xa0412924
;tree "InstLockdownByWay_4"
group 0--3
line.long 0 "InstLockdownByWay_4"
hexfld.word 0 " INSTRLOCK100 "
;tree.end

base ad:0xa0412928
;tree "DataLockdownByWay_5"
group 0--3
line.long 0 "DataLockdownByWay_5"
hexfld.word 0 " DATALOCK101 "
;tree.end

base ad:0xa041292c
;tree "InstLockdownByWay_5"
group 0--3
line.long 0 "InstLockdownByWay_5"
hexfld.word 0 " INSTRLOCK101 "
;tree.end

base ad:0xa0412930
;tree "DataLockdownByWay_6"
group 0--3
line.long 0 "DataLockdownByWay_6"
hexfld.word 0 " DATALOCK110 "
;tree.end

base ad:0xa0412934
;tree "InstLockdownByWay_6"
group 0--3
line.long 0 "InstLockdownByWay_6"
hexfld.word 0 " INSTRLOCK110 "
;tree.end

base ad:0xa0412938
;tree "DataLockdownByWay_7"
group 0--3
line.long 0 "DataLockdownByWay_7"
hexfld.word 0 " DATALOCK111 "
;tree.end

base ad:0xa041293c
;tree "InstLockdownByWay_7"
group 0--3
line.long 0 "InstLockdownByWay_7"
hexfld.word 0 " INSTRLOCK111 "
;tree.end

base ad:0xa0412950
;tree "LockdownByLineEnable"
group 0--3
line.long 0 "LockdownByLineEnable"
bitfld.long 0 0. " EN "  "0 ,1 "
;tree.end

base ad:0xa0412954
;tree "UnlockAllLinesByWay"
group 0--3
line.long 0 "UnlockAllLinesByWay"
hexfld.word 0 " UNLOCK "
;tree.end

base ad:0xa0412c00
;tree "AddrFilterStart"
group 0--3
line.long 0 "AddrFilterStart"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 20.--31. " AFS "  " "
;tree.end

base ad:0xa0412c04
;tree "AddrFilterEnd"
group 0--3
line.long 0 "AddrFilterEnd"
bitfld.long 0 20.--31. " AFE "  " "
;tree.end

base ad:0xa0412f40
;tree "DebugControl"
group 0--3
line.long 0 "DebugControl"
bitfld.long 0 0. " DCL "  "0 ,1 "
bitfld.long 0 1. " DWB "  "0 ,1 "
bitfld.long 0 2. " SPNIDEN "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "PRCMU"
;==============================================================
base ad:0x801570b4
;tree "prcm_timer_0_ref"
group 0--3
line.long 0 "prcm_timer_0_ref"
bitfld.long 0 0. " ref_value "  "0 ,1 "
;tree.end

base ad:0x801570b8
;tree "prcm_timer_0_downcount"
rgroup 0--3
line.long 0 "prcm_timer_0_downcount"
bitfld.long 0 0. " downcounter "  "0 ,1 "
;tree.end

base ad:0x801570bc
;tree "prcm_timer_0_mode"
group 0--3
line.long 0 "prcm_timer_0_mode"
bitfld.long 0 0. " mode "  "0 ,1 "
;tree.end

base ad:0x801570c0
;tree "prcm_timer_1_ref"
group 0--3
line.long 0 "prcm_timer_1_ref"
bitfld.long 0 0. " ref_value "  "0 ,1 "
;tree.end

base ad:0x801570c4
;tree "prcm_timer_1_downcount"
rgroup 0--3
line.long 0 "prcm_timer_1_downcount"
bitfld.long 0 0. " downcounter "  "0 ,1 "
;tree.end

base ad:0x801570c8
;tree "prcm_timer_1_mode"
group 0--3
line.long 0 "prcm_timer_1_mode"
bitfld.long 0 0. " mode "  "0 ,1 "
;tree.end

base ad:0x801570cc
;tree "prcm_timer_2_ref"
group 0--3
line.long 0 "prcm_timer_2_ref"
bitfld.long 0 0. " ref_value "  "0 ,1 "
;tree.end

base ad:0x801570d0
;tree "prcm_timer_2_downcount"
rgroup 0--3
line.long 0 "prcm_timer_2_downcount"
bitfld.long 0 0. " downcounter "  "0 ,1 "
;tree.end

base ad:0x801570d4
;tree "prcm_timer_2_mode"
group 0--3
line.long 0 "prcm_timer_2_mode"
bitfld.long 0 0. " mode "  "0 ,1 "
;tree.end

base ad:0x801570fc
;tree "prcm_mbox_cpu_val"
rgroup 0--3
line.long 0 "prcm_mbox_cpu_val"
hexfld.byte 0 " cpu_val "
;tree.end

base ad:0x80157100
;tree "prcm_mbox_cpu_set"
wgroup 0--3
line.long 0 "prcm_mbox_cpu_set"
hexfld.byte 0 " cpu_set "
;tree.end

base ad:0x80157104
;tree "prcm_mbox_cpu_clr"
wgroup 0--3
line.long 0 "prcm_mbox_cpu_clr"
hexfld.byte 0 " cpu_clr "
;tree.end

base ad:0x801571b0
;tree "prcm_hwi2c_div"
group 0--3
line.long 0 "prcm_hwi2c_div"
bitfld.long 0 0.--3. " SCLFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x801571b4
;tree "prcm_hwi2c_go"
wgroup 0--3
line.long 0 "prcm_hwi2c_go"
bitfld.long 0 0. " GO "  "0 ,1 "
;tree.end

base ad:0x801571b8
;tree "prcm_hwi2c_cmd"
group 0--3
line.long 0 "prcm_hwi2c_cmd"
bitfld.long 0 0. " RWb "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--9. " TSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " HWGCEN "  "0 ,1 "
bitfld.long 0 11. " STOPEN "  "0 ,1 "
hexfld.byte 2 " REG_ADD "
hexfld.byte 3 " DATA0 "
;tree.end

base ad:0x801571bc
;tree "prcm_hwi2c_data123"
group 0--3
line.long 0 "prcm_hwi2c_data123"
hexfld.byte 0 " DATA1 "
hexfld.byte 1 " DATA2 "
hexfld.byte 2 " DATA3 "
;tree.end

base ad:0x801571c0
;tree "prcm_hwi2c_sr"
rgroup 0--3
line.long 0 "prcm_hwi2c_sr"
bitfld.long 0 0.--1. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80157310
;tree "PRCMU_IOCR"
group 0--3
line.long 0 "PRCMU_IOCR"
bitfld.long 0 0. " IOFORCE "  "0 ,1 "
;tree.end

base ad:0x80157300
;tree "prcm_sram_dedcstov_reg"
group 0--3
line.long 0 "prcm_sram_dedcstov_reg"
bitfld.long 0 0.--4. " sxa_dc "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " sxa_de "  "0 ,1 "
bitfld.long 0 6. " sxa_stov "  "0 ,1 "
;tree.end

base ad:0x80157304
;tree "prcm_sram_ls_sleep_reg"
group 0--3
line.long 0 "prcm_sram_ls_sleep_reg"
bitfld.long 0 0. " sga_sleep "  "0 ,1 "
bitfld.long 0 1. " sga_ls "  "0 ,1 "
bitfld.long 0 2. " svacore_sleep "  "0 ,1 "
bitfld.long 0 3. " svacore_ls "  "0 ,1 "
bitfld.long 0 4. " sva_mmdsp_sleep "  "0 ,1 "
bitfld.long 0 5. " sva_mmdsp_ls "  "0 ,1 "
bitfld.long 0 6. " sia_core_sleep "  "0 ,1 "
bitfld.long 0 7. " sia_core_ls "  "0 ,1 "
bitfld.long 0 8. " sia_mmdsp_sleep "  "0 ,1 "
bitfld.long 0 9. " sia_mmdsp_ls "  "0 ,1 "
bitfld.long 0 10. " b2r2_sleep "  "0 ,1 "
bitfld.long 0 11. " b2r2_ls "  "0 ,1 "
bitfld.long 0 12. " saa_mmdsp_sleep "  "0 ,1 "
bitfld.long 0 13. " saa_mmdsp_ls "  "0 ,1 "
bitfld.long 0 14. " ape_sleep "  "0 ,1 "
bitfld.long 0 15. " ape_ls "  "0 ,1 "
bitfld.long 0 16. " esram_sleep0 "  "0 ,1 "
bitfld.long 0 17. " esram_ls0 "  "0 ,1 "
bitfld.long 0 18. " esram_sleep1 "  "0 ,1 "
bitfld.long 0 19. " esram_ls1 "  "0 ,1 "
bitfld.long 0 20. " esram_sleep2 "  "0 ,1 "
bitfld.long 0 21. " esram_ls2 "  "0 ,1 "
bitfld.long 0 22. " esram_sleep3 "  "0 ,1 "
bitfld.long 0 23. " esram_ls3 "  "0 ,1 "
bitfld.long 0 24. " esram_sleep4 "  "0 ,1 "
bitfld.long 0 25. " esram_ls4 "  "0 ,1 "
bitfld.long 0 26. " esram_sleep5 "  "0 ,1 "
bitfld.long 0 27. " esram_ls5 "  "0 ,1 "
bitfld.long 0 28. " PDN_BOOT "  "0 ,1 "
bitfld.long 0 29. " PDN_SVA_ROM "  "0 ,1 "
;tree.end

base ad:0x80157308
;tree "prcm_sram_a9_reg"
group 0--3
line.long 0 "prcm_sram_a9_reg"
bitfld.long 0 0.--5. " a9_dc "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " a9_de "  "0 ,1 "
bitfld.long 0 7. " a9_stov "  "0 ,1 "
bitfld.long 0 8. " a9_sleep "  "0 ,1 "
bitfld.long 0 9. " a9_ls "  "0 ,1 "
;tree.end

base ad:0x8015730c
;tree "prcm_ARM_ls_clamp_reg"
group 0--3
line.long 0 "prcm_ARM_ls_clamp_reg"
bitfld.long 0 0. " inclamp_ni "  "0 ,1 "
bitfld.long 0 1. " outclamp_ni "  "0 ,1 "
bitfld.long 0 2.--3. " tst_spare_in "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " tst_inclamp_ni "  "0 ,1 "
bitfld.long 0 5. " tst_outclamp_ni "  "0 ,1 "
;tree.end

base ad:0x80157080
;tree "prcm_pllsoc0_freq_reg"
group 0--3
line.long 0 "prcm_pllsoc0_freq_reg"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " seldiv2 "  "0 ,1 "
;tree.end

base ad:0x80157090
;tree "prcm_pllsoc0_enable_reg"
group 0--3
line.long 0 "prcm_pllsoc0_enable_reg"
bitfld.long 0 0. " enable "  "0 ,1 "
;tree.end

base ad:0x801570a0
;tree "prcm_pllsoc0_lockp_reg"
rgroup 0--3
line.long 0 "prcm_pllsoc0_lockp_reg"
bitfld.long 0 0. " lockp10 "  "0 ,1 "
bitfld.long 0 1. " lockp3 "  "0 ,1 "
;tree.end

base ad:0x80157084
;tree "prcm_pllsoc1_freq_reg"
group 0--3
line.long 0 "prcm_pllsoc1_freq_reg"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " seldiv2 "  "0 ,1 "
;tree.end

base ad:0x80157094
;tree "prcm_pllsoc1_enable_reg"
group 0--3
line.long 0 "prcm_pllsoc1_enable_reg"
bitfld.long 0 0. " enable "  "0 ,1 "
;tree.end

base ad:0x801570a4
;tree "prcm_pllsoc1_lockp_reg"
rgroup 0--3
line.long 0 "prcm_pllsoc1_lockp_reg"
bitfld.long 0 0. " lockp10 "  "0 ,1 "
bitfld.long 0 1. " lockp3 "  "0 ,1 "
;tree.end

base ad:0x8015710c
;tree "prcm_pll32k_enable_reg"
group 0--3
line.long 0 "prcm_pll32k_enable_reg"
bitfld.long 0 0. " enable "  "0 ,1 "
bitfld.long 0 1. " IN "  "0 ,1 "
;tree.end

base ad:0x80157088
;tree "prcm_pllarm_freq_reg"
group 0--3
line.long 0 "prcm_pllarm_freq_reg"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " seldiv2 "  "0 ,1 "
;tree.end

base ad:0x80157098
;tree "prcm_pllarm_enable_reg"
group 0--3
line.long 0 "prcm_pllarm_enable_reg"
bitfld.long 0 0. " enable "  "0 ,1 "
;tree.end

base ad:0x801570a8
;tree "prcm_pllarm_lockp_reg"
rgroup 0--3
line.long 0 "prcm_pllarm_lockp_reg"
bitfld.long 0 0. " lockp10 "  "0 ,1 "
bitfld.long 0 1. " lockp3 "  "0 ,1 "
;tree.end

base ad:0x80157114
;tree "prcm_arm_chgclkreq_reg"
group 0--3
line.long 0 "prcm_arm_chgclkreq_reg"
bitfld.long 0 0. " chgclkreq "  "0 ,1 "
;tree.end

base ad:0x80157118
;tree "prcm_arm_plldivps_reg"
group 0--3
line.long 0 "prcm_arm_plldivps_reg"
bitfld.long 0 0.--2. " plldivps "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8015708c
;tree "prcm_pllddr_freq_reg"
group 0--3
line.long 0 "prcm_pllddr_freq_reg"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " seldiv2 "  "0 ,1 "
;tree.end

base ad:0x8015709c
;tree "prcm_pllddr_enable_reg"
group 0--3
line.long 0 "prcm_pllddr_enable_reg"
bitfld.long 0 0. " enable "  "0 ,1 "
;tree.end

base ad:0x801570ac
;tree "prcm_pllddr_lockp_reg"
rgroup 0--3
line.long 0 "prcm_pllddr_lockp_reg"
bitfld.long 0 0. " lockp10 "  "0 ,1 "
bitfld.long 0 1. " lockp3 "  "0 ,1 "
;tree.end

base ad:0x801570ec
;tree "prcm_dll_ldo_ddr_reg"
group 0--3
line.long 0 "prcm_dll_ldo_ddr_reg"
bitfld.long 0 0. " dllpwren "  "0 ,1 "
bitfld.long 0 1. " pwrenldophy "  "0 ,1 "
bitfld.long 0 2. " vrefonphy "  "0 ,1 "
bitfld.long 0 3. " vokvrefphy "  "0 ,1 "
bitfld.long 0 4. " vokldophy "  "0 ,1 "
;tree.end

base ad:0x801570e8
;tree "prcm_modeclk_reg"
group 0--3
line.long 0 "prcm_modeclk_reg"
bitfld.long 0 0. " 32KMODE "  "0 ,1 "
bitfld.long 0 1. " 38MMODE "  "0 ,1 "
bitfld.long 0 2. " PLLMODE "  "0 ,1 "
;tree.end

base ad:0x80157000
;tree "prcm_armclkfix_mgt_reg"
group 0--3
line.long 0 "prcm_armclkfix_mgt_reg"
bitfld.long 0 0.--4. " ARMCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " ARMCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 9. " ARMCLK38 "  "0 ,1 "
bitfld.long 0 10. " ARMCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157004
;tree "prcm_aclk_mgt_reg"
group 0--3
line.long 0 "prcm_aclk_mgt_reg"
bitfld.long 0 0.--4. " ACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " ACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " ACLKEN "  "0 ,1 "
bitfld.long 0 9. " ACLK38 "  "0 ,1 "
bitfld.long 0 10. " ACLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157008
;tree "prcm_svammdspclk_mgt_reg"
group 0--3
line.long 0 "prcm_svammdspclk_mgt_reg"
bitfld.long 0 0.--4. " SVAMMDSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SVAMMDSPCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 9. " SVAMMDSPCLK38 "  "0 ,1 "
bitfld.long 0 10. " SVAMMDSPCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SVA_low_freq "  "0 ,1 "
bitfld.long 0 12. " SVA_phy_en "  "0 ,1 "
bitfld.long 0 13. " SVA_phy_ack "  "0 ,1 "
;tree.end

base ad:0x8015700c
;tree "prcm_siammdspclk_mgt_reg"
group 0--3
line.long 0 "prcm_siammdspclk_mgt_reg"
bitfld.long 0 0.--4. " SIAMMDSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SIAMMDSPCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 9. " SIAMMDSPCLK38 "  "0 ,1 "
bitfld.long 0 10. " SIAMMDSPCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SIA_low_freq "  "0 ,1 "
bitfld.long 0 12. " SIA_phy_en "  "0 ,1 "
bitfld.long 0 13. " SIA_phy_ack "  "0 ,1 "
;tree.end

base ad:0x80157010
;tree "prcm_saammdspclk_mgt_reg"
group 0--3
line.long 0 "prcm_saammdspclk_mgt_reg"
bitfld.long 0 0.--4. " SAAMMDSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SAAMMDSPCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SAAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 9. " SAAMMDSPCLK38 "  "0 ,1 "
bitfld.long 0 10. " SAAMMDSPCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SAA_low_freq "  "0 ,1 "
bitfld.long 0 12. " SAA_phy_en "  "0 ,1 "
bitfld.long 0 13. " SAA_phy_ack "  "0 ,1 "
;tree.end

base ad:0x80157014
;tree "prcm_sgaclk_mgt_reg"
group 0--3
line.long 0 "prcm_sgaclk_mgt_reg"
bitfld.long 0 0.--4. " SGACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SGACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SGACLKEN "  "0 ,1 "
bitfld.long 0 9. " SGACLK38 "  "0 ,1 "
bitfld.long 0 10. " SGACLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157018
;tree "prcm_uartclk_mgt_reg"
group 0--3
line.long 0 "prcm_uartclk_mgt_reg"
bitfld.long 0 0.--4. " UARTCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " UARTCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 9. " UARTCLK38 "  "0 ,1 "
bitfld.long 0 10. " UARTCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x8015701c
;tree "prcm_mspclk_mgt_reg"
group 0--3
line.long 0 "prcm_mspclk_mgt_reg"
bitfld.long 0 0.--4. " MSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " MSPCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " MSPCLKEN "  "0 ,1 "
bitfld.long 0 9. " MSPCLK38 "  "0 ,1 "
bitfld.long 0 10. " MSPCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157020
;tree "prcm_i2cclk_mgt_reg"
group 0--3
line.long 0 "prcm_i2cclk_mgt_reg"
bitfld.long 0 0.--4. " I2CCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " I2CCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " I2CCLK38 "  "0 ,1 "
bitfld.long 0 10. " I2CCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157024
;tree "prcm_sdmmcclk_mgt_reg"
group 0--3
line.long 0 "prcm_sdmmcclk_mgt_reg"
bitfld.long 0 0.--4. " SDMMCCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SDMMCCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLK38 "  "0 ,1 "
bitfld.long 0 10. " SDMMCCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157028
;tree "prcm_slimclk_mgt_reg"
group 0--3
line.long 0 "prcm_slimclk_mgt_reg"
bitfld.long 0 0.--4. " SLIMCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SLIMCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SLIMCLKEN "  "0 ,1 "
bitfld.long 0 9. " SLIMCLK38 "  "0 ,1 "
bitfld.long 0 10. " SLIMCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x8015702c
;tree "prcm_per1clk_mgt_reg"
group 0--3
line.long 0 "prcm_per1clk_mgt_reg"
bitfld.long 0 0.--4. " PER1CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER1CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER1CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER1CLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157030
;tree "prcm_per2clk_mgt_reg"
group 0--3
line.long 0 "prcm_per2clk_mgt_reg"
bitfld.long 0 0.--4. " PER2CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER2CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER2CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER2CLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157034
;tree "prcm_per3clk_mgt_reg"
group 0--3
line.long 0 "prcm_per3clk_mgt_reg"
bitfld.long 0 0.--4. " PER3CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER3CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER3CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER3CLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157038
;tree "prcm_per5clk_mgt_reg"
group 0--3
line.long 0 "prcm_per5clk_mgt_reg"
bitfld.long 0 0.--4. " PER5CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER5CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER5CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER5CLK38SRC "  "0 ,1 "
;tree.end

base ad:0x8015703c
;tree "prcm_per6clk_mgt_reg"
group 0--3
line.long 0 "prcm_per6clk_mgt_reg"
bitfld.long 0 0.--4. " PER6CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER6CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER6CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER6CLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157040
;tree "prcm_per7clk_mgt_reg"
group 0--3
line.long 0 "prcm_per7clk_mgt_reg"
bitfld.long 0 0.--4. " PER7CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER7CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER7CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER7CLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157044
;tree "prcm_lcdclk_mgt_reg"
group 0--3
line.long 0 "prcm_lcdclk_mgt_reg"
bitfld.long 0 0.--4. " LCDCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " LCDCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 9. " LCDCLK38 "  "0 ,1 "
bitfld.long 0 10. " LCDCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x8015704c
;tree "prcm_bmlclk_mgt_reg"
group 0--3
line.long 0 "prcm_bmlclk_mgt_reg"
bitfld.long 0 0.--4. " BMLCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " BMLCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " BMLCLKEN "  "0 ,1 "
bitfld.long 0 9. " BMLCLK38 "  "0 ,1 "
bitfld.long 0 10. " BMLCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157050
;tree "prcm_hsitxclk_mgt_reg"
group 0--3
line.long 0 "prcm_hsitxclk_mgt_reg"
bitfld.long 0 0.--4. " HSITXCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " HSITXCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 9. " HSITXCLK38 "  "0 ,1 "
bitfld.long 0 10. " HSITXCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157054
;tree "prcm_hsirxclk_mgt_reg"
group 0--3
line.long 0 "prcm_hsirxclk_mgt_reg"
bitfld.long 0 0.--4. " HSIRXCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " HSIRXCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 9. " HSIRXCLK38 "  "0 ,1 "
bitfld.long 0 10. " HSIRXCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157058
;tree "prcm_hdmiclk_mgt_reg"
group 0--3
line.long 0 "prcm_hdmiclk_mgt_reg"
bitfld.long 0 0.--4. " HDMICLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " HDMICLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 9. " HDMICLK38 "  "0 ,1 "
bitfld.long 0 10. " HDMICLK38SRC "  "0 ,1 "
;tree.end

base ad:0x8015705c
;tree "prcm_apeatclk_mgt_reg"
group 0--3
line.long 0 "prcm_apeatclk_mgt_reg"
bitfld.long 0 0.--4. " APEATCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " APEATCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 9. " APEATCLK38 "  "0 ,1 "
bitfld.long 0 10. " APEATCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157060
;tree "prcm_apetraceclk_mgt_reg"
group 0--3
line.long 0 "prcm_apetraceclk_mgt_reg"
bitfld.long 0 0.--4. " APETRACECLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " APETRACECLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 9. " APETRACECLK38 "  "0 ,1 "
bitfld.long 0 10. " APETRACECLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157064
;tree "prcm_mcdeclk_mgt_reg"
group 0--3
line.long 0 "prcm_mcdeclk_mgt_reg"
bitfld.long 0 0.--4. " MCDECLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " MCDECLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 9. " MCDECLK38 "  "0 ,1 "
bitfld.long 0 10. " MCDECLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157068
;tree "prcm_ipi2cclk_mgt_reg"
group 0--3
line.long 0 "prcm_ipi2cclk_mgt_reg"
bitfld.long 0 0.--4. " IPI2CCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " IPI2CCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " IPI2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " IPI2CCLK38 "  "0 ,1 "
bitfld.long 0 10. " IPI2CCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x8015706c
;tree "prcm_occclk_mgt_reg"
group 0--3
line.long 0 "prcm_occclk_mgt_reg"
bitfld.long 0 0.--4. " OCCCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " OCCCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " OCCCLKEN "  "0 ,1 "
bitfld.long 0 9. " OCCCLK38 "  "0 ,1 "
bitfld.long 0 10. " OCCCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157074
;tree "prcm_dmaclk_mgt_reg"
group 0--3
line.long 0 "prcm_dmaclk_mgt_reg"
bitfld.long 0 0.--4. " DMACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " DMACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " DMACLKEN "  "0 ,1 "
bitfld.long 0 9. " DMACLK38 "  "0 ,1 "
bitfld.long 0 10. " DMACLK38SRC "  "0 ,1 "
;tree.end

base ad:0x80157078
;tree "prcm_b2r2clk_mgt_reg"
group 0--3
line.long 0 "prcm_b2r2clk_mgt_reg"
bitfld.long 0 0.--4. " B2R2CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " B2R2CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 9. " B2R2CLK38 "  "0 ,1 "
bitfld.long 0 10. " B2R2CLK38SRC "  "0 ,1 "
;tree.end

base ad:0x8015707c
;tree "prcm_tvclk_mgt_reg"
group 0--3
line.long 0 "prcm_tvclk_mgt_reg"
bitfld.long 0 0.--4. " TVCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " TVCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " TVCLKEN "  "0 ,1 "
bitfld.long 0 9. " TVCLK38 "  "0 ,1 "
bitfld.long 0 10. " TVCLK38SRC "  "0 ,1 "
;tree.end

base ad:0x801570e4
;tree "prcm_clk009_mgt_reg"
group 0--3
line.long 0 "prcm_clk009_mgt_reg"
bitfld.long 0 0.--2. " CLK009DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CLK009CLK38SRC "  "0 ,1 "
;tree.end

base ad:0x801570b0
;tree "prcm_xp70clk_mgt_reg"
group 0--3
line.long 0 "prcm_xp70clk_mgt_reg"
bitfld.long 0 0.--26. " prcm_xp70clk_mgt "  " "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 0. " SGA_resetn "  "0 ,1 "
bitfld.long 0 1. " SGA_init_n "  "0 ,1 "
bitfld.long 0 2. " B2R2_resetn "  "0 ,1 "
bitfld.long 0 3. " B2R2_init_n "  "0 ,1 "
bitfld.long 0 4. " SVA_MMDSP_Vidcore_resetn "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 6. " SVA_MMDSP_Vidcore_init_n "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_init_n_tcm "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
bitfld.long 0 14. " SAA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 15. " SAA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 16. " SAA_MMDSP_init_n_tcm "  "0 ,1 "
bitfld.long 0 17. " ddrctrl_fifoape_resetn "  "0 ,1 "
bitfld.long 0 18. " ddrctrl_fifomodem_resetn "  "0 ,1 "
bitfld.long 0 19. " DDR_resetn "  "0 ,1 "
bitfld.long 0 20. " DDR_PHY_resetn "  "0 ,1 "
bitfld.long 0 21. " DDR_AXI_resetn "  "0 ,1 "
bitfld.long 0 22. " DDR_AHB_resetn "  "0 ,1 "
bitfld.long 0 23. " esram0_init_n "  "0 ,1 "
bitfld.long 0 24. " esram1_init_n "  "0 ,1 "
bitfld.long 0 25. " esram2_init_n "  "0 ,1 "
bitfld.long 0 26. " esram3_init_n "  "0 ,1 "
bitfld.long 0 27. " esram4_init_n "  "0 ,1 "
bitfld.long 0 28. " esram5_init_n "  "0 ,1 "
bitfld.long 0 29. " SOC_mem_init_n "  "0 ,1 "
bitfld.long 0 30. " APE_PORn "  "0 ,1 "
bitfld.long 0 31. " APE_resetn "  "0 ,1 "
;tree.end

base ad:0x801571e8
;tree "prcm_ape_resetn_clr_reg"
group 0--3
line.long 0 "prcm_ape_resetn_clr_reg"
bitfld.long 0 0. " SGA_resetn "  "0 ,1 "
bitfld.long 0 1. " SGA_init_n "  "0 ,1 "
bitfld.long 0 2. " B2R2_resetn "  "0 ,1 "
bitfld.long 0 3. " B2R2_init_n "  "0 ,1 "
bitfld.long 0 4. " SVA_MMDSP_Vidcore_resetn "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 6. " SVA_MMDSP_Vidcore_init_n "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_init_n_tcm "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
bitfld.long 0 14. " SAA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 15. " SAA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 16. " SAA_MMDSP_init_n_tcm "  "0 ,1 "
bitfld.long 0 17. " ddrctrl_fifoape_resetn "  "0 ,1 "
bitfld.long 0 18. " ddrctrl_fifomodem_resetn "  "0 ,1 "
bitfld.long 0 19. " DDR_resetn "  "0 ,1 "
bitfld.long 0 20. " DDR_PHY_resetn "  "0 ,1 "
bitfld.long 0 21. " DDR_AXI_resetn "  "0 ,1 "
bitfld.long 0 22. " DDR_AHB_resetn "  "0 ,1 "
bitfld.long 0 23. " esram0_init_n "  "0 ,1 "
bitfld.long 0 24. " esram1_init_n "  "0 ,1 "
bitfld.long 0 25. " esram2_init_n "  "0 ,1 "
bitfld.long 0 26. " esram3_init_n "  "0 ,1 "
bitfld.long 0 27. " esram4_init_n "  "0 ,1 "
bitfld.long 0 28. " esram5_init_n "  "0 ,1 "
bitfld.long 0 29. " SOC_mem_init_n "  "0 ,1 "
bitfld.long 0 30. " APE_PORn "  "0 ,1 "
bitfld.long 0 31. " APE_resetn "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 0. " SGA_resetn "  "0 ,1 "
bitfld.long 0 1. " SGA_init_n "  "0 ,1 "
bitfld.long 0 2. " B2R2_resetn "  "0 ,1 "
bitfld.long 0 3. " B2R2_init_n "  "0 ,1 "
bitfld.long 0 4. " SVA_MMDSP_Vidcore_resetn "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 6. " SVA_MMDSP_Vidcore_init_n "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_init_n_tcm "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
bitfld.long 0 14. " SAA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 15. " SAA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 16. " SAA_MMDSP_init_n_tcm "  "0 ,1 "
bitfld.long 0 17. " ddrctrl_fifoape_resetn "  "0 ,1 "
bitfld.long 0 18. " ddrctrl_fifomodem_resetn "  "0 ,1 "
bitfld.long 0 19. " DDR_resetn "  "0 ,1 "
bitfld.long 0 20. " DDR_PHY_resetn "  "0 ,1 "
bitfld.long 0 21. " DDR_AXI_resetn "  "0 ,1 "
bitfld.long 0 22. " DDR_AHB_resetn "  "0 ,1 "
bitfld.long 0 23. " esram0_init_n "  "0 ,1 "
bitfld.long 0 24. " esram1_init_n "  "0 ,1 "
bitfld.long 0 25. " esram2_init_n "  "0 ,1 "
bitfld.long 0 26. " esram3_init_n "  "0 ,1 "
bitfld.long 0 27. " esram4_init_n "  "0 ,1 "
bitfld.long 0 28. " esram5_init_n "  "0 ,1 "
bitfld.long 0 29. " SOC_mem_init_n "  "0 ,1 "
bitfld.long 0 30. " APE_PORn "  "0 ,1 "
bitfld.long 0 31. " APE_resetn "  "0 ,1 "
;tree.end

base ad:0x801571f0
;tree "prcm_a9_resetn_set_reg"
group 0--3
line.long 0 "prcm_a9_resetn_set_reg"
bitfld.long 0 0. " A9_nPOReset "  "0 ,1 "
bitfld.long 0 1. " A9_nResetFifo "  "0 ,1 "
bitfld.long 0 2. " A9_nResetITresync "  "0 ,1 "
bitfld.long 0 3. " A9_nResetDbg "  "0 ,1 "
bitfld.long 0 4. " A9_nReset0 "  "0 ,1 "
bitfld.long 0 5. " A9_nReset1 "  "0 ,1 "
bitfld.long 0 6. " A9_wd_req_resetn "  "0 ,1 "
;tree.end

base ad:0x801571f4
;tree "prcm_a9_resetn_clr_reg"
group 0--3
line.long 0 "prcm_a9_resetn_clr_reg"
bitfld.long 0 0. " A9_nPOReset "  "0 ,1 "
bitfld.long 0 1. " A9_nResetFifo "  "0 ,1 "
bitfld.long 0 2. " A9_nResetITresync "  "0 ,1 "
bitfld.long 0 3. " A9_nResetDbg "  "0 ,1 "
bitfld.long 0 4. " A9_nReset0 "  "0 ,1 "
bitfld.long 0 5. " A9_nReset1 "  "0 ,1 "
bitfld.long 0 6. " A9_wd_req_resetn "  "0 ,1 "
;tree.end

base ad:0x801571f8
;tree "prcm_a9_resetn_val_reg"
group 0--3
line.long 0 "prcm_a9_resetn_val_reg"
bitfld.long 0 0. " A9_nPOReset "  "0 ,1 "
bitfld.long 0 1. " A9_nResetFifo "  "0 ,1 "
bitfld.long 0 2. " A9_nResetITresync "  "0 ,1 "
bitfld.long 0 3. " A9_nResetDbg "  "0 ,1 "
bitfld.long 0 4. " A9_nReset0 "  "0 ,1 "
bitfld.long 0 5. " A9_nReset1 "  "0 ,1 "
bitfld.long 0 6. " A9_wd_req_resetn "  "0 ,1 "
;tree.end

base ad:0x801571fc
;tree "prcm_mod_resetn_set_reg"
group 0--3
line.long 0 "prcm_mod_resetn_set_reg"
bitfld.long 0 0. " Modem_nPOReset "  "0 ,1 "
bitfld.long 0 1. " Modem_nSWReset "  "0 ,1 "
bitfld.long 0 2. " Modem_nHWReset "  "0 ,1 "
;tree.end

base ad:0x80157200
;tree "prcm_mod_resetn_clr_reg"
group 0--3
line.long 0 "prcm_mod_resetn_clr_reg"
bitfld.long 0 0. " Modem_nPOReset "  "0 ,1 "
bitfld.long 0 1. " Modem_nSWReset "  "0 ,1 "
bitfld.long 0 2. " Modem_nHWReset "  "0 ,1 "
;tree.end

base ad:0x80157204
;tree "prcm_mod_resetn_val_reg"
group 0--3
line.long 0 "prcm_mod_resetn_val_reg"
bitfld.long 0 0. " Modem_nPOReset "  "0 ,1 "
bitfld.long 0 1. " Modem_nSWReset "  "0 ,1 "
bitfld.long 0 2. " Modem_nHWReset "  "0 ,1 "
;tree.end

base ad:0x80157208
;tree "prcm_gpio_resetn_set_reg"
group 0--3
line.long 0 "prcm_gpio_resetn_set_reg"
bitfld.long 0 0. " gpio_resetn "  "0 ,1 "
bitfld.long 0 1. " gpio_mux_resetn "  "0 ,1 "
;tree.end

base ad:0x8015720c
;tree "prcm_gpio_resetn_clr_reg"
group 0--3
line.long 0 "prcm_gpio_resetn_clr_reg"
bitfld.long 0 0. " gpio_resetn "  "0 ,1 "
bitfld.long 0 1. " gpio_mux_resetn "  "0 ,1 "
;tree.end

base ad:0x80157210
;tree "prcm_gpio_resetn_val_reg"
group 0--3
line.long 0 "prcm_gpio_resetn_val_reg"
bitfld.long 0 0. " gpio_resetn "  "0 ,1 "
bitfld.long 0 1. " gpio_mux_resetn "  "0 ,1 "
;tree.end

base ad:0x80157214
;tree "prcm_4500_resetn_set_reg"
group 0--3
line.long 0 "prcm_4500_resetn_set_reg"
bitfld.long 0 0. " 4500_resetn "  "0 ,1 "
;tree.end

base ad:0x80157218
;tree "prcm_4500_resetn_clr_reg"
group 0--3
line.long 0 "prcm_4500_resetn_clr_reg"
bitfld.long 0 0. " 4500_resetn "  "0 ,1 "
;tree.end

base ad:0x8015721c
;tree "prcm_4500_resetn_val_reg"
group 0--3
line.long 0 "prcm_4500_resetn_val_reg"
bitfld.long 0 0. " 4500_resetn "  "0 ,1 "
;tree.end

base ad:0x8015722c
;tree "prcm_periph4_resetn_set_reg"
group 0--3
line.long 0 "prcm_periph4_resetn_set_reg"
bitfld.long 0 0. " RTC_resetn "  "0 ,1 "
bitfld.long 0 1. " RTT0_resetn "  "0 ,1 "
bitfld.long 0 2. " RTT1_resetn "  "0 ,1 "
bitfld.long 0 3. " BACKUPRAM_resetn "  "0 ,1 "
bitfld.long 0 4. " SECREG_resetn "  "0 ,1 "
;tree.end

base ad:0x80157230
;tree "prcm_periph4_resetn_clr_reg"
group 0--3
line.long 0 "prcm_periph4_resetn_clr_reg"
bitfld.long 0 0. " RTC_resetn "  "0 ,1 "
bitfld.long 0 1. " RTT0_resetn "  "0 ,1 "
bitfld.long 0 2. " RTT1_resetn "  "0 ,1 "
bitfld.long 0 3. " BACKUPRAM_resetn "  "0 ,1 "
bitfld.long 0 4. " SECREG_resetn "  "0 ,1 "
;tree.end

base ad:0x80157234
;tree "prcm_periph4_resetn_val_reg"
group 0--3
line.long 0 "prcm_periph4_resetn_val_reg"
bitfld.long 0 0. " RTC_resetn "  "0 ,1 "
bitfld.long 0 1. " RTT0_resetn "  "0 ,1 "
bitfld.long 0 2. " RTT1_resetn "  "0 ,1 "
bitfld.long 0 3. " BACKUPRAM_resetn "  "0 ,1 "
bitfld.long 0 4. " SECREG_resetn "  "0 ,1 "
;tree.end

base ad:0x801572a0
;tree "prcm_dap_resetn_set_reg"
group 0--3
line.long 0 "prcm_dap_resetn_set_reg"
bitfld.long 0 0. " DAP_resetn "  "0 ,1 "
;tree.end

base ad:0x801572a4
;tree "prcm_dap_resetn_clr_reg"
group 0--3
line.long 0 "prcm_dap_resetn_clr_reg"
bitfld.long 0 0. " DAP_resetn "  "0 ,1 "
;tree.end

base ad:0x801572a8
;tree "prcm_dap_resetn_val_reg"
group 0--3
line.long 0 "prcm_dap_resetn_val_reg"
bitfld.long 0 0. " DAP_resetn "  "0 ,1 "
;tree.end

base ad:0x80157238
;tree "prcm_swd_rst_tempo"
group 0--3
line.long 0 "prcm_swd_rst_tempo"
hexfld.byte 0 " rst_tempo "
;tree.end

base ad:0x8015723c
;tree "prcm_rst_4500_tempo"
group 0--3
line.long 0 "prcm_rst_4500_tempo"
hexfld.byte 0 " 4500_tempo "
;tree.end

base ad:0x80157220
;tree "prcm_swd_resetn_cfg_reg"
group 0--3
line.long 0 "prcm_swd_resetn_cfg_reg"
bitfld.long 0 0. " GPIO_resetn "  "0 ,1 "
bitfld.long 0 1. " GPIO_mux_resetn "  "0 ,1 "
bitfld.long 0 2. " 4500_resetn "  "0 ,1 "
bitfld.long 0 3. " DAP_resetn "  "0 ,1 "
bitfld.long 0 4. " RTC_resetn "  "0 ,1 "
bitfld.long 0 5. " RTT0_resetn "  "0 ,1 "
bitfld.long 0 6. " RTT1_resetn "  "0 ,1 "
bitfld.long 0 7. " BACKUPRAM_resetn "  "0 ,1 "
bitfld.long 0 8. " SECREG_resetn "  "0 ,1 "
bitfld.long 0 9. " PLL_CLK_resetn "  "0 ,1 "
;tree.end

base ad:0x801572ac
;tree "prcm_reset_status_reg"
group 0--3
line.long 0 "prcm_reset_status_reg"
bitfld.long 0 0. " A9_CPU0_WDG_reset "  "0 ,1 "
bitfld.long 0 1. " A9_CPU1_WDG_reset "  "0 ,1 "
bitfld.long 0 2. " APE_SFT_reset "  "0 ,1 "
bitfld.long 0 3. " APE_reset "  "0 ,1 "
bitfld.long 0 4. " SECWDG "  "0 ,1 "
bitfld.long 0 5. " PORn "  "0 ,1 "
bitfld.long 0 6. " A9_restart_DP "  "0 ,1 "
bitfld.long 0 7. " APE_restart_DP "  "0 ,1 "
;tree.end

base ad:0x80157148
;tree "prcm_itstatus0_reg"
rgroup 0--3
line.long 0 "prcm_itstatus0_reg"
hexfld.byte 0 " itstatus0 "
;tree.end

base ad:0x8015714c
;tree "prcm_itclr0_reg"
wgroup 0--3
line.long 0 "prcm_itclr0_reg"
hexfld.byte 0 " itclr0 "
;tree.end

base ad:0x80157150
;tree "prcm_itstatus1_reg"
rgroup 0--3
line.long 0 "prcm_itstatus1_reg"
bitfld.long 0 0. " itstatus1 "  "0 ,1 "
;tree.end

base ad:0x80157154
;tree "prcm_itclr1_reg"
wgroup 0--3
line.long 0 "prcm_itclr1_reg"
bitfld.long 0 0. " itclr1 "  "0 ,1 "
;tree.end

base ad:0x80157158
;tree "prcm_itstatus2_reg"
rgroup 0--3
line.long 0 "prcm_itstatus2_reg"
bitfld.long 0 0.--6. " itstatus2 "  " "
;tree.end

base ad:0x8015715c
;tree "prcm_itclr2_reg"
wgroup 0--3
line.long 0 "prcm_itclr2_reg"
bitfld.long 0 0.--6. " itclr2 "  " "
;tree.end

base ad:0x80157160
;tree "prcm_itstatus3_reg"
rgroup 0--3
line.long 0 "prcm_itstatus3_reg"
hexfld.byte 0 " itstatus3 "
;tree.end

base ad:0x80157164
;tree "prcm_itclr3_reg"
wgroup 0--3
line.long 0 "prcm_itclr3_reg"
hexfld.byte 0 " itclr3 "
;tree.end

base ad:0x80157168
;tree "prcm_itstatus4_reg"
rgroup 0--3
line.long 0 "prcm_itstatus4_reg"
bitfld.long 0 0.--8. " itstatus4 "  " "
;tree.end

base ad:0x8015716c
;tree "prcm_itclr4_reg"
wgroup 0--3
line.long 0 "prcm_itclr4_reg"
bitfld.long 0 0.--8. " itclr4 "  " "
;tree.end

base ad:0x80157170
;tree "prcm_line_value_reg"
rgroup 0--3
line.long 0 "prcm_line_value_reg"
hexfld.long 0 " line_value "
;tree.end

base ad:0x80157174
;tree "prcm_hold_evt_reg"
group 0--3
line.long 0 "prcm_hold_evt_reg"
hexfld.long 0 " hold_evt "
;tree.end

base ad:0x80157178
;tree "prcm_edge_sens_l_reg"
group 0--3
line.long 0 "prcm_edge_sens_l_reg"
hexfld.long 0 " edge_sens "
;tree.end

base ad:0x8015717c
;tree "prcm_edge_sens_h_reg"
group 0--3
line.long 0 "prcm_edge_sens_h_reg"
hexfld.long 0 " edge_sens "
;tree.end

base ad:0x80157184
;tree "prcm_ddr_phy_dll_status_reg"
group 0--3
line.long 0 "prcm_ddr_phy_dll_status_reg"
bitfld.long 0 0.--3. " dll_status "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80157180
;tree "prcm_ddr_srefresh_reg"
group 0--3
line.long 0 "prcm_ddr_srefresh_reg"
bitfld.long 0 0. " srefresh "  "0 ,1 "
;tree.end

base ad:0x801570f0
;tree "prcm_arm_it_reg"
group 0--3
line.long 0 "prcm_arm_it_reg"
hexfld.long 0 " arm_it "
;tree.end

base ad:0x801570f4
;tree "prcm_arm_it_clr_reg"
group 0--3
line.long 0 "prcm_arm_it_clr_reg"
bitfld.long 0 0. " arm_it_clr "  "0 ,1 "
;tree.end

base ad:0x80157240
;tree "prcm_svammdsp_it_reg"
group 0--3
line.long 0 "prcm_svammdsp_it_reg"
bitfld.long 0 0. " svammdsp_it "  "0 ,1 "
;tree.end

base ad:0x80157244
;tree "prcm_svammdsp_it_clr_reg"
group 0--3
line.long 0 "prcm_svammdsp_it_clr_reg"
bitfld.long 0 0. " svammdsp_it_clr "  "0 ,1 "
;tree.end

base ad:0x80157248
;tree "prcm_siammdsp_it_reg"
group 0--3
line.long 0 "prcm_siammdsp_it_reg"
bitfld.long 0 0. " siammdsp_it "  "0 ,1 "
;tree.end

base ad:0x8015724c
;tree "prcm_siammdsp_it_clr_reg"
group 0--3
line.long 0 "prcm_siammdsp_it_clr_reg"
bitfld.long 0 0. " siammdsp_it_clr "  "0 ,1 "
;tree.end

base ad:0x801570f8
;tree "prcm_4500_clk_req_reg"
group 0--3
line.long 0 "prcm_4500_clk_req_reg"
bitfld.long 0 0. " 4500_clk_req "  "0 ,1 "
;tree.end

base ad:0x801570d8
;tree "prcm_pipelinedcr"
group 0--3
line.long 0 "prcm_pipelinedcr"
hexfld.long 0 " pipelinecr "
;tree.end

base ad:0x801570dc
;tree "prcm_volatileiocr"
group 0--3
line.long 0 "prcm_volatileiocr"
hexfld.long 0 " volatileiocr "
;tree.end

base ad:0x801570e0
;tree "prcm_xp70cfgcr"
group 0--3
line.long 0 "prcm_xp70cfgcr"
bitfld.long 0 0. " p_fetch_en "  "0 ,1 "
bitfld.long 0 1. " wake_up "  "0 ,1 "
bitfld.long 0 2. " except_vb "  "0 ,1 "
bitfld.long 0 3. " idle_ack "  "0 ,1 "
;tree.end

base ad:0x801571d0
;tree "prcm_itstatus_dbg_reg"
rgroup 0--3
line.long 0 "prcm_itstatus_dbg_reg"
bitfld.long 0 0. " cdbbgpwrupreq "  "0 ,1 "
bitfld.long 0 1. " dap_csyspwrupreq "  "0 ,1 "
bitfld.long 0 2. " modem_csyspwrupreq "  "0 ,1 "
;tree.end

base ad:0x801571d4
;tree "prcm_itclr_dbg_reg"
wgroup 0--3
line.long 0 "prcm_itclr_dbg_reg"
bitfld.long 0 0. " cdbbgpwrupclr "  "0 ,1 "
bitfld.long 0 1. " dap_csyspwrupclr "  "0 ,1 "
bitfld.long 0 2. " modem_csyspwrupclr "  "0 ,1 "
;tree.end

base ad:0x801571d8
;tree "prcm_line_value_dbg_reg"
rgroup 0--3
line.long 0 "prcm_line_value_dbg_reg"
bitfld.long 0 0. " cdbbgpwrupval "  "0 ,1 "
bitfld.long 0 1. " dap_csyspwrupval "  "0 ,1 "
bitfld.long 0 2. " modem_csyspwrupval "  "0 ,1 "
;tree.end

base ad:0x801571dc
;tree "prcm_dbg_hold_reg"
group 0--3
line.long 0 "prcm_dbg_hold_reg"
bitfld.long 0 0. " cdbbgpwrupval_hold "  "0 ,1 "
bitfld.long 0 1. " dap_csyspwrupval_hold "  "0 ,1 "
bitfld.long 0 2. " modem_csyspwrupval_hold "  "0 ,1 "
;tree.end

base ad:0x801571e0
;tree "prcm_edge_sens_dbg_reg"
group 0--3
line.long 0 "prcm_edge_sens_dbg_reg"
bitfld.long 0 0.--1. " cdbbgpwrupval_edge "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " dap_csyspwrupval_edge "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " modem_csyspwrupval_edge "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80157190
;tree "prcm_debug_ctrl_val"
rgroup 0--3
line.long 0 "prcm_debug_ctrl_val"
bitfld.long 0 0. " cdbgpwrupreq "  "0 ,1 "
bitfld.long 0 1. " dap_csyspwrupreq "  "0 ,1 "
bitfld.long 0 2. " modem_csyspwrupreq "  "0 ,1 "
;tree.end

base ad:0x80157194
;tree "prcm_debug_nopwrdown_val"
rgroup 0--3
line.long 0 "prcm_debug_nopwrdown_val"
bitfld.long 0 0. " arm_debug_nopower_down_req "  "0 ,1 "
bitfld.long 0 1. " sva_debug_nopower_down_req "  "0 ,1 "
bitfld.long 0 2. " sia_debug_nopower_down_req "  "0 ,1 "
;tree.end

base ad:0x80157198
;tree "prcm_debug_ctrl_ack"
group 0--3
line.long 0 "prcm_debug_ctrl_ack"
bitfld.long 0 0. " arm_debug_nopower_down_ack "  "0 ,1 "
bitfld.long 0 1. " sva_debug_nopower_down_ack "  "0 ,1 "
bitfld.long 0 2. " sia_debug_nopower_down_ack "  "0 ,1 "
bitfld.long 0 3. " cdbgpwrup_ack "  "0 ,1 "
bitfld.long 0 4. " dap_csyspwrup_ack "  "0 ,1 "
bitfld.long 0 5. " modem_csyspwrup_ack "  "0 ,1 "
;tree.end

base ad:0x8015719c
;tree "prcm_a9pl_force_clken_reg"
group 0--3
line.long 0 "prcm_a9pl_force_clken_reg"
bitfld.long 0 0. " a9pl_force_clken "  "0 ,1 "
;tree.end

base ad:0x801571a0
;tree "prcm_a9atb_afvalid_reg"
group 0--3
line.long 0 "prcm_a9atb_afvalid_reg"
bitfld.long 0 0. " a9atb_afvalid "  "0 ,1 "
;tree.end

base ad:0x801571a4
;tree "prcm_a9atb_afready_reg"
rgroup 0--3
line.long 0 "prcm_a9atb_afready_reg"
bitfld.long 0 0. " a9atb_afready "  "0 ,1 "
;tree.end

base ad:0x801571a8
;tree "prcm_stp_flush_reg"
group 0--3
line.long 0 "prcm_stp_flush_reg"
bitfld.long 0 0. " stp_flush "  "0 ,1 "
;tree.end

base ad:0x801571ac
;tree "prcm_stp_ack_reg"
rgroup 0--3
line.long 0 "prcm_stp_ack_reg"
bitfld.long 0 0. " stp_ack "  "0 ,1 "
;tree.end

base ad:0x8015725c
;tree "prcm_power_state_val"
group 0--3
line.long 0 "prcm_power_state_val"
bitfld.long 0 9. " CSI_DSI "  "0 ,1 "
bitfld.long 0 8. " Vmodem "  "0 ,1 "
bitfld.long 0 7. " B2R2_MCDE "  "0 ,1 "
bitfld.long 0 6. " SVA_pipe "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP "  "0 ,1 "
bitfld.long 0 4. " SIA_pipe "  "0 ,1 "
bitfld.long 0 3. " SIA_MMDSP "  "0 ,1 "
bitfld.long 0 2. " DDR_controller_PHY "  "0 ,1 "
bitfld.long 0 1. " Varm "  "0 ,1 "
bitfld.long 0 0. " Vape "  "0 ,1 "
;tree.end

base ad:0x80157254
;tree "prcm_power_state_set"
wgroup 0--3
line.long 0 "prcm_power_state_set"
bitfld.long 0 0. " CSI_DSI "  "0 ,1 "
bitfld.long 0 1. " Vmodem "  "0 ,1 "
bitfld.long 0 2. " B2R2_MCDE "  "0 ,1 "
bitfld.long 0 3. " SVA_pipe "  "0 ,1 "
bitfld.long 0 4. " SVA_MMDSP "  "0 ,1 "
bitfld.long 0 5. " SIA_pipe "  "0 ,1 "
bitfld.long 0 6. " SIA_MMDSP "  "0 ,1 "
bitfld.long 0 7. " DDR_controller_PHY "  "0 ,1 "
bitfld.long 0 8. " Varm "  "0 ,1 "
bitfld.long 0 9. " Vape "  "0 ,1 "
;tree.end

base ad:0x80157258
;tree "prcm_power_state_clr"
wgroup 0--3
line.long 0 "prcm_power_state_clr"
bitfld.long 0 0. " CSI_DSI "  "0 ,1 "
bitfld.long 0 1. " Vmodem "  "0 ,1 "
bitfld.long 0 2. " B2R2_MCDE "  "0 ,1 "
bitfld.long 0 3. " SVA_pipe "  "0 ,1 "
bitfld.long 0 4. " SVA_MMDSP "  "0 ,1 "
bitfld.long 0 5. " SIA_pipe "  "0 ,1 "
bitfld.long 0 6. " SIA_MMDSP "  "0 ,1 "
bitfld.long 0 7. " DDR_controller_PHY "  "0 ,1 "
bitfld.long 0 8. " Varm "  "0 ,1 "
bitfld.long 0 9. " Vape "  "0 ,1 "
;tree.end

base ad:0x8015711c
;tree "prcm_armitmsk31to0"
group 0--3
line.long 0 "prcm_armitmsk31to0"
hexfld.long 0 " armitmsk31to0 "
;tree.end

base ad:0x80157120
;tree "prcm_armitmsk63to32"
group 0--3
line.long 0 "prcm_armitmsk63to32"
hexfld.long 0 " armitmsk63to32 "
;tree.end

base ad:0x80157124
;tree "prcm_armitmsk95to64"
group 0--3
line.long 0 "prcm_armitmsk95to64"
hexfld.long 0 " armitmsk95to64 "
;tree.end

base ad:0x80157128
;tree "prcm_armitmsk127to96"
group 0--3
line.long 0 "prcm_armitmsk127to96"
hexfld.long 0 " armitmsk127to96 "
;tree.end

base ad:0x80157260
;tree "prcm_armitvalue31to0"
group 0--3
line.long 0 "prcm_armitvalue31to0"
hexfld.long 0 " armitvalue31to0 "
;tree.end

base ad:0x80157264
;tree "prcm_armitvalue63to32"
group 0--3
line.long 0 "prcm_armitvalue63to32"
hexfld.long 0 " armitvalue63to32 "
;tree.end

base ad:0x80157268
;tree "prcm_armitvalue95to64"
group 0--3
line.long 0 "prcm_armitvalue95to64"
hexfld.long 0 " armitvalue95to64 "
;tree.end

base ad:0x8015726c
;tree "prcm_armitvalue127to96"
group 0--3
line.long 0 "prcm_armitvalue127to96"
hexfld.long 0 " armitvalue127to96 "
;tree.end

base ad:0x8015712c
;tree "prcm_armit_maskxp70_it"
group 0--3
line.long 0 "prcm_armit_maskxp70_it"
bitfld.long 0 0. " armit_maskxp70_it "  "0 ,1 "
;tree.end

base ad:0x80157130
;tree "prcm_armstandby_status_reg"
group 0--3
line.long 0 "prcm_armstandby_status_reg"
bitfld.long 0 0. " pl320_idle "  "0 ,1 "
bitfld.long 0 1.--2. " standbywfe "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " standbywfi "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " standby "  "0 ,1 "
bitfld.long 0 6. " event_o "  "0 ,1 "
;tree.end

base ad:0x80157328
;tree "prcm_a9_mask_req_reg"
group 0--3
line.long 0 "prcm_a9_mask_req_reg"
bitfld.long 0 0. " prcm_a9_mask_req_reg "  "0 ,1 "
;tree.end

base ad:0x8015732c
;tree "prcm_a9_mask_ack_reg"
rgroup 0--3
line.long 0 "prcm_a9_mask_ack_reg"
bitfld.long 0 0. " prcm_a9_mask_ack_reg "  "0 ,1 "
;tree.end

base ad:0x80157270
;tree "prcm_redun_load_reg"
group 0--3
line.long 0 "prcm_redun_load_reg"
hexfld.byte 0 " redun_load "
;tree.end

base ad:0x80157274
;tree "prcm_redun_status_reg"
rgroup 0--3
line.long 0 "prcm_redun_status_reg"
hexfld.byte 0 " edun_status "
;tree.end

base ad:0x80157134
;tree "prcm_icn_subclk_ctrl_reg"
group 0--3
line.long 0 "prcm_icn_subclk_ctrl_reg"
bitfld.long 0 0.--3. " icn_subclk_ctrl "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80157138
;tree "PRCMU_GPIOCR"
group 0--3
line.long 0 "PRCMU_GPIOCR"
bitfld.long 0 0. " DBG_UARTMOD_CMD0 "  "0 ,1 "
bitfld.long 0 1. " DBG_UARTMOD_CMD1 "  "0 ,1 "
bitfld.long 0 2. " DBG_ETM_R4_CMD0 "  "0 ,1 "
bitfld.long 0 3. " DBG_HSI_CMD "  "0 ,1 "
bitfld.long 0 4. " DBG_NEXUS_CMD "  "0 ,1 "
bitfld.long 0 5. " DBG_PTM_A9_CMD0 "  "0 ,1 "
bitfld.long 0 6. " DBG_PTM_A9_CMD1 "  "0 ,1 "
bitfld.long 0 7. " DBG_SBAG_CMD0 "  "0 ,1 "
bitfld.long 0 8. " DBG_SBAG_CMD1 "  "0 ,1 "
bitfld.long 0 9. " DBG_STM_APE_CMD "  "0 ,1 "
bitfld.long 0 10. " DBG_STM_MOD_CMD0 "  "0 ,1 "
bitfld.long 0 11. " DBG_STM_MOD_CMD1 "  "0 ,1 "
bitfld.long 0 12. " DBG_KBD_CMD "  "0 ,1 "
bitfld.long 0 13. " DBG_STM_MOD_CMD2 "  "0 ,1 "
bitfld.long 0 14. " DBG_PTM_A9_CMD2 "  "0 ,1 "
bitfld.long 0 15. " DBG_ETM_R4_CMD1 "  "0 ,1 "
bitfld.long 0 16. " DBG_UARTMOD_CMD2 "  "0 ,1 "
bitfld.long 0 17. " TRIGGER_SELECT "  "0 ,1 "
bitfld.long 0 18. " REMAP_SELECT_ON "  "0 ,1 "
bitfld.long 0 19. " DBG_ETM_R4_CMD2 "  "0 ,1 "
bitfld.long 0 20. " DBG_PTM_A9_CMD3 "  "0 ,1 "
bitfld.long 0 21. " DBG_PTM_A9_CMD4 "  "0 ,1 "
bitfld.long 0 22. " DBG_PTM_A9_CMD5 "  "0 ,1 "
bitfld.long 0 27. " MSPBYP01AEN "  "0 ,1 "
bitfld.long 0 28. " MSPBYP01CK10 "  "0 ,1 "
bitfld.long 0 29. " MSPBYP01CK01 "  "0 ,1 "
bitfld.long 0 30. " MSPBYP01FS10 "  "0 ,1 "
bitfld.long 0 31. " MSPBYP01FS01 "  "0 ,1 "
;tree.end

base ad:0x8015713c
;tree "PRCMU_LEMI"
group 0--3
line.long 0 "PRCMU_LEMI"
bitfld.long 0 0. " APECLK "  "0 ,1 "
bitfld.long 0 1. " APEINT "  "0 ,1 "
bitfld.long 0 2. " I2CAPE "  "0 ,1 "
bitfld.long 0 3. " I2CMOD "  "0 ,1 "
bitfld.long 0 4. " GPS "  "0 ,1 "
bitfld.long 0 5. " UICC "  "0 ,1 "
bitfld.long 0 6. " LINKO "  "0 ,1 "
bitfld.long 0 7. " MOD4500 "  "0 ,1 "
bitfld.long 0 8. " RST4500 "  "0 ,1 "
bitfld.long 0 9. " RTCK "  "0 ,1 "
bitfld.long 0 10. " CLKREQ "  "0 ,1 "
bitfld.long 0 11. " JTAG "  "0 ,1 "
;tree.end

base ad:0x80157140
;tree "PRCMU_COMPCR"
group 0--3
line.long 0 "PRCMU_COMPCR"
bitfld.long 0 0. " 1V2COMPTYP "  "0 ,1 "
bitfld.long 0 1. " 1V2COMPFRZ "  "0 ,1 "
bitfld.long 0 2. " 1V2COMPN "  "0 ,1 "
bitfld.long 0 3. " 1V8COMPTYP "  "0 ,1 "
bitfld.long 0 4. " 1V8COMPFRZ "  "0 ,1 "
bitfld.long 0 5. " 1V8COMPN "  "0 ,1 "
;tree.end

base ad:0x80157144
;tree "PRCMU_COMPSTA"
group 0--3
line.long 0 "PRCMU_COMPSTA"
bitfld.long 0 0. " 1V2COMPOK "  "0 ,1 "
bitfld.long 0 2.--8. " 1V2NASRC "  " "
bitfld.long 0 9.--15. " 1V2PASRC "  " "
bitfld.long 0 16. " 1V8COMPOK "  "0 ,1 "
bitfld.long 0 18.--24. " 1V8NASRC "  " "
bitfld.long 0 25.--31. " 1V8PASRC "  " "
;tree.end

base ad:0x80157324
;tree "HSI_CTRL"
group 0--3
line.long 0 "HSI_CTRL"
bitfld.long 0 0. " MDMACWAKE "  "0 ,1 "
bitfld.long 0 1. " EXTMDMHSI "  "0 ,1 "
bitfld.long 0 2. " EXTAPEHSI "  "0 ,1 "
;tree.end

base ad:0x801571c4
;tree "PRCMU_REMAPCR"
group 0--3
line.long 0 "PRCMU_REMAPCR"
bitfld.long 0 0. " REMAPCLR "  "0 ,1 "
bitfld.long 0 1. " REMAPSTAT "  "0 ,1 "
;tree.end

base ad:0x801571c8
;tree "PRCMU_TCR"
group 0--3
line.long 0 "PRCMU_TCR"
bitfld.long 0 0. " TENSEL0 "  "0 ,1 "
bitfld.long 0 1. " TENSEL1 "  "0 ,1 "
bitfld.long 0 2. " TENSEL2 "  "0 ,1 "
bitfld.long 0 3. " TENSEL3 "  "0 ,1 "
bitfld.long 0 4. " TENSEL4 "  "0 ,1 "
bitfld.long 0 5. " TENSEL5 "  "0 ,1 "
bitfld.long 0 6. " TENSEL6 "  "0 ,1 "
bitfld.long 0 7. " TENSEL7 "  "0 ,1 "
bitfld.long 0 16. " STOP_TIMERS "  "0 ,1 "
bitfld.long 0 17. " DOZE_MODE "  "0 ,1 "
;tree.end

base ad:0x801571cc
;tree "PRCMU_CLKOCR"
group 0--3
line.long 0 "PRCMU_CLKOCR"
bitfld.long 0 0.--5. " CLKODIV0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--8. " CLKOSEL0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--21. " CLKODIV1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--24. " CLKOSEL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 28. " CLK1TYPE "  "0 ,1 "
;tree.end

base ad:0x80157224
;tree "HSI_S0FTRST"
group 0--3
line.long 0 "HSI_S0FTRST"
bitfld.long 0 0. " HSITX_SOFTRST "  "0 ,1 "
bitfld.long 0 1. " HSIRX_SOFTRST "  "0 ,1 "
;tree.end

base ad:0x80157228
;tree "APE_S0FTRST"
group 0--3
line.long 0 "APE_S0FTRST"
bitfld.long 0 0. " APE_SOFTRST "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "PWL"
;==============================================================
base ad:0x80113000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PWLEN "  "0 ,1 "
;tree.end

base ad:0x80113004
;tree "LR"
group 0--3
line.long 0 "LR"
hexfld.byte 0 " PWLVL "
;tree.end

base ad:0x80113080
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80113088
;tree "ITOP"
rgroup 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " PWLOUT "  "0 ,1 "
;tree.end

base ad:0x80113fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80113fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80113fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80113fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80113ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

base ad:0x80113ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

base ad:0x80113ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

base ad:0x80113ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

;==============================================================
tree "RNG"
;==============================================================
base ad:0xa03c0000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SEC "  "0 ,1 "
bitfld.long 0 1. " PRIV "  "0 ,1 "
bitfld.long 0 2. " RNGDIS "  "0 ,1 "
bitfld.long 0 3. " TSTCLK "  "0 ,1 "
;tree.end

base ad:0xa03c0004
;tree "SR"
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RNGRDY "  "0 ,1 "
bitfld.long 0 1. " REVCLK "  "0 ,1 "
bitfld.long 0 2. " FAULT "  "0 ,1 "
;tree.end

base ad:0xa03c0008
;tree "VAL"
rgroup 0--3
line.long 0 "VAL"
;tree.end

base ad:0xa03c0080
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0xa03c0084
;tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
;tree.end

base ad:0xa03c0fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03c0fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c0fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c0fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03c0ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

base ad:0xa03c0ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

base ad:0xa03c0ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

base ad:0xa03c0ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

;==============================================================
tree "RTC"
;==============================================================
base ad:0x80154000
;tree "DR"
rgroup 0--3
line.long 0 "DR"
bitfld.long 0 0.--5. " CWSEC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " WMIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--16. " CWHOUR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 17.--19. " CWDAYW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--24. " CWDAYM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--28. " CWMONTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80154004
;tree "MR"
group 0--3
line.long 0 "MR"
bitfld.long 0 0.--5. " CWSECM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " WMINM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--16. " CWHOURM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 17.--19. " CWDAYWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--24. " CWDAYMM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--28. " CWMONTHM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80154008
;tree "LR"
group 0--3
line.long 0 "LR"
bitfld.long 0 0.--5. " CWSECL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " WMINL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--16. " CWHOURL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 17.--19. " CWDAYWL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--24. " CWDAYML "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--28. " CWMONTHL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8015400c
;tree "TCR"
group 0--3
line.long 0 "TCR"
hexfld.word 0 " CKDIV "
bitfld.long 0 16.--25. " CKDEL "  " "
bitfld.long 0 26. " RTCEN "  "0 ,1 "
bitfld.long 0 27. " SEC "  "0 ,1 "
;tree.end

base ad:0x80154010
;tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTCIMSC "  "0 ,1 "
bitfld.long 0 1. " RTTIMSC "  "0 ,1 "
;tree.end

base ad:0x80154014
;tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTCRIS "  "0 ,1 "
bitfld.long 0 1. " RTTRIS "  "0 ,1 "
;tree.end

base ad:0x80154018
;tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTCMIS "  "0 ,1 "
bitfld.long 0 1. " RTTMIS "  "0 ,1 "
;tree.end

base ad:0x8015401c
;tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTCIC "  "0 ,1 "
bitfld.long 0 1. " RTTIC "  "0 ,1 "
;tree.end

base ad:0x80154020
;tree "RTT_DR"
group 0--3
line.long 0 "RTT_DR"
hexfld.long 0 " Data "
;tree.end

base ad:0x80154024
;tree "RTT_LR1"
group 0--3
line.long 0 "RTT_LR1"
hexfld.long 0 " Load "
;tree.end

base ad:0x8015402c
;tree "RTT_LR2"
group 0--3
line.long 0 "RTT_LR2"
hexfld.long 0 " Load "
;tree.end

base ad:0x8015403c
;tree "RTT_PR1"
group 0--3
line.long 0 "RTT_PR1"
hexfld.long 0 " Load "
;tree.end

base ad:0x80154040
;tree "RTT_PR2"
group 0--3
line.long 0 "RTT_PR2"
hexfld.long 0 " Load "
;tree.end

base ad:0x80154044
;tree "RTT_PR3"
group 0--3
line.long 0 "RTT_PR3"
hexfld.long 0 " Load "
;tree.end

base ad:0x80154048
;tree "RTT_PR4"
group 0--3
line.long 0 "RTT_PR4"
hexfld.long 0 " Load "
;tree.end

base ad:0x8015404c
;tree "IN"
rgroup 0--3
line.long 0 "IN"
hexfld.long 0 " TINTERRUPT "
;tree.end

base ad:0x80154050
;tree "WK"
group 0--3
line.long 0 "WK"
hexfld.long 0 " TINTERRUPT "
;tree.end

base ad:0x80154054
;tree "SMIN"
rgroup 0--3
line.long 0 "SMIN"
hexfld.long 0 " SINTERRUPT "
;tree.end

base ad:0x80154028
;tree "RTT_CR"
group 0--3
line.long 0 "RTT_CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
bitfld.long 0 2. " RTTSS "  "0 ,1 "
bitfld.long 0 3. " RTTSM "  "0 ,1 "
bitfld.long 0 4.--10. " RTTPS "  " "
bitfld.long 0 11. " RTTCLK "  "0 ,1 "
;tree.end

base ad:0x80154030
;tree "YR"
rgroup 0--3
line.long 0 "YR"
bitfld.long 0 0.--13. " CWYEAR "  " "
;tree.end

base ad:0x80154034
;tree "YMR"
group 0--3
line.long 0 "YMR"
bitfld.long 0 0.--13. " CWYEARM "  " "
;tree.end

base ad:0x80154038
;tree "YLR"
group 0--3
line.long 0 "YLR"
bitfld.long 0 0.--13. " CWYEARL "  " "
;tree.end

base ad:0x80154080
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTCNT "  "0 ,1 "
;tree.end

base ad:0x80154084
;tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
;tree.end

base ad:0x80154088
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTCINTR "  "0 ,1 "
bitfld.long 0 1. " RTCWKUP "  "0 ,1 "
bitfld.long 0 2. " PWLOUT "  "0 ,1 "
bitfld.long 0 3. " RTTINTR "  "0 ,1 "
bitfld.long 0 4. " RTTWKUP "  "0 ,1 "
;tree.end

base ad:0x80154fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80154fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80154fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80154fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80154ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " RTCPCellID0 "
;tree.end

base ad:0x80154ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " RTCPCellID1 "
;tree.end

base ad:0x80154ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " RTCPCellID2 "
;tree.end

base ad:0x80154ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " RTCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "RTT0"
;==============================================================
base ad:0x80152000
;tree "CTCR"
group 0--3
line.long 0 "CTCR"
hexfld.word 0 " CKDIV "
;tree.end

base ad:0x80152004
;tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTTIMSC "  "0 ,1 "
;tree.end

base ad:0x80152008
;tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTTRIS "  "0 ,1 "
;tree.end

base ad:0x8015200c
;tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTTMIS "  "0 ,1 "
;tree.end

base ad:0x80152010
;tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTTIC "  "0 ,1 "
;tree.end

base ad:0x80152014
;tree "DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " Data "
;tree.end

base ad:0x80152018
;tree "LR"
group 0--3
line.long 0 "LR"
hexfld.long 0 " Load "
;tree.end

base ad:0x8015201c
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
;tree.end

base ad:0x80152080
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80152084
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTTINTR "  "0 ,1 "
bitfld.long 0 1. " RTTWKUP "  "0 ,1 "
;tree.end

base ad:0x80152fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80152fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80152fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80152fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80152ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " RTCPCellID0 "
;tree.end

base ad:0x80152ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " RTCPCellID1 "
;tree.end

base ad:0x80152ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " RTCPCellID2 "
;tree.end

base ad:0x80152ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " RTCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "RTT1"
;==============================================================
base ad:0x80153000
;tree "CTCR"
group 0--3
line.long 0 "CTCR"
hexfld.word 0 " CKDIV "
;tree.end

base ad:0x80153004
;tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTTIMSC "  "0 ,1 "
;tree.end

base ad:0x80153008
;tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTTRIS "  "0 ,1 "
;tree.end

base ad:0x8015300c
;tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTTMIS "  "0 ,1 "
;tree.end

base ad:0x80153010
;tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTTIC "  "0 ,1 "
;tree.end

base ad:0x80153014
;tree "DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " Data "
;tree.end

base ad:0x80153018
;tree "LR"
group 0--3
line.long 0 "LR"
hexfld.long 0 " Load "
;tree.end

base ad:0x8015301c
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
;tree.end

base ad:0x80153080
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80153084
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTTINTR "  "0 ,1 "
bitfld.long 0 1. " RTTWKUP "  "0 ,1 "
;tree.end

base ad:0x80153fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80153fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80153fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80153fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80153ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " RTCPCellID0 "
;tree.end

base ad:0x80153ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " RTCPCellID1 "
;tree.end

base ad:0x80153ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " RTCPCellID2 "
;tree.end

base ad:0x80153ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " RTCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "SBAG"
;==============================================================
base ad:0xa0390000
;tree "BA_ENABLE_L"
group 0--3
line.long 0 "BA_ENABLE_L"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390004
;tree "BA_ENABLE_H"
group 0--3
line.long 0 "BA_ENABLE_H"
;tree.end

base ad:0xa0390008
;tree "BA_MODE_L"
group 0--3
line.long 0 "BA_MODE_L"
bitfld.long 0 0.--2. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa039000c
;tree "BA_MODE_H"
group 0--3
line.long 0 "BA_MODE_H"
;tree.end

base ad:0xa0390010
;tree "BA_MSG_PORT_PACE_L"
group 0--3
line.long 0 "BA_MSG_PORT_PACE_L"
hexfld.word 0 " DIVIDER "
;tree.end

base ad:0xa0390014
;tree "BA_MSG_PORT_PACE_H"
group 0--3
line.long 0 "BA_MSG_PORT_PACE_H"
;tree.end

base ad:0xa0390018
;tree "BA_STATUS_L"
rgroup 0--3
line.long 0 "BA_STATUS_L"
bitfld.long 0 0.--1. " FF_FLAGS "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa039001c
;tree "BA_STATUS_H"
rgroup 0--3
line.long 0 "BA_STATUS_H"
;tree.end

base ad:0xa0390200
;tree "TIME_ABSOLUTE_L"
group 0--3
line.long 0 "TIME_ABSOLUTE_L"
hexfld.long 0 " TIME "
;tree.end

base ad:0xa0390204
;tree "TIME_ABSOLUTE_H"
rgroup 0--3
line.long 0 "TIME_ABSOLUTE_H"
hexfld.word 0 " TIME "
;tree.end

base ad:0xa0390400
;tree "WP0_CTRL_L"
group 0--3
line.long 0 "WP0_CTRL_L"
hexfld.byte 0 " RSRC_MSK "
hexfld.byte 1 " RSRC_VAL "
hexfld.byte 2 " SRC_MSK "
hexfld.byte 3 " SRC_VAL "
;tree.end

base ad:0xa0390404
;tree "WP0_CTRL_H"
group 0--3
line.long 0 "WP0_CTRL_H"
hexfld.byte 0 " OPC_MSK "
hexfld.byte 1 " OPC_VAL "
bitfld.long 0 16. " OUT_OF_RANGE "  "0 ,1 "
;tree.end

base ad:0xa0390408
;tree "WP0_EX_CTRL_L"
group 0--3
line.long 0 "WP0_EX_CTRL_L"
bitfld.long 0 0. " CBUF_FREEZE "  "0 ,1 "
;tree.end

base ad:0xa039040c
;tree "WP0_EX_CTRL_H"
group 0--3
line.long 0 "WP0_EX_CTRL_H"
;tree.end

base ad:0xa0390410
;tree "WP0_MATCH_START_L"
group 0--3
line.long 0 "WP0_MATCH_START_L"
bitfld.long 0 2.--23. " START_ADDR "  " "
;tree.end

base ad:0xa0390414
;tree "WP0_MATCH_START_H"
group 0--3
line.long 0 "WP0_MATCH_START_H"
;tree.end

base ad:0xa0390418
;tree "WP0_MATCH_END_L"
group 0--3
line.long 0 "WP0_MATCH_END_L"
bitfld.long 0 2.--23. " END_ADDR "  " "
;tree.end

base ad:0xa039041c
;tree "WP0_MATCH_END_H"
group 0--3
line.long 0 "WP0_MATCH_END_H"
;tree.end

base ad:0xa0390420
;tree "WP0_CB_HDR_L"
rgroup 0--3
line.long 0 "WP0_CB_HDR_L"
hexfld.byte 0 " SB3_DEST "
hexfld.byte 1 " SB3_OPC "
hexfld.byte 2 " SB3_TID "
hexfld.byte 3 " SB3_SRC "
;tree.end

base ad:0xa0390424
;tree "WP0_CB_HDR_H"
rgroup 0--3
line.long 0 "WP0_CB_HDR_H"
bitfld.long 0 3.--23. " SB3_ADDR "  " "
hexfld.byte 3 " SB3_MSK "
;tree.end

base ad:0xa0390428
;tree "WP0_CB_DATA_L"
rgroup 0--3
line.long 0 "WP0_CB_DATA_L"
hexfld.long 0 " SB3_DATA "
;tree.end

base ad:0xa039042c
;tree "WP0_CB_DATA_H"
rgroup 0--3
line.long 0 "WP0_CB_DATA_H"
hexfld.long 0 " SB3_DATA "
;tree.end

base ad:0xa0390430
;tree "WP0_ENABLE_L"
group 0--3
line.long 0 "WP0_ENABLE_L"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390434
;tree "WP0_ENABLE_H"
group 0--3
line.long 0 "WP0_ENABLE_H"
;tree.end

base ad:0xa0390480
;tree "WP1_CTRL_L"
group 0--3
line.long 0 "WP1_CTRL_L"
hexfld.byte 0 " RSRC_MSK "
hexfld.byte 1 " RSRC_VAL "
hexfld.byte 2 " SRC_MSK "
hexfld.byte 3 " SRC_VAL "
;tree.end

base ad:0xa0390484
;tree "WP1_CTRL_H"
group 0--3
line.long 0 "WP1_CTRL_H"
hexfld.byte 0 " OPC_MSK "
hexfld.byte 1 " OPC_VAL "
bitfld.long 0 16. " OUT_OF_RANGE "  "0 ,1 "
;tree.end

base ad:0xa0390488
;tree "WP1_EX_CTRL_L"
group 0--3
line.long 0 "WP1_EX_CTRL_L"
bitfld.long 0 0. " CBUF_FREEZE "  "0 ,1 "
;tree.end

base ad:0xa039048c
;tree "WP1_EX_CTRL_H"
group 0--3
line.long 0 "WP1_EX_CTRL_H"
;tree.end

base ad:0xa0390490
;tree "WP1_MATCH_START_L"
group 0--3
line.long 0 "WP1_MATCH_START_L"
bitfld.long 0 2.--23. " START_ADDR "  " "
;tree.end

base ad:0xa0390494
;tree "WP1_MATCH_START_H"
group 0--3
line.long 0 "WP1_MATCH_START_H"
;tree.end

base ad:0xa0390498
;tree "WP1_MATCH_END_L"
group 0--3
line.long 0 "WP1_MATCH_END_L"
bitfld.long 0 2.--23. " END_ADDR "  " "
;tree.end

base ad:0xa039049c
;tree "WP1_MATCH_END_H"
group 0--3
line.long 0 "WP1_MATCH_END_H"
;tree.end

base ad:0xa03904a0
;tree "WP1_CB_HDR_L"
rgroup 0--3
line.long 0 "WP1_CB_HDR_L"
hexfld.byte 0 " SB3_DEST "
hexfld.byte 1 " SB3_OPC "
hexfld.byte 2 " SB3_TID "
hexfld.byte 3 " SB3_SRC "
;tree.end

base ad:0xa03904a4
;tree "WP1_CB_HDR_H"
rgroup 0--3
line.long 0 "WP1_CB_HDR_H"
bitfld.long 0 3.--23. " SB3_ADDR "  " "
hexfld.byte 3 " SB3_MSK "
;tree.end

base ad:0xa03904a8
;tree "WP1_CB_DATA_L"
rgroup 0--3
line.long 0 "WP1_CB_DATA_L"
hexfld.long 0 " SB3_DATA "
;tree.end

base ad:0xa03904ac
;tree "WP1_CB_DATA_H"
rgroup 0--3
line.long 0 "WP1_CB_DATA_H"
hexfld.long 0 " SB3_DATA "
;tree.end

base ad:0xa03904b0
;tree "WP1_ENABLE_L"
group 0--3
line.long 0 "WP1_ENABLE_L"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa03904b4
;tree "WP1_ENABLE_H"
group 0--3
line.long 0 "WP1_ENABLE_H"
;tree.end

base ad:0xa0390600
;tree "MSG_REF_PACE_L"
group 0--3
line.long 0 "MSG_REF_PACE_L"
hexfld.long 0 " PACE "
;tree.end

base ad:0xa0390604
;tree "MSG_REF_PACE_H"
group 0--3
line.long 0 "MSG_REF_PACE_H"
;tree.end

base ad:0xa0390608
;tree "MSG_FPF_DATA_L"
group 0--3
line.long 0 "MSG_FPF_DATA_L"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa039060c
;tree "MSG_FPF_DATA_H"
group 0--3
line.long 0 "MSG_FPF_DATA_H"
;tree.end

base ad:0xa0390610
;tree "MSG_FPF_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG_FPF_TRACE_CTRL_L"
bitfld.long 0 0. " DATA "  "0 ,1 "
;tree.end

base ad:0xa0390614
;tree "MSG_FPF_TRACE_CTRL_H"
group 0--3
line.long 0 "MSG_FPF_TRACE_CTRL_H"
bitfld.long 0 16. " TIME "  "0 ,1 "
bitfld.long 0 17. " IT_EN "  "0 ,1 "
bitfld.long 0 31. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390618
;tree "MSG_PI_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG_PI_TRACE_CTRL_L"
hexfld.word 0 " INCDATA "
;tree.end

base ad:0xa039061c
;tree "MSG_PI_TRACE_CTRL_H"
group 0--3
line.long 0 "MSG_PI_TRACE_CTRL_H"
bitfld.long 0 16. " TIME "  "0 ,1 "
bitfld.long 0 31. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390a00
;tree "PI_TRIGGER_RAISE_L"
group 0--3
line.long 0 "PI_TRIGGER_RAISE_L"
hexfld.word 0 " RISING "
;tree.end

base ad:0xa0390a04
;tree "PI_TRIGGER_RAISE_H"
group 0--3
line.long 0 "PI_TRIGGER_RAISE_H"
;tree.end

base ad:0xa0390a08
;tree "PI_TRIGGER_FALLING_L"
group 0--3
line.long 0 "PI_TRIGGER_FALLING_L"
hexfld.word 0 " RISING "
;tree.end

base ad:0xa0390a0c
;tree "PI_TRIGGER_FALLING_H"
group 0--3
line.long 0 "PI_TRIGGER_FALLING_H"
;tree.end

base ad:0xa0390620
;tree "MSG0_BUS_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG0_BUS_TRACE_CTRL_L"
bitfld.long 0 0. " OPC "  "0 ,1 "
bitfld.long 0 1. " SRC "  "0 ,1 "
bitfld.long 0 2. " TID "  "0 ,1 "
bitfld.long 0 3. " MSK "  "0 ,1 "
bitfld.long 0 8. " ADDR "  "0 ,1 "
bitfld.long 0 16. " DATA "  "0 ,1 "
bitfld.long 0 24.--25. " DWIDTH "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0390624
;tree "MSG0_BUS_TRACE_CTRL_H"
group 0--3
line.long 0 "MSG0_BUS_TRACE_CTRL_H"
bitfld.long 0 16. " TIME "  "0 ,1 "
bitfld.long 0 31. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390628
;tree "MSG1_BUS_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG1_BUS_TRACE_CTRL_L"
bitfld.long 0 0. " OPC "  "0 ,1 "
bitfld.long 0 1. " SRC "  "0 ,1 "
bitfld.long 0 2. " TID "  "0 ,1 "
bitfld.long 0 3. " MSK "  "0 ,1 "
bitfld.long 0 8. " ADDR "  "0 ,1 "
bitfld.long 0 16. " DATA "  "0 ,1 "
bitfld.long 0 24.--25. " DWIDTH "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa039062c
;tree "MSG1_BUS_TRACE_CTRL_H"
group 0--3
line.long 0 "MSG1_BUS_TRACE_CTRL_H"
bitfld.long 0 16. " TIME "  "0 ,1 "
bitfld.long 0 31. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390630
;tree "MSG_ERR_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG_ERR_TRACE_CTRL_L"
bitfld.long 0 0. " FLG0 "  "0 ,1 "
bitfld.long 0 8. " FLG1 "  "0 ,1 "
bitfld.long 0 9. " FLG2 "  "0 ,1 "
bitfld.long 0 16. " FLG3 "  "0 ,1 "
;tree.end

base ad:0xa0390634
;tree "MSG_ERR_TRACE_CTRL_H"
group 0--3
line.long 0 "MSG_ERR_TRACE_CTRL_H"
bitfld.long 0 31. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390638
;tree "MSG_TM_TRACE_ENABLE_L"
group 0--3
line.long 0 "MSG_TM_TRACE_ENABLE_L"
bitfld.long 0 0.--12. " ENABLE "  " "
;tree.end

base ad:0xa039063c
;tree "MSG_TM_TRACE_ENABLE_H"
group 0--3
line.long 0 "MSG_TM_TRACE_ENABLE_H"
;tree.end

base ad:0xa0390640
;tree "MSG_TM0_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG_TM0_TRACE_CTRL_L"
bitfld.long 0 0. " INCM1 "  "0 ,1 "
bitfld.long 0 1. " INCM2 "  "0 ,1 "
bitfld.long 0 2. " INCM3 "  "0 ,1 "
bitfld.long 0 8. " INCERR "  "0 ,1 "
;tree.end

base ad:0xa0390644
;tree "MSG_TM0_TRACE_CTRL_H"
group 0--3
line.long 0 "MSG_TM0_TRACE_CTRL_H"
;tree.end

base ad:0xa0390800
;tree "TM_PORT0_FILTER_L"
group 0--3
line.long 0 "TM_PORT0_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390804
;tree "TM_PORT0_FILTER_H"
group 0--3
line.long 0 "TM_PORT0_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390808
;tree "TM_PORT1_FILTER_L"
group 0--3
line.long 0 "TM_PORT1_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa039080c
;tree "TM_PORT1_FILTER_H"
group 0--3
line.long 0 "TM_PORT1_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390810
;tree "TM_PORT2_FILTER_L"
group 0--3
line.long 0 "TM_PORT2_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390814
;tree "TM_PORT2_FILTER_H"
group 0--3
line.long 0 "TM_PORT2_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390818
;tree "TM_PORT3_FILTER_L"
group 0--3
line.long 0 "TM_PORT3_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa039081c
;tree "TM_PORT3_FILTER_H"
group 0--3
line.long 0 "TM_PORT3_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390820
;tree "TM_PORT4_FILTER_L"
group 0--3
line.long 0 "TM_PORT4_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390824
;tree "TM_PORT4_FILTER_H"
group 0--3
line.long 0 "TM_PORT4_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390828
;tree "TM_PORT5_FILTER_L"
group 0--3
line.long 0 "TM_PORT5_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa039082c
;tree "TM_PORT5_FILTER_H"
group 0--3
line.long 0 "TM_PORT5_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390830
;tree "TM_PORT6_FILTER_L"
group 0--3
line.long 0 "TM_PORT6_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390834
;tree "TM_PORT6_FILTER_H"
group 0--3
line.long 0 "TM_PORT6_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390838
;tree "TM_PORT7_FILTER_L"
group 0--3
line.long 0 "TM_PORT7_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa039083c
;tree "TM_PORT7_FILTER_H"
group 0--3
line.long 0 "TM_PORT7_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390840
;tree "TM_PORT8_FILTER_L"
group 0--3
line.long 0 "TM_PORT8_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390844
;tree "TM_PORT8_FILTER_H"
group 0--3
line.long 0 "TM_PORT8_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390848
;tree "TM_PORT9_FILTER_L"
group 0--3
line.long 0 "TM_PORT9_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa039084c
;tree "TM_PORT9_FILTER_H"
group 0--3
line.long 0 "TM_PORT9_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390850
;tree "TM_PORT10_FILTER_L"
group 0--3
line.long 0 "TM_PORT10_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390854
;tree "TM_PORT10_FILTER_H"
group 0--3
line.long 0 "TM_PORT10_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390858
;tree "TM_PORT11_FILTER_L"
group 0--3
line.long 0 "TM_PORT11_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa039085c
;tree "TM_PORT11_FILTER_H"
group 0--3
line.long 0 "TM_PORT11_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390860
;tree "TM_PORT12_FILTER_L"
group 0--3
line.long 0 "TM_PORT12_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390864
;tree "TM_PORT12_FILTER_H"
group 0--3
line.long 0 "TM_PORT12_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390880
;tree "TM_PORT0_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC1_L"
hexfld.word 0 " MCT "
hexfld.word 0 " MCT "
;tree.end

base ad:0xa0390884
;tree "TM_PORT0_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC1_H"
;tree.end

base ad:0xa0390880
;tree "TM_PORT0_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC1_L"
hexfld.word 0 " MCT "
hexfld.word 0 " MCT "
;tree.end

base ad:0xa0390884
;tree "TM_PORT0_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC1_H"
;tree.end

base ad:0xa0390888
;tree "TM_PORT1_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT1_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa039088c
;tree "TM_PORT1_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT1_METRIC1_H"
;tree.end

base ad:0xa0390890
;tree "TM_PORT2_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT2_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa0390894
;tree "TM_PORT2_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT2_METRIC1_H"
;tree.end

base ad:0xa0390898
;tree "TM_PORT3_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT3_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa039089c
;tree "TM_PORT3_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT3_METRIC1_H"
;tree.end

base ad:0xa03908a0
;tree "TM_PORT4_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT4_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908a4
;tree "TM_PORT4_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT4_METRIC1_H"
;tree.end

base ad:0xa03908a8
;tree "TM_PORT5_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT5_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908ac
;tree "TM_PORT5_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT5_METRIC1_H"
;tree.end

base ad:0xa03908b0
;tree "TM_PORT6_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT6_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908b4
;tree "TM_PORT6_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT6_METRIC1_H"
;tree.end

base ad:0xa03908b8
;tree "TM_PORT7_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT7_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908bc
;tree "TM_PORT7_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT7_METRIC1_H"
;tree.end

base ad:0xa03908c0
;tree "TM_PORT8_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT8_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908c4
;tree "TM_PORT8_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT8_METRIC1_H"
;tree.end

base ad:0xa03908c8
;tree "TM_PORT9_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT9_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908cc
;tree "TM_PORT9_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT9_METRIC1_H"
;tree.end

base ad:0xa03908d0
;tree "TM_PORT10_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT10_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908d4
;tree "TM_PORT10_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT10_METRIC1_H"
;tree.end

base ad:0xa03908d8
;tree "TM_PORT11_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT11_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908dc
;tree "TM_PORT11_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT11_METRIC1_H"
;tree.end

base ad:0xa03908e0
;tree "TM_PORT12_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT12_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908e4
;tree "TM_PORT12_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT12_METRIC1_H"
;tree.end

base ad:0xa03908e8
;tree "TM_PORT13_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT13_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908ec
;tree "TM_PORT13_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT13_METRIC1_H"
;tree.end

base ad:0xa03908f0
;tree "TM_PORT14_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT14_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908f4
;tree "TM_PORT14_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT14_METRIC1_H"
;tree.end

base ad:0xa03908f8
;tree "TM_PORT15_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT15_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908fc
;tree "TM_PORT15_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT15_METRIC1_H"
;tree.end

base ad:0xa0390900
;tree "TM_PORT0_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390904
;tree "TM_PORT0_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC2_H"
;tree.end

base ad:0xa0390908
;tree "TM_PORT1_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT1_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039090c
;tree "TM_PORT1_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT1_METRIC2_H"
;tree.end

base ad:0xa0390910
;tree "TM_PORT2_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT2_METRIC2_L"
;tree.end

base ad:0xa0390914
;tree "TM_PORT2_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT2_METRIC2_H"
;tree.end

base ad:0xa0390918
;tree "TM_PORT3_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT3_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039091c
;tree "TM_PORT3_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT3_METRIC2_H"
;tree.end

base ad:0xa0390920
;tree "TM_PORT4_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT4_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390924
;tree "TM_PORT4_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT4_METRIC2_H"
;tree.end

base ad:0xa0390928
;tree "TM_PORT5_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT5_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039092c
;tree "TM_PORT5_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT5_METRIC2_H"
;tree.end

base ad:0xa0390930
;tree "TM_PORT6_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT6_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390934
;tree "TM_PORT6_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT6_METRIC2_H"
;tree.end

base ad:0xa0390938
;tree "TM_PORT7_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT7_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039093c
;tree "TM_PORT7_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT7_METRIC2_H"
;tree.end

base ad:0xa0390940
;tree "TM_PORT8_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT8_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390944
;tree "TM_PORT8_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT8_METRIC2_H"
;tree.end

base ad:0xa0390948
;tree "TM_PORT9_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT9_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039094c
;tree "TM_PORT9_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT9_METRIC2_H"
;tree.end

base ad:0xa0390950
;tree "TM_PORT10_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT10_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390954
;tree "TM_PORT10_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT10_METRIC2_H"
;tree.end

base ad:0xa0390958
;tree "TM_PORT11_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT11_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039095c
;tree "TM_PORT11_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT11_METRIC2_H"
;tree.end

base ad:0xa0390960
;tree "TM_PORT12_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT12_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390964
;tree "TM_PORT12_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT12_METRIC2_H"
;tree.end

base ad:0xa0390968
;tree "TM_PORT13_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT13_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039096c
;tree "TM_PORT13_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT13_METRIC2_H"
;tree.end

base ad:0xa0390970
;tree "TM_PORT14_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT14_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390974
;tree "TM_PORT14_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT14_METRIC2_H"
;tree.end

base ad:0xa0390978
;tree "TM_PORT15_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT15_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039097c
;tree "TM_PORT15_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT15_METRIC2_H"
;tree.end

base ad:0xa0390980
;tree "TM_PORT0_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC3_L"
hexfld.word 0 " BAT "
hexfld.word 0 " BAT "
;tree.end

base ad:0xa0390984
;tree "TM_PORT0_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC3_H"
;tree.end

base ad:0xa0390980
;tree "TM_PORT0_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC3_L"
hexfld.word 0 " BAT "
hexfld.word 0 " BAT "
;tree.end

base ad:0xa0390984
;tree "TM_PORT0_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC3_H"
;tree.end

base ad:0xa0390988
;tree "TM_PORT1_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT1_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa039098c
;tree "TM_PORT1_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT1_METRIC3_H"
;tree.end

base ad:0xa0390990
;tree "TM_PORT2_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT2_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa0390994
;tree "TM_PORT2_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT2_METRIC3_H"
;tree.end

base ad:0xa0390998
;tree "TM_PORT3_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT3_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa039099c
;tree "TM_PORT3_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT3_METRIC3_H"
;tree.end

base ad:0xa03909a0
;tree "TM_PORT4_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT4_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909a4
;tree "TM_PORT4_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT4_METRIC3_H"
;tree.end

base ad:0xa03909a8
;tree "TM_PORT5_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT5_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909ac
;tree "TM_PORT5_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT5_METRIC3_H"
;tree.end

base ad:0xa03909b0
;tree "TM_PORT6_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT6_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909b4
;tree "TM_PORT6_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT6_METRIC3_H"
;tree.end

base ad:0xa03909b8
;tree "TM_PORT7_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT7_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909bc
;tree "TM_PORT7_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT7_METRIC3_H"
;tree.end

base ad:0xa03909c0
;tree "TM_PORT8_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT8_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909c4
;tree "TM_PORT8_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT8_METRIC3_H"
;tree.end

base ad:0xa03909c8
;tree "TM_PORT9_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT9_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909cc
;tree "TM_PORT9_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT9_METRIC3_H"
;tree.end

base ad:0xa03909d0
;tree "TM_PORT10_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT10_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909d4
;tree "TM_PORT10_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT10_METRIC3_H"
;tree.end

base ad:0xa03909d8
;tree "TM_PORT11_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT11_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909dc
;tree "TM_PORT11_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT11_METRIC3_H"
;tree.end

base ad:0xa03909e0
;tree "TM_PORT12_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT12_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909e4
;tree "TM_PORT12_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT12_METRIC3_H"
;tree.end

base ad:0xa03909e8
;tree "TM_PORT13_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT13_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909ec
;tree "TM_PORT13_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT13_METRIC3_H"
;tree.end

base ad:0xa03909f0
;tree "TM_PORT14_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT14_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909f4
;tree "TM_PORT14_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT14_METRIC3_H"
;tree.end

base ad:0xa03909f8
;tree "TM_PORT15_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT15_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909fc
;tree "TM_PORT15_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT15_METRIC3_H"
;tree.end

tree.end

;==============================================================
tree "SCR"
;==============================================================
base ad:0x80155000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " APEDBGEN0 "  "0 ,1 "
bitfld.long 0 1. " APENIDEN0 "  "0 ,1 "
bitfld.long 0 2. " APESPNIDEN0 "  "0 ,1 "
bitfld.long 0 3. " APESPIDEN0 "  "0 ,1 "
bitfld.long 0 4. " APEDBGEN1 "  "0 ,1 "
bitfld.long 0 5. " APENIDEN1 "  "0 ,1 "
bitfld.long 0 6. " APESPNIDEN1 "  "0 ,1 "
bitfld.long 0 7. " APESPIDEN1 "  "0 ,1 "
bitfld.long 0 8. " TOPDBGEN "  "0 ,1 "
bitfld.long 0 10. " APESTRCEN "  "0 ,1 "
bitfld.long 0 11. " APESTMEN "  "0 ,1 "
bitfld.long 0 12. " SIADBGEN "  "0 ,1 "
bitfld.long 0 13. " TOPAPEDBGEN "  "0 ,1 "
bitfld.long 0 14. " SPRSTEN0 "  "0 ,1 "
bitfld.long 0 15. " SPRSTEN1 "  "0 ,1 "
bitfld.long 0 16. " MODEMDIS "  "0 ,1 "
bitfld.long 0 17. " SFRDIS "  "0 ,1 "
bitfld.long 0 18. " CRRSTEN "  "0 ,1 "
bitfld.long 0 21.--23. " PROCESS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " FBVALDIS "  "0 ,1 "
bitfld.long 0 25. " SCRDAF "  "0 ,1 "
bitfld.long 0 26. " SWDGCLK "  "0 ,1 "
bitfld.long 0 27. " APECLKSW "  "0 ,1 "
bitfld.long 0 28. " cJTAGEn "  "0 ,1 "
bitfld.long 0 29. " REMAPDIS "  "0 ,1 "
bitfld.long 0 30. " SECMODDIS "  "0 ,1 "
bitfld.long 0 31. " OPENDEVn "  "0 ,1 "
;tree.end

base ad:0x80155004
;tree "WDR"
rgroup 0--3
line.long 0 "WDR"
hexfld.long 0 " SWDTVAL "
;tree.end

base ad:0x80155008
;tree "WLR"
group 0--3
line.long 0 "WLR"
hexfld.long 0 " SWDTLOAD "
;tree.end

base ad:0x8015500c
;tree "WCR"
group 0--3
line.long 0 "WCR"
bitfld.long 0 0. " SWDTDIS "  "0 ,1 "
bitfld.long 0 1. " SWDTLDIS "  "0 ,1 "
;tree.end

base ad:0x80155010
;tree "FVR0"
rgroup 0--3
line.long 0 "FVR0"
hexfld.long 0 " FUSE0_VALUE "
;tree.end

base ad:0x80155014
;tree "FVR1"
rgroup 0--3
line.long 0 "FVR1"
hexfld.long 0 " FUSE1_VALUE "
;tree.end

base ad:0x80155018
;tree "FVR2"
rgroup 0--3
line.long 0 "FVR2"
hexfld.long 0 " FUSE2_VALUE "
;tree.end

base ad:0x8015501c
;tree "FVR3"
rgroup 0--3
line.long 0 "FVR3"
hexfld.long 0 " FUSE3_VALUE "
;tree.end

base ad:0x80155020
;tree "FVR4"
rgroup 0--3
line.long 0 "FVR4"
hexfld.long 0 " FUSE4_VALUE "
;tree.end

base ad:0x80155024
;tree "FVR5"
rgroup 0--3
line.long 0 "FVR5"
hexfld.long 0 " FUSE5_VALUE "
;tree.end

base ad:0x80155028
;tree "FVR6"
rgroup 0--3
line.long 0 "FVR6"
hexfld.long 0 " FUSE6_VALUE "
;tree.end

base ad:0x8015502c
;tree "FVR7"
rgroup 0--3
line.long 0 "FVR7"
hexfld.long 0 " FUSE7_VALUE "
;tree.end

base ad:0x80155030
;tree "FVR8"
rgroup 0--3
line.long 0 "FVR8"
hexfld.long 0 " FUSE8_VALUE "
;tree.end

base ad:0x80155034
;tree "FVR9"
rgroup 0--3
line.long 0 "FVR9"
hexfld.long 0 " FUSE9_VALUE "
;tree.end

base ad:0x80155038
;tree "FVR10"
rgroup 0--3
line.long 0 "FVR10"
hexfld.long 0 " FUSE10_VALUE "
;tree.end

base ad:0x8015503c
;tree "FVR11"
rgroup 0--3
line.long 0 "FVR11"
hexfld.long 0 " FUSE11_VALUE "
;tree.end

base ad:0x80155040
;tree "FVR12"
rgroup 0--3
line.long 0 "FVR12"
hexfld.long 0 " FUSE12_VALUE "
;tree.end

base ad:0x80155044
;tree "FVR13"
rgroup 0--3
line.long 0 "FVR13"
hexfld.long 0 " FUSE13_VALUE "
;tree.end

base ad:0x80155048
;tree "FVR14"
rgroup 0--3
line.long 0 "FVR14"
hexfld.long 0 " FUSE14_VALUE "
;tree.end

base ad:0x8015504c
;tree "FVR15"
rgroup 0--3
line.long 0 "FVR15"
hexfld.long 0 " FUSE15_VALUE "
;tree.end

base ad:0x80155050
;tree "FVR16"
rgroup 0--3
line.long 0 "FVR16"
hexfld.long 0 " FUSE16_VALUE "
;tree.end

base ad:0x80155054
;tree "FVR17"
rgroup 0--3
line.long 0 "FVR17"
hexfld.long 0 " FUSE17_VALUE "
;tree.end

base ad:0x80155058
;tree "FVR18"
rgroup 0--3
line.long 0 "FVR18"
hexfld.long 0 " FUSE18_VALUE "
;tree.end

base ad:0x8015505c
;tree "FVR19"
rgroup 0--3
line.long 0 "FVR19"
hexfld.long 0 " FUSE19_VALUE "
;tree.end

base ad:0x80155060
;tree "FVR20"
rgroup 0--3
line.long 0 "FVR20"
hexfld.long 0 " FUSE20_VALUE "
;tree.end

base ad:0x80155064
;tree "FVR21"
rgroup 0--3
line.long 0 "FVR21"
hexfld.long 0 " FUSE21_VALUE "
;tree.end

base ad:0x80155068
;tree "FVR22"
rgroup 0--3
line.long 0 "FVR22"
hexfld.long 0 " FUSE22_VALUE "
;tree.end

base ad:0x8015506c
;tree "FVR23"
rgroup 0--3
line.long 0 "FVR23"
hexfld.long 0 " FUSE23_VALUE "
;tree.end

base ad:0x80155070
;tree "SRAMPROT0"
group 0--3
line.long 0 "SRAMPROT0"
hexfld.long 0 " SRAMPROT "
;tree.end

base ad:0x80155074
;tree "SRAMPROT1"
group 0--3
line.long 0 "SRAMPROT1"
hexfld.long 0 " SRAMPROT "
;tree.end

base ad:0x80155078
;tree "SRAMPROT2"
group 0--3
line.long 0 "SRAMPROT2"
hexfld.long 0 " SRAMPROT "
;tree.end

base ad:0x8015507c
;tree "SRAMPROT3"
group 0--3
line.long 0 "SRAMPROT3"
hexfld.long 0 " SRAMPROT "
;tree.end

base ad:0x80155080
;tree "SRAMPROT4"
group 0--3
line.long 0 "SRAMPROT4"
hexfld.long 0 " SRAMPROT "
;tree.end

base ad:0x80155084
;tree "SRAMPROT5"
group 0--3
line.long 0 "SRAMPROT5"
hexfld.long 0 " SRAMPROT "
;tree.end

base ad:0x80155090
;tree "SPR0"
group 0--3
line.long 0 "SPR0"
hexfld.long 0 " SSPR0 "
;tree.end

base ad:0x80155094
;tree "SPR1"
group 0--3
line.long 0 "SPR1"
hexfld.long 0 " SSPR1 "
;tree.end

base ad:0x801550a0
;tree "DDRMODLOW"
group 0--3
line.long 0 "DDRMODLOW"
hexfld.long 0 " DDRMODLOW "
;tree.end

base ad:0x801550a4
;tree "DDRMODHIGH"
group 0--3
line.long 0 "DDRMODHIGH"
hexfld.long 0 " DDRMODHIGH "
;tree.end

base ad:0x801550a8
;tree "DDRSHAREHIGH"
group 0--3
line.long 0 "DDRSHAREHIGH"
hexfld.long 0 " DDRSHAREHIGH "
;tree.end

base ad:0x801550b0
;tree "FUSECRC"
group 0--3
line.long 0 "FUSECRC"
hexfld.byte 0 " CRC0 "
hexfld.byte 1 " CRC1 "
hexfld.byte 2 " CRC2 "
;tree.end

base ad:0x801550c0
;tree "SCRBCTRL"
group 0--3
line.long 0 "SCRBCTRL"
bitfld.long 0 0. " SCRBEN "  "0 ,1 "
;tree.end

base ad:0x801550c4
;tree "SCRBKEY_L"
group 0--3
line.long 0 "SCRBKEY_L"
hexfld.long 0 " SCRAMBLE_KEY "
;tree.end

base ad:0x801550c8
;tree "SCRBKEY_H"
group 0--3
line.long 0 "SCRBKEY_H"
hexfld.long 0 " SCRAMBLE_KEY "
;tree.end

base ad:0x80155fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80155fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80155fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80155fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80155ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

base ad:0x80155ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

base ad:0x80155ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

base ad:0x80155ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

;==============================================================
tree "SCU"
;==============================================================
base ad:0xa0410000
;tree "SCU_CR"
group 0--3
line.long 0 "SCU_CR"
bitfld.long 0 0. " SCUCREN "  "0 ,1 "
bitfld.long 0 1. " SCUCRAFEN "  "0 ,1 "
bitfld.long 0 2. " SCUCRRPE "  "0 ,1 "
;tree.end

base ad:0xa0410004
;tree "SCU_CONFR"
group 0--3
line.long 0 "SCU_CONFR"
bitfld.long 0 0.--1. " SCUCONFRCPUN "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " SCUCONFRCPUSMP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " SCUCONFRTRS "
;tree.end

base ad:0xa0410008
;tree "SCU_CPUPSR"
group 0--3
line.long 0 "SCU_CPUPSR"
bitfld.long 0 0.--1. " SCUCPUPSRCPU0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " SCUCPUPSRCPU1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " SCUCPUPSRCPU2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " SCUCPUPSRCPU3 "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa041000c
;tree "SCU_IA"
wgroup 0--3
line.long 0 "SCU_IA"
bitfld.long 0 0.--3. " SCUIACPU0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " SCUIACPU1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " SCUIACPU2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " SCUIACPU3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0410040
;tree "SCU_FSAR"
group 0--3
line.long 0 "SCU_FSAR"
bitfld.long 0 20.--31. " SCUFSARFSA "  " "
;tree.end

base ad:0xa0410044
;tree "SCU_FEAR"
group 0--3
line.long 0 "SCU_FEAR"
bitfld.long 0 20.--31. " SCUFEARFEA "  " "
;tree.end

base ad:0xa0410050
;tree "SCU_ACR"
group 0--3
line.long 0 "SCU_ACR"
bitfld.long 0 0. " SCUACRCPU0 "  "0 ,1 "
bitfld.long 0 1. " SCUACRCPU1 "  "0 ,1 "
bitfld.long 0 2. " SCUACRCPU2 "  "0 ,1 "
bitfld.long 0 3. " SCUACRCPU3 "  "0 ,1 "
;tree.end

base ad:0xa0410054
;tree "SCU_SACR"
group 0--3
line.long 0 "SCU_SACR"
bitfld.long 0 0. " SCUSACRCPU0 "  "0 ,1 "
bitfld.long 0 1. " SCUSACRCPU1 "  "0 ,1 "
bitfld.long 0 2. " SCUSACRCPU2 "  "0 ,1 "
bitfld.long 0 3. " SCUSACRCPU3 "  "0 ,1 "
bitfld.long 0 4. " SCUSACRTCPU0 "  "0 ,1 "
bitfld.long 0 5. " SCUSACRTCPU1 "  "0 ,1 "
bitfld.long 0 6. " SCUSACRTCPU2 "  "0 ,1 "
bitfld.long 0 7. " SCUSACRTCPU3 "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "SGA"
;==============================================================
if (((data.long(ad:0x80157014)&0x100)!=0x100)||((data.long(ad:0x801571ec)&0x03)!=0x03))

base ad:0x80157014
;tree "prcm_sgaclk_mgt_reg"
group 0--3
line.long 0 "prcm_sgaclk_mgt_reg"
bitfld.long 0 8. " SGACLKEN "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 0. " SGA_resetn "  "0 ,1 "
bitfld.long 0 1. " SGA_init_n "  "0 ,1 "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 0. " SGA_resetn "  "0 ,1 "
bitfld.long 0 1. " SGA_init_n "  "0 ,1 "
;tree.end

else

base ad:0xa0300000
;tree "REND_LIST_ADDR"
group 0--3
line.long 0 "REND_LIST_ADDR"
bitfld.long 0 5.--31. " REND_LIST_ADDR "  " "
;tree.end

base ad:0xa0300004
;tree "REND_RSW_BASE"
group 0--3
line.long 0 "REND_RSW_BASE"
bitfld.long 0 6.--31. " REND_RSW_BASE "  " "
;tree.end

base ad:0xa0300008
;tree "REND_VERTEX_BASE"
group 0--3
line.long 0 "REND_VERTEX_BASE"
bitfld.long 0 6.--31. " REND_VERTEX_BASE "  " "
;tree.end

base ad:0xa030000c
;tree "FEATURE_ENABLE"
group 0--3
line.long 0 "FEATURE_ENABLE"
bitfld.long 0 0. " FP_TILEBUF_ENABLE "  "0 ,1 "
bitfld.long 0 1. " EARLYZ_ENABLE "  "0 ,1 "
bitfld.long 0 2. " IGNORE_CLEAR_BITS "  "0 ,1 "
bitfld.long 0 3. " EARLYZ_DISABLE1 "  "0 ,1 "
bitfld.long 0 4. " EARLYZ_DISABLE2 "  "0 ,1 "
bitfld.long 0 5. " ORIGIN_LOWER_LEFT "  "0 ,1 "
bitfld.long 0 6. " SUMMATE_QUAD_COVER "  "0 ,1 "
;tree.end

base ad:0xa0300010
;tree "Z_CLEAR_VALUE"
group 0--3
line.long 0 "Z_CLEAR_VALUE"
bitfld.long 0 0.--23. " Z_CLEAR_VALUE "  " "
;tree.end

base ad:0xa0300014
;tree "STENCIL_CLEAR_VALUE"
group 0--3
line.long 0 "STENCIL_CLEAR_VALUE"
hexfld.byte 0 " STENCIL_CLEAR_VALUE "
;tree.end

base ad:0xa0300018
;tree "ARGB_CLEAR_VALUE_0"
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_0"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

base ad:0xa030001c
;tree "ARGB_CLEAR_VALUE_1"
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_1"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

base ad:0xa0300020
;tree "ARGB_CLEAR_VALUE_2"
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_2"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

base ad:0xa0300024
;tree "ARGB_CLEAR_VALUE_3"
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_3"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

base ad:0xa0300028
;tree "BOUNDING_BOX_LEFT_RIGHT"
group 0--3
line.long 0 "BOUNDING_BOX_LEFT_RIGHT"
bitfld.long 0 0.--13. " BOUNDING_BOX_RIGHT "  " "
bitfld.long 0 16.--19. " BOUNDING_BOX_LEFT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa030002c
;tree "BOUNDING_BOX_BOTTOM"
group 0--3
line.long 0 "BOUNDING_BOX_BOTTOM"
bitfld.long 0 0.--13. " BOUNDING_BOX_BOTTOM "  " "
;tree.end

base ad:0xa0300030
;tree "FS_STACK_ADDR"
group 0--3
line.long 0 "FS_STACK_ADDR"
bitfld.long 0 3.--31. " FS_STACK_ADDR "  " "
;tree.end

base ad:0xa0300034
;tree "FS_STACK_SIZE_AND_INIT_VAL"
group 0--3
line.long 0 "FS_STACK_SIZE_AND_INIT_VAL"
hexfld.word 0 " FP_STACK_SIZE "
hexfld.word 0 " FS_STACK_INIT_VAL "
;tree.end

base ad:0xa0300040
;tree "ORIGIN_OFFSET_X"
group 0--3
line.long 0 "ORIGIN_OFFSET_X"
hexfld.word 0 " ORIGIN_OFFSET_X "
;tree.end

base ad:0xa0300044
;tree "ORIGIN_OFFSET_Y"
group 0--3
line.long 0 "ORIGIN_OFFSET_Y"
hexfld.word 0 " ORIGIN_OFFSET_Y "
;tree.end

base ad:0xa0300048
;tree "SUBPIXEL_SPECIFIER"
group 0--3
line.long 0 "SUBPIXEL_SPECIFIER"
hexfld.byte 0 " SUBPIXEL_SPECIFIER "
;tree.end

base ad:0xa030004c
;tree "TIEBREAK_MODE"
group 0--3
line.long 0 "TIEBREAK_MODE"
bitfld.long 0 0.--2. " TIEBREAK_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0300100
;tree "WB0_SOURCE_SELECT"
group 0--3
line.long 0 "WB0_SOURCE_SELECT"
bitfld.long 0 0.--1. " WB0_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0300104
;tree "WB0_TARGET_ADDR"
group 0--3
line.long 0 "WB0_TARGET_ADDR"
bitfld.long 0 3.--31. " WB0_TARGET_ADDR "  " "
;tree.end

base ad:0xa0300108
;tree "WB0_TARGET_PIXEL_FORMAT"
group 0--3
line.long 0 "WB0_TARGET_PIXEL_FORMAT"
bitfld.long 0 0.--3. " WB0_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa030010c
;tree "WB0_TARGET_AA_FORMAT"
group 0--3
line.long 0 "WB0_TARGET_AA_FORMAT"
bitfld.long 0 0.--2. " WB0_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0300110
;tree "WB0_TARGET_LAYOUT"
group 0--3
line.long 0 "WB0_TARGET_LAYOUT"
bitfld.long 0 0.--1. " WB0_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0300114
;tree "WB0_TARGET_SCANLINE_LENGTH"
group 0--3
line.long 0 "WB0_TARGET_SCANLINE_LENGTH"
hexfld.word 0 " WB0_TARGET_SCANLINE_LENGTH "
;tree.end

base ad:0xa0300118
;tree "WB0_TARGET_FLAGS"
group 0--3
line.long 0 "WB0_TARGET_FLAGS"
bitfld.long 0 0. " WB0_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB0_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB0_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB0_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB0_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB0_BIG_ENDIAN "  "0 ,1 "
;tree.end

base ad:0xa030011c
;tree "WB0_MRT_ENABLE"
group 0--3
line.long 0 "WB0_MRT_ENABLE"
bitfld.long 0 0.--3. " WB0_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0300120
;tree "WB0_MRT_OFFSET"
group 0--3
line.long 0 "WB0_MRT_OFFSET"
bitfld.long 0 3.--31. " WB0_MRT_OFFSET "  " "
;tree.end

base ad:0xa0300124
;tree "WB0_GLOBAL_TEST_ENABLE"
group 0--3
line.long 0 "WB0_GLOBAL_TEST_ENABLE"
bitfld.long 0 0. " WB0_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0300128
;tree "WB0_GLOBAL_TEST_REF_VALUE"
group 0--3
line.long 0 "WB0_GLOBAL_TEST_REF_VALUE"
hexfld.word 0 " WB0_GLOBAL_TEST_REF_VALUE "
;tree.end

base ad:0xa030012c
;tree "WB0_GLOBAL_TEST_CMP_FUNC"
group 0--3
line.long 0 "WB0_GLOBAL_TEST_CMP_FUNC"
bitfld.long 0 0.--2. " WB0_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0300200
;tree "WB1_SOURCE_SELECT"
group 0--3
line.long 0 "WB1_SOURCE_SELECT"
bitfld.long 0 0.--1. " WB1_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0300204
;tree "WB1_TARGET_ADDR"
group 0--3
line.long 0 "WB1_TARGET_ADDR"
bitfld.long 0 3.--31. " WB1_TARGET_ADDR "  " "
;tree.end

base ad:0xa0300208
;tree "WB1_TARGET_PIXEL_FORMAT"
group 0--3
line.long 0 "WB1_TARGET_PIXEL_FORMAT"
bitfld.long 0 0.--3. " WB1_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa030020c
;tree "WB1_TARGET_AA_FORMAT"
group 0--3
line.long 0 "WB1_TARGET_AA_FORMAT"
bitfld.long 0 0.--2. " WB1_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0300210
;tree "WB1_TARGET_LAYOUT"
group 0--3
line.long 0 "WB1_TARGET_LAYOUT"
bitfld.long 0 0.--1. " WB1_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0300214
;tree "WB1_TARGET_SCANLINE_LENGTH"
group 0--3
line.long 0 "WB1_TARGET_SCANLINE_LENGTH"
hexfld.word 0 " WB1_TARGET_SCANLINE_LENGTH "
;tree.end

base ad:0xa0300218
;tree "WB1_TARGET_FLAGS"
group 0--3
line.long 0 "WB1_TARGET_FLAGS"
bitfld.long 0 0. " WB1_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB1_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB1_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB1_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB1_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB1_BIG_ENDIAN "  "0 ,1 "
;tree.end

base ad:0xa030021c
;tree "WB1_MRT_ENABLE"
group 0--3
line.long 0 "WB1_MRT_ENABLE"
bitfld.long 0 0.--3. " WB1_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0300220
;tree "WB1_MRT_OFFSET"
group 0--3
line.long 0 "WB1_MRT_OFFSET"
bitfld.long 0 3.--31. " WB1_MRT_OFFSET "  " "
;tree.end

base ad:0xa0300224
;tree "WB1_GLOBAL_TEST_ENABLE"
group 0--3
line.long 0 "WB1_GLOBAL_TEST_ENABLE"
bitfld.long 0 0. " WB1_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0300228
;tree "WB1_GLOBAL_TEST_REF_VALUE"
group 0--3
line.long 0 "WB1_GLOBAL_TEST_REF_VALUE"
hexfld.word 0 " WB1_GLOBAL_TEST_REF_VALUE "
;tree.end

base ad:0xa030022c
;tree "WB1_GLOBAL_TEST_CMP_FUNC"
group 0--3
line.long 0 "WB1_GLOBAL_TEST_CMP_FUNC"
bitfld.long 0 0.--2. " WB1_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0300300
;tree "WB2_SOURCE_SELECT"
group 0--3
line.long 0 "WB2_SOURCE_SELECT"
bitfld.long 0 0.--1. " WB2_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0300304
;tree "WB2_TARGET_ADDR"
group 0--3
line.long 0 "WB2_TARGET_ADDR"
bitfld.long 0 3.--31. " WB2_TARGET_ADDR "  " "
;tree.end

base ad:0xa0300308
;tree "WB2_TARGET_PIXEL_FORMAT"
group 0--3
line.long 0 "WB2_TARGET_PIXEL_FORMAT"
bitfld.long 0 0.--3. " WB2_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa030030c
;tree "WB2_TARGET_AA_FORMAT"
group 0--3
line.long 0 "WB2_TARGET_AA_FORMAT"
bitfld.long 0 0.--2. " WB2_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0300310
;tree "WB2_TARGET_LAYOUT"
group 0--3
line.long 0 "WB2_TARGET_LAYOUT"
bitfld.long 0 0.--1. " WB2_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0300314
;tree "WB2_TARGET_SCANLINE_LENGTH"
group 0--3
line.long 0 "WB2_TARGET_SCANLINE_LENGTH"
hexfld.word 0 " WB2_TARGET_SCANLINE_LENGTH "
;tree.end

base ad:0xa0300318
;tree "WB2_TARGET_FLAGS"
group 0--3
line.long 0 "WB2_TARGET_FLAGS"
bitfld.long 0 0. " WB2_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB2_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB2_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB2_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB2_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB2_BIG_ENDIAN "  "0 ,1 "
;tree.end

base ad:0xa030031c
;tree "WB2_MRT_ENABLE"
group 0--3
line.long 0 "WB2_MRT_ENABLE"
bitfld.long 0 0.--3. " WB2_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0300320
;tree "WB2_MRT_OFFSET"
group 0--3
line.long 0 "WB2_MRT_OFFSET"
bitfld.long 0 3.--31. " WB2_MRT_OFFSET "  " "
;tree.end

base ad:0xa0300324
;tree "WB2_GLOBAL_TEST_ENABLE"
group 0--3
line.long 0 "WB2_GLOBAL_TEST_ENABLE"
bitfld.long 0 0. " WB2_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0300328
;tree "WB2_GLOBAL_TEST_REF_VALUE"
group 0--3
line.long 0 "WB2_GLOBAL_TEST_REF_VALUE"
hexfld.word 0 " WB2_GLOBAL_TEST_REF_VALUE "
;tree.end

base ad:0xa030032c
;tree "WB2_GLOBAL_TEST_CMP_FUNC"
group 0--3
line.long 0 "WB2_GLOBAL_TEST_CMP_FUNC"
bitfld.long 0 0.--2. " WB2_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0301000
;tree "MGMT_VERSION"
rgroup 0--3
line.long 0 "MGMT_VERSION"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 0 " PRODUCT_ID "
;tree.end

base ad:0xa0301004
;tree "MGMT_CURRENT_REND_LIST_ADDR"
group 0--3
line.long 0 "MGMT_CURRENT_REND_LIST_ADDR"
bitfld.long 0 5.--31. " CURRENT_REND_LIST_ADDR "  " "
;tree.end

base ad:0xa0301008
;tree "MGMT_STATUS"
group 0--3
line.long 0 "MGMT_STATUS"
bitfld.long 0 0. " RENDERING_ACTIVE "  "0 ,1 "
bitfld.long 0 1. " TILE_STOPPED "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 4. " BUS_STOPPED "  "0 ,1 "
bitfld.long 0 5. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 6. " INTERRUPT_ASSERTED "  "0 ,1 "
;tree.end

base ad:0xa030100c
;tree "MGMT_CTRL"
group 0--3
line.long 0 "MGMT_CTRL"
bitfld.long 0 0. " STOP_BUS "  "0 ,1 "
bitfld.long 0 1. " START_BUS "  "0 ,1 "
bitfld.long 0 2. " END_AFTER_TILE "  "0 ,1 "
bitfld.long 0 3. " FLUSH_CACHES "  "0 ,1 "
bitfld.long 0 4. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 5. " FORCE_RESET "  "0 ,1 "
bitfld.long 0 6. " START_RENDERING "  "0 ,1 "
;tree.end

base ad:0xa0301020
;tree "MGMT_INT_RAWSTAT"
group 0--3
line.long 0 "MGMT_INT_RAWSTAT"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0301024
;tree "MGMT_INT_CLEAR"
group 0--3
line.long 0 "MGMT_INT_CLEAR"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0301028
;tree "MGMT_INT_MASK"
group 0--3
line.long 0 "MGMT_INT_MASK"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
;tree.end

base ad:0xa030102c
;tree "MGMT_INT_STATUS"
rgroup 0--3
line.long 0 "MGMT_INT_STATUS"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0301040
;tree "MGMT_WRITE_BOUNDARY_ENABLE"
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ENABLE"
bitfld.long 0 0. " WRITE_BOUNDARY_ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0301044
;tree "MGMT_WRITE_BOUNDARY_LOW"
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_LOW"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_LOW "  " "
;tree.end

base ad:0xa0301048
;tree "MGMT_WRITE_BOUNDARY_HIGH"
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_HIGH"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_HIGH "  " "
;tree.end

base ad:0xa030104c
;tree "MGMT_WRITE_BOUNDARY_ADDRESS"
rgroup 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ADDRESS"
bitfld.long 0 2.--31. " WRITE_BOUNDARY_ADDRESS "  " "
;tree.end

base ad:0xa0301050
;tree "MGMT_BUS_ERROR_STATUS"
rgroup 0--3
line.long 0 "MGMT_BUS_ERROR_STATUS"
bitfld.long 0 0. " WRITE_ERROR "  "0 ,1 "
bitfld.long 0 1. " READ_ERROR "  "0 ,1 "
bitfld.long 0 2.--5. " WRITE_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--9. " READ_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0301060
;tree "MGMT_WATCHDOG_DISABLE"
group 0--3
line.long 0 "MGMT_WATCHDOG_DISABLE"
bitfld.long 0 0. " WATCHDOG_DISABLE "  "0 ,1 "
;tree.end

base ad:0xa0301064
;tree "MGMT_WATCHDOG_TIMEOUT"
group 0--3
line.long 0 "MGMT_WATCHDOG_TIMEOUT"
bitfld.long 0 0.--23. " WATCHDOG_TIMEOUT "  " "
;tree.end

base ad:0xa0301080
;tree "MGMT_PERF_CNT_0_ENABLE"
group 0--3
line.long 0 "MGMT_PERF_CNT_0_ENABLE"
bitfld.long 0 0. " PERF_CNT_0_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_0_LIM_EN "  "0 ,1 "
;tree.end

base ad:0xa0301084
;tree "MGMT_PERF_CNT_0_SRC"
group 0--3
line.long 0 "MGMT_PERF_CNT_0_SRC"
bitfld.long 0 0.--5. " PERF_CNT_0_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa0301088
;tree "MGMT_PERF_CNT_0_LIMIT"
group 0--3
line.long 0 "MGMT_PERF_CNT_0_LIMIT"
hexfld.long 0 " PERF_CNT_0_LIMIT "
;tree.end

base ad:0xa030108c
;tree "MGMT_PERF_CNT_0_VALUE"
group 0--3
line.long 0 "MGMT_PERF_CNT_0_VALUE"
hexfld.long 0 " PERF_CNT_0_VALUE "
;tree.end

base ad:0xa03010a0
;tree "MGMT_PERF_CNT_1_ENABLE"
group 0--3
line.long 0 "MGMT_PERF_CNT_1_ENABLE"
bitfld.long 0 0. " PERF_CNT_1_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_1_LIM_EN "  "0 ,1 "
;tree.end

base ad:0xa03010a4
;tree "MGMT_PERF_CNT_1_SRC"
group 0--3
line.long 0 "MGMT_PERF_CNT_1_SRC"
bitfld.long 0 0.--5. " PERF_CNT_1_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa03010a8
;tree "MGMT_PERF_CNT_1_LIMIT"
group 0--3
line.long 0 "MGMT_PERF_CNT_1_LIMIT"
hexfld.long 0 " PERF_CNT_1_LIMIT "
;tree.end

base ad:0xa03010ac
;tree "MGMT_PERF_CNT_1_VALUE"
group 0--3
line.long 0 "MGMT_PERF_CNT_1_VALUE"
hexfld.long 0 " PERF_CNT_1_VALUE "
;tree.end

base ad:0xa0302000
;tree "GP2_VSCL_START_ADDR"
group 0--3
line.long 0 "GP2_VSCL_START_ADDR"
bitfld.long 0 4.--31. " VSCL_START "  " "
;tree.end

base ad:0xa0302004
;tree "GP2_VSCL_END_ADDR"
group 0--3
line.long 0 "GP2_VSCL_END_ADDR"
bitfld.long 0 4.--31. " VSCL_END "  " "
;tree.end

base ad:0xa0302008
;tree "GP2_PLBCL_START_ADDR"
group 0--3
line.long 0 "GP2_PLBCL_START_ADDR"
bitfld.long 0 4.--31. " PLBCL_START "  " "
;tree.end

base ad:0xa030200c
;tree "GP2_PLBCL_END_ADDR"
group 0--3
line.long 0 "GP2_PLBCL_END_ADDR"
bitfld.long 0 4.--31. " PLBCL_END "  " "
;tree.end

base ad:0xa0302010
;tree "GP2_PLB_ALLOC_START_ADDR"
group 0--3
line.long 0 "GP2_PLB_ALLOC_START_ADDR"
bitfld.long 0 7.--31. " PLB_ALLOC_START_ADDR "  " "
;tree.end

base ad:0xa0302014
;tree "GP2_PLB_ALLOC_END_ADDR"
group 0--3
line.long 0 "GP2_PLB_ALLOC_END_ADDR"
bitfld.long 0 7.--31. " PLB_ALLOC_END_ADDR "  " "
;tree.end

base ad:0xa0302020
;tree "GP2_CMD"
group 0--3
line.long 0 "GP2_CMD"
bitfld.long 0 0. " START_VS "  "0 ,1 "
bitfld.long 0 1. " START_PLB "  "0 ,1 "
bitfld.long 0 4. " UPDATE_PLB_ALLOC "  "0 ,1 "
bitfld.long 0 5. " RESET "  "0 ,1 "
bitfld.long 0 6. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 7. " FLUSH_CACHE "  "0 ,1 "
bitfld.long 0 8. " START_BUS "  "0 ,1 "
bitfld.long 0 9. " STOP_BUS "  "0 ,1 "
;tree.end

base ad:0xa0302024
;tree "GP2_INT_RAWSTAT"
group 0--3
line.long 0 "GP2_INT_RAWSTAT"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0302028
;tree "GP2_INT_CLEAR"
wgroup 0--3
line.long 0 "GP2_INT_CLEAR"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa030202c
;tree "GP2_INT_MASK"
group 0--3
line.long 0 "GP2_INT_MASK"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0302030
;tree "GP2_INT_STAT"
rgroup 0--3
line.long 0 "GP2_INT_STAT"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0302034
;tree "GP2_WRITE_BOUNDARY_LOW"
group 0--3
line.long 0 "GP2_WRITE_BOUNDARY_LOW"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_LOW "  " "
;tree.end

base ad:0xa0302038
;tree "GP2_WRITE_BOUNDARY_HIGH"
group 0--3
line.long 0 "GP2_WRITE_BOUNDARY_HIGH"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_HIGH "  " "
;tree.end

base ad:0xa030203c
;tree "GP2_PERF_CNT_0_ENABLE"
group 0--3
line.long 0 "GP2_PERF_CNT_0_ENABLE"
bitfld.long 0 0. " PERF_CNT_0_ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0302040
;tree "GP2_PERF_CNT_1_ENABLE"
group 0--3
line.long 0 "GP2_PERF_CNT_1_ENABLE"
bitfld.long 0 0. " PERF_CNT_1_ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0302044
;tree "GP2_PERF_CNT_0_SRC"
group 0--3
line.long 0 "GP2_PERF_CNT_0_SRC"
bitfld.long 0 0.--4. " PERF_CNT_0_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0302048
;tree "GP2_PERF_CNT_1_SRC"
group 0--3
line.long 0 "GP2_PERF_CNT_1_SRC"
bitfld.long 0 0.--4. " PERF_CNT_1_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa030204c
;tree "GP2_PERF_CNT_0_VAL"
rgroup 0--3
line.long 0 "GP2_PERF_CNT_0_VAL"
bitfld.long 0 0.--23. " PERF_CNT_0_VAL "  " "
;tree.end

base ad:0xa0302050
;tree "GP2_PERF_CNT_1_VAL"
rgroup 0--3
line.long 0 "GP2_PERF_CNT_1_VAL"
bitfld.long 0 0.--23. " PERF_CNT_1_VAL "  " "
;tree.end

base ad:0xa0302054
;tree "GP2_PERF_CNT_0_LIMIT"
group 0--3
line.long 0 "GP2_PERF_CNT_0_LIMIT"
bitfld.long 0 0.--23. " PERF_CNT_0_LIMIT "  " "
;tree.end

base ad:0xa0302058
;tree "GP2_PERF_CNT_1_LIMIT"
group 0--3
line.long 0 "GP2_PERF_CNT_1_LIMIT"
bitfld.long 0 0.--23. " PERF_CNT_1_LIMIT "  " "
;tree.end

base ad:0xa0302068
;tree "GP2_STATUS"
rgroup 0--3
line.long 0 "GP2_STATUS"
bitfld.long 0 0. " IRQ "  "0 ,1 "
bitfld.long 0 1. " VS_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " BUS_STOPPED "  "0 ,1 "
bitfld.long 0 3. " PLB_ACTIVE "  "0 ,1 "
bitfld.long 0 5. " PLB_STALLED "  "0 ,1 "
bitfld.long 0 6. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 7. " HANG "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUND_ERR "  "0 ,1 "
;tree.end

base ad:0xa030206c
;tree "GP2_VERSION"
rgroup 0--3
line.long 0 "GP2_VERSION"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 0 " PRODUCT_ID "
;tree.end

base ad:0xa0302080
;tree "GP2_VSCL_INITIAL_ADDR"
rgroup 0--3
line.long 0 "GP2_VSCL_INITIAL_ADDR"
bitfld.long 0 4.--31. " VSCL_INITIAL_ADDR "  " "
;tree.end

base ad:0xa0302084
;tree "GP2_PLBCL_INITIAL_ADDR"
rgroup 0--3
line.long 0 "GP2_PLBCL_INITIAL_ADDR"
bitfld.long 0 4.--31. " PLBCL_INITIAL_ADDR "  " "
;tree.end

base ad:0xa0302088
;tree "GP2_WRITE_BOUNDARY_ERROR_ADDR"
rgroup 0--3
line.long 0 "GP2_WRITE_BOUNDARY_ERROR_ADDR"
bitfld.long 0 0. " WRITE_BOUNDARY_ERROR_ADDR "  "0 ,1 "
;tree.end

base ad:0xa030208c
;tree "GP2_AXI_BUS_ERROR_STAT"
rgroup 0--3
line.long 0 "GP2_AXI_BUS_ERROR_STAT"
bitfld.long 0 0. " READ_ERROR "  "0 ,1 "
bitfld.long 0 1. " WRITE_ERROR "  "0 ,1 "
bitfld.long 0 2.--5. " READ_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--9. " WRITE_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03020a0
;tree "GP2_WATCHDOG_DISABLE"
group 0--3
line.long 0 "GP2_WATCHDOG_DISABLE"
bitfld.long 0 0. " WATCHDOG_DISABLE "  "0 ,1 "
;tree.end

base ad:0xa03020a4
;tree "GP2_WATCHDOG_TIMEOUT"
group 0--3
line.long 0 "GP2_WATCHDOG_TIMEOUT"
bitfld.long 0 0.--23. " WATCHDOG_TIMEOUT "  " "
;tree.end

base ad:0xa0303000
;tree "MMU_DTE_ADDR"
group 0--3
line.long 0 "MMU_DTE_ADDR"
bitfld.long 0 0.--19. " DTE_ADDR "  " "
;tree.end

base ad:0xa0303004
;tree "MMU_STATUS"
rgroup 0--3
line.long 0 "MMU_STATUS"
bitfld.long 0 0. " PAGING_ENABLED "  "0 ,1 "
bitfld.long 0 1. " PAGE_FAULT_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " STALL_ACTIVE "  "0 ,1 "
bitfld.long 0 3. " IDLE "  "0 ,1 "
bitfld.long 0 4. " REPLAY_BUFFER_EMPTY "  "0 ,1 "
bitfld.long 0 5. " PAGE_FAULT_IS_WRITE "  "0 ,1 "
bitfld.long 0 6.--10. " PAGE_FAULT_BUS_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0303008
;tree "MMU_COMMAND"
group 0--3
line.long 0 "MMU_COMMAND"
bitfld.long 0 0. " COMMAND "  "0 ,1 "
;tree.end

base ad:0xa030300c
;tree "MMU_PAGE_FAULT_ADDR"
rgroup 0--3
line.long 0 "MMU_PAGE_FAULT_ADDR"
bitfld.long 0 0. " PAGE_FAULT_ADDR "  "0 ,1 "
;tree.end

base ad:0xa0303010
;tree "MMU_ZAPE_ONE_LINE"
group 0--3
line.long 0 "MMU_ZAPE_ONE_LINE"
bitfld.long 0 0. " ZAPE_ONE_LINE "  "0 ,1 "
;tree.end

base ad:0xa0303014
;tree "MMU_INT_RAWSTAT"
group 0--3
line.long 0 "MMU_INT_RAWSTAT"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0303018
;tree "MMU_INT_CLEAR"
wgroup 0--3
line.long 0 "MMU_INT_CLEAR"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa030301c
;tree "MMU_INT_MASK"
group 0--3
line.long 0 "MMU_INT_MASK"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0303020
;tree "MMU_INT_STATUS"
rgroup 0--3
line.long 0 "MMU_INT_STATUS"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

endif

tree.end

;==============================================================
tree "SIA (6 instances)"
;==============================================================
base ad:0xA0254000
;********************************************
tree "SIA-SIA"
;********************************************
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x801571ec)&0x3E00)!=0x3E00)||((data.long(ad:0x8015725c)&0x1F)!=0x1F))

base ad:0x8015700c
;tree "prcm_siammdspclk_mgt_reg"
group 0--3
line.long 0 "prcm_siammdspclk_mgt_reg"
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SIA_phy_en "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x8015725c
;tree "prcm_power_state_val"
group 0--3
line.long 0 "prcm_power_state_val"
bitfld.long 0 3. " SIA_pipe "  "0 ,1 "
bitfld.long 0 4. " SIA_MMDSP "  "0 ,1 "
;tree.end

else

base ad:0xA0258404
sgroup "SIA_REG_CKEN"
constx 0 %l 0xFFFF
setx 0 %l 0
line.long 0 "SIA_REG_CKEN"
base ad:0xA0258404
;tree "SIA_REG_CKEN"
group 0--3
line.long 0 "SIA_REG_CKEN"
;tree.end

if ((data.long(ad:0xA0258404)&0x01FB)==0x01FB)

base ad:0xA0254000
;tree "SIARESET"
group 0--3
line.long 0 "RESET"
bitfld.long 0 4. " ROT "  "0 ,1 "
bitfld.long 0 3. " PROJ "  "0 ,1 "
bitfld.long 0 2. " VCF "  "0 ,1 "
bitfld.long 0 1. " IPP "  "0 ,1 "
bitfld.long 0 0. " SIA_CORE "  "0 ,1 "
;tree.end

base ad:0xA0254010
;tree "SIACLOCK_ENABLE"
group 0--3
line.long 0 "CLOCK_ENABLE"
bitfld.long 0 4. " PROJ "  "0 ,1 "
bitfld.long 0 3. " VCF "  "0 ,1 "
bitfld.long 0 2. " IPP "  "0 ,1 "
bitfld.long 0 1. " STBP "  "0 ,1 "
bitfld.long 0 0. " DMA "  "0 ,1 "
;tree.end

base ad:0xA0254020
;tree "SIAIDN_HRV"
rgroup 0--3
line.long 0 "IDN_HRV"
bitfld.long 0 0.--3. " R0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " R1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " R2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA0254030
;tree "SIAVCF_ENABLE"
group 0--3
line.long 0 "VCF_ENABLE"
bitfld.long 0 0. " EN "  "0 ,1 "
;tree.end

base ad:0xA0254032
;tree "SIAROTATION"
group 0--3
line.long 0 "ROTATION"
bitfld.long 0 0.--1. " ROTATION "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254040
;tree "SIAISP_MCU_SYS_ADDR0"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR0"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA0254042
;tree "SIAISP_MCU_SYS_SIZE0"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE0"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254044
;tree "SIAISP_MCU_SYS_ADDR1"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR1"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA0254046
;tree "SIAISP_MCU_SYS_SIZE1"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE1"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254048
;tree "SIAISP_MCU_SYS_ADDR2"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR2"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA025404A
;tree "SIAISP_MCU_SYS_SIZE2"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE2"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA025404C
;tree "SIAISP_MCU_SYS_ADDR3"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR3"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA025404E
;tree "SIAISP_MCU_SYS_SIZE3"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE3"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254050
;tree "SIAISP_MCU_SYS_ADDR4"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR4"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA0254052
;tree "SIAISP_MCU_SYS_SIZE4"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE4"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254054
;tree "SIAISP_MCU_SYS_ADDR5"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR5"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA0254056
;tree "SIAISP_MCU_SYS_SIZE5"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE5"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254058
;tree "SIAISP_MCU_SYS_ADDR6"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR6"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA025405A
;tree "SIAISP_MCU_SYS_SIZE6"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE6"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA025405C
;tree "SIAISP_MCU_SYS_ADDR7"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR7"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA025405E
;tree "SIAISP_MCU_SYS_SIZE7"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE7"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254060
;tree "SIAISP_MCU_IO_ADDR_0"
group 0--3
line.long 0 "ISP_MCU_IO_ADDR_0"
hexfld.byte 0 " REGION_BA "
;tree.end

base ad:0xA0254062
;tree "SIAISP_MCU_IO_ADDR_1"
group 0--3
line.long 0 "ISP_MCU_IO_ADDR_1"
hexfld.byte 0 " REGION_BA "
;tree.end

base ad:0xA0254070
;tree "SIAISP_MEM_PAGE"
group 0--3
line.long 0 "ISP_MEM_PAGE"
bitfld.long 0 0.--5. " INDEX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254072
;tree "SIAXBUS_BYTE_ENABLE"
group 0--3
line.long 0 "XBUS_BYTE_ENABLE"
bitfld.long 0 0.--1. " BE0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BE1 "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254080
;tree "SIAPIPE03_SELECT"
group 0--3
line.long 0 "PIPE03_SELECT"
bitfld.long 0 0. " AP "  "0 ,1 "
;tree.end

base ad:0xA0254090
;tree "SIALICN_ITS"
rgroup 0--3
line.long 0 "LICN_ITS"
bitfld.long 0 0. " BUSERR "  "0 ,1 "
;tree.end

base ad:0xA0254092
;tree "SIALICN_ITS_BCLR"
wgroup 0--3
line.long 0 "LICN_ITS_BCLR"
bitfld.long 0 0. " BUSERR "  "0 ,1 "
;tree.end

base ad:0xA0254094
;tree "SIALICN_ITS_BSET"
wgroup 0--3
line.long 0 "LICN_ITS_BSET"
bitfld.long 0 0. " BUSERR "  "0 ,1 "
;tree.end

base ad:0xA0254096
;tree "SIALICN_ITM"
rgroup 0--3
line.long 0 "LICN_ITM"
bitfld.long 0 0. " BUSERR "  "0 ,1 "
;tree.end

base ad:0xA0254098
;tree "SIALICN_ITM_BCLR"
wgroup 0--3
line.long 0 "LICN_ITM_BCLR"
bitfld.long 0 0. " BUSERR "  "0 ,1 "
;tree.end

base ad:0xA025409A
;tree "SIALICN_ITM_BSET"
wgroup 0--3
line.long 0 "LICN_ITM_BSET"
bitfld.long 0 0. " BUSERR "  "0 ,1 "
;tree.end

endif

endif

tree.end

base ad:0xA0254200
;********************************************
tree "SIA-PROJ"
;********************************************
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x801571ec)&0x3E00)!=0x3E00)||((data.long(ad:0x8015725c)&0x1F)!=0x1F))

base ad:0x8015700c
;tree "prcm_siammdspclk_mgt_reg"
group 0--3
line.long 0 "prcm_siammdspclk_mgt_reg"
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SIA_phy_en "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x8015725c
;tree "prcm_power_state_val"
group 0--3
line.long 0 "prcm_power_state_val"
bitfld.long 0 3. " SIA_pipe "  "0 ,1 "
bitfld.long 0 4. " SIA_MMDSP "  "0 ,1 "
;tree.end

else

base ad:0xA0258404
sgroup "SIA_REG_CKEN"
constx 0 %l 0xFFFF
setx 0 %l 0
line.long 0 "SIA_REG_CKEN"
base ad:0xA0258404
;tree "SIA_REG_CKEN"
group 0--3
line.long 0 "SIA_REG_CKEN"
;tree.end

if ((data.long(ad:0xA0258404)&0x01FB)==0x01FB)

base ad:0xA0254200
;tree "PROJENR"
group 0--3
line.long 0 "ENR"
bitfld.long 0 0. " HCP "  "0 ,1 "
bitfld.long 0 1. " VCP "  "0 ,1 "
;tree.end

base ad:0xA0254210
;tree "PROJITS"
rgroup 0--3
line.long 0 "ITS"
bitfld.long 0 0. " HCP_EOT "  "0 ,1 "
bitfld.long 0 1. " VCP_EOT "  "0 ,1 "
bitfld.long 0 2. " VCP_ERR "  "0 ,1 "
;tree.end

base ad:0xA0254212
;tree "PROJITS_BCLR"
wgroup 0--3
line.long 0 "ITS_BCLR"
bitfld.long 0 0. " HCP_EOT "  "0 ,1 "
bitfld.long 0 1. " VCP_EOT "  "0 ,1 "
bitfld.long 0 2. " VCP_ERR "  "0 ,1 "
;tree.end

base ad:0xA0254214
;tree "PROJITS_BSET"
wgroup 0--3
line.long 0 "ITS_BSET"
bitfld.long 0 0. " HCP_EOT "  "0 ,1 "
bitfld.long 0 1. " VCP_EOT "  "0 ,1 "
bitfld.long 0 2. " VCP_ERR "  "0 ,1 "
;tree.end

base ad:0xA0254216
;tree "PROJITM"
rgroup 0--3
line.long 0 "ITM"
bitfld.long 0 0. " HCP_EOT "  "0 ,1 "
bitfld.long 0 1. " VCP_EOT "  "0 ,1 "
bitfld.long 0 2. " VCP_ERR "  "0 ,1 "
;tree.end

base ad:0xA0254218
;tree "PROJITM_BCLR"
wgroup 0--3
line.long 0 "ITM_BCLR"
bitfld.long 0 0. " HCP_EOT "  "0 ,1 "
bitfld.long 0 1. " VCP_EOT "  "0 ,1 "
bitfld.long 0 2. " VCP_ERR "  "0 ,1 "
;tree.end

base ad:0xA025421A
;tree "PROJITM_BSET"
wgroup 0--3
line.long 0 "ITM_BSET"
bitfld.long 0 0. " HCP_EOT "  "0 ,1 "
bitfld.long 0 1. " VCP_EOT "  "0 ,1 "
bitfld.long 0 2. " VCP_ERR "  "0 ,1 "
;tree.end

base ad:0xA0254220
;tree "PROJHSIZE"
group 0--3
line.long 0 "HSIZE"
bitfld.long 0 4.--12. " HSIZE "  " "
;tree.end

base ad:0xA0254222
;tree "PROJVSIZE"
group 0--3
line.long 0 "VSIZE"
bitfld.long 0 4.--12. " VSIZE "  " "
;tree.end

base ad:0xA0254230
;tree "PROJGCF_W_DIS"
group 0--3
line.long 0 "GCF_W_DIS"
bitfld.long 0 0. " GCF_W_DIS "  "0 ,1 "
;tree.end

base ad:0xA0254240
;tree "PROJENDIAN"
group 0--3
line.long 0 "ENDIAN"
bitfld.long 0 0. " ENDIAN "  "0 ,1 "
;tree.end

endif

endif

tree.end

base ad:0xA0254400
;********************************************
tree "SIA-DMA"
;********************************************
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x801571ec)&0x3E00)!=0x3E00)||((data.long(ad:0x8015725c)&0x1F)!=0x1F))

base ad:0x8015700c
;tree "prcm_siammdspclk_mgt_reg"
group 0--3
line.long 0 "prcm_siammdspclk_mgt_reg"
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SIA_phy_en "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x8015725c
;tree "prcm_power_state_val"
group 0--3
line.long 0 "prcm_power_state_val"
bitfld.long 0 3. " SIA_pipe "  "0 ,1 "
bitfld.long 0 4. " SIA_MMDSP "  "0 ,1 "
;tree.end

else

base ad:0xA0258404
sgroup "SIA_REG_CKEN"
constx 0 %l 0xFFFF
setx 0 %l 0
line.long 0 "SIA_REG_CKEN"
base ad:0xA0258404
;tree "SIA_REG_CKEN"
group 0--3
line.long 0 "SIA_REG_CKEN"
;tree.end

if ((data.long(ad:0xA0258404)&0x01FB)==0x01FB)

base ad:0xA0254400
;tree "DMAENR"
group 0--3
line.long 0 "ENR"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254402
;tree "DMADIR"
group 0--3
line.long 0 "DIR"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254404
;tree "DMAPEN"
rgroup 0--3
line.long 0 "PEN"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254406
;tree "DMAINTERLACE_EN"
group 0--3
line.long 0 "INTERLACE_EN"
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254410
;tree "DMAITS1"
rgroup 0--3
line.long 0 "ITS1"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254412
;tree "DMAITS1_BCLR"
wgroup 0--3
line.long 0 "ITS1_BCLR"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254416
;tree "DMAIMR1"
group 0--3
line.long 0 "IMR1"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254420
;tree "DMAITS2"
rgroup 0--3
line.long 0 "ITS2"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254422
;tree "DMAITS2_BCLR"
wgroup 0--3
line.long 0 "ITS2_BCLR"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254424
;tree "DMAIMR2"
group 0--3
line.long 0 "IMR2"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254430
;tree "DMASOFT_RST"
wgroup 0--3
line.long 0 "SOFT_RST"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254432
;tree "DMAFIFO_STA"
rgroup 0--3
line.long 0 "FIFO_STA"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254434
;tree "DMAFIFO_FLUSH"
wgroup 0--3
line.long 0 "FIFO_FLUSH"
bitfld.long 0 0. " IRP3_JPG_W "  "0 ,1 "
;tree.end

base ad:0xA0254440
;tree "DMAIRP03_DLS_L"
group 0--3
line.long 0 "IRP03_DLS_L"
bitfld.long 0 2.--15. " DMA_IRP03_DLS_L "  " "
;tree.end

base ad:0xA0254442
;tree "DMAIRP03_DLS_H"
group 0--3
line.long 0 "IRP03_DLS_H"
hexfld.word 0 " DMA_IRP03_DLS_H "
;tree.end

base ad:0xA0254444
;tree "DMAIRP03_DCS_L"
group 0--3
line.long 0 "IRP03_DCS_L"
bitfld.long 0 2.--15. " DMA_IRP03_DCS_L "  " "
;tree.end

base ad:0xA0254446
;tree "DMAIRP03_DCS_H"
group 0--3
line.long 0 "IRP03_DCS_H"
hexfld.word 0 " DMA_IRP03_DCS_H "
;tree.end

base ad:0xA0254448
;tree "DMAIRP03_CLS_L"
group 0--3
line.long 0 "IRP03_CLS_L"
bitfld.long 0 2.--15. " DMA_IRP03_CLS_L "  " "
;tree.end

base ad:0xA025444A
;tree "DMAIRP03_CLS_H"
group 0--3
line.long 0 "IRP03_CLS_H"
hexfld.word 0 " DMA_IRP03_CLS_H "
;tree.end

base ad:0xA025444C
;tree "DMAIRP03_CCS_L"
group 0--3
line.long 0 "IRP03_CCS_L"
bitfld.long 0 2.--15. " DMA_IRP03_CCS_L "  " "
;tree.end

base ad:0xA025444E
;tree "DMAIRP03_CCS_H"
group 0--3
line.long 0 "IRP03_CCS_H"
hexfld.word 0 " DMA_IRP03_CCS_H "
;tree.end

base ad:0xA0254450
;tree "DMAIRP03_DC1S_L"
group 0--3
line.long 0 "IRP03_DC1S_L"
bitfld.long 0 2.--15. " DMA_IRP03_DC1S_L "  " "
;tree.end

base ad:0xA0254452
;tree "DMAIRP03_DC1S_H"
group 0--3
line.long 0 "IRP03_DC1S_H"
hexfld.word 0 " DMA_IRP03_DC1S_H "
;tree.end

base ad:0xA0254454
;tree "DMAIRP03_DC2S_L"
group 0--3
line.long 0 "IRP03_DC2S_L"
bitfld.long 0 2.--15. " DMA_IRP03_DC2S_L "  " "
;tree.end

base ad:0xA0254456
;tree "DMAIRP03_DC2S_H"
group 0--3
line.long 0 "IRP03_DC2S_H"
hexfld.word 0 " DMA_IRP03_DC2S_H "
;tree.end

base ad:0xA0254458
;tree "DMAIRP03_DRS_L"
group 0--3
line.long 0 "IRP03_DRS_L"
bitfld.long 0 2.--15. " DMA_IRP03_DRS_L "  " "
;tree.end

base ad:0xA025445A
;tree "DMAIRP03_DRS_H"
group 0--3
line.long 0 "IRP03_DRS_H"
hexfld.word 0 " DMA_IRP03_DRS_H "
;tree.end

base ad:0xA0254460
;tree "DMAIRP03_HPS_L"
group 0--3
line.long 0 "IRP03_HPS_L"
bitfld.long 0 2.--15. " DMA_IRP03_HPS_L "  " "
;tree.end

base ad:0xA0254462
;tree "DMAIRP03_HPS_H"
group 0--3
line.long 0 "IRP03_HPS_H"
hexfld.word 0 " DMA_IRP03_HPS_H "
;tree.end

base ad:0xA0254464
;tree "DMAIRP03_VPS_L"
group 0--3
line.long 0 "IRP03_VPS_L"
bitfld.long 0 2.--15. " DMA_IRP03_VPS_L "  " "
;tree.end

base ad:0xA0254466
;tree "DMAIRP03_VPS_H"
group 0--3
line.long 0 "IRP03_VPS_H"
hexfld.word 0 " DMA_IRP03_VPS_H "
;tree.end

base ad:0xA0254468
;tree "DMAIRP03_JPGS_L"
group 0--3
line.long 0 "IRP03_JPGS_L"
bitfld.long 0 2.--15. " DMA_IRP03_JPGS_L "  " "
;tree.end

base ad:0xA025446A
;tree "DMAIRP03_JPGS_H"
group 0--3
line.long 0 "IRP03_JPGS_H"
hexfld.word 0 " DMA_IRP03_JPGS_H "
;tree.end

base ad:0xA025446C
;tree "DMAIRP03_DFW"
group 0--3
line.long 0 "IRP03_DFW"
bitfld.long 0 2.--15. " DMA_IRP03_DFW "  " "
;tree.end

base ad:0xA025446E
;tree "DMAIRP03_DWW"
group 0--3
line.long 0 "IRP03_DWW"
bitfld.long 0 2.--15. " DMA_IRP03_DWW "  " "
;tree.end

base ad:0xA0254470
;tree "DMAIRP03_DWH"
group 0--3
line.long 0 "IRP03_DWH"
hexfld.word 0 " DMA_IRP03_DWH "
;tree.end

base ad:0xA0254472
;tree "DMAIRP03_JPG_DBS_L"
group 0--3
line.long 0 "IRP03_JPG_DBS_L"
bitfld.long 0 2.--15. " DMA_IRP03_JPG_DBS_L "  " "
;tree.end

base ad:0xA0254474
;tree "DMAIRP03_JPG_DBS_H"
group 0--3
line.long 0 "IRP03_JPG_DBS_H"
hexfld.word 0 " DMA_IRP03_JPG_DBS_H "
;tree.end

base ad:0xA0254476
;tree "DMAIMR1"
group 0--3
line.long 0 "IMR1"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254478
;tree "DMAIRP03_RASTER"
group 0--3
line.long 0 "IRP03_RASTER"
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA025447A
;tree "DMAIRP03_ROTATION"
group 0--3
line.long 0 "IRP03_ROTATION"
bitfld.long 0 0.--1. " DMA_IRP03_ROTATION "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254480
;tree "DMAIRP0_SRS_L"
group 0--3
line.long 0 "IRP0_SRS_L"
bitfld.long 0 2.--15. " DMA_IRP0_SRS_L "  " "
;tree.end

base ad:0xA0254482
;tree "DMAIRP0_SRS_H"
group 0--3
line.long 0 "IRP0_SRS_H"
hexfld.word 0 " DMA_IRP0_SRS_H "
;tree.end

base ad:0xA0254484
;tree "DMAIRP0_SFW"
group 0--3
line.long 0 "IRP0_SFW"
bitfld.long 0 2.--15. " DMA_IRP0_SFW "  " "
;tree.end

base ad:0xA0254486
;tree "DMAIRP0_SWW"
group 0--3
line.long 0 "IRP0_SWW"
bitfld.long 0 2.--15. " DMA_IRP0_SWW "  " "
;tree.end

base ad:0xA0254488
;tree "DMAIRP0_SWH"
group 0--3
line.long 0 "IRP0_SWH"
hexfld.word 0 " DMA_IRP0_SWH "
;tree.end

base ad:0xA0254490
;tree "DMAIRP1_DRS_L"
group 0--3
line.long 0 "IRP1_DRS_L"
bitfld.long 0 2.--15. " DMA_IRP1_DRS_L "  " "
;tree.end

base ad:0xA0254492
;tree "DMAIRP1_DRS_H"
group 0--3
line.long 0 "IRP1_DRS_H"
hexfld.word 0 " DMA_IRP1_DRS_H "
;tree.end

base ad:0xA0254494
;tree "DMAIRP1_DFW"
group 0--3
line.long 0 "IRP1_DFW"
bitfld.long 0 2.--15. " DMA_IRP1_DFW "  " "
;tree.end

base ad:0xA0254496
;tree "DMAIRP1_DWW"
group 0--3
line.long 0 "IRP1_DWW"
bitfld.long 0 2.--15. " DMA_IRP1_DWW "  " "
;tree.end

base ad:0xA0254498
;tree "DMAIRP1_DWH"
group 0--3
line.long 0 "IRP1_DWH"
hexfld.word 0 " DMA_IRP1_DWH "
;tree.end

base ad:0xA02544A0
;tree "DMAIRP2_DRS_L"
group 0--3
line.long 0 "IRP2_DRS_L"
bitfld.long 0 2.--15. " DMA_IRP2_DRS_L "  " "
;tree.end

base ad:0xA02544A2
;tree "DMAIRP2_DRS_H"
group 0--3
line.long 0 "IRP2_DRS_H"
hexfld.word 0 " DMA_IRP2_DRS_H "
;tree.end

base ad:0xA02544A4
;tree "DMAIRP2_DFW"
group 0--3
line.long 0 "IRP2_DFW"
bitfld.long 0 2.--15. " DMA_IRP2_DFW "  " "
;tree.end

base ad:0xA02544A6
;tree "DMAIRP2_DWW"
group 0--3
line.long 0 "IRP2_DWW"
bitfld.long 0 2.--15. " DMA_IRP2_DWW "  " "
;tree.end

base ad:0xA02544A8
;tree "DMAIRP2_DWH"
group 0--3
line.long 0 "IRP2_DWH"
hexfld.word 0 " DMA_IRP2_DWH "
;tree.end

base ad:0xA02544B0
;tree "DMATST_CID"
wgroup 0--3
line.long 0 "TST_CID"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA02544B4
;tree "DMATST_SADD_L"
rgroup 0--3
line.long 0 "TST_SADD_L"
bitfld.long 0 2.--15. " DMA_CURADDR_L "  " "
;tree.end

base ad:0xA02544B6
;tree "DMATST_SADD_H"
rgroup 0--3
line.long 0 "TST_SADD_H"
hexfld.word 0 " DMA_CURADDR_H "
;tree.end

endif

endif

tree.end

base ad:0xA0254600
;********************************************
tree "SIA-STBP"
;********************************************
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x801571ec)&0x3E00)!=0x3E00)||((data.long(ad:0x8015725c)&0x1F)!=0x1F))

base ad:0x8015700c
;tree "prcm_siammdspclk_mgt_reg"
group 0--3
line.long 0 "prcm_siammdspclk_mgt_reg"
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SIA_phy_en "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x8015725c
;tree "prcm_power_state_val"
group 0--3
line.long 0 "prcm_power_state_val"
bitfld.long 0 3. " SIA_pipe "  "0 ,1 "
bitfld.long 0 4. " SIA_MMDSP "  "0 ,1 "
;tree.end

else

base ad:0xA0258404
sgroup "SIA_REG_CKEN"
constx 0 %l 0xFFFF
setx 0 %l 0
line.long 0 "SIA_REG_CKEN"
base ad:0xA0258404
;tree "SIA_REG_CKEN"
group 0--3
line.long 0 "SIA_REG_CKEN"
;tree.end

if ((data.long(ad:0xA0258404)&0x01FB)==0x01FB)

base ad:0xA0254600
;tree "STBPBSM"
group 0--3
line.long 0 "BSM"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254602
;tree "STBPMIN_OPC_SZ"
group 0--3
line.long 0 "MIN_OPC_SZ"
bitfld.long 0 0.--2. " MIN_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254604
;tree "STBPPAGE_SZ_SRAM"
group 0--3
line.long 0 "PAGE_SZ_SRAM"
bitfld.long 0 0.--3. " PSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA0254606
;tree "STBPPAGE_SZ_DRAM"
group 0--3
line.long 0 "PAGE_SZ_DRAM"
bitfld.long 0 0.--3. " PSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA0254608
;tree "STBPMAX_PRI"
group 0--3
line.long 0 "MAX_PRI"
bitfld.long 0 0.--3. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA0254620
;tree "STBPPEAK_LEVEL0"
group 0--3
line.long 0 "PEAK_LEVEL0"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254622
;tree "STBPPEAK_LEVEL1"
group 0--3
line.long 0 "PEAK_LEVEL1"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254624
;tree "STBPPEAK_LEVEL2"
group 0--3
line.long 0 "PEAK_LEVEL2"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254626
;tree "STBPPEAK_LEVEL3"
group 0--3
line.long 0 "PEAK_LEVEL3"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254628
;tree "STBPPEAK_LEVEL4"
group 0--3
line.long 0 "PEAK_LEVEL4"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA025462A
;tree "STBPPEAK_LEVEL5"
group 0--3
line.long 0 "PEAK_LEVEL5"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA025462C
;tree "STBPPEAK_LEVEL6"
group 0--3
line.long 0 "PEAK_LEVEL6"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA025462E
;tree "STBPPEAK_LEVEL7"
group 0--3
line.long 0 "PEAK_LEVEL7"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254630
;tree "STBPPEAK_LEVEL8"
group 0--3
line.long 0 "PEAK_LEVEL8"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254632
;tree "STBPPEAK_LEVEL9"
group 0--3
line.long 0 "PEAK_LEVEL9"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254634
;tree "STBPPEAK_LEVEL10"
group 0--3
line.long 0 "PEAK_LEVEL10"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254636
;tree "STBPPEAK_LEVEL11"
group 0--3
line.long 0 "PEAK_LEVEL11"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254638
;tree "STBPPEAK_LEVEL12"
group 0--3
line.long 0 "PEAK_LEVEL12"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254640
;tree "STBPMAX_OPC_SZ0"
group 0--3
line.long 0 "MAX_OPC_SZ0"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254642
;tree "STBPMAX_OPC_SZ1"
group 0--3
line.long 0 "MAX_OPC_SZ1"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254644
;tree "STBPMAX_OPC_SZ2"
group 0--3
line.long 0 "MAX_OPC_SZ2"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254646
;tree "STBPMAX_OPC_SZ3"
group 0--3
line.long 0 "MAX_OPC_SZ3"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254648
;tree "STBPMAX_OPC_SZ4"
group 0--3
line.long 0 "MAX_OPC_SZ4"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025464A
;tree "STBPMAX_OPC_SZ5"
group 0--3
line.long 0 "MAX_OPC_SZ5"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025464C
;tree "STBPMAX_OPC_SZ6"
group 0--3
line.long 0 "MAX_OPC_SZ6"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025464E
;tree "STBPMAX_OPC_SZ7"
group 0--3
line.long 0 "MAX_OPC_SZ7"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254650
;tree "STBPMAX_OPC_SZ8"
group 0--3
line.long 0 "MAX_OPC_SZ8"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254652
;tree "STBPMAX_OPC_SZ9"
group 0--3
line.long 0 "MAX_OPC_SZ9"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254654
;tree "STBPMAX_OPC_SZ10"
group 0--3
line.long 0 "MAX_OPC_SZ10"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254656
;tree "STBPMAX_OPC_SZ11"
group 0--3
line.long 0 "MAX_OPC_SZ11"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254658
;tree "STBPMAX_OPC_SZ12"
group 0--3
line.long 0 "MAX_OPC_SZ12"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254660
;tree "STBPMAX_CHCK_SZ0"
group 0--3
line.long 0 "MAX_CHCK_SZ0"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254662
;tree "STBPMAX_CHCK_SZ1"
group 0--3
line.long 0 "MAX_CHCK_SZ1"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254664
;tree "STBPMAX_CHCK_SZ2"
group 0--3
line.long 0 "MAX_CHCK_SZ2"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254666
;tree "STBPMAX_CHCK_SZ3"
group 0--3
line.long 0 "MAX_CHCK_SZ3"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254668
;tree "STBPMAX_CHCK_SZ4"
group 0--3
line.long 0 "MAX_CHCK_SZ4"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025466A
;tree "STBPMAX_CHCK_SZ5"
group 0--3
line.long 0 "MAX_CHCK_SZ5"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025466C
;tree "STBPMAX_CHCK_SZ6"
group 0--3
line.long 0 "MAX_CHCK_SZ6"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025466E
;tree "STBPMAX_CHCK_SZ7"
group 0--3
line.long 0 "MAX_CHCK_SZ7"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254670
;tree "STBPMAX_CHCK_SZ8"
group 0--3
line.long 0 "MAX_CHCK_SZ8"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254672
;tree "STBPMAX_CHCK_SZ9"
group 0--3
line.long 0 "MAX_CHCK_SZ9"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254674
;tree "STBPMAX_CHCK_SZ10"
group 0--3
line.long 0 "MAX_CHCK_SZ10"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254676
;tree "STBPMAX_CHCK_SZ11"
group 0--3
line.long 0 "MAX_CHCK_SZ11"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254678
;tree "STBPMAX_CHCK_SZ12"
group 0--3
line.long 0 "MAX_CHCK_SZ12"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254680
;tree "STBPMAX_MSSG_SZ0"
group 0--3
line.long 0 "MAX_MSSG_SZ0"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254682
;tree "STBPMAX_MSSG_SZ1"
group 0--3
line.long 0 "MAX_MSSG_SZ1"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254684
;tree "STBPMAX_MSSG_SZ2"
group 0--3
line.long 0 "MAX_MSSG_SZ2"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254686
;tree "STBPMAX_MSSG_SZ3"
group 0--3
line.long 0 "MAX_MSSG_SZ3"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254688
;tree "STBPMAX_MSSG_SZ4"
group 0--3
line.long 0 "MAX_MSSG_SZ4"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025468A
;tree "STBPMAX_MSSG_SZ5"
group 0--3
line.long 0 "MAX_MSSG_SZ5"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025468C
;tree "STBPMAX_MSSG_SZ6"
group 0--3
line.long 0 "MAX_MSSG_SZ6"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025468E
;tree "STBPMAX_MSSG_SZ7"
group 0--3
line.long 0 "MAX_MSSG_SZ7"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254690
;tree "STBPMAX_MSSG_SZ8"
group 0--3
line.long 0 "MAX_MSSG_SZ8"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254692
;tree "STBPMAX_MSSG_SZ9"
group 0--3
line.long 0 "MAX_MSSG_SZ9"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254694
;tree "STBPMAX_MSSG_SZ10"
group 0--3
line.long 0 "MAX_MSSG_SZ10"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254696
;tree "STBPMAX_MSSG_SZ11"
group 0--3
line.long 0 "MAX_MSSG_SZ11"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254698
;tree "STBPMAX_MSSG_SZ12"
group 0--3
line.long 0 "MAX_MSSG_SZ12"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546A0
;tree "STBPPRIO_LEVEL0"
group 0--3
line.long 0 "PRIO_LEVEL0"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546A2
;tree "STBPPRIO_LEVEL1"
group 0--3
line.long 0 "PRIO_LEVEL1"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546A4
;tree "STBPPRIO_LEVEL2"
group 0--3
line.long 0 "PRIO_LEVEL2"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546A6
;tree "STBPPRIO_LEVEL3"
group 0--3
line.long 0 "PRIO_LEVEL3"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546A8
;tree "STBPPRIO_LEVEL4"
group 0--3
line.long 0 "PRIO_LEVEL4"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546AA
;tree "STBPPRIO_LEVEL5"
group 0--3
line.long 0 "PRIO_LEVEL5"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546AC
;tree "STBPPRIO_LEVEL6"
group 0--3
line.long 0 "PRIO_LEVEL6"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546AE
;tree "STBPPRIO_LEVEL7"
group 0--3
line.long 0 "PRIO_LEVEL7"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546B0
;tree "STBPPRIO_LEVEL8"
group 0--3
line.long 0 "PRIO_LEVEL8"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546B2
;tree "STBPPRIO_LEVEL9"
group 0--3
line.long 0 "PRIO_LEVEL9"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546B4
;tree "STBPPRIO_LEVEL10"
group 0--3
line.long 0 "PRIO_LEVEL10"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546B6
;tree "STBPPRIO_LEVEL11"
group 0--3
line.long 0 "PRIO_LEVEL11"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546B8
;tree "STBPPRIO_LEVEL12"
group 0--3
line.long 0 "PRIO_LEVEL12"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546C0
;tree "STBPPROCESS_EN"
group 0--3
line.long 0 "PROCESS_EN"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA02546C2
;tree "STBPPORT_CTRL"
group 0--3
line.long 0 "PORT_CTRL"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA02546D0
;tree "STBPERR_ITS"
rgroup 0--3
line.long 0 "ERR_ITS"
bitfld.long 0 0. " ERR "  "0 ,1 "
;tree.end

base ad:0xA02546D2
;tree "STBPERR_ITS_BSET"
wgroup 0--3
line.long 0 "ERR_ITS_BSET"
bitfld.long 0 0. " ERR "  "0 ,1 "
;tree.end

base ad:0xA02546D4
;tree "STBPERR_ITS_BCLR"
wgroup 0--3
line.long 0 "ERR_ITS_BCLR"
bitfld.long 0 0. " ERR "  "0 ,1 "
;tree.end

base ad:0xA02546D6
;tree "STBPERR_ITM"
rgroup 0--3
line.long 0 "ERR_ITM"
bitfld.long 0 0. " ERR "  "0 ,1 "
;tree.end

base ad:0xA02546D8
;tree "STBPERR_ITM_BSET"
wgroup 0--3
line.long 0 "ERR_ITM_BSET"
bitfld.long 0 0. " ERR "  "0 ,1 "
;tree.end

base ad:0xA02546DA
;tree "STBPERR_ITM_BCLR"
wgroup 0--3
line.long 0 "ERR_ITM_BCLR"
bitfld.long 0 0. " ERR "  "0 ,1 "
;tree.end

base ad:0xA02546DC
;tree "STBPERR_INFO"
rgroup 0--3
line.long 0 "ERR_INFO"
hexfld.byte 0 " R_OPC "
bitfld.long 0 7.--15. " R_SRC "  " "
;tree.end

base ad:0xA02546DE
;tree "STBPERR_INFO_CLR"
wgroup 0--3
line.long 0 "ERR_INFO_CLR"
bitfld.long 0 0. " CLR "  "0 ,1 "
;tree.end

endif

endif

tree.end

base ad:0xA0254800
;********************************************
tree "SIA-IPP"
;********************************************
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x801571ec)&0x3E00)!=0x3E00)||((data.long(ad:0x8015725c)&0x1F)!=0x1F))

base ad:0x8015700c
;tree "prcm_siammdspclk_mgt_reg"
group 0--3
line.long 0 "prcm_siammdspclk_mgt_reg"
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SIA_phy_en "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x8015725c
;tree "prcm_power_state_val"
group 0--3
line.long 0 "prcm_power_state_val"
bitfld.long 0 3. " SIA_pipe "  "0 ,1 "
bitfld.long 0 4. " SIA_MMDSP "  "0 ,1 "
;tree.end

else

base ad:0xA0258404
sgroup "SIA_REG_CKEN"
constx 0 %l 0xFFFF
setx 0 %l 0
line.long 0 "SIA_REG_CKEN"
base ad:0xA0258404
;tree "SIA_REG_CKEN"
group 0--3
line.long 0 "SIA_REG_CKEN"
;tree.end

if ((data.long(ad:0xA0258404)&0x01FB)==0x01FB)

base ad:0xA0254800
;tree "IPPDPHY_TOP_IF_EN"
group 0--3
line.long 0 "DPHY_TOP_IF_EN"
bitfld.long 0 0. " DPHY_TOP_IF_EN "  "0 ,1 "
;tree.end

base ad:0xA0254802
;tree "IPPSTATIC_TOP_IF_SEL"
group 0--3
line.long 0 "STATIC_TOP_IF_SEL"
bitfld.long 0 0.--1. " STATIC_TOP_IF_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254804
;tree "IPPSTATIC_CCP_IF"
group 0--3
line.long 0 "STATIC_CCP_IF"
bitfld.long 0 0. " STATIC_CCP_DSCLK "  "0 ,1 "
bitfld.long 0 7.--11. " STATIC_CCP_BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0254806
;tree "IPPINTERNAL_EN_CLK_CPP"
group 0--3
line.long 0 "INTERNAL_EN_CLK_CPP"
bitfld.long 0 0. " INTERNAL_EN_CLK_CPP "  "0 ,1 "
;tree.end

base ad:0xA0254808
;tree "IPPDPHY_COMPENSATION_CTRL"
group 0--3
line.long 0 "DPHY_COMPENSATION_CTRL"
bitfld.long 0 0. " CLK_1_5M_COMPENSATION_EN "  "0 ,1 "
bitfld.long 0 4. " DPHY_COMPENSATION_CALIB_START "  "0 ,1 "
bitfld.long 0 2. " DPHY_COMPENSATION_CALIB_WRITE_EN "  "0 ,1 "
bitfld.long 0 3.--5. " DPHY_COMPENSATION_CALIB_WRITE_CODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025480A
;tree "IPPDPHY_COMPENSATION_STATUS"
rgroup 0--3
line.long 0 "DPHY_COMPENSATION_STATUS"
bitfld.long 0 0. " DPHY_COMPENSATION_OK "  "0 ,1 "
bitfld.long 0 1.--3. " DPHY_COMPENSATION_CALIB_READ_CODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4. " DPHY_COMPENSATION_DBG_COMP_FLAG "  "0 ,1 "
;tree.end

base ad:0xA025480C
;tree "IPPSTATIC_CSI0_DATA_LANES"
group 0--3
line.long 0 "STATIC_CSI0_DATA_LANES"
bitfld.long 0 0.--1. " STATIC_CSI0_DATA_LANES_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--12. " STATIC_CSI0_DATA_LANES_MAP "  " "
;tree.end

base ad:0xA025480E
;tree "IPPCSI2_DPHY0_CL_CTRL"
group 0--3
line.long 0 "CSI2_DPHY0_CL_CTRL"
bitfld.long 0 0.--5. " CSI0_UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8. " CSI0_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 9. " CSI0_SWAP_PINS_CL "  "0 ,1 "
bitfld.long 0 10. " CSI0_HS_INVERT_CL "  "0 ,1 "
bitfld.long 0 11. " CSI0_HSRX_TERM_SHIFT_UP_CL "  "0 ,1 "
bitfld.long 0 12. " CSI0_HSRX_TERM_SHIFT_DOWN_CL "  "0 ,1 "
bitfld.long 0 13. " CSI0_TEST_RESERVED_1_CL "  "0 ,1 "
;tree.end

base ad:0xA0254810
;tree "IPPCSI2_DPHY0_DL1_CTRL"
group 0--3
line.long 0 "CSI2_DPHY0_DL1_CTRL"
bitfld.long 0 0. " CSI0_SWAP_PINS_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI0_HS_INVERT_DL1 "  "0 ,1 "
bitfld.long 0 2. " CSI0_FORCE_RX_MODE_DL1 "  "0 ,1 "
bitfld.long 0 3. " CSI0_CD_OFF_DL1 "  "0 ,1 "
bitfld.long 0 4. " CSI0_EOT_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 5. " CSI0_HSRX_TERM_SHIFT_UP_DL1 "  "0 ,1 "
bitfld.long 0 6. " CSI0_HSRX_TERM_SHIFT_DOWN_DL1 "  "0 ,1 "
bitfld.long 0 7. " CSI0_TEST_RESERVED_1_DL1 "  "0 ,1 "
;tree.end

base ad:0xA0254812
;tree "IPPCSI2_DPHY0_DL2_CTRL"
group 0--3
line.long 0 "CSI2_DPHY0_DL2_CTRL"
bitfld.long 0 0. " CSI0_SWAP_PINS_DL2 "  "0 ,1 "
bitfld.long 0 1. " CSI0_HS_INVERT_DL2 "  "0 ,1 "
bitfld.long 0 2. " CSI0_FORCE_RX_MODE_DL2 "  "0 ,1 "
bitfld.long 0 3. " CSI0_CD_OFF_DL2 "  "0 ,1 "
bitfld.long 0 4. " CSI0_EOT_BYPASS_DL2 "  "0 ,1 "
bitfld.long 0 5. " CSI0_HSRX_TERM_SHIFT_UP_DL2 "  "0 ,1 "
bitfld.long 0 6. " CSI0_HSRX_TERM_SHIFT_DOWN_DL2 "  "0 ,1 "
bitfld.long 0 7. " CSI0_TEST_RESERVED_1_DL2 "  "0 ,1 "
;tree.end

base ad:0xA0254814
;tree "IPPCSI2_DPHY0_DL3_CTRL"
group 0--3
line.long 0 "CSI2_DPHY0_DL3_CTRL"
bitfld.long 0 0. " CSI0_SWAP_PINS_DL3 "  "0 ,1 "
bitfld.long 0 1. " CSI0_HS_INVERT_DL3 "  "0 ,1 "
bitfld.long 0 2. " CSI0_FORCE_RX_MODE_DL3 "  "0 ,1 "
bitfld.long 0 3. " CSI0_CD_OFF_DL3 "  "0 ,1 "
bitfld.long 0 4. " CSI0_EOT_BYPASS_DL3 "  "0 ,1 "
bitfld.long 0 5. " CSI0_HSRX_TERM_SHIFT_UP_DL3 "  "0 ,1 "
bitfld.long 0 6. " CSI0_HSRX_TERM_SHIFT_DOWN_DL3 "  "0 ,1 "
bitfld.long 0 7. " CSI0_TEST_RESERVED_1_DL3 "  "0 ,1 "
;tree.end

base ad:0xA0254816
;tree "IPPCSI2_DPHY0_CL_DBG"
group 0--3
line.long 0 "CSI2_DPHY0_CL_DBG"
bitfld.long 0 0.--2. " CSI0_HS_RX_OFFSET_CL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CSI0_MIPI_IN_SHORT_CL "  "0 ,1 "
bitfld.long 0 8. " CSI0_LP_HS_BYPASS_CL "  "0 ,1 "
bitfld.long 0 9.--10. " CSI0_LP_RX_VIL_CL "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " CSI0_DIRECT_DYN_ACCESS_CL "  "0 ,1 "
;tree.end

base ad:0xA0254818
;tree "IPPCSI2_DPHY0_DL1_DBG"
group 0--3
line.long 0 "CSI2_DPHY0_DL1_DBG"
bitfld.long 0 0.--2. " CSI0_HS_RX_OFFSET_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CSI0_MIPI_IN_SHORT_DL1 "  "0 ,1 "
bitfld.long 0 4.--6. " CSI0_SKEW_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " CSI0_OVERSAMPLE_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 8. " CSI0_LP_HS_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 9.--10. " CSI0_LP_RX_VIL_DL1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " CSI0_DIRECT_DYN_ACCESS_DL1 "  "0 ,1 "
;tree.end

base ad:0xA025481A
;tree "IPPCSI2_DPHY0_DL2_DBG"
group 0--3
line.long 0 "CSI2_DPHY0_DL2_DBG"
bitfld.long 0 0.--2. " CSI0_HS_RX_OFFSET_DL2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CSI0_MIPI_IN_SHORT_DL2 "  "0 ,1 "
bitfld.long 0 4.--6. " CSI0_SKEW_DL2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " CSI0_OVERSAMPLE_BYPASS_DL2 "  "0 ,1 "
bitfld.long 0 8. " CSI0_LP_HS_BYPASS_DL2 "  "0 ,1 "
bitfld.long 0 9.--10. " CSI0_LP_RX_VIL_DL2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " CSI0_DIRECT_DYN_ACCESS_DL2 "  "0 ,1 "
;tree.end

base ad:0xA025481C
;tree "IPPCSI2_DPHY0_DL3_DBG"
group 0--3
line.long 0 "CSI2_DPHY0_DL3_DBG"
bitfld.long 0 0.--2. " CSI0_HS_RX_OFFSET_DL3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CSI0_MIPI_IN_SHORT_DL3 "  "0 ,1 "
bitfld.long 0 4.--6. " CSI0_SKEW_DL3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " CSI0_OVERSAMPLE_BYPASS_DL3 "  "0 ,1 "
bitfld.long 0 8. " CSI0_LP_HS_BYPASS_DL3 "  "0 ,1 "
bitfld.long 0 9.--10. " CSI0_LP_RX_VIL_DL3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " CSI0_DIRECT_DYN_ACCESS_DL3 "  "0 ,1 "
;tree.end

base ad:0xA025481E
;tree "IPPCSI2_DPHY0_XL_DBG0_OBS"
rgroup 0--3
line.long 0 "CSI2_DPHY0_XL_DBG0_OBS"
bitfld.long 0 0. " CSI0_OVERSAMPLE_FLAG1_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI0_OVERSAMPLE_FLAG1_DL2 "  "0 ,1 "
bitfld.long 0 2. " CSI0_OVERSAMPLE_FLAG1_DL3 "  "0 ,1 "
bitfld.long 0 3. " CSI0_OVERSAMPLE_FLAG2_DL1 "  "0 ,1 "
bitfld.long 0 4. " CSI0_OVERSAMPLE_FLAG2_DL2 "  "0 ,1 "
bitfld.long 0 5. " CSI0_OVERSAMPLE_FLAG2_DL3 "  "0 ,1 "
bitfld.long 0 6. " CSI0_HS_RX_ZM_CL "  "0 ,1 "
bitfld.long 0 7. " CSI0_HS_RX_ZM_DL1 "  "0 ,1 "
bitfld.long 0 8. " CSI0_HS_RX_ZM_DL2 "  "0 ,1 "
bitfld.long 0 9. " CSI0_HS_RX_ZM_DL3 "  "0 ,1 "
bitfld.long 0 10. " CSI0_RX_INIT_CLK "  "0 ,1 "
;tree.end

base ad:0xA0254820
;tree "IPPCSI2_DPHY0_XL_DBG1_OBS"
rgroup 0--3
line.long 0 "CSI2_DPHY0_XL_DBG1_OBS"
bitfld.long 0 0. " CSI0_STOP_STATE_CL "  "0 ,1 "
bitfld.long 0 1. " CSI0_STOP_STATE_DL1 "  "0 ,1 "
bitfld.long 0 2. " CSI0_STOP_STATE_DL2 "  "0 ,1 "
bitfld.long 0 3. " CSI0_STOP_STATE_DL3 "  "0 ,1 "
bitfld.long 0 4. " CSI0_ULP_ACTIVE_NOT_CL "  "0 ,1 "
bitfld.long 0 5. " CSI0_ULP_ACTIVE_NOT_DL1 "  "0 ,1 "
bitfld.long 0 6. " CSI0_ULP_ACTIVE_NOT_DL2 "  "0 ,1 "
bitfld.long 0 7. " CSI0_ULP_ACTIVE_NOT_DL3 "  "0 ,1 "
;tree.end

base ad:0xA0254822
;tree "IPPCSI2_DPHY1_CL_CTRL"
group 0--3
line.long 0 "CSI2_DPHY1_CL_CTRL"
bitfld.long 0 0.--5. " CSI0_UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8. " CSI0_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 9. " CSI0_SWAP_PINS_CL "  "0 ,1 "
bitfld.long 0 10. " CSI0_HS_INVERT_CL "  "0 ,1 "
bitfld.long 0 11. " CSI0_HSRX_TERM_SHIFT_UP_CL "  "0 ,1 "
bitfld.long 0 12. " CSI0_HSRX_TERM_SHIFT_DOWN_CL "  "0 ,1 "
bitfld.long 0 13. " CSI0_TEST_RESERVED_1_CL "  "0 ,1 "
;tree.end

base ad:0xA0254824
;tree "IPPCSI2_DPHY1_DL1_CTRL"
group 0--3
line.long 0 "CSI2_DPHY1_DL1_CTRL"
bitfld.long 0 0. " CSI0_SWAP_PINS_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI0_HS_INVERT_DL1 "  "0 ,1 "
bitfld.long 0 2. " CSI0_FORCE_RX_MODE_DL1 "  "0 ,1 "
bitfld.long 0 3. " CSI0_CD_OFF_DL1 "  "0 ,1 "
bitfld.long 0 4. " CSI0_EOT_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 5. " CSI0_HSRX_TERM_SHIFT_UP_DL1 "  "0 ,1 "
bitfld.long 0 6. " CSI0_HSRX_TERM_SHIFT_DOWN_DL1 "  "0 ,1 "
bitfld.long 0 7. " CSI0_TEST_RESERVED_1_DL1 "  "0 ,1 "
;tree.end

base ad:0xA0254826
;tree "IPPCSI2_DPHY1_CL_DBG"
group 0--3
line.long 0 "CSI2_DPHY1_CL_DBG"
bitfld.long 0 0.--2. " CSI0_HS_RX_OFFSET_CL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CSI0_MIPI_IN_SHORT_CL "  "0 ,1 "
bitfld.long 0 8. " CSI0_LP_HS_BYPASS_CL "  "0 ,1 "
bitfld.long 0 9.--10. " CSI0_LP_RX_VIL_CL "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " CSI0_DIRECT_DYN_ACCESS_CL "  "0 ,1 "
;tree.end

base ad:0xA0254828
;tree "IPPCSI2_DPHY1_DL1_DBG"
group 0--3
line.long 0 "CSI2_DPHY1_DL1_DBG"
bitfld.long 0 0.--2. " CSI0_HS_RX_OFFSET_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CSI0_MIPI_IN_SHORT_DL1 "  "0 ,1 "
bitfld.long 0 4.--6. " CSI0_SKEW_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " CSI0_OVERSAMPLE_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 8. " CSI0_LP_HS_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 9.--10. " CSI0_LP_RX_VIL_DL1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " CSI0_DIRECT_DYN_ACCESS_DL1 "  "0 ,1 "
;tree.end

base ad:0xA025482A
;tree "IPPCSI2_DPHY1_XL_DBG_OBS"
rgroup 0--3
line.long 0 "CSI2_DPHY1_XL_DBG_OBS"
bitfld.long 0 0. " CSI1_OVERSAMPLE_FLAG1_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI1_OVERSAMPLE_FLAG2_DL1 "  "0 ,1 "
bitfld.long 0 2. " CSI1_HS_RX_ZM_CL "  "0 ,1 "
bitfld.long 0 3. " CSI1_HS_RX_ZM_DL1 "  "0 ,1 "
bitfld.long 0 4. " CSI1_RX_INIT_CLK "  "0 ,1 "
bitfld.long 0 8. " CSI1_STOP_STATE_CL "  "0 ,1 "
bitfld.long 0 9. " CSI1_STOP_STATE_DL1 "  "0 ,1 "
bitfld.long 0 10. " CSI1_ULP_ACTIVE_NOT_CL "  "0 ,1 "
bitfld.long 0 11. " CSI1_ULP_ACTIVE_NOT_DL1 "  "0 ,1 "
;tree.end

base ad:0xA025482C
;tree "IPPCSI2_DPHY0_DBG_ITS"
rgroup 0--3
line.long 0 "CSI2_DPHY0_DBG_ITS"
bitfld.long 0 0. " CSI0_ERR_ESC_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI0_ERR_ESC_DL2 "  "0 ,1 "
bitfld.long 0 2. " CSI0_ERR_ESC_DL3 "  "0 ,1 "
bitfld.long 0 3. " CSI0_ERR_SYNC_ESC_DL1 "  "0 ,1 "
bitfld.long 0 4. " CSI0_ERR_SYNC_ESC_DL2 "  "0 ,1 "
bitfld.long 0 5. " CSI0_ERR_SYNC_ESC_DL3 "  "0 ,1 "
;tree.end

base ad:0xA025482E
;tree "IPPCSI2_DPHY0_DBG_ITS_BCLR"
wgroup 0--3
line.long 0 "CSI2_DPHY0_DBG_ITS_BCLR"
bitfld.long 0 0.--5. " CSI0_DBG_ITS_BCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254830
;tree "IPPCSI2_DPHY0_DBG_ITS_BSET"
wgroup 0--3
line.long 0 "CSI2_DPHY0_DBG_ITS_BSET"
bitfld.long 0 0.--5. " CSI0_DBG_ITS_BSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254832
;tree "IPPCSI2_DPHY0_DBG_ITM"
rgroup 0--3
line.long 0 "CSI2_DPHY0_DBG_ITM"
bitfld.long 0 0.--5. " CSI0_DBG_ITM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254834
;tree "IPPCSI2_DPHY0_DBG_ITM_BCLR"
wgroup 0--3
line.long 0 "CSI2_DPHY0_DBG_ITM_BCLR"
bitfld.long 0 0.--5. " CSI0_DBG_ITM_BCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254836
;tree "IPPCSI2_DPHY0_DBG_ITM_BSET"
wgroup 0--3
line.long 0 "CSI2_DPHY0_DBG_ITM_BSET"
bitfld.long 0 0.--5. " CSI0_DBG_ITM_BSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254838
;tree "IPPCSI2_DPHY1_DBG_ITS"
rgroup 0--3
line.long 0 "CSI2_DPHY1_DBG_ITS"
bitfld.long 0 0. " CSI1_ERR_ESC_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI1_ERR_SYNC_ESC_DL1 "  "0 ,1 "
;tree.end

base ad:0xA025483A
;tree "IPPCSI2_DPHY1_DBG_ITS_BCLR"
wgroup 0--3
line.long 0 "CSI2_DPHY1_DBG_ITS_BCLR"
bitfld.long 0 0.--1. " CSI1_DBG_ITS_BCLR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA025483C
;tree "IPPCSI2_DPHY1_DBG_ITS_BSET"
wgroup 0--3
line.long 0 "CSI2_DPHY1_DBG_ITS_BSET"
bitfld.long 0 0.--1. " CSI1_DBG_ITS_BSET "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA025483E
;tree "IPPCSI2_DPHY1_DBG_ITM"
rgroup 0--3
line.long 0 "CSI2_DPHY1_DBG_ITM"
bitfld.long 0 0.--1. " CSI1_DBG_ITM "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254840
;tree "IPPCSI2_DPHY1_DBG_ITM_BCLR"
wgroup 0--3
line.long 0 "CSI2_DPHY1_DBG_ITM_BCLR"
bitfld.long 0 0.--1. " CSI1_DBG_ITM_BCLR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254842
;tree "IPPCSI2_DPHY1_DBG_ITM_BSET"
wgroup 0--3
line.long 0 "CSI2_DPHY1_DBG_ITM_BSET"
bitfld.long 0 0.--1. " CSI1_DBG_ITM_BSET "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254844
;tree "IPPCSI2_PACKET_DBG_ITS"
rgroup 0--3
line.long 0 "CSI2_PACKET_DBG_ITS"
bitfld.long 0 0. " CSI2_PACKET_ECC_CORRECTED_DBG "  "0 ,1 "
;tree.end

base ad:0xA0254846
;tree "IPPCSI2_PACKET_DBG_ITS_BCLR"
wgroup 0--3
line.long 0 "CSI2_PACKET_DBG_ITS_BCLR"
bitfld.long 0 0. " CSI2_PACKET_DBG_ITS_BCLR "  "0 ,1 "
;tree.end

base ad:0xA0254848
;tree "IPPCSI2_PACKET_DBG_ITS_BSET"
wgroup 0--3
line.long 0 "CSI2_PACKET_DBG_ITS_BSET"
bitfld.long 0 0. " CSI2_PACKET_DBG_ITS_BSET "  "0 ,1 "
;tree.end

base ad:0xA025484A
;tree "IPPCSI2_PACKET_DBG_ITM"
rgroup 0--3
line.long 0 "CSI2_PACKET_DBG_ITM"
bitfld.long 0 0. " CSI2_PACKET_ECC_CORRECTED_DBG "  "0 ,1 "
;tree.end

base ad:0xA025484C
;tree "IPPCSI2_PACKET_DBG_ITM_BCLR"
wgroup 0--3
line.long 0 "CSI2_PACKET_DBG_ITM_BCLR"
bitfld.long 0 0. " CSI2_PACKET_DBG_ITM_BCLR "  "0 ,1 "
;tree.end

base ad:0xA025484E
;tree "IPPCSI2_PACKET_DBG_ITM_BSET"
wgroup 0--3
line.long 0 "CSI2_PACKET_DBG_ITM_BSET"
bitfld.long 0 0. " CSI2_PACKET_DBG_ITM_BSET "  "0 ,1 "
;tree.end

base ad:0xA0254850
;tree "IPPCSI2RX_VC_DATA_TYPE_R"
rgroup 0--3
line.long 0 "CSI2RX_VC_DATA_TYPE_R"
bitfld.long 0 0.--5. " CSI2RX_VC_DATA_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--7. " CSI2RX_VIRTUAL_CHANNEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254852
;tree "IPPSTATIC_CSI2RX_VC_DATA_TYPE_W"
group 0--3
line.long 0 "STATIC_CSI2RX_VC_DATA_TYPE_W"
bitfld.long 0 0.--5. " CSI2RX_IMAGE_DATA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8.--13. " CSI2RX_NON_IMAGE_DATA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254854
;tree "IPPSTATIC_CSI2RX_VC_W"
wgroup 0--3
line.long 0 "STATIC_CSI2RX_VC_W"
bitfld.long 0 0.--1. " STATIC_CSI2RX_VC "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254856
;tree "IPPCSI2RX_FRAME_NB_R"
rgroup 0--3
line.long 0 "CSI2RX_FRAME_NB_R"
hexfld.word 0 " CSI2RX_FRAME_NB "
;tree.end

base ad:0xA0254858
;tree "IPPCSI2RX_DATA_FIELD_R"
rgroup 0--3
line.long 0 "CSI2RX_DATA_FIELD_R"
hexfld.word 0 " CSI2RX_DATA_FIELD "
;tree.end

base ad:0xA025485A
;tree "IPPSTATIC_CSI2RX_PIX_WIDTH_W"
group 0--3
line.long 0 "STATIC_CSI2RX_PIX_WIDTH_W"
bitfld.long 0 0.--3. " STATIC_CSI2RX_ACTDATA_PIXWIDTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " STATIC_CSI2RX_EMBDATA_PIXWIDTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA025485C
;tree "IPPCSI2_DPHY_ERROR_ITS"
rgroup 0--3
line.long 0 "CSI2_DPHY_ERROR_ITS"
bitfld.long 0 0. " CSI0_ERR_EOT_SYNC_HS_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI0_ERR_EOT_SYNC_HS_DL2 "  "0 ,1 "
bitfld.long 0 2. " CSI0_ERR_EOT_SYNC_HS_DL3 "  "0 ,1 "
bitfld.long 0 3. " CSI0_ERR_SOT_HS_DL1 "  "0 ,1 "
bitfld.long 0 4. " CSI0_ERR_SOT_HS_DL2 "  "0 ,1 "
bitfld.long 0 5. " CSI0_ERR_SOT_HS_DL3 "  "0 ,1 "
bitfld.long 0 6. " CSI0_ERR_SOT_SYNC_HS_DL1 "  "0 ,1 "
bitfld.long 0 7. " CSI0_ERR_SOT_SYNC_HS_DL2 "  "0 ,1 "
bitfld.long 0 8. " CSI0_ERR_SOT_SYNC_HS_DL3 "  "0 ,1 "
bitfld.long 0 9. " CSI0_ERR_CONTROL_DL1 "  "0 ,1 "
bitfld.long 0 10. " CSI0_ERR_CONTROL_DL2 "  "0 ,1 "
bitfld.long 0 11. " CSI0_ERR_CONTROL_DL3 "  "0 ,1 "
bitfld.long 0 12. " CSI1_ERR_EOT_SYNC_HS_DL1 "  "0 ,1 "
bitfld.long 0 13. " CSI1_ERR_SOT_HS_DL1 "  "0 ,1 "
bitfld.long 0 14. " CSI1_ERR_SOT_SYNC_HS_DL1 "  "0 ,1 "
bitfld.long 0 15. " CSI1_ERR_CONTROL_DL1 "  "0 ,1 "
;tree.end

base ad:0xA025485E
;tree "IPPCSI2_DPHY_ERROR_ITS_BCLR"
wgroup 0--3
line.long 0 "CSI2_DPHY_ERROR_ITS_BCLR"
hexfld.word 0 " CSI_DPHY_ERROR_ITS_BCLR "
;tree.end

base ad:0xA0254860
;tree "IPPCSI2_DPHY_ERROR_ITS_BSET"
wgroup 0--3
line.long 0 "CSI2_DPHY_ERROR_ITS_BSET"
hexfld.word 0 " CSI_DPHY_ERROR_ITS_BSET "
;tree.end

base ad:0xA0254862
;tree "IPPCSI2_DPHY_ERROR_ITM"
rgroup 0--3
line.long 0 "CSI2_DPHY_ERROR_ITM"
hexfld.word 0 " CSI_DPHY_ERROR_ITM "
;tree.end

base ad:0xA0254864
;tree "IPPCSI2_DPHY_ERROR_ITM_BCLR"
wgroup 0--3
line.long 0 "CSI2_DPHY_ERROR_ITM_BCLR"
hexfld.word 0 " CSI_DPHY_ERROR_ITM_BCLR "
;tree.end

base ad:0xA0254866
;tree "IPPCSI2_DPHY_ERROR_ITM_BSET"
wgroup 0--3
line.long 0 "CSI2_DPHY_ERROR_ITM_BSET"
hexfld.word 0 " CSI_DPHY_ERROR_ITM_BSET "
;tree.end

base ad:0xA0254868
;tree "IPPCSI2_PACKET_ERROR_ITS"
rgroup 0--3
line.long 0 "CSI2_PACKET_ERROR_ITS"
bitfld.long 0 0. " CSI2_PACKET_PAYLOAD_CRC_ERROR "  "0 ,1 "
bitfld.long 0 1. " CSI2_PACKET_HEADER_ECC_ERROR "  "0 ,1 "
;tree.end

base ad:0xA025486A
;tree "IPPCSI2_PACKET_ERROR_ITS_BCLR"
wgroup 0--3
line.long 0 "CSI2_PACKET_ERROR_ITS_BCLR"
bitfld.long 0 0.--1. " CSI_PACKET_ERROR_ITS_BCLR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA025486C
;tree "IPPCSI2_PACKET_ERROR_ITS_BSET"
wgroup 0--3
line.long 0 "CSI2_PACKET_ERROR_ITS_BSET"
bitfld.long 0 0.--1. " CSI_PACKET_ERROR_ITS_BSET "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA025486E
;tree "IPPCSI2_PACKET_ERROR_ITM"
rgroup 0--3
line.long 0 "CSI2_PACKET_ERROR_ITM"
bitfld.long 0 0.--1. " CSI_PACKET_ERROR_ITM "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254870
;tree "IPPCSI2_PACKET_ERROR_ITM_BCLR"
wgroup 0--3
line.long 0 "CSI2_PACKET_ERROR_ITM_BCLR"
bitfld.long 0 0.--1. " CSI_PACKET_ERROR_ITM_BCLR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254872
;tree "IPPCSI2_PACKET_ERROR_ITM_BSET"
wgroup 0--3
line.long 0 "CSI2_PACKET_ERROR_ITM_BSET"
bitfld.long 0 0.--1. " CSI_PACKET_ERROR_ITM_BSET "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254874
;tree "IPPSTATIC_OPIPE03_SEL"
group 0--3
line.long 0 "STATIC_OPIPE03_SEL"
bitfld.long 0 0. " STATIC_OPIPE03_SEL "  "0 ,1 "
;tree.end

base ad:0xA0254880
;tree "IPPISP_ASYNC_RESET"
wgroup 0--3
line.long 0 "ISP_ASYNC_RESET"
hexfld.long 0 " ISP_ASYNC_RESET "
;tree.end

base ad:0xA0254882
;tree "IPPISP_SD_RESET"
wgroup 0--3
line.long 0 "ISP_SD_RESET"
hexfld.long 0 " ISP_SD_RESET "
;tree.end

base ad:0xA0254884
;tree "IPPSD_STATIC_CCP_EN"
group 0--3
line.long 0 "SD_STATIC_CCP_EN"
bitfld.long 0 0. " STATIC_SD_CCP_EN "  "0 ,1 "
;tree.end

base ad:0xA0254886
;tree "IPPSD_STATIC_SDG_CSI_MODE"
group 0--3
line.long 0 "SD_STATIC_SDG_CSI_MODE"
bitfld.long 0 0. " STATIC_SDG_CSI_MODE "  "0 ,1 "
;tree.end

base ad:0xA0254888
;tree "IPPSD_PRY0_ENABLE_SET"
wgroup 0--3
line.long 0 "SD_PRY0_ENABLE_SET"
hexfld.long 0 " SD_PRY0_ENABLE_SET "
;tree.end

base ad:0xA025488A
;tree "IPPSD_PRY1_ENABLE_SET"
wgroup 0--3
line.long 0 "SD_PRY1_ENABLE_SET"
hexfld.long 0 " SD_PRY1_ENABLE_SET "
;tree.end

base ad:0xA025488C
;tree "IPPSD_PRY1_ENABLE_CLR"
wgroup 0--3
line.long 0 "SD_PRY1_ENABLE_CLR"
hexfld.long 0 " SD_PRY1_ENABLE_CLR "
;tree.end

base ad:0xA025488E
;tree "IPPSD_PRY1_ENABLE_CLR"
wgroup 0--3
line.long 0 "SD_PRY1_ENABLE_CLR"
hexfld.long 0 " SD_PRY1_ENABLE_CLR "
;tree.end

base ad:0xA0254890
;tree "IPPSD_PRY0_ENABLE_STATUS"
rgroup 0--3
line.long 0 "SD_PRY0_ENABLE_STATUS"
bitfld.long 0 0. " PRY0_ENABLE_STATUS "  "0 ,1 "
;tree.end

base ad:0xA0254892
;tree "IPPSD_PRY1_ENABLE_STATUS"
rgroup 0--3
line.long 0 "SD_PRY1_ENABLE_STATUS"
bitfld.long 0 0. " PRY1_ENABLE_STATUS "  "0 ,1 "
;tree.end

base ad:0xA0254894
;tree "IPPSD_BMS_ENABLE_SET"
wgroup 0--3
line.long 0 "SD_BMS_ENABLE_SET"
hexfld.long 0 " SD_BMS_ENABLE_SET "
;tree.end

base ad:0xA0254896
;tree "IPPSD_BMS_ENABLE_CLR"
wgroup 0--3
line.long 0 "SD_BMS_ENABLE_CLR"
hexfld.long 0 " SD_BMS_ENABLE_CLR "
;tree.end

base ad:0xA0254898
;tree "IPPSD_BMS_ENABLE_STATUS"
rgroup 0--3
line.long 0 "SD_BMS_ENABLE_STATUS"
bitfld.long 0 0. " BMS_ENABLE_STATUS "  "0 ,1 "
;tree.end

base ad:0xA025489A
;tree "IPPSD_PRY0_FORMAT"
group 0--3
line.long 0 "SD_PRY0_FORMAT"
bitfld.long 0 8.--11. " PRY0_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA025489C
;tree "IPPSD_PRY1_FORMAT"
group 0--3
line.long 0 "SD_PRY1_FORMAT"
hexfld.byte 0 " PRY1_ALPHA "
bitfld.long 0 8.--11. " PRY1_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA025489E
;tree "IPPSD_BMS_FORMAT"
group 0--3
line.long 0 "SD_BMS_FORMAT"
bitfld.long 0 0. " BMS_RAW_FORMAT "  "0 ,1 "
bitfld.long 0 1. " BMS_RAW_SEL "  "0 ,1 "
;tree.end

base ad:0xA02548A0
;tree "IPPSD_STATIC_MEM_LOAD_EN"
group 0--3
line.long 0 "SD_STATIC_MEM_LOAD_EN"
bitfld.long 0 0. " STATIC_MEM_LOAD_EN "  "0 ,1 "
;tree.end

base ad:0xA02548A2
;tree "IPPSD_STATIC_LOAD_FORMAT"
group 0--3
line.long 0 "SD_STATIC_LOAD_FORMAT"
bitfld.long 0 0.--1. " STATIC_LOAD_FORMAT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " STATIC_LOAD_RAW_SEL "  "0 ,1 "
;tree.end

base ad:0xA02548A4
;tree "IPPSD_STATIC_LOAD_LINE_TIME_LSB_EN"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TIME_LSB_EN"
bitfld.long 0 0. " STATIC_LOAD_LINE_TIME_EN "  "0 ,1 "
bitfld.long 0 1.--15. " STATIC_LOAD_LINE_TIME_LSB "  " "
;tree.end

base ad:0xA02548A6
;tree "IPPSD_STATIC_LOAD_LINE_TIME_MSB"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TIME_MSB"
bitfld.long 0 0.--4. " STATIC_INTERLINE_TIME_MSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA02548A8
;tree "IPPSD_STATIC_LOAD_WW"
group 0--3
line.long 0 "SD_STATIC_LOAD_WW"
bitfld.long 0 0.--11. " STATIC_LOAD_WW "  " "
;tree.end

base ad:0xA02548AA
;tree "IPPSD_STATIC_LOAD_BML_PIXEL_ORDER"
group 0--3
line.long 0 "SD_STATIC_LOAD_BML_PIXEL_ORDER"
bitfld.long 0 0.--1. " STATIC_LOAD_BML_PIXEL_ORDER "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA02548AC
;tree "IPPSD_STATIC_LOAD_LINE_TYPE0"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE0"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT0 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548AE
;tree "IPPSD_STATIC_LOAD_LINE_TYPE1"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE1"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT1 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548B0
;tree "IPPSD_STATIC_LOAD_LINE_TYPE2"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE2"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT2 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548B2
;tree "IPPSD_STATIC_LOAD_LINE_TYPE3"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE3"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT3 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548B4
;tree "IPPSD_STATIC_LOAD_LINE_TYPE4"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE4"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT4 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548B6
;tree "IPPSD_STATIC_LOAD_LINE_TYPE5"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE5"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT5 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID5 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548B8
;tree "IPPSD_STATIC_LOAD_LINE_TYPE6"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE6"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT6 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID6 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548BA
;tree "IPPSD_STATIC_LOAD_LINE_TYPE7"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE7"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT7 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID7 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548BC
;tree "IPPSD_ERROR_ITS"
rgroup 0--3
line.long 0 "SD_ERROR_ITS"
bitfld.long 0 0. " CCP_SHIFT_SYNC "  "0 ,1 "
bitfld.long 0 1. " CCP_FALSE_SYNC "  "0 ,1 "
bitfld.long 0 2. " CCP_CRC_ERROR "  "0 ,1 "
bitfld.long 0 3. " OPIPE0_CH0_OVERFLOW "  "0 ,1 "
bitfld.long 0 4. " OPIPE0_CH1_OVERFLOW "  "0 ,1 "
bitfld.long 0 5. " OPIPE0_CH2_OVERFLOW "  "0 ,1 "
bitfld.long 0 6. " OPIPE1_OVERFLOW "  "0 ,1 "
bitfld.long 0 7. " OPIPE2_OVERFLOW "  "0 ,1 "
bitfld.long 0 8. " OPIPE0_MULT_ERR "  "0 ,1 "
bitfld.long 0 9. " OPIPE1_MULT_ERR "  "0 ,1 "
bitfld.long 0 10. " SD_CSI2_PACKET_ERROR "  "0 ,1 "
bitfld.long 0 11. " SD_CSI2_DPHY_ERROR "  "0 ,1 "
;tree.end

base ad:0xA02548BE
;tree "IPPSD_ERROR_ITS_BCLR"
wgroup 0--3
line.long 0 "SD_ERROR_ITS_BCLR"
bitfld.long 0 0.--11. " SD_ERROR_ITS_BCLR "  " "
;tree.end

base ad:0xA02548C0
;tree "IPPSD_ERROR_ITS_BSET"
wgroup 0--3
line.long 0 "SD_ERROR_ITS_BSET"
bitfld.long 0 0.--11. " SD_ERROR_ITS_BSET "  " "
;tree.end

base ad:0xA02548C2
;tree "IPPSD_ERROR_ITM"
rgroup 0--3
line.long 0 "SD_ERROR_ITM"
bitfld.long 0 0.--11. " SD_ERROR_ITM "  " "
;tree.end

base ad:0xA02548C4
;tree "IPPSD_ERROR_ITM_BCLR"
wgroup 0--3
line.long 0 "SD_ERROR_ITM_BCLR"
bitfld.long 0 0.--11. " SD_ERROR_ITM_BCLR "  " "
;tree.end

base ad:0xA02548C6
;tree "IPPSD_ERROR_ITM_BSET"
wgroup 0--3
line.long 0 "SD_ERROR_ITM_BSET"
bitfld.long 0 0.--11. " SD_ERROR_ITM_BSET "  " "
;tree.end

base ad:0xA02548C8
;tree "IPPSD_OPIPE0_MULT_ERR_DBG"
rgroup 0--3
line.long 0 "SD_OPIPE0_MULT_ERR_DBG"
bitfld.long 0 0. " SD_OPIPE0_CH0_MULT_ERR_DBG "  "0 ,1 "
bitfld.long 0 1. " SD_OPIPE0_CH1_MULT_ERR_DBG "  "0 ,1 "
bitfld.long 0 2. " SD_OPIPE0_CH2_MULT_ERR_DBG "  "0 ,1 "
;tree.end

base ad:0xA02548D0
;tree "IPPCD_RESET"
wgroup 0--3
line.long 0 "CD_RESET"
hexfld.long 0 " CD_RESET "
;tree.end

base ad:0xA02548D2
;tree "IPPCD_START"
wgroup 0--3
line.long 0 "CD_START"
hexfld.long 0 " CD_START "
;tree.end

base ad:0xA02548D4
;tree "IPPCD_STATIC_EN"
group 0--3
line.long 0 "CD_STATIC_EN"
bitfld.long 0 0. " STATIC_CD_EN "  "0 ,1 "
;tree.end

base ad:0xA02548D6
;tree "IPPCD_STATIC_CDG_CSI_PADD_EN"
group 0--3
line.long 0 "CD_STATIC_CDG_CSI_PADD_EN"
bitfld.long 0 0. " STATIC_CDG_CSI_PADD_EN "  "0 ,1 "
;tree.end

base ad:0xA02548D8
;tree "IPPCD_STATIC_CCP_FC"
group 0--3
line.long 0 "CD_STATIC_CCP_FC"
hexfld.byte 0 " STATIC_CCP_FS "
bitfld.long 0 7.--15. " STATIC_CCP_FE "  " "
;tree.end

base ad:0xA02548DA
;tree "IPPCD_STATIC_CCP_LC"
group 0--3
line.long 0 "CD_STATIC_CCP_LC"
hexfld.byte 0 " STATIC_CCP_LS "
bitfld.long 0 7.--15. " STATIC_CCP_LE "  " "
;tree.end

base ad:0xA02548DC
;tree "IPPCD_RAW"
group 0--3
line.long 0 "CD_RAW"
bitfld.long 0 0. " JPEG_PADD_EN "  "0 ,1 "
bitfld.long 0 1.--2. " CCP_RAW_SWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA02548DE
;tree "IPPCD_PIPE3_FORMAT"
group 0--3
line.long 0 "CD_PIPE3_FORMAT"
bitfld.long 0 0.--2. " PIPE3_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BT601_EN "  "0 ,1 "
;tree.end

base ad:0xA02548E0
;tree "IPPCD_CROP_EN"
group 0--3
line.long 0 "CD_CROP_EN"
bitfld.long 0 0. " CROP_EN "  "0 ,1 "
;tree.end

base ad:0xA02548E2
;tree "IPPCD_CROP_H0"
group 0--3
line.long 0 "CD_CROP_H0"
bitfld.long 0 1.--11. " CROP_H0 "  " "
;tree.end

base ad:0xA02548E4
;tree "IPPCD_CROP_V0"
group 0--3
line.long 0 "CD_CROP_V0"
bitfld.long 0 1.--11. " CROP_V0 "  " "
;tree.end

base ad:0xA02548E6
;tree "IPPCD_CROP_H1"
group 0--3
line.long 0 "CD_CROP_H1"
bitfld.long 0 1.--11. " CROP_H1 "  " "
;tree.end

base ad:0xA02548E8
;tree "IPPCD_CROP_V1"
group 0--3
line.long 0 "CD_CROP_V1"
bitfld.long 0 1.--11. " CROP_V1 "  " "
;tree.end

base ad:0xA02548EA
;tree "IPPCD_ERROR_ITS"
rgroup 0--3
line.long 0 "CD_ERROR_ITS"
bitfld.long 0 1. " CCP_ERROR "  "0 ,1 "
bitfld.long 0 2. " RAW_DATA_ERROR_NOT_X8_BYTES "  "0 ,1 "
bitfld.long 0 3. " RAW_DATA_ERROR_OVERFLOW "  "0 ,1 "
bitfld.long 0 4. " LUMA_ERROR_NOT_X8_LUMA_BYTES "  "0 ,1 "
bitfld.long 0 5. " LUMA_ERROR_OVERFLOW "  "0 ,1 "
bitfld.long 0 6. " CHROMA_ERROR_NOT_X16BYTES_3BUF "  "0 ,1 "
bitfld.long 0 7. " CHROMA_ERROR_NOT_X8BYTES_2BUF "  "0 ,1 "
bitfld.long 0 8. " CHROMA_ERROR_OVERFLOW "  "0 ,1 "
bitfld.long 0 9. " CD_CSI2_PACKET_ERROR "  "0 ,1 "
bitfld.long 0 10. " CD_CSI2_DPHY_ERROR "  "0 ,1 "
;tree.end

base ad:0xA02548EC
;tree "IPPCD_ERROR_ITS_BCLR"
wgroup 0--3
line.long 0 "CD_ERROR_ITS_BCLR"
bitfld.long 0 0.--10. " CD_ERROR_ITS_BCLR "  " "
;tree.end

base ad:0xA02548EE
;tree "IPPCD_ERROR_ITS_BSET"
wgroup 0--3
line.long 0 "CD_ERROR_ITS_BSET"
bitfld.long 0 0.--10. " CD_ERROR_ITS_BSET "  " "
;tree.end

base ad:0xA02548F0
;tree "IPPCD_ERROR_ITM"
rgroup 0--3
line.long 0 "CD_ERROR_ITM"
bitfld.long 0 0.--10. " CD_ERROR_ITM "  " "
;tree.end

base ad:0xA02548F2
;tree "IPPCD_ERROR_ITM_BCLR"
wgroup 0--3
line.long 0 "CD_ERROR_ITM_BCLR"
bitfld.long 0 0.--10. " CD_ERROR_ITM_BCLR "  " "
;tree.end

base ad:0xA02548F4
;tree "IPPCD_ERROR_ITM_BSET"
wgroup 0--3
line.long 0 "CD_ERROR_ITM_BSET"
bitfld.long 0 0.--10. " CD_ERROR_ITM_BSET "  " "
;tree.end

base ad:0xA02548F6
;tree "IPPCD_RAW_EOF_ITS"
rgroup 0--3
line.long 0 "CD_RAW_EOF_ITS"
bitfld.long 0 0. " CD_RAW_EOF_ITS "  "0 ,1 "
;tree.end

base ad:0xA02548F8
;tree "IPPCD_RAW_EOF_ITS_BCLR"
wgroup 0--3
line.long 0 "CD_RAW_EOF_ITS_BCLR"
bitfld.long 0 0. " CD_RAW_EOF_ITS_BCLR "  "0 ,1 "
;tree.end

base ad:0xA02548FA
;tree "IPPCD_RAW_EOF_ITS_BSET"
wgroup 0--3
line.long 0 "CD_RAW_EOF_ITS_BSET"
bitfld.long 0 0. " CD_RAW_EOF_ITS_BSET "  "0 ,1 "
;tree.end

base ad:0xA02548FC
;tree "IPPCD_RAW_EOF_ITM"
rgroup 0--3
line.long 0 "CD_RAW_EOF_ITM"
bitfld.long 0 0. " CD_RAW_EOF_ITM "  "0 ,1 "
;tree.end

base ad:0xA02548FE
;tree "IPPCD_RAW_EOF_ITM_BCLR"
wgroup 0--3
line.long 0 "CD_RAW_EOF_ITM_BCLR"
bitfld.long 0 0. " CD_RAW_EOF_ITM_BCLR "  "0 ,1 "
;tree.end

base ad:0xA0254900
;tree "IPPCD_RAW_EOF_ITM_BSET"
wgroup 0--3
line.long 0 "CD_RAW_EOF_ITM_BSET"
bitfld.long 0 0. " CD_RAW_EOF_ITM_BSET "  "0 ,1 "
;tree.end

base ad:0xA0254902
;tree "IPPCD_CCP_ERR_DBG_ITS"
rgroup 0--3
line.long 0 "CD_CCP_ERR_DBG_ITS"
bitfld.long 0 0.--2. " CD_CCP_ERR_DBG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254920
;tree "IPPISP_INTERNAL_ITS_L"
rgroup 0--3
line.long 0 "ISP_INTERNAL_ITS_L"
bitfld.long 0 0. " USER_IF "  "0 ,1 "
bitfld.long 0 2. " MASTER_CCI "  "0 ,1 "
bitfld.long 0 3. " LBE "  "0 ,1 "
bitfld.long 0 5. " ISP_RX "  "0 ,1 "
bitfld.long 0 6. " VIDEO_COMPLETE_PIPE0 "  "0 ,1 "
bitfld.long 0 7. " VIDEO_COMPLETE_PIPE1 "  "0 ,1 "
bitfld.long 0 8. " HISTOGRAM_256_BINS "  "0 ,1 "
bitfld.long 0 9. " EXPOSURE_6X8 "  "0 ,1 "
bitfld.long 0 10. " AF_STATS "  "0 ,1 "
bitfld.long 0 11. " WB_STATS "  "0 ,1 "
bitfld.long 0 12. " SKIN_TONE_STATS "  "0 ,1 "
bitfld.long 0 14. " ARCTIC "  "0 ,1 "
bitfld.long 0 15. " ACCWGZONE "  "0 ,1 "
;tree.end

base ad:0xA0254922
;tree "IPPISP_INTERNAL_ITS_BCLR_L"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITS_BCLR_L"
bitfld.long 0 0. " USER_IF "  "0 ,1 "
bitfld.long 0 2. " MASTER_CCI "  "0 ,1 "
bitfld.long 0 3. " LBE "  "0 ,1 "
bitfld.long 0 5. " ISP_RX "  "0 ,1 "
bitfld.long 0 6. " VIDEO_COMPLETE_PIPE0 "  "0 ,1 "
bitfld.long 0 7. " VIDEO_COMPLETE_PIPE1 "  "0 ,1 "
bitfld.long 0 8. " HISTOGRAM_256_BINS "  "0 ,1 "
bitfld.long 0 9. " EXPOSURE_6X8 "  "0 ,1 "
bitfld.long 0 10. " AF_STATS "  "0 ,1 "
bitfld.long 0 11. " WB_STATS "  "0 ,1 "
bitfld.long 0 12. " SKIN_TONE_STATS "  "0 ,1 "
bitfld.long 0 14. " ARCTIC "  "0 ,1 "
bitfld.long 0 15. " ACCWGZONE "  "0 ,1 "
;tree.end

base ad:0xA0254924
;tree "IPPISP_INTERNAL_ITS_BSET_L"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITS_BSET_L"
bitfld.long 0 0. " USER_IF "  "0 ,1 "
bitfld.long 0 2. " MASTER_CCI "  "0 ,1 "
bitfld.long 0 3. " LBE "  "0 ,1 "
bitfld.long 0 5. " ISP_RX "  "0 ,1 "
bitfld.long 0 6. " VIDEO_COMPLETE_PIPE0 "  "0 ,1 "
bitfld.long 0 7. " VIDEO_COMPLETE_PIPE1 "  "0 ,1 "
bitfld.long 0 8. " HISTOGRAM_256_BINS "  "0 ,1 "
bitfld.long 0 9. " EXPOSURE_6X8 "  "0 ,1 "
bitfld.long 0 10. " AF_STATS "  "0 ,1 "
bitfld.long 0 11. " WB_STATS "  "0 ,1 "
bitfld.long 0 12. " SKIN_TONE_STATS "  "0 ,1 "
bitfld.long 0 14. " ARCTIC "  "0 ,1 "
bitfld.long 0 15. " ACCWGZONE "  "0 ,1 "
;tree.end

base ad:0xA0254926
;tree "IPPISP_INTERNAL_ITM_L"
rgroup 0--3
line.long 0 "ISP_INTERNAL_ITM_L"
bitfld.long 0 0. " USER_IF "  "0 ,1 "
bitfld.long 0 2. " MASTER_CCI "  "0 ,1 "
bitfld.long 0 3. " LBE "  "0 ,1 "
bitfld.long 0 5. " ISP_RX "  "0 ,1 "
bitfld.long 0 6. " VIDEO_COMPLETE_PIPE0 "  "0 ,1 "
bitfld.long 0 7. " VIDEO_COMPLETE_PIPE1 "  "0 ,1 "
bitfld.long 0 8. " HISTOGRAM_256_BINS "  "0 ,1 "
bitfld.long 0 9. " EXPOSURE_6X8 "  "0 ,1 "
bitfld.long 0 10. " AF_STATS "  "0 ,1 "
bitfld.long 0 11. " WB_STATS "  "0 ,1 "
bitfld.long 0 12. " SKIN_TONE_STATS "  "0 ,1 "
bitfld.long 0 14. " ARCTIC "  "0 ,1 "
bitfld.long 0 15. " ACCWGZONE "  "0 ,1 "
;tree.end

base ad:0xA0254928
;tree "IPPISP_INTERNAL_ITM_BCLR_L"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITM_BCLR_L"
bitfld.long 0 0. " USER_IF "  "0 ,1 "
bitfld.long 0 2. " MASTER_CCI "  "0 ,1 "
bitfld.long 0 3. " LBE "  "0 ,1 "
bitfld.long 0 5. " ISP_RX "  "0 ,1 "
bitfld.long 0 6. " VIDEO_COMPLETE_PIPE0 "  "0 ,1 "
bitfld.long 0 7. " VIDEO_COMPLETE_PIPE1 "  "0 ,1 "
bitfld.long 0 8. " HISTOGRAM_256_BINS "  "0 ,1 "
bitfld.long 0 9. " EXPOSURE_6X8 "  "0 ,1 "
bitfld.long 0 10. " AF_STATS "  "0 ,1 "
bitfld.long 0 11. " WB_STATS "  "0 ,1 "
bitfld.long 0 12. " SKIN_TONE_STATS "  "0 ,1 "
bitfld.long 0 14. " ARCTIC "  "0 ,1 "
bitfld.long 0 15. " ACCWGZONE "  "0 ,1 "
;tree.end

base ad:0xA025492A
;tree "IPPISP_INTERNAL_ITM_BSET_L"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITM_BSET_L"
bitfld.long 0 0. " USER_IF "  "0 ,1 "
bitfld.long 0 2. " MASTER_CCI "  "0 ,1 "
bitfld.long 0 3. " LBE "  "0 ,1 "
bitfld.long 0 5. " ISP_RX "  "0 ,1 "
bitfld.long 0 6. " VIDEO_COMPLETE_PIPE0 "  "0 ,1 "
bitfld.long 0 7. " VIDEO_COMPLETE_PIPE1 "  "0 ,1 "
bitfld.long 0 8. " HISTOGRAM_256_BINS "  "0 ,1 "
bitfld.long 0 9. " EXPOSURE_6X8 "  "0 ,1 "
bitfld.long 0 10. " AF_STATS "  "0 ,1 "
bitfld.long 0 11. " WB_STATS "  "0 ,1 "
bitfld.long 0 12. " SKIN_TONE_STATS "  "0 ,1 "
bitfld.long 0 14. " ARCTIC "  "0 ,1 "
bitfld.long 0 15. " ACCWGZONE "  "0 ,1 "
;tree.end

base ad:0xA0254930
;tree "IPPISP_INTERNAL_ITS_H"
rgroup 0--3
line.long 0 "ISP_INTERNAL_ITS_H"
bitfld.long 0 0. " GLACE "  "0 ,1 "
;tree.end

base ad:0xA0254932
;tree "IPPISP_INTERNAL_ITS_BCLR_H"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITS_BCLR_H"
bitfld.long 0 0. " GLACE "  "0 ,1 "
;tree.end

base ad:0xA0254934
;tree "IPPISP_INTERNAL_ITS_BSET_H"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITS_BSET_H"
bitfld.long 0 0. " GLACE "  "0 ,1 "
;tree.end

base ad:0xA0254936
;tree "IPPISP_INTERNAL_ITM_H"
rgroup 0--3
line.long 0 "ISP_INTERNAL_ITM_H"
bitfld.long 0 0. " GLACE "  "0 ,1 "
;tree.end

base ad:0xA0254938
;tree "IPPISP_INTERNAL_ITM_BCLR_H"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITM_BCLR_H"
bitfld.long 0 0. " GLACE "  "0 ,1 "
;tree.end

base ad:0xA025493A
;tree "IPPISP_INTERNAL_ITM_BSET_H"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITM_BSET_H"
bitfld.long 0 0. " GLACE "  "0 ,1 "
;tree.end

base ad:0xA0254940
;tree "IPPSIA_ITEXT_ITS"
rgroup 0--3
line.long 0 "SIA_ITEXT_ITS"
bitfld.long 0 0. " ITEXT0 "  "0 ,1 "
bitfld.long 0 1. " ITEXT1 "  "0 ,1 "
bitfld.long 0 2. " ITEXT2 "  "0 ,1 "
bitfld.long 0 3. " ITEXT3 "  "0 ,1 "
bitfld.long 0 4. " ITEXT4 "  "0 ,1 "
bitfld.long 0 5. " ITEXT5 "  "0 ,1 "
bitfld.long 0 6. " ITEXT6 "  "0 ,1 "
bitfld.long 0 7. " ITEXT7 "  "0 ,1 "
bitfld.long 0 8. " ITEXT8 "  "0 ,1 "
bitfld.long 0 9. " ITEXT9 "  "0 ,1 "
bitfld.long 0 10. " ITEXT10 "  "0 ,1 "
bitfld.long 0 11. " ITEXT11 "  "0 ,1 "
bitfld.long 0 12. " ITEXT12 "  "0 ,1 "
;tree.end

base ad:0xA0254942
;tree "IPPSIA_ITEXT_ITS_BCLR"
wgroup 0--3
line.long 0 "SIA_ITEXT_ITS_BCLR"
bitfld.long 0 0. " ITEXT0 "  "0 ,1 "
bitfld.long 0 1. " ITEXT1 "  "0 ,1 "
bitfld.long 0 2. " ITEXT2 "  "0 ,1 "
bitfld.long 0 3. " ITEXT3 "  "0 ,1 "
bitfld.long 0 4. " ITEXT4 "  "0 ,1 "
bitfld.long 0 5. " ITEXT5 "  "0 ,1 "
bitfld.long 0 6. " ITEXT6 "  "0 ,1 "
bitfld.long 0 7. " ITEXT7 "  "0 ,1 "
bitfld.long 0 8. " ITEXT8 "  "0 ,1 "
bitfld.long 0 9. " ITEXT9 "  "0 ,1 "
bitfld.long 0 10. " ITEXT10 "  "0 ,1 "
bitfld.long 0 11. " ITEXT11 "  "0 ,1 "
bitfld.long 0 12. " ITEXT12 "  "0 ,1 "
;tree.end

base ad:0xA0254944
;tree "IPPSIA_ITEXT_ITS_BSET"
wgroup 0--3
line.long 0 "SIA_ITEXT_ITS_BSET"
bitfld.long 0 0. " ITEXT0 "  "0 ,1 "
bitfld.long 0 1. " ITEXT1 "  "0 ,1 "
bitfld.long 0 2. " ITEXT2 "  "0 ,1 "
bitfld.long 0 3. " ITEXT3 "  "0 ,1 "
bitfld.long 0 4. " ITEXT4 "  "0 ,1 "
bitfld.long 0 5. " ITEXT5 "  "0 ,1 "
bitfld.long 0 6. " ITEXT6 "  "0 ,1 "
bitfld.long 0 7. " ITEXT7 "  "0 ,1 "
bitfld.long 0 8. " ITEXT8 "  "0 ,1 "
bitfld.long 0 9. " ITEXT9 "  "0 ,1 "
bitfld.long 0 10. " ITEXT10 "  "0 ,1 "
bitfld.long 0 11. " ITEXT11 "  "0 ,1 "
bitfld.long 0 12. " ITEXT12 "  "0 ,1 "
;tree.end

base ad:0xA0254946
;tree "IPPSIA_ITEXT_ITM"
rgroup 0--3
line.long 0 "SIA_ITEXT_ITM"
bitfld.long 0 0. " ITEXT0 "  "0 ,1 "
bitfld.long 0 1. " ITEXT1 "  "0 ,1 "
bitfld.long 0 2. " ITEXT2 "  "0 ,1 "
bitfld.long 0 3. " ITEXT3 "  "0 ,1 "
bitfld.long 0 4. " ITEXT4 "  "0 ,1 "
bitfld.long 0 5. " ITEXT5 "  "0 ,1 "
bitfld.long 0 6. " ITEXT6 "  "0 ,1 "
bitfld.long 0 7. " ITEXT7 "  "0 ,1 "
bitfld.long 0 8. " ITEXT8 "  "0 ,1 "
bitfld.long 0 9. " ITEXT9 "  "0 ,1 "
bitfld.long 0 10. " ITEXT10 "  "0 ,1 "
bitfld.long 0 11. " ITEXT11 "  "0 ,1 "
bitfld.long 0 12. " ITEXT12 "  "0 ,1 "
;tree.end

base ad:0xA0254948
;tree "IPPSIA_ITEXT_ITM_BCLR"
wgroup 0--3
line.long 0 "SIA_ITEXT_ITM_BCLR"
bitfld.long 0 0. " ITEXT0 "  "0 ,1 "
bitfld.long 0 1. " ITEXT1 "  "0 ,1 "
bitfld.long 0 2. " ITEXT2 "  "0 ,1 "
bitfld.long 0 3. " ITEXT3 "  "0 ,1 "
bitfld.long 0 4. " ITEXT4 "  "0 ,1 "
bitfld.long 0 5. " ITEXT5 "  "0 ,1 "
bitfld.long 0 6. " ITEXT6 "  "0 ,1 "
bitfld.long 0 7. " ITEXT7 "  "0 ,1 "
bitfld.long 0 8. " ITEXT8 "  "0 ,1 "
bitfld.long 0 9. " ITEXT9 "  "0 ,1 "
bitfld.long 0 10. " ITEXT10 "  "0 ,1 "
bitfld.long 0 11. " ITEXT11 "  "0 ,1 "
bitfld.long 0 12. " ITEXT12 "  "0 ,1 "
;tree.end

base ad:0xA025494A
;tree "IPPSIA_ITEXT_ITM_BSET"
wgroup 0--3
line.long 0 "SIA_ITEXT_ITM_BSET"
bitfld.long 0 0. " ITEXT0 "  "0 ,1 "
bitfld.long 0 1. " ITEXT1 "  "0 ,1 "
bitfld.long 0 2. " ITEXT2 "  "0 ,1 "
bitfld.long 0 3. " ITEXT3 "  "0 ,1 "
bitfld.long 0 4. " ITEXT4 "  "0 ,1 "
bitfld.long 0 5. " ITEXT5 "  "0 ,1 "
bitfld.long 0 6. " ITEXT6 "  "0 ,1 "
bitfld.long 0 7. " ITEXT7 "  "0 ,1 "
bitfld.long 0 8. " ITEXT8 "  "0 ,1 "
bitfld.long 0 9. " ITEXT9 "  "0 ,1 "
bitfld.long 0 10. " ITEXT10 "  "0 ,1 "
bitfld.long 0 11. " ITEXT11 "  "0 ,1 "
bitfld.long 0 12. " ITEXT12 "  "0 ,1 "
;tree.end

base ad:0xA0254950
;tree "IPPEVT_ITS"
rgroup 0--3
line.long 0 "EVT_ITS"
bitfld.long 0 0. " SD_ERROR "  "0 ,1 "
bitfld.long 0 1. " CD_ERROR "  "0 ,1 "
bitfld.long 0 2. " CD_RAW_EOF "  "0 ,1 "
;tree.end

base ad:0xA0254952
;tree "IPPEVT_ITS_BCLR"
wgroup 0--3
line.long 0 "EVT_ITS_BCLR"
bitfld.long 0 0. " SD_ERROR "  "0 ,1 "
bitfld.long 0 1. " CD_ERROR "  "0 ,1 "
bitfld.long 0 2. " CD_RAW_EOF "  "0 ,1 "
;tree.end

base ad:0xA0254954
;tree "IPPEVT_ITS_BSET"
wgroup 0--3
line.long 0 "EVT_ITS_BSET"
bitfld.long 0 0. " SD_ERROR "  "0 ,1 "
bitfld.long 0 1. " CD_ERROR "  "0 ,1 "
bitfld.long 0 2. " CD_RAW_EOF "  "0 ,1 "
;tree.end

base ad:0xA0254956
;tree "IPPEVT_ITM"
rgroup 0--3
line.long 0 "EVT_ITM"
bitfld.long 0 0. " SD_ERROR "  "0 ,1 "
bitfld.long 0 1. " CD_ERROR "  "0 ,1 "
bitfld.long 0 2. " CD_RAW_EOF "  "0 ,1 "
;tree.end

base ad:0xA0254958
;tree "IPPEVT_ITM_BCLR"
wgroup 0--3
line.long 0 "EVT_ITM_BCLR"
bitfld.long 0 0. " SD_ERROR "  "0 ,1 "
bitfld.long 0 1. " CD_ERROR "  "0 ,1 "
bitfld.long 0 2. " CD_RAW_EOF "  "0 ,1 "
;tree.end

base ad:0xA025495A
;tree "IPPEVT_ITM_BSET"
wgroup 0--3
line.long 0 "EVT_ITM_BSET"
bitfld.long 0 0. " SD_ERROR "  "0 ,1 "
bitfld.long 0 1. " CD_ERROR "  "0 ,1 "
bitfld.long 0 2. " CD_RAW_EOF "  "0 ,1 "
;tree.end

endif

endif

tree.end

base ad:0xA0254A00
;********************************************
tree "SIA-CRM"
;********************************************
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x801571ec)&0x3E00)!=0x3E00)||((data.long(ad:0x8015725c)&0x1F)!=0x1F))

base ad:0x8015700c
;tree "prcm_siammdspclk_mgt_reg"
group 0--3
line.long 0 "prcm_siammdspclk_mgt_reg"
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SIA_phy_en "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 9. " SIA_MMDSP_Imgcore_resetn "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 11. " SIA_MMDSP_Imgcore_init_n "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x8015725c
;tree "prcm_power_state_val"
group 0--3
line.long 0 "prcm_power_state_val"
bitfld.long 0 3. " SIA_pipe "  "0 ,1 "
bitfld.long 0 4. " SIA_MMDSP "  "0 ,1 "
;tree.end

else

base ad:0xA0258404
sgroup "SIA_REG_CKEN"
constx 0 %l 0xFFFF
setx 0 %l 0
line.long 0 "SIA_REG_CKEN"
base ad:0xA0258404
;tree "SIA_REG_CKEN"
group 0--3
line.long 0 "SIA_REG_CKEN"
;tree.end

if ((data.long(ad:0xA0258404)&0x01FB)==0x01FB)

base ad:0xA0254A00
;tree "CRMEN_CLK_SD_HISPEED"
group 0--3
line.long 0 "EN_CLK_SD_HISPEED"
bitfld.long 0 0. " EN_CLK_SD_HISPEED "  "0 ,1 "
;tree.end

base ad:0xA0254A04
;tree "CRMEN_CLK_SD_LOSPEED"
group 0--3
line.long 0 "EN_CLK_SD_LOSPEED"
bitfld.long 0 0. " EN_CLK_SD_LOSPEED "  "0 ,1 "
;tree.end

base ad:0xA0254A08
;tree "CRMEN_CLK_PIPE"
group 0--3
line.long 0 "EN_CLK_PIPE"
bitfld.long 0 0. " EN_CLK_PIPE "  "0 ,1 "
;tree.end

base ad:0xA0254A0C
;tree "CRMEN_CLK_BML"
group 0--3
line.long 0 "EN_CLK_BML"
bitfld.long 0 0. " EN_CLK_BML "  "0 ,1 "
;tree.end

base ad:0xA0254A10
;tree "CRMEN_CLK_BMS"
group 0--3
line.long 0 "EN_CLK_BMS"
bitfld.long 0 0. " EN_CLK_BMS "  "0 ,1 "
;tree.end

base ad:0xA0254A14
;tree "CRMEN_CLK_PIPE_IN"
group 0--3
line.long 0 "EN_CLK_PIPE_IN"
bitfld.long 0 0. " EN_CLK_PIPE_IN "  "0 ,1 "
;tree.end

base ad:0xA0254A18
;tree "CRMEN_CLK_PICTOR_GPIO"
group 0--3
line.long 0 "EN_CLK_PICTOR_GPIO"
bitfld.long 0 0. " EN_CLK_PICTOR_GPIO "  "0 ,1 "
;tree.end

base ad:0xA0254A1C
;tree "CRMEN_CLK_PIPE_IN_DIV"
group 0--3
line.long 0 "EN_CLK_PIPE_IN_DIV"
bitfld.long 0 0.--4. " EN_CLK_PIPE_IN_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0254A20
;tree "CRMEN_CLK_HOST_IPP_DIV"
group 0--3
line.long 0 "EN_CLK_HOST_IPP_DIV"
bitfld.long 0 0.--4. " EN_CLK_HOST_IPP_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0254A24
;tree "CRMEN_CLK_PICTOR_GPIO_DIV"
group 0--3
line.long 0 "EN_CLK_PICTOR_GPIO_DIV"
bitfld.long 0 0.--4. " EN_CLK_PICTOR_GPIO_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0254A28
;tree "CRMEN_CLK_STATIC_SD_CCP_PIXEL_CLOCK_DIV"
group 0--3
line.long 0 "EN_CLK_STATIC_SD_CCP_PIXEL_CLOCK_DIV"
bitfld.long 0 0.--4. " EN_CLK_STATIC_SD_CCP_PIXEL_CLOCK_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0254A2C
;tree "CRMEN_CLK_STATIC_SD_HISPEED_SOURCE_SEL"
group 0--3
line.long 0 "EN_CLK_STATIC_SD_HISPEED_SOURCE_SEL"
bitfld.long 0 0.--1. " EN_CLK_STATIC_SD_HISPEED_SOURCE_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254A30
;tree "CRMEN_CLK_STATIC_SD_LOSPEED_SOURCE_SEL"
group 0--3
line.long 0 "EN_CLK_STATIC_SD_LOSPEED_SOURCE_SEL"
bitfld.long 0 0.--1. " EN_CLK_STATIC_SD_LOSPEED_SOURCE_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254A34
;tree "CRMEN_CLK_STATIC_SD_PIPE_SOURCE_SEL"
group 0--3
line.long 0 "EN_CLK_STATIC_SD_PIPE_SOURCE_SEL"
bitfld.long 0 0.--1. " EN_CLK_STATIC_SD_PIPE_SOURCE_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254A38
;tree "CRMEN_CLK_STATIC_SD_BMS_SOURCE_SEL"
group 0--3
line.long 0 "EN_CLK_STATIC_SD_BMS_SOURCE_SEL"
bitfld.long 0 0.--1. " EN_CLK_STATIC_SD_BMS_SOURCE_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254A3C
;tree "CRMEN_CLK_STATIC_SD_PICTOR_GPIO_SOURCE_SEL"
group 0--3
line.long 0 "EN_CLK_STATIC_SD_PICTOR_GPIO_SOURCE_SEL"
bitfld.long 0 0.--1. " EN_CLK_STATIC_SD_PICTOR_GPIO_SOURCE_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254A50
;tree "CRMEMUL_SENSOR_CLOCK"
group 0--3
line.long 0 "EMUL_SENSOR_CLOCK"
bitfld.long 0 0. " EMUL_SENSOR_CLOCK "  "0 ,1 "
;tree.end

base ad:0xA0254A54
;tree "CRMCHEKER_LOST_EN_CTRL_N"
group 0--3
line.long 0 "CHEKER_LOST_EN_CTRL_N"
bitfld.long 0 0. " CHEKER_LOST_EN_CTRL_N "  "0 ,1 "
;tree.end

base ad:0xA0254A58
;tree "CRMCHEKER_RESET"
group 0--3
line.long 0 "CHEKER_RESET"
hexfld.long 0 " CHEKER_RESET "
;tree.end

base ad:0xA0254A5C
;tree "CRMCHEKER_ITS"
rgroup 0--3
line.long 0 "CHEKER_ITS"
bitfld.long 0 0. " CKC_CK_ITS "  "0 ,1 "
bitfld.long 0 1. " CKC_LOST_ITS "  "0 ,1 "
;tree.end

base ad:0xA0254A60
;tree "CRMCHEKER_ITS_BCLR"
wgroup 0--3
line.long 0 "CHEKER_ITS_BCLR"
bitfld.long 0 0. " CKC_CK_ITS_BCLR "  "0 ,1 "
bitfld.long 0 1. " CKC_LOST_ITS_BCLR "  "0 ,1 "
;tree.end

base ad:0xA0254A64
;tree "CRMCHEKER_ITS_BSET"
wgroup 0--3
line.long 0 "CHEKER_ITS_BSET"
bitfld.long 0 0. " CKC_CK_ITS_BSET "  "0 ,1 "
bitfld.long 0 1. " CKC_LOST_ITS_BSET "  "0 ,1 "
;tree.end

base ad:0xA0254A68
;tree "CRMCHEKER_ITM"
rgroup 0--3
line.long 0 "CHEKER_ITM"
bitfld.long 0 0. " CKC_CK_ITM "  "0 ,1 "
bitfld.long 0 1. " CKC_LOST_ITM "  "0 ,1 "
;tree.end

base ad:0xA0254A6C
;tree "CRMCHEKER_ITM_BCLR"
wgroup 0--3
line.long 0 "CHEKER_ITM_BCLR"
bitfld.long 0 0. " CKC_CK_ITM_BCLR "  "0 ,1 "
bitfld.long 0 1. " CKC_LOST_ITM_BCLR "  "0 ,1 "
;tree.end

base ad:0xA0254A70
;tree "CRMCHEKER_ITM_BSET"
wgroup 0--3
line.long 0 "CHEKER_ITM_BSET"
bitfld.long 0 0. " CKC_CK_ITM_BSET "  "0 ,1 "
bitfld.long 0 1. " CKC_LOST_ITM_BSET "  "0 ,1 "
;tree.end

base ad:0xA0254A74
;tree "CRMCHEKER_DETECT_WDW"
group 0--3
line.long 0 "CHEKER_DETECT_WDW"
bitfld.long 0 0.--6. " CKC_DETECT_WDW "  " "
;tree.end

endif

endif

tree.end

tree.end

;==============================================================
tree "SKE"
;==============================================================
base ad:0x80006000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SKEN0 "  "0 ,1 "
bitfld.long 0 1. " SKEN1 "  "0 ,1 "
bitfld.long 0 2. " KPASEN "  "0 ,1 "
bitfld.long 0 3.--5. " KPCN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6. " KPMLT "  "0 ,1 "
bitfld.long 0 7. " KPSON "  "0 ,1 "
bitfld.long 0 8. " KPOC0 "  "0 ,1 "
bitfld.long 0 9. " KPOC1 "  "0 ,1 "
bitfld.long 0 10. " KPOC2 "  "0 ,1 "
bitfld.long 0 11. " KPOC3 "  "0 ,1 "
bitfld.long 0 12. " KPOC4 "  "0 ,1 "
bitfld.long 0 13. " KPOC5 "  "0 ,1 "
bitfld.long 0 14. " KPOC6 "  "0 ,1 "
bitfld.long 0 15. " KPOC7 "  "0 ,1 "
;tree.end

base ad:0x80006004
;tree "VAL0"
group 0--3
line.long 0 "VAL0"
hexfld.byte 0 " SKEVAL0 "
bitfld.long 0 14. " UDF0 "  "0 ,1 "
bitfld.long 0 15. " OVF0 "  "0 ,1 "
;tree.end

base ad:0x80006008
;tree "VAL1"
group 0--3
line.long 0 "VAL1"
hexfld.byte 0 " SKEVAL1 "
bitfld.long 0 14. " UDF1 "  "0 ,1 "
bitfld.long 0 15. " OVF1 "  "0 ,1 "
;tree.end

base ad:0x8000600c
;tree "DBCR"
group 0--3
line.long 0 "DBCR"
hexfld.byte 0 " SKEDBC "
hexfld.byte 1 " KPDBC "
;tree.end

base ad:0x80006010
;tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " SKEIM0 "  "0 ,1 "
bitfld.long 0 1. " SKEIM1 "  "0 ,1 "
bitfld.long 0 2. " KPIMA "  "0 ,1 "
bitfld.long 0 3. " KPIMS "  "0 ,1 "
;tree.end

base ad:0x80006014
;tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " SKERIS0 "  "0 ,1 "
bitfld.long 0 1. " SKERIS1 "  "0 ,1 "
bitfld.long 0 2. " KPRISA "  "0 ,1 "
bitfld.long 0 3. " KPRISS "  "0 ,1 "
;tree.end

base ad:0x80006018
;tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " SKEMIS0 "  "0 ,1 "
bitfld.long 0 1. " SKEMIS1 "  "0 ,1 "
bitfld.long 0 2. " KPMISA "  "0 ,1 "
bitfld.long 0 3. " KPMISS "  "0 ,1 "
;tree.end

base ad:0x8000601c
;tree "ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " SKEIC0 "  "0 ,1 "
bitfld.long 0 1. " SKEIC1 "  "0 ,1 "
bitfld.long 0 2. " KPICA "  "0 ,1 "
bitfld.long 0 3. " KPICS "  "0 ,1 "
;tree.end

base ad:0x80006020
;tree "ASR0"
group 0--3
line.long 0 "ASR0"
hexfld.byte 0 " KPRVAL0 "
hexfld.byte 1 " KPRVAL1 "
;tree.end

base ad:0x80006024
;tree "ASR1"
group 0--3
line.long 0 "ASR1"
hexfld.byte 0 " KPRVAL2 "
hexfld.byte 1 " KPRVAL3 "
;tree.end

base ad:0x80006028
;tree "ASR2"
group 0--3
line.long 0 "ASR2"
hexfld.byte 0 " KPRVAL4 "
hexfld.byte 1 " KPRVAL5 "
;tree.end

base ad:0x8000602c
;tree "ASR3"
group 0--3
line.long 0 "ASR3"
hexfld.byte 0 " KPRVAL6 "
hexfld.byte 1 " KPRVAL7 "
;tree.end

base ad:0x80006080
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " RITEN "  "0 ,1 "
bitfld.long 0 1. " KBD_ERR "  "0 ,1 "
;tree.end

base ad:0x80006084
;tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " PKI0 "  "0 ,1 "
bitfld.long 0 1. " PKI1 "  "0 ,1 "
bitfld.long 0 2. " PKI2 "  "0 ,1 "
bitfld.long 0 3. " PKI3 "  "0 ,1 "
bitfld.long 0 4. " PKI4 "  "0 ,1 "
bitfld.long 0 5. " PKI5 "  "0 ,1 "
bitfld.long 0 6. " PKI6 "  "0 ,1 "
bitfld.long 0 7. " PKI7 "  "0 ,1 "
bitfld.long 0 8. " SKA0 "  "0 ,1 "
bitfld.long 0 9. " SKB0 "  "0 ,1 "
bitfld.long 0 10. " SKA1 "  "0 ,1 "
bitfld.long 0 11. " SKB1 "  "0 ,1 "
;tree.end

base ad:0x80006088
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " KPO0 "  "0 ,1 "
bitfld.long 0 1. " KPO1 "  "0 ,1 "
bitfld.long 0 2. " KPO2 "  "0 ,1 "
bitfld.long 0 3. " KPO3 "  "0 ,1 "
bitfld.long 0 4. " KPO4 "  "0 ,1 "
bitfld.long 0 5. " KPO5 "  "0 ,1 "
bitfld.long 0 6. " KPO6 "  "0 ,1 "
bitfld.long 0 7. " KPO7 "  "0 ,1 "
bitfld.long 0 8. " SKEINTR0 "  "0 ,1 "
bitfld.long 0 9. " SKEINTR1 "  "0 ,1 "
bitfld.long 0 10. " KPINTR "  "0 ,1 "
;tree.end

base ad:0x80006fe0
;tree "SKEPeriphID0"
rgroup 0--3
line.long 0 "SKEPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80006fe4
;tree "SKEPeriphID1"
rgroup 0--3
line.long 0 "SKEPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80006fe8
;tree "SKEPeriphID2"
rgroup 0--3
line.long 0 "SKEPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80006fec
;tree "SKEPeriphID3"
rgroup 0--3
line.long 0 "SKEPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80006ff0
;tree "SKEPCellID0"
rgroup 0--3
line.long 0 "SKEPCellID0"
hexfld.byte 0 " SKEPCellID0 "
;tree.end

base ad:0x80006ff4
;tree "SKEPCellID1"
rgroup 0--3
line.long 0 "SKEPCellID1"
hexfld.byte 0 " SKEPCellID1 "
;tree.end

base ad:0x80006ff8
;tree "SKEPCellID2"
rgroup 0--3
line.long 0 "SKEPCellID2"
hexfld.byte 0 " SKEPCellID2 "
;tree.end

base ad:0x80006ffc
;tree "SKEPCellID3"
rgroup 0--3
line.long 0 "SKEPCellID3"
hexfld.byte 0 " SKEPCellID3 "
;tree.end

tree.end

;==============================================================
tree "SPI (4 instances)"
;==============================================================
base ad:0x80129000
;********************************************
tree "SPI-3"
;********************************************
base ad:0x80129000
;tree "3CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

base ad:0x80129004
;tree "3CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80129008
;tree "3DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8012900c
;tree "3SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

base ad:0x80129010
;tree "3CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

base ad:0x80129014
;tree "3IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

base ad:0x80129018
;tree "3RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

base ad:0x8012901c
;tree "3MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

base ad:0x80129020
;tree "3ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

base ad:0x80129024
;tree "3DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

base ad:0x80129fe0
;tree "3PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80129fe4
;tree "3PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80129fe8
;tree "3PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80129fec
;tree "3PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80129ff0
;tree "3PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
;tree.end

base ad:0x80129ff4
;tree "3PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
;tree.end

base ad:0x80129ff8
;tree "3PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
;tree.end

base ad:0x80129ffc
;tree "3PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
;tree.end

tree.end

base ad:0x80111000
;********************************************
tree "SPI-2"
;********************************************
base ad:0x80111000
;tree "2CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

base ad:0x80111004
;tree "2CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80111008
;tree "2DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8011100c
;tree "2SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

base ad:0x80111010
;tree "2CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

base ad:0x80111014
;tree "2IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

base ad:0x80111018
;tree "2RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

base ad:0x8011101c
;tree "2MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

base ad:0x80111020
;tree "2ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

base ad:0x80111024
;tree "2DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

base ad:0x80111fe0
;tree "2PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80111fe4
;tree "2PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80111fe8
;tree "2PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80111fec
;tree "2PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80111ff0
;tree "2PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
;tree.end

base ad:0x80111ff4
;tree "2PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
;tree.end

base ad:0x80111ff8
;tree "2PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
;tree.end

base ad:0x80111ffc
;tree "2PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
;tree.end

tree.end

base ad:0x80112000
;********************************************
tree "SPI-1"
;********************************************
base ad:0x80112000
;tree "1CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

base ad:0x80112004
;tree "1CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80112008
;tree "1DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8011200c
;tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

base ad:0x80112010
;tree "1CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

base ad:0x80112014
;tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

base ad:0x80112018
;tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

base ad:0x8011201c
;tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

base ad:0x80112020
;tree "1ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

base ad:0x80112024
;tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

base ad:0x80112fe0
;tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80112fe4
;tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80112fe8
;tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80112fec
;tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80112ff0
;tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
;tree.end

base ad:0x80112ff4
;tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
;tree.end

base ad:0x80112ff8
;tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
;tree.end

base ad:0x80112ffc
;tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
;tree.end

tree.end

base ad:0x8011a000
;********************************************
tree "SPI-0"
;********************************************
base ad:0x8011a000
;tree "0CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

base ad:0x8011a004
;tree "0CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8011a008
;tree "0DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8011a00c
;tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

base ad:0x8011a010
;tree "0CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

base ad:0x8011a014
;tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

base ad:0x8011a018
;tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

base ad:0x8011a01c
;tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

base ad:0x8011a020
;tree "0ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

base ad:0x8011a024
;tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

base ad:0x8011afe0
;tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x8011afe4
;tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011afe8
;tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011afec
;tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8011aff0
;tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
;tree.end

base ad:0x8011aff4
;tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
;tree.end

base ad:0x8011aff8
;tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
;tree.end

base ad:0x8011affc
;tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "SSP (2 instances)"
;==============================================================
base ad:0x80002000
;********************************************
tree "SSP-0"
;********************************************
base ad:0x80002000
;tree "0CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " HALFDUP "  "0 ,1 "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
bitfld.long 0 16.--20. " CSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21.--22. " FRF "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80002004
;tree "0CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " LBM "  "0 ,1 "
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 6. " MWAIT "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80002008
;tree "0DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8000200c
;tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

base ad:0x80002010
;tree "0CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

base ad:0x80002014
;tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

base ad:0x80002018
;tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

base ad:0x8000201c
;tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

base ad:0x80002020
;tree "0ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

base ad:0x80002024
;tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

base ad:0x80002080
;tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

base ad:0x80002084
;tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SSPRXD "  "0 ,1 "
bitfld.long 0 1. " SSPFSSIN "  "0 ,1 "
bitfld.long 0 2. " SSPCLKIN "  "0 ,1 "
bitfld.long 0 3. " RXDMAC "  "0 ,1 "
bitfld.long 0 4. " TXDMAC "  "0 ,1 "
bitfld.long 0 5. " SSPTXDIN "  "0 ,1 "
;tree.end

base ad:0x80002088
;tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " SSTXDOUT "  "0 ,1 "
bitfld.long 0 1. " SSPFSSOUT "  "0 ,1 "
bitfld.long 0 2. " SSPCLKOUT "  "0 ,1 "
bitfld.long 0 3. " SSPOEn "  "0 ,1 "
bitfld.long 0 4. " SSPCTLOEn "  "0 ,1 "
bitfld.long 0 5. " RORINTR "  "0 ,1 "
bitfld.long 0 6. " RINTR "  "0 ,1 "
bitfld.long 0 7. " RXINTR "  "0 ,1 "
bitfld.long 0 8. " TXINTR "  "0 ,1 "
bitfld.long 0 9. " INTR "  "0 ,1 "
bitfld.long 0 10. " RXDMABREQ "  "0 ,1 "
bitfld.long 0 11. " RXDMASREQ "  "0 ,1 "
bitfld.long 0 12. " TXDMABREQ "  "0 ,1 "
bitfld.long 0 13. " TXDMASREQ "  "0 ,1 "
;tree.end

base ad:0x8000208c
;tree "0TDR"
group 0--3
line.long 0 "TDR"
hexfld.long 0 " TestDATA "
;tree.end

base ad:0x80002fe0
;tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80002fe4
;tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80002fe8
;tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80002fec
;tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80002ff0
;tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SSPPCellID0 "
;tree.end

base ad:0x80002ff4
;tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SSPPCellID1 "
;tree.end

base ad:0x80002ff8
;tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SSPPCellID2 "
;tree.end

base ad:0x80002ffc
;tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SSPPCellID3 "
;tree.end

tree.end

base ad:0x80003000
;********************************************
tree "SSP-1"
;********************************************
base ad:0x80003000
;tree "1CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " HALFDUP "  "0 ,1 "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
bitfld.long 0 16.--20. " CSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21.--22. " FRF "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80003004
;tree "1CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " LBM "  "0 ,1 "
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 6. " MWAIT "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80003008
;tree "1DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8000300c
;tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

base ad:0x80003010
;tree "1CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

base ad:0x80003014
;tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

base ad:0x80003018
;tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

base ad:0x8000301c
;tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

base ad:0x80003020
;tree "1ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

base ad:0x80003024
;tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

base ad:0x80003080
;tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

base ad:0x80003084
;tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SSPRXD "  "0 ,1 "
bitfld.long 0 1. " SSPFSSIN "  "0 ,1 "
bitfld.long 0 2. " SSPCLKIN "  "0 ,1 "
bitfld.long 0 3. " RXDMAC "  "0 ,1 "
bitfld.long 0 4. " TXDMAC "  "0 ,1 "
bitfld.long 0 5. " SSPTXDIN "  "0 ,1 "
;tree.end

base ad:0x80003088
;tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " SSTXDOUT "  "0 ,1 "
bitfld.long 0 1. " SSPFSSOUT "  "0 ,1 "
bitfld.long 0 2. " SSPCLKOUT "  "0 ,1 "
bitfld.long 0 3. " SSPOEn "  "0 ,1 "
bitfld.long 0 4. " SSPCTLOEn "  "0 ,1 "
bitfld.long 0 5. " RORINTR "  "0 ,1 "
bitfld.long 0 6. " RINTR "  "0 ,1 "
bitfld.long 0 7. " RXINTR "  "0 ,1 "
bitfld.long 0 8. " TXINTR "  "0 ,1 "
bitfld.long 0 9. " INTR "  "0 ,1 "
bitfld.long 0 10. " RXDMABREQ "  "0 ,1 "
bitfld.long 0 11. " RXDMASREQ "  "0 ,1 "
bitfld.long 0 12. " TXDMABREQ "  "0 ,1 "
bitfld.long 0 13. " TXDMASREQ "  "0 ,1 "
;tree.end

base ad:0x8000308c
;tree "1TDR"
group 0--3
line.long 0 "TDR"
hexfld.long 0 " TestDATA "
;tree.end

base ad:0x80003fe0
;tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80003fe4
;tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80003fe8
;tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80003fec
;tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80003ff0
;tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SSPPCellID0 "
;tree.end

base ad:0x80003ff4
;tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SSPPCellID1 "
;tree.end

base ad:0x80003ff8
;tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SSPPCellID2 "
;tree.end

base ad:0x80003ffc
;tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SSPPCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "STM"
;==============================================================
base ad:0x8010f000
;tree "CR_L"
group 0--3
line.long 0 "CR_L"
bitfld.long 0 0. " PLP0 "  "0 ,1 "
bitfld.long 0 1. " PLP1 "  "0 ,1 "
bitfld.long 0 4.--5. " DWNG "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " XCKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8010f004
;tree "CR_H"
group 0--3
line.long 0 "CR_H"
;tree.end

base ad:0x8010f008
;tree "MMCR_L"
group 0--3
line.long 0 "MMCR_L"
bitfld.long 0 0. " HWnSW0 "  "0 ,1 "
bitfld.long 0 1. " HWnSW1 "  "0 ,1 "
bitfld.long 0 2. " HWnSW2 "  "0 ,1 "
bitfld.long 0 3. " HWnSW3 "  "0 ,1 "
;tree.end

base ad:0x8010f00c
;tree "MMCR_H"
group 0--3
line.long 0 "MMCR_H"
;tree.end

base ad:0x8010f010
;tree "TER_L"
group 0--3
line.long 0 "TER_L"
bitfld.long 0 0. " TE0 "  "0 ,1 "
bitfld.long 0 2. " TE2 "  "0 ,1 "
bitfld.long 0 3. " TE3 "  "0 ,1 "
bitfld.long 0 4. " TE4 "  "0 ,1 "
;tree.end

base ad:0x8010f014
;tree "TER_H"
group 0--3
line.long 0 "TER_H"
;tree.end

base ad:0x8010f018
;tree "TDSR_L"
rgroup 0--3
line.long 0 "TDSR_L"
bitfld.long 0 0. " TDis0 "  "0 ,1 "
bitfld.long 0 1. " TDis1 "  "0 ,1 "
bitfld.long 0 2. " TDis2 "  "0 ,1 "
bitfld.long 0 3. " TDis3 "  "0 ,1 "
bitfld.long 0 4. " TDis4 "  "0 ,1 "
;tree.end

base ad:0x8010f01c
;tree "TDSR_H"
rgroup 0--3
line.long 0 "TDSR_H"
;tree.end

base ad:0x8010f020
;tree "OFSR_L"
rgroup 0--3
line.long 0 "OFSR_L"
bitfld.long 0 0. " ovF0 "  "0 ,1 "
bitfld.long 0 1. " ovF1 "  "0 ,1 "
bitfld.long 0 2. " ovF2 "  "0 ,1 "
bitfld.long 0 3. " ovF3 "  "0 ,1 "
bitfld.long 0 4. " ovF4 "  "0 ,1 "
bitfld.long 0 8. " SecTrej "  "0 ,1 "
bitfld.long 0 9. " DecErr "  "0 ,1 "
bitfld.long 0 10. " SlvErr "  "0 ,1 "
bitfld.long 0 11.--14. " AddrErr "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8010f024
;tree "OFSR_H"
rgroup 0--3
line.long 0 "OFSR_H"
;tree.end

base ad:0x8010f028
;tree "TFSR_L"
rgroup 0--3
line.long 0 "TFSR_L"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TFF "  "0 ,1 "
;tree.end

base ad:0x8010f02c
;tree "TFSR_H"
rgroup 0--3
line.long 0 "TFSR_H"
;tree.end

base ad:0x8010f030
;tree "SBSR_L"
rgroup 0--3
line.long 0 "SBSR_L"
bitfld.long 0 0. " SBFE "  "0 ,1 "
bitfld.long 0 1. " SBFF "  "0 ,1 "
bitfld.long 0 2. " SBOv "  "0 ,1 "
bitfld.long 0 3.--7. " SBOvNb "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8010f034
;tree "SBSR_H"
rgroup 0--3
line.long 0 "SBSR_H"
;tree.end

base ad:0x8010f050
;tree "TSR_L"
rgroup 0--3
line.long 0 "TSR_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " Stamp "  "0 ,1 "
bitfld.long 0 2. " Time "  "0 ,1 "
;tree.end

base ad:0x8010f054
;tree "TSR_H"
rgroup 0--3
line.long 0 "TSR_H"
;tree.end

base ad:0x8010f058
;tree "SCCR_L"
group 0--3
line.long 0 "SCCR_L"
hexfld.long 0 " SCC "
;tree.end

base ad:0x8010f05c
;tree "SCCR_H"
group 0--3
line.long 0 "SCCR_H"
;tree.end

base ad:0x8010f038
;tree "DBG_L"
group 0--3
line.long 0 "DBG_L"
bitfld.long 0 0. " DBGEn "  "0 ,1 "
bitfld.long 0 1. " DBGM "  "0 ,1 "
bitfld.long 0 3.--5. " PTICSSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--10. " FTFSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 12. " FSBFF "  "0 ,1 "
bitfld.long 0 16.--24. " PTI_State "  " "
;tree.end

base ad:0x8010f03c
;tree "DBG_H"
group 0--3
line.long 0 "DBG_H"
;tree.end

base ad:0x8010ffc0
;tree "PerophlD0_L"
rgroup 0--3
line.long 0 "PerophlD0_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " PartNumber0 "  "0 ,1 "
;tree.end

base ad:0x8010ffc4
;tree "PerophlD0_H"
rgroup 0--3
line.long 0 "PerophlD0_H"
;tree.end

base ad:0x8010ffc8
;tree "PerophlD1_L"
rgroup 0--3
line.long 0 "PerophlD1_L"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8010ffcc
;tree "PerophlD1_H"
rgroup 0--3
line.long 0 "PerophlD1_H"
;tree.end

base ad:0x8010ffd0
;tree "PerophlD2_L"
rgroup 0--3
line.long 0 "PerophlD2_L"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8010ffd4
;tree "PerophlD2_H"
rgroup 0--3
line.long 0 "PerophlD2_H"
;tree.end

base ad:0x8010ffd8
;tree "PerophlD3_L"
rgroup 0--3
line.long 0 "PerophlD3_L"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8010ffdc
;tree "PerophD3_H"
rgroup 0--3
line.long 0 "PerophD3_H"
;tree.end

base ad:0x8010ffe0
;tree "PCelllD0_L"
rgroup 0--3
line.long 0 "PCelllD0_L"
hexfld.byte 0 " STMPCelllD0 "
;tree.end

base ad:0x8010ffe4
;tree "PCelllD0_H"
rgroup 0--3
line.long 0 "PCelllD0_H"
;tree.end

base ad:0x8010ffe8
;tree "PCelllD1_L"
rgroup 0--3
line.long 0 "PCelllD1_L"
hexfld.byte 0 " STMPCelllD1 "
;tree.end

base ad:0x8010ffec
;tree "PCelllD1_H"
rgroup 0--3
line.long 0 "PCelllD1_H"
;tree.end

base ad:0x8010fff0
;tree "PCelllD2_L"
rgroup 0--3
line.long 0 "PCelllD2_L"
hexfld.byte 0 " STMPCelllD2 "
;tree.end

base ad:0x8010fff4
;tree "PCelllD2_H"
rgroup 0--3
line.long 0 "PCelllD2_H"
;tree.end

base ad:0x8010fff8
;tree "PCelllD3_L"
rgroup 0--3
line.long 0 "PCelllD3_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " STMPCelllD3 "  "0 ,1 "
;tree.end

base ad:0x8010fffc
;tree "PCelllD3_H"
rgroup 0--3
line.long 0 "PCelllD3_H"
;tree.end

tree.end

;==============================================================
tree "SVA"
;==============================================================
if (((data.long(ad:0x80157008)&0x1100)!=0x1100)||((data.long(ad:0x801571ec)&0x01F0)!=0x01F0)||((data.long(ad:0x8015725c)&0x60)!=0x60))

base ad:0x80157008
;tree "prcm_svammdspclk_mgt_reg"
group 0--3
line.long 0 "prcm_svammdspclk_mgt_reg"
bitfld.long 0 8. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SVA_phy_en "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "prcm_ape_resetn_val_reg"
group 0--3
line.long 0 "prcm_ape_resetn_val_reg"
bitfld.long 0 4. " SVA_MMDSP_Vidcore_resetn "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 6. " SVA_MMDSP_Vidcore_init_n "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x801571e4
;tree "prcm_ape_resetn_set_reg"
group 0--3
line.long 0 "prcm_ape_resetn_set_reg"
bitfld.long 0 4. " SVA_MMDSP_Vidcore_resetn "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_resetn "  "0 ,1 "
bitfld.long 0 6. " SVA_MMDSP_Vidcore_init_n "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_init_n "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_init_n_tcm "  "0 ,1 "
;tree.end

base ad:0x8015725c
;tree "prcm_power_state_val"
group 0--3
line.long 0 "prcm_power_state_val"
bitfld.long 0 6. " SVA_pipe "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP "  "0 ,1 "
;tree.end

else

base ad:0xA0158408
sgroup "SVA_REG_CKEN"
constx 0 %l 0xFFFFFFFF
setx 0 %l 0
line.long 0 "SVA_REG_CKEN"
base ad:0xA0158408
;tree "SVA_REG_CKEN"
group 0--3
line.long 0 "SVA_REG_CKEN"
;tree.end

if ((data.long(ad:0xA0158408)&0x7FFFFFFF)==0x7FFFFFFF)

base ad:0xA0158404
;tree "CFG_RST"
group 0--3
line.long 0 "CFG_RST"
bitfld.long 0 0. " SRS "  "0 ,1 "
;tree.end

base ad:0xA0158408
;tree "CKG_CKEN"
group 0--3
line.long 0 "CKG_CKEN"
bitfld.long 0 29. " ENABLE_CLK_DMA "  "0 ,1 "
bitfld.long 0 28. " ENABLE_CLK_HED "  "0 ,1 "
bitfld.long 0 27. " ENABLE_CLK_VLC "  "0 ,1 "
bitfld.long 0 26. " ENABLE_CLK_FIFO2 "  "0 ,1 "
bitfld.long 0 25. " ENABLE_CLK_VBF "  "0 ,1 "
bitfld.long 0 24. " ENABLE_CLK_DMA "  "0 ,1 "
bitfld.long 0 23. " ENABLE_CLK_VC1IT "  "0 ,1 "
bitfld.long 0 22. " ENABLE_CLK_QTAB "  "0 ,1 "
bitfld.long 0 21. " ENABLE_CLK_FIFO "  "0 ,1 "
bitfld.long 0 20. " ENABLE_CLK_REC "  "0 ,1 "
bitfld.long 0 19. " ENABLE_CLK_PA "  "0 ,1 "
bitfld.long 0 18. " ENABLE_CLK_IACDC "  "0 ,1 "
bitfld.long 0 17. " ENABLE_CLK_RLC "  "0 ,1 "
bitfld.long 0 16. " ENABLE_CLK_SCN "  "0 ,1 "
bitfld.long 0 15. " ENABLE_CLK_IQ "  "0 ,1 "
bitfld.long 0 14. " ENABLE_CLK_Q "  "0 ,1 "
bitfld.long 0 13. " ENABLE_CLK_IDCT "  "0 ,1 "
bitfld.long 0 12. " ENABLE_CLK_DCT "  "0 ,1 "
bitfld.long 0 11. " ENABLE_CLK_H264IT "  "0 ,1 "
bitfld.long 0 10. " ENABLE_CLK_H264T "  "0 ,1 "
bitfld.long 0 9. " ENABLE_CLK_H264IQ "  "0 ,1 "
bitfld.long 0 8. " ENABLE_CLK_H264Q "  "0 ,1 "
bitfld.long 0 7. " ENABLE_CLK_H264VLC "  "0 ,1 "
bitfld.long 0 6. " ENABLE_CLK_IPA "  "0 ,1 "
bitfld.long 0 5. " ENABLE_CLK_MECC "  "0 ,1 "
bitfld.long 0 4. " ENABLE_CLK_BPU "  "0 ,1 "
bitfld.long 0 3. " ENABLE_CLK_BDU "  "0 ,1 "
bitfld.long 0 2. " ENABLE_CLK_DFI "  "0 ,1 "
bitfld.long 0 1. " ENABLE_CLK_VPP "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_MTF "  "0 ,1 "
;tree.end

base ad:0xA01585C0
;tree "IDN_HRV"
group 0--3
line.long 0 "IDN_HRV"
hexfld.word 0 " HRV "
;tree.end

base ad:0xA0158700
;tree "NODE_INIT_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_INIT_1_PRIORITY_REG"
bitfld.long 0 5. " MIR1 "  "0 ,1 "
bitfld.long 0 0.--4. " PRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158704
;tree "NODE_INIT_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_INIT_2_PRIORITY_REG"
bitfld.long 0 5. " MIR2 "  "0 ,1 "
bitfld.long 0 0.--4. " PRI2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158708
;tree "NODE_INIT_3_PRIORITY_REG"
group 0--3
line.long 0 "NODE_INIT_3_PRIORITY_REG"
bitfld.long 0 5. " MIR3 "  "0 ,1 "
bitfld.long 0 0.--4. " PRI3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA015870C
;tree "NODE_INIT_1_LATENCY_REG"
group 0--3
line.long 0 "NODE_INIT_1_LATENCY_REG"
hexfld.word 0 " LAT1 "
;tree.end

base ad:0xA0158710
;tree "NODE_INIT_2_LATENCY_REG"
group 0--3
line.long 0 "NODE_INIT_2_LATENCY_REG"
hexfld.word 0 " LAT2 "
;tree.end

base ad:0xA0158714
;tree "NODE_INIT_3_LATENCY_REG"
group 0--3
line.long 0 "NODE_INIT_3_LATENCY_REG"
hexfld.word 0 " LAT3 "
;tree.end

base ad:0xA0158724
;tree "NODE_INIT_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_INIT_1_LIMIT_REG"
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 4.--12. " FSIZE1 "  " "
bitfld.long 0 0.--4. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158728
;tree "NODE_INIT_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_INIT_2_LIMIT_REG"
bitfld.long 0 12.--16. " LIMIT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 4.--12. " FSIZE2 "  " "
bitfld.long 0 0.--4. " NEWPRI2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA015872C
;tree "NODE_INIT_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_INIT_3_LIMIT_REG"
bitfld.long 0 12.--16. " LIMIT3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 4.--12. " FSIZE3 "  " "
bitfld.long 0 0.--4. " NEWPRI3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158740
;tree "DMA_MAX_OPC_SZ0"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ0"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158742
;tree "DMA_MAX_OPC_SZ1"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ1"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158744
;tree "DMA_MAX_OPC_SZ2"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ2"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158746
;tree "DMA_MAX_OPC_SZ3"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ3"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158748
;tree "DMA_MAX_OPC_SZ4"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ4"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015874A
;tree "DMA_MAX_OPC_SZ5"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ5"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015874C
;tree "DMA_MAX_OPC_SZ6"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ6"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015874E
;tree "DMA_MAX_OPC_SZ7"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ7"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158750
;tree "DMA_MAX_OPC_SZ8"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ8"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158752
;tree "DMA_MAX_OPC_SZ9"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ9"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158754
;tree "DMA_MAX_OPC_SZ10"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ10"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
