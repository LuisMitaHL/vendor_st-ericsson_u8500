;PER file generated from pmapv2 
;by script version 1.12 27-July-10
;Author : N. PERRIN - Modified : F.GOHIER

config 16. 8.
width  40. 8.

;==============================================================
tree "B2R2"
;==============================================================
if (((data.long(ad:0x80157078)&0x100)!=0x100)||((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x8015741c)&0x100000)!=0x100000)||((data.long(ad:0x801571ec)&0x4)!=0x4)||((data.long(ad:0x80157428)&0x400)!=0x0))

base ad:0x80157078
group 0--3
line.long 0 "PRCM_B2R2CLK_MGT"
bitfld.long 0 8. " B2R2CLKEN "  "0 ,1 "

base ad:0x80157064
group 0--3
line.long 0 "PRCM_MCDECLK_MGT"
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 20. " DSS_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "

else

base ad:0x80130a00
;tree "BLT_CTL"
group 0--3
line.long 0 "BLT_CTL"
bitfld.long 0 28. " Big_not_little "  "0 ,1 "
bitfld.long 0 29. " Step_By_Step "  "0 ,1 "
bitfld.long 0 31. " GLOBAL_soft_reset "  "0 ,1 "
;tree.end

base ad:0x80130a04
;tree "BLT_ITS"
group 0--3
line.long 0 "BLT_ITS"
bitfld.long 0 0. " CQ1_completed "  "0 ,1 "
bitfld.long 0 1. " CQ1_retriggered "  "0 ,1 "
bitfld.long 0 2. " CQ1_Node_Notif "  "0 ,1 "
bitfld.long 0 3. " CQ1_Repaced "  "0 ,1 "
bitfld.long 0 4. " CQ2_completed "  "0 ,1 "
bitfld.long 0 5. " CQ2_retriggered "  "0 ,1 "
bitfld.long 0 6. " CQ2_Node_Notif "  "0 ,1 "
bitfld.long 0 7. " CQ2_Repaced "  "0 ,1 "
bitfld.long 0 12. " AQ1_LNA_Reached "  "0 ,1 "
bitfld.long 0 13. " AQ1_Stopped "  "0 ,1 "
bitfld.long 0 14. " AQ1_Node_repeat "  "0 ,1 "
bitfld.long 0 15. " AQ1_Node_Notif "  "0 ,1 "
bitfld.long 0 16. " AQ2_LNA_Reached "  "0 ,1 "
bitfld.long 0 17. " AQ2_Stopped "  "0 ,1 "
bitfld.long 0 18. " AQ2_Node_repeat "  "0 ,1 "
bitfld.long 0 19. " AQ2_Node_Notif "  "0 ,1 "
bitfld.long 0 20. " AQ3_LNA_Reached "  "0 ,1 "
bitfld.long 0 21. " AQ3_Stopped "  "0 ,1 "
bitfld.long 0 22. " AQ3_Node_repeat "  "0 ,1 "
bitfld.long 0 23. " AQ3_Node_Notif "  "0 ,1 "
bitfld.long 0 24. " AQ4_LNA_Reached "  "0 ,1 "
bitfld.long 0 25. " AQ4_Stopped "  "0 ,1 "
bitfld.long 0 26. " AQ4_Node_repeat "  "0 ,1 "
bitfld.long 0 27. " AQ4_Node_Notif "  "0 ,1 "
bitfld.long 0 31. " RLD_ERROR "  "0 ,1 "
;tree.end

base ad:0x80130a08
;tree "BLT_STA1"
group 0--3
line.long 0 "BLT_STA1"
bitfld.long 0 0. " BDISP_IDLE "  "0 ,1 "
;tree.end

base ad:0x80130a10
;tree "BLT_SSBA1"
group 0--3
line.long 0 "BLT_SSBA1"
bitfld.long 0 0.--25. " SSBA1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA1_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a14
;tree "BLT_SSBA2"
group 0--3
line.long 0 "BLT_SSBA2"
bitfld.long 0 0.--25. " SSBA2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA2_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a18
;tree "BLT_SSBA3"
group 0--3
line.long 0 "BLT_SSBA3"
bitfld.long 0 0.--25. " SSBA3_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA3_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a1c
;tree "BLT_SSBA4"
group 0--3
line.long 0 "BLT_SSBA4"
bitfld.long 0 0.--25. " SSBA4_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA4_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a20
;tree "BLT_SSBA5"
group 0--3
line.long 0 "BLT_SSBA5"
bitfld.long 0 0.--25. " SSBA5_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA5_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a24
;tree "BLT_SSBA6"
group 0--3
line.long 0 "BLT_SSBA6"
bitfld.long 0 0.--25. " SSBA6_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA6_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a28
;tree "BLT_SSBA7"
group 0--3
line.long 0 "BLT_SSBA7"
bitfld.long 0 0.--25. " SSBA7_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA7_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a2c
;tree "BLT_SSBA8"
group 0--3
line.long 0 "BLT_SSBA8"
bitfld.long 0 0.--25. " SSBA8_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA8_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130aa0
;tree "BLT_SSBA9"
group 0--3
line.long 0 "BLT_SSBA9"
bitfld.long 0 0.--25. " SSBA9_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA9_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130aa4
;tree "BLT_SSBA10"
group 0--3
line.long 0 "BLT_SSBA10"
bitfld.long 0 0.--25. " SSBA10_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA10_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130aa8
;tree "BLT_SSBA11"
group 0--3
line.long 0 "BLT_SSBA11"
bitfld.long 0 0.--25. " SSBA11_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA11_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130aac
;tree "BLT_SSBA12"
group 0--3
line.long 0 "BLT_SSBA12"
bitfld.long 0 0.--25. " SSBA12_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA12_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130ab0
;tree "BLT_SSBA13"
group 0--3
line.long 0 "BLT_SSBA13"
bitfld.long 0 0.--25. " SSBA13_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA13_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130ab4
;tree "BLT_SSBA14"
group 0--3
line.long 0 "BLT_SSBA14"
bitfld.long 0 0.--25. " SSBA14_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA14_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130ab8
;tree "BLT_SSBA15"
group 0--3
line.long 0 "BLT_SSBA15"
bitfld.long 0 0.--25. " SSBA15_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA15_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130abc
;tree "BLT_SSBA16"
group 0--3
line.long 0 "BLT_SSBA16"
bitfld.long 0 0.--25. " SSBA16_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA16_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a30
;tree "BLT_STBA1"
group 0--3
line.long 0 "BLT_STBA1"
bitfld.long 0 0.--25. " STBA1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA1_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a34
;tree "BLT_STBA2"
group 0--3
line.long 0 "BLT_STBA2"
bitfld.long 0 0.--25. " STBA2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA2_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a38
;tree "BLT_STBA3"
group 0--3
line.long 0 "BLT_STBA3"
bitfld.long 0 0.--25. " STBA3_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA3_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a3c
;tree "BLT_STBA4"
group 0--3
line.long 0 "BLT_STBA4"
bitfld.long 0 0.--25. " STBA4_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA4_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a40
;tree "BLT_CQ1_TRIG_IP"
group 0--3
line.long 0 "BLT_CQ1_TRIG_IP"
bitfld.long 0 0.--25. " CQ1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " TRIG_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a50
;tree "BLT_CQ2_TRIG_IP"
group 0--3
line.long 0 "BLT_CQ2_TRIG_IP"
bitfld.long 0 0.--25. " CQ2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " TRIG_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a44
;tree "BLT_CQ1_TRIG_CTL"
group 0--3
line.long 0 "BLT_CQ1_TRIG_CTL"
bitfld.long 0 0.--11. " Trigger_line_num "  " "
bitfld.long 0 12.--15. " Trig_cond "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " Retrig_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

base ad:0x80130a54
;tree "BLT_CQ2_TRIG_CTL"
group 0--3
line.long 0 "BLT_CQ2_TRIG_CTL"
bitfld.long 0 0.--11. " Trigger_line_num "  " "
bitfld.long 0 12.--15. " Trig_cond "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " Retrig_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

base ad:0x80130a48
;tree "BLT_CQ1_PACE_CTL"
group 0--3
line.long 0 "BLT_CQ1_PACE_CTL"
bitfld.long 0 0.--11. " Pace_start "  " "
bitfld.long 0 16.--27. " Pace_Count "  " "
bitfld.long 0 31. " Dynamic_Pace "  "0 ,1 "
;tree.end

base ad:0x80130a58
;tree "BLT_CQ2_PACE_CTL"
group 0--3
line.long 0 "BLT_CQ2_PACE_CTL"
bitfld.long 0 0.--11. " Pace_start "  " "
bitfld.long 0 16.--27. " Pace_Count "  " "
bitfld.long 0 31. " Dynamic_Pace "  "0 ,1 "
;tree.end

base ad:0x80130a4c
;tree "BLT_CQ1_IP"
rgroup 0--3
line.long 0 "BLT_CQ1_IP"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a5c
;tree "BLT_CQ2_IP"
rgroup 0--3
line.long 0 "BLT_CQ2_IP"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a60
;tree "BLT_AQ1_CTL"
group 0--3
line.long 0 "BLT_AQ1_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

base ad:0x80130a70
;tree "BLT_AQ2_CTL"
group 0--3
line.long 0 "BLT_AQ2_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

base ad:0x80130a80
;tree "BLT_AQ3_CTL"
group 0--3
line.long 0 "BLT_AQ3_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

base ad:0x80130a90
;tree "BLT_AQ4_CTL"
group 0--3
line.long 0 "BLT_AQ4_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

base ad:0x80130a64
;tree "BLT_AQ1_IP"
group 0--3
line.long 0 "BLT_AQ1_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a74
;tree "BLT_AQ2_IP"
group 0--3
line.long 0 "BLT_AQ2_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a84
;tree "BLT_AQ3_IP"
group 0--3
line.long 0 "BLT_AQ3_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a94
;tree "BLT_AQ4_IP"
group 0--3
line.long 0 "BLT_AQ4_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a68
;tree "BLT_AQ1_LNA"
group 0--3
line.long 0 "BLT_AQ1_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a78
;tree "BLT_AQ2_LNA"
group 0--3
line.long 0 "BLT_AQ2_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a88
;tree "BLT_AQ3_LNA"
group 0--3
line.long 0 "BLT_AQ3_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a98
;tree "BLT_AQ4_LNA"
group 0--3
line.long 0 "BLT_AQ4_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a6c
;tree "BLT_AQ1_STA"
rgroup 0--3
line.long 0 "BLT_AQ1_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a7c
;tree "BLT_AQ2_STA"
rgroup 0--3
line.long 0 "BLT_AQ2_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a8c
;tree "BLT_AQ3_STA"
rgroup 0--3
line.long 0 "BLT_AQ3_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130a9c
;tree "BLT_AQ4_STA"
rgroup 0--3
line.long 0 "BLT_AQ4_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130ac0
;tree "BLT_SGA1"
group 0--3
line.long 0 "BLT_SGA1"
hexfld.byte 0 " Alpha1 "
hexfld.byte 1 " Alpha2 "
hexfld.byte 2 " Alpha3 "
hexfld.byte 3 " Alpha4 "
;tree.end

base ad:0x80130ac4
;tree "BLT_SGA2"
group 0--3
line.long 0 "BLT_SGA2"
hexfld.byte 0 " Alpha5 "
hexfld.byte 1 " Alpha6 "
hexfld.byte 2 " Alpha7 "
hexfld.byte 3 " Alpha8 "
;tree.end

base ad:0x80130ad0
;tree "BLT_ITM0"
group 0--3
line.long 0 "BLT_ITM0"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

base ad:0x80130ad4
;tree "BLT_ITM1"
group 0--3
line.long 0 "BLT_ITM1"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

base ad:0x80130ad8
;tree "BLT_ITM2"
group 0--3
line.long 0 "BLT_ITM2"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

base ad:0x80130adc
;tree "BLT_ITM3"
group 0--3
line.long 0 "BLT_ITM3"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

base ad:0x80130af4
;tree "BLT_DFV1"
group 0--3
line.long 0 "BLT_DFV1"
bitfld.long 0 0.--11. " DFV1_Line_count "  " "
bitfld.long 0 12. " DFV1_ITM0_IT "  "0 ,1 "
bitfld.long 0 13. " DFV1_ITM1_IT "  "0 ,1 "
bitfld.long 0 14. " DFV1_ITM2_IT "  "0 ,1 "
bitfld.long 0 15. " DFV1_ITM3_IT "  "0 ,1 "
bitfld.long 0 16. " DFV1_AQ1_IT "  "0 ,1 "
bitfld.long 0 17. " DFV1_AQ2_IT "  "0 ,1 "
bitfld.long 0 18. " DFV1_AQ3_IT "  "0 ,1 "
bitfld.long 0 19. " DFV1_AQ4_IT "  "0 ,1 "
bitfld.long 0 20. " DFV1_CQ1_IT "  "0 ,1 "
bitfld.long 0 21. " DFV1_CQ2_IT "  "0 ,1 "
bitfld.long 0 24. " DFV1_GPO "  "0 ,1 "
bitfld.long 0 28. " DFV1_req "  "0 ,1 "
bitfld.long 0 29. " DFV1_ntop_bot "  "0 ,1 "
bitfld.long 0 30. " DFV1_Vsync "  "0 ,1 "
bitfld.long 0 31. " DFV1_Mode_En "  "0 ,1 "
;tree.end

base ad:0x80130af0
;tree "BLT_DFV2"
group 0--3
line.long 0 "BLT_DFV2"
bitfld.long 0 0.--11. " DFV2_Line_count "  " "
bitfld.long 0 28. " DFV2_req "  "0 ,1 "
bitfld.long 0 29. " DFV2_ntop_bot "  "0 ,1 "
bitfld.long 0 30. " DFV2_Vsync "  "0 ,1 "
bitfld.long 0 31. " DFV2_Mode_En "  "0 ,1 "
;tree.end

base ad:0x80130af8
;tree "BLT_PRI"
group 0--3
line.long 0 "BLT_PRI"
bitfld.long 0 0.--3. " CQ1_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " CQ2_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " AQ1_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " AQ2_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " AQ3_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " AQ4_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130900
;tree "BLT_SSBA17"
group 0--3
line.long 0 "BLT_SSBA17"
bitfld.long 0 0.--25. " SSBA17_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA17_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130904
;tree "BLT_SSBA18"
group 0--3
line.long 0 "BLT_SSBA18"
bitfld.long 0 0.--25. " SSBA18_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA18_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130908
;tree "BLT_SSBA19"
group 0--3
line.long 0 "BLT_SSBA19"
bitfld.long 0 0.--25. " SSBA19_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA19_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8013090c
;tree "BLT_SSBA20"
group 0--3
line.long 0 "BLT_SSBA20"
bitfld.long 0 0.--25. " SSBA20_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA20_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130910
;tree "BLT_SSBA21"
group 0--3
line.long 0 "BLT_SSBA21"
bitfld.long 0 0.--25. " SSBA21_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA21_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130914
;tree "BLT_SSBA22"
group 0--3
line.long 0 "BLT_SSBA22"
bitfld.long 0 0.--25. " SSBA22_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA22_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130918
;tree "BLT_SSBA23"
group 0--3
line.long 0 "BLT_SSBA23"
bitfld.long 0 0.--25. " SSBA23_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA23_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8013091c
;tree "BLT_SSBA24"
group 0--3
line.long 0 "BLT_SSBA24"
bitfld.long 0 0.--25. " SSBA24_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA24_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130940
;tree "BLT_STBA5"
group 0--3
line.long 0 "BLT_STBA5"
bitfld.long 0 0.--25. " STBA5_Mem_address "  " "
bitfld.long 0 26.--31. " STBA5_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130944
;tree "BLT_STBA6"
group 0--3
line.long 0 "BLT_STBA6"
bitfld.long 0 0.--25. " STBA6_Mem_address "  " "
bitfld.long 0 26.--31. " STBA6_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130948
;tree "BLT_STBA7"
group 0--3
line.long 0 "BLT_STBA7"
bitfld.long 0 0.--25. " STBA7_Mem_address "  " "
bitfld.long 0 26.--31. " STBA7_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8013094c
;tree "BLT_STBA8"
group 0--3
line.long 0 "BLT_STBA8"
bitfld.long 0 0.--25. " STBA8_Mem_address "  " "
bitfld.long 0 26.--31. " STBA8_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130b04
;tree "PLUGS1_OP2"
group 0--3
line.long 0 "PLUGS1_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b24
;tree "PLUGS2_OP2"
group 0--3
line.long 0 "PLUGS2_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b44
;tree "PLUGS3_OP2"
group 0--3
line.long 0 "PLUGS3_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b08
;tree "PLUGS1_CHZ"
group 0--3
line.long 0 "PLUGS1_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b28
;tree "PLUGS2_CHZ"
group 0--3
line.long 0 "PLUGS2_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b48
;tree "PLUGS3_CHZ"
group 0--3
line.long 0 "PLUGS3_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b0c
;tree "PLUGS1_MSZ"
group 0--3
line.long 0 "PLUGS1_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 1 " MinSpaceBetweenReq "
;tree.end

base ad:0x80130b2c
;tree "PLUGS2_MSZ"
group 0--3
line.long 0 "PLUGS2_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 1 " MinSpaceBetweenReq "
;tree.end

base ad:0x80130b4c
;tree "PLUGS3_MSZ"
group 0--3
line.long 0 "PLUGS3_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 1 " MinSpaceBetweenReq "
;tree.end

base ad:0x80130b10
;tree "PLUGS1_PGZ"
group 0--3
line.long 0 "PLUGS1_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130b30
;tree "PLUGS2_PGZ"
group 0--3
line.long 0 "PLUGS2_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130b50
;tree "PLUGS3_PGZ"
group 0--3
line.long 0 "PLUGS3_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130b84
;tree "PLUGT_OP2"
group 0--3
line.long 0 "PLUGT_OP2"
bitfld.long 0 0.--2. " Max_code "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b88
;tree "PLUGT_CHZ"
group 0--3
line.long 0 "PLUGT_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130b8c
;tree "PLUGT_MSZ"
group 0--3
line.long 0 "PLUGT_MSZ"
bitfld.long 0 0.--2. " Message_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 1 " MinSpaceBetweenReq "
;tree.end

base ad:0x80130b90
;tree "PLUGT_PGZ"
group 0--3
line.long 0 "PLUGT_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130c00
;tree "BLT_NIP"
group 0--3
line.long 0 "BLT_NIP"
bitfld.long 0 0.--25. " NIP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " NIP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c04
;tree "BLT_CIC"
group 0--3
line.long 0 "BLT_CIC"
bitfld.long 0 2. " Group2 "  "0 ,1 "
bitfld.long 0 3. " Group3 "  "0 ,1 "
bitfld.long 0 4. " Group4 "  "0 ,1 "
bitfld.long 0 5. " Group5 "  "0 ,1 "
bitfld.long 0 6. " Group6 "  "0 ,1 "
bitfld.long 0 7. " Group7 "  "0 ,1 "
bitfld.long 0 8. " Group8 "  "0 ,1 "
bitfld.long 0 9. " Group9 "  "0 ,1 "
bitfld.long 0 10. " Group10 "  "0 ,1 "
bitfld.long 0 11. " Group11 "  "0 ,1 "
bitfld.long 0 12. " Group12 "  "0 ,1 "
bitfld.long 0 13. " Group13 "  "0 ,1 "
bitfld.long 0 14. " Group14 "  "0 ,1 "
bitfld.long 0 15. " Group15 "  "0 ,1 "
bitfld.long 0 16. " Group16 "  "0 ,1 "
bitfld.long 0 17. " Group17 "  "0 ,1 "
bitfld.long 0 18. " Group18 "  "0 ,1 "
;tree.end

base ad:0x80130c08
;tree "BLT_INS"
group 0--3
line.long 0 "BLT_INS"
bitfld.long 0 0.--2. " SOURCE1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--4. " SOURCE2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " SOURCE3 "  "0 ,1 "
bitfld.long 0 6. " IVMX "  "0 ,1 "
bitfld.long 0 7. " CLUTOP "  "0 ,1 "
bitfld.long 0 8. " 2DRESCALE "  "0 ,1 "
bitfld.long 0 9. " FILCK_FILT "  "0 ,1 "
bitfld.long 0 10. " RECT_CLIP "  "0 ,1 "
bitfld.long 0 11. " CKEY "  "0 ,1 "
bitfld.long 0 12. " OVMX "  "0 ,1 "
bitfld.long 0 13. " DEI "  "0 ,1 "
bitfld.long 0 14. " PLANE_MASK "  "0 ,1 "
bitfld.long 0 15. " XYL "  "0 ,1 "
bitfld.long 0 16. " DOT "  "0 ,1 "
bitfld.long 0 17. " VC1R "  "0 ,1 "
bitfld.long 0 18. " ROTATION "  "0 ,1 "
bitfld.long 0 30. " Pace_down "  "0 ,1 "
bitfld.long 0 31. " BlitCompIRQ "  "0 ,1 "
;tree.end

base ad:0x80130c0c
;tree "BLT_ACK"
group 0--3
line.long 0 "BLT_ACK"
bitfld.long 0 0.--3. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " SWAP_FG_BG "  "0 ,1 "
hexfld.byte 1 " GALPHA_ROPID "
bitfld.long 0 16.--21. " ACK_CKEY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--23. " CKEY_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80130c10
;tree "BLT_TBA"
group 0--3
line.long 0 "BLT_TBA"
bitfld.long 0 0.--25. " TBA_mem_addr "  " "
bitfld.long 0 26.--31. " TBA_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c14
;tree "BLT_TTY"
group 0--3
line.long 0 "BLT_TTY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 26. " RGB_ROUND "  "0 ,1 "
bitfld.long 0 27. " CHROMA_notLUMA "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

base ad:0x80130c18
;tree "BLT_TXY"
group 0--3
line.long 0 "BLT_TXY"
hexfld.word 0 " XCOORD "
hexfld.word 1 " YCOORD "
;tree.end

base ad:0x80130c1c
;tree "BLT_TSZ"
group 0--3
line.long 0 "BLT_TSZ"
bitfld.long 0 0.--11. " WIN_WIDTH "  " "
bitfld.long 0 16.--27. " WIN_HEIGHT "  " "
;tree.end

base ad:0x80130c20
;tree "BLT_S1CF"
group 0--3
line.long 0 "BLT_S1CF"
hexfld.long 0 " SRC1_COLOR_FILL "
;tree.end

base ad:0x80130c24
;tree "BLT_S2CF"
group 0--3
line.long 0 "BLT_S2CF"
hexfld.long 0 " SRC2_COLOR_FILL "
;tree.end

base ad:0x80130c28
;tree "BLT_S1BA"
group 0--3
line.long 0 "BLT_S1BA"
bitfld.long 0 0.--25. " S1BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S1BA_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c2c
;tree "BLT_S1TY"
group 0--3
line.long 0 "BLT_S1TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 22. " A1_SUBST "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 27. " ROTATION "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 29. " RGB_EXP "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

base ad:0x80130c30
;tree "BLT_S1XY"
group 0--3
line.long 0 "BLT_S1XY"
hexfld.word 0 " XCOORD "
hexfld.word 1 " YCOORD "
;tree.end

base ad:0x80130c38
;tree "BLT_S2BA"
group 0--3
line.long 0 "BLT_S2BA"
bitfld.long 0 0.--25. " S2BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S2BA_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c3c
;tree "BLT_S2TY"
group 0--3
line.long 0 "BLT_S2TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 22. " A1_SUBST "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 26. " CHROMA_LEFT "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 29. " RGB_EXP "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

base ad:0x80130c40
;tree "BLT_S2XY"
group 0--3
line.long 0 "BLT_S2XY"
hexfld.word 0 " XCOORD "
hexfld.word 1 " YCOORD "
;tree.end

base ad:0x80130c44
;tree "BLT_S2SZ"
group 0--3
line.long 0 "BLT_S2SZ"
bitfld.long 0 0.--11. " SRC2_WIN_WIDTH "  " "
bitfld.long 0 16.--27. " SRC2_WIN_HEIGHT "  " "
;tree.end

base ad:0x80130c48
;tree "BLT_S3BA"
group 0--3
line.long 0 "BLT_S3BA"
bitfld.long 0 0.--25. " S3BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S3BA_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c4c
;tree "BLT_S3TY"
group 0--3
line.long 0 "BLT_S3TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " VSO "  "0 ,1 "
bitfld.long 0 25. " HSO "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

base ad:0x80130c50
;tree "BLT_S3XY"
group 0--3
line.long 0 "BLT_S3XY"
hexfld.word 0 " XCOORD "
hexfld.word 1 " YCOORD "
;tree.end

base ad:0x80130c54
;tree "BLT_S3SZ"
group 0--3
line.long 0 "BLT_S3SZ"
bitfld.long 0 0.--11. " SRC3_WIN_WIDTH "  " "
bitfld.long 0 16.--27. " SRC3_WIN_HEIGHT "  " "
;tree.end

base ad:0x80130c58
;tree "BLT_CWO"
group 0--3
line.long 0 "BLT_CWO"
bitfld.long 0 0.--14. " XDO "  " "
bitfld.long 0 16.--26. " YDO "  " "
bitfld.long 0 27. " INTNL "  "0 ,1 "
;tree.end

base ad:0x80130c5c
;tree "BLT_CWS"
group 0--3
line.long 0 "BLT_CWS"
bitfld.long 0 0.--14. " XDS "  " "
bitfld.long 0 16.--26. " YDS "  " "
;tree.end

base ad:0x80130c60
;tree "BLT_CCO"
group 0--3
line.long 0 "BLT_CCO"
bitfld.long 0 15. " CLUT_NS2_1S1 "  "0 ,1 "
bitfld.long 0 16.--17. " CLUT_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " CLUT_UPDATE "  "0 ,1 "
bitfld.long 0 19.--22. " CLUT_ERRDIFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130c64
;tree "BLT_CML"
group 0--3
line.long 0 "BLT_CML"
bitfld.long 0 4.--25. " CML_MEM_ADDR "  " "
bitfld.long 0 26.--31. " CML_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c68
;tree "BLT_FCTL"
group 0--3
line.long 0 "BLT_FCTL"
bitfld.long 0 0.--2. " 2DHF_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " 2DVF_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12. " AB_Right "  "0 ,1 "
bitfld.long 0 13. " AB_Left "  "0 ,1 "
bitfld.long 0 14. " AB_BOT "  "0 ,1 "
bitfld.long 0 15. " AB_TOP "  "0 ,1 "
bitfld.long 0 24.--25. " Luma_2Dhf_mode "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " Luma_2Dvf_mode "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80130c6c
;tree "BLT_PMK"
group 0--3
line.long 0 "BLT_PMK"
bitfld.long 0 0. " PLANE_MASK "  "0 ,1 "
;tree.end

base ad:0x80130c70
;tree "BLT_RSF"
group 0--3
line.long 0 "BLT_RSF"
hexfld.word 0 " HSRC_INC "
hexfld.word 1 " VSRC_INC "
;tree.end

base ad:0x80130c74
;tree "BLT_RZI"
group 0--3
line.long 0 "BLT_RZI"
bitfld.long 0 0.--9. " HSRC_INIT "  " "
bitfld.long 0 12.--14. " Hnb_repeat "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--25. " VSRC_INIT "  " "
bitfld.long 0 28.--30. " Vnb_repeat "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130c78
;tree "BLT_HFP"
group 0--3
line.long 0 "BLT_HFP"
bitfld.long 0 0.--25. " HFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " HFP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c7c
;tree "BLT_VFP"
group 0--3
line.long 0 "BLT_VFP"
bitfld.long 0 0.--25. " VFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " VFP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c80
;tree "BLT_Y_RSF"
group 0--3
line.long 0 "BLT_Y_RSF"
hexfld.word 0 " Luma_HSRC_INC "
hexfld.word 1 " Luma_VSRC_INC "
;tree.end

base ad:0x80130c84
;tree "BLT_Y_RZI"
group 0--3
line.long 0 "BLT_Y_RZI"
bitfld.long 0 0.--9. " Hsrc_init_luma "  " "
bitfld.long 0 12.--14. " Hnb_repeat_luma "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--25. " Vsrc_init_luma "  " "
bitfld.long 0 28.--30. " Vnb_repeat_Luma "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80130c88
;tree "BLT_Y_HFP"
group 0--3
line.long 0 "BLT_Y_HFP"
bitfld.long 0 0.--25. " Y_HFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " Y_Hfp_Bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130c8c
;tree "BLT_Y_VFP"
group 0--3
line.long 0 "BLT_Y_VFP"
bitfld.long 0 0.--25. " Y_VFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " Y_Vfp_Bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80130ca0
;tree "BLT_KEY1"
group 0--3
line.long 0 "BLT_KEY1"
hexfld.byte 0 " BLUE_MIN "
hexfld.byte 1 " GREEN_MIN "
hexfld.byte 2 " RED_MIN "
hexfld.byte 3 " ALPHA0 "
;tree.end

base ad:0x80130ca4
;tree "BLT_KEY2"
group 0--3
line.long 0 "BLT_KEY2"
hexfld.byte 0 " BLUE_MAX "
hexfld.byte 1 " GREEN_MAX "
hexfld.byte 2 " RED_MAX "
hexfld.byte 3 " ALPHA1 "
;tree.end

base ad:0x80130cb0
;tree "BLT_SAR"
group 0--3
line.long 0 "BLT_SAR"
bitfld.long 0 0.--4. " S1_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " S2_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " S3_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--27. " T_STBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " A_SGA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80130cb4
;tree "BLT_USR"
group 0--3
line.long 0 "BLT_USR"
hexfld.long 0 " GENERAL_PURPOSE "
;tree.end

base ad:0x80130cc0
;tree "BLT_IVMX0"
group 0--3
line.long 0 "BLT_IVMX0"
bitfld.long 0 0.--9. " Coeff13 "  " "
bitfld.long 0 10.--20. " Coeff12 "  " "
bitfld.long 0 21.--31. " Coeff11 "  " "
;tree.end

base ad:0x80130cc4
;tree "BLT_IVMX1"
group 0--3
line.long 0 "BLT_IVMX1"
bitfld.long 0 0.--9. " Coeff23 "  " "
bitfld.long 0 10.--20. " Coeff22 "  " "
bitfld.long 0 21.--31. " Coeff21 "  " "
;tree.end

base ad:0x80130cc8
;tree "BLT_IVMX2"
group 0--3
line.long 0 "BLT_IVMX2"
bitfld.long 0 0.--9. " Coeff33 "  " "
bitfld.long 0 10.--20. " Coeff32 "  " "
bitfld.long 0 21.--31. " Coeff31 "  " "
;tree.end

base ad:0x80130ccc
;tree "BLT_IVMX3"
group 0--3
line.long 0 "BLT_IVMX3"
bitfld.long 0 0.--9. " Offset3 "  " "
bitfld.long 0 10.--19. " Offset2 "  " "
bitfld.long 0 20.--29. " Offset1 "  " "
;tree.end

base ad:0x80130cd0
;tree "BLT_OVMX0"
group 0--3
line.long 0 "BLT_OVMX0"
bitfld.long 0 0.--9. " Coeff13 "  " "
bitfld.long 0 10.--20. " Coeff12 "  " "
bitfld.long 0 21.--31. " Coeff11 "  " "
;tree.end

base ad:0x80130cd4
;tree "BLT_OVMX1"
group 0--3
line.long 0 "BLT_OVMX1"
bitfld.long 0 0.--9. " Coeff23 "  " "
bitfld.long 0 10.--20. " Coeff22 "  " "
bitfld.long 0 21.--31. " Coeff21 "  " "
;tree.end

base ad:0x80130cd8
;tree "BLT_OVMX2"
group 0--3
line.long 0 "BLT_OVMX2"
bitfld.long 0 0.--9. " Coeff33 "  " "
bitfld.long 0 10.--20. " Coeff32 "  " "
bitfld.long 0 21.--31. " Coeff31 "  " "
;tree.end

base ad:0x80130cdc
;tree "BLT_OVMX3"
group 0--3
line.long 0 "BLT_OVMX3"
bitfld.long 0 0.--9. " Offset3 "  " "
bitfld.long 0 10.--19. " Offset2 "  " "
bitfld.long 0 20.--29. " Offset1 "  " "
;tree.end

base ad:0x80130ce8
;tree "BLT_VC1R"
group 0--3
line.long 0 "BLT_VC1R"
bitfld.long 0 0.--2. " Luma_coeff "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " Luma_Map "  "0 ,1 "
bitfld.long 0 4.--6. " Chroma_coeff "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " Chroma_map "  "0 ,1 "
;tree.end

base ad:0x80130e00
;tree "BLT_HFC0"
group 0--3
line.long 0 "BLT_HFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

base ad:0x80130e04
;tree "BLT_HFC1"
group 0--3
line.long 0 "BLT_HFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K5 "
hexfld.byte 2 " K6 "
hexfld.byte 3 " K7 "
;tree.end

base ad:0x80130e08
;tree "BLT_HFC2"
group 0--3
line.long 0 "BLT_HFC2"
hexfld.byte 0 " K10 "
hexfld.byte 1 " K11 "
hexfld.byte 2 " K12 "
hexfld.byte 3 " K13 "
;tree.end

base ad:0x80130e0c
;tree "BLT_HFC3"
group 0--3
line.long 0 "BLT_HFC3"
hexfld.byte 0 " K14 "
hexfld.byte 1 " K15 "
hexfld.byte 2 " K16 "
hexfld.byte 3 " K17 "
;tree.end

base ad:0x80130e10
;tree "BLT_HFC4"
group 0--3
line.long 0 "BLT_HFC4"
hexfld.byte 0 " K20 "
hexfld.byte 1 " K21 "
hexfld.byte 2 " K22 "
hexfld.byte 3 " K23 "
;tree.end

base ad:0x80130e14
;tree "BLT_HFC5"
group 0--3
line.long 0 "BLT_HFC5"
hexfld.byte 0 " K24 "
hexfld.byte 1 " K25 "
hexfld.byte 2 " K26 "
hexfld.byte 3 " K27 "
;tree.end

base ad:0x80130e18
;tree "BLT_HFC6"
group 0--3
line.long 0 "BLT_HFC6"
hexfld.byte 0 " K30 "
hexfld.byte 1 " K31 "
hexfld.byte 2 " K32 "
hexfld.byte 3 " K33 "
;tree.end

base ad:0x80130e1c
;tree "BLT_HFC7"
group 0--3
line.long 0 "BLT_HFC7"
hexfld.byte 0 " K34 "
hexfld.byte 1 " K35 "
hexfld.byte 2 " K36 "
hexfld.byte 3 " K37 "
;tree.end

base ad:0x80130e20
;tree "BLT_HFC8"
group 0--3
line.long 0 "BLT_HFC8"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

base ad:0x80130e24
;tree "BLT_HFC9"
group 0--3
line.long 0 "BLT_HFC9"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K45 "
hexfld.byte 2 " K46 "
hexfld.byte 3 " K47 "
;tree.end

base ad:0x80130e28
;tree "BLT_HFC10"
group 0--3
line.long 0 "BLT_HFC10"
hexfld.byte 0 " K50 "
hexfld.byte 1 " K51 "
hexfld.byte 2 " K52 "
hexfld.byte 3 " K53 "
;tree.end

base ad:0x80130e2c
;tree "BLT_HFC11"
group 0--3
line.long 0 "BLT_HFC11"
hexfld.byte 0 " K54 "
hexfld.byte 1 " K55 "
hexfld.byte 2 " K56 "
hexfld.byte 3 " K57 "
;tree.end

base ad:0x80130e30
;tree "BLT_HFC12"
group 0--3
line.long 0 "BLT_HFC12"
hexfld.byte 0 " K60 "
hexfld.byte 1 " K61 "
hexfld.byte 2 " K62 "
hexfld.byte 3 " K63 "
;tree.end

base ad:0x80130e34
;tree "BLT_HFC13"
group 0--3
line.long 0 "BLT_HFC13"
hexfld.byte 0 " K64 "
hexfld.byte 1 " K65 "
hexfld.byte 2 " K66 "
hexfld.byte 3 " K67 "
;tree.end

base ad:0x80130e38
;tree "BLT_HFC14"
group 0--3
line.long 0 "BLT_HFC14"
hexfld.byte 0 " K70 "
hexfld.byte 1 " K71 "
hexfld.byte 2 " K72 "
hexfld.byte 3 " K73 "
;tree.end

base ad:0x80130e3c
;tree "BLT_HFC15"
group 0--3
line.long 0 "BLT_HFC15"
hexfld.byte 0 " K74 "
hexfld.byte 1 " K75 "
hexfld.byte 2 " K76 "
hexfld.byte 3 " K77 "
;tree.end

base ad:0x80130e90
;tree "BLT_VFC0"
group 0--3
line.long 0 "BLT_VFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

base ad:0x80130e94
;tree "BLT_VFC1"
group 0--3
line.long 0 "BLT_VFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K10 "
hexfld.byte 2 " K11 "
hexfld.byte 3 " K12 "
;tree.end

base ad:0x80130e98
;tree "BLT_VFC2"
group 0--3
line.long 0 "BLT_VFC2"
hexfld.byte 0 " K13 "
hexfld.byte 1 " K14 "
hexfld.byte 2 " K20 "
hexfld.byte 3 " K21 "
;tree.end

base ad:0x80130e9c
;tree "BLT_VFC3"
group 0--3
line.long 0 "BLT_VFC3"
hexfld.byte 0 " K22 "
hexfld.byte 1 " K23 "
hexfld.byte 2 " K24 "
hexfld.byte 3 " K30 "
;tree.end

base ad:0x80130ea0
;tree "BLT_VFC4"
group 0--3
line.long 0 "BLT_VFC4"
hexfld.byte 0 " K31 "
hexfld.byte 1 " K32 "
hexfld.byte 2 " K33 "
hexfld.byte 3 " K34 "
;tree.end

base ad:0x80130ea4
;tree "BLT_VFC5"
group 0--3
line.long 0 "BLT_VFC5"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

base ad:0x80130ea8
;tree "BLT_VFC6"
group 0--3
line.long 0 "BLT_VFC6"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K50 "
hexfld.byte 2 " K51 "
hexfld.byte 3 " K52 "
;tree.end

base ad:0x80130eac
;tree "BLT_VFC7"
group 0--3
line.long 0 "BLT_VFC7"
hexfld.byte 0 " K53 "
hexfld.byte 1 " K54 "
hexfld.byte 2 " K60 "
hexfld.byte 3 " K61 "
;tree.end

base ad:0x80130eb0
;tree "BLT_VFC8"
group 0--3
line.long 0 "BLT_VFC8"
hexfld.byte 0 " K62 "
hexfld.byte 1 " K63 "
hexfld.byte 2 " K64 "
hexfld.byte 3 " K70 "
;tree.end

base ad:0x80130eb4
;tree "BLT_VFC9"
group 0--3
line.long 0 "BLT_VFC9"
hexfld.byte 0 " K71 "
hexfld.byte 1 " K72 "
hexfld.byte 2 " K73 "
hexfld.byte 3 " K74 "
;tree.end

base ad:0x80130d00
;tree "BLT_Y_HFC0"
group 0--3
line.long 0 "BLT_Y_HFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

base ad:0x80130d04
;tree "BLT_Y_HFC1"
group 0--3
line.long 0 "BLT_Y_HFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K5 "
hexfld.byte 2 " K6 "
hexfld.byte 3 " K7 "
;tree.end

base ad:0x80130d08
;tree "BLT_Y_HFC2"
group 0--3
line.long 0 "BLT_Y_HFC2"
hexfld.byte 0 " K10 "
hexfld.byte 1 " K11 "
hexfld.byte 2 " K12 "
hexfld.byte 3 " K13 "
;tree.end

base ad:0x80130d0c
;tree "BLT_Y_HFC3"
group 0--3
line.long 0 "BLT_Y_HFC3"
hexfld.byte 0 " K14 "
hexfld.byte 1 " K15 "
hexfld.byte 2 " K16 "
hexfld.byte 3 " K17 "
;tree.end

base ad:0x80130d10
;tree "BLT_Y_HFC4"
group 0--3
line.long 0 "BLT_Y_HFC4"
hexfld.byte 0 " K20 "
hexfld.byte 1 " K21 "
hexfld.byte 2 " K22 "
hexfld.byte 3 " K23 "
;tree.end

base ad:0x80130d14
;tree "BLT_Y_HFC5"
group 0--3
line.long 0 "BLT_Y_HFC5"
hexfld.byte 0 " K24 "
hexfld.byte 1 " K25 "
hexfld.byte 2 " K26 "
hexfld.byte 3 " K27 "
;tree.end

base ad:0x80130d18
;tree "BLT_Y_HFC6"
group 0--3
line.long 0 "BLT_Y_HFC6"
hexfld.byte 0 " K30 "
hexfld.byte 1 " K31 "
hexfld.byte 2 " K32 "
hexfld.byte 3 " K33 "
;tree.end

base ad:0x80130d1c
;tree "BLT_Y_HFC7"
group 0--3
line.long 0 "BLT_Y_HFC7"
hexfld.byte 0 " K34 "
hexfld.byte 1 " K35 "
hexfld.byte 2 " K36 "
hexfld.byte 3 " K37 "
;tree.end

base ad:0x80130d20
;tree "BLT_Y_HFC8"
group 0--3
line.long 0 "BLT_Y_HFC8"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

base ad:0x80130d24
;tree "BLT_Y_HFC9"
group 0--3
line.long 0 "BLT_Y_HFC9"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K45 "
hexfld.byte 2 " K46 "
hexfld.byte 3 " K47 "
;tree.end

base ad:0x80130d28
;tree "BLT_Y_HFC10"
group 0--3
line.long 0 "BLT_Y_HFC10"
hexfld.byte 0 " K50 "
hexfld.byte 1 " K51 "
hexfld.byte 2 " K52 "
hexfld.byte 3 " K53 "
;tree.end

base ad:0x80130d2c
;tree "BLT_Y_HFC11"
group 0--3
line.long 0 "BLT_Y_HFC11"
hexfld.byte 0 " K54 "
hexfld.byte 1 " K55 "
hexfld.byte 2 " K56 "
hexfld.byte 3 " K57 "
;tree.end

base ad:0x80130d30
;tree "BLT_Y_HFC12"
group 0--3
line.long 0 "BLT_Y_HFC12"
hexfld.byte 0 " K60 "
hexfld.byte 1 " K61 "
hexfld.byte 2 " K62 "
hexfld.byte 3 " K63 "
;tree.end

base ad:0x80130d34
;tree "BLT_Y_HFC13"
group 0--3
line.long 0 "BLT_Y_HFC13"
hexfld.byte 0 " K64 "
hexfld.byte 1 " K65 "
hexfld.byte 2 " K66 "
hexfld.byte 3 " K67 "
;tree.end

base ad:0x80130d38
;tree "BLT_Y_HFC14"
group 0--3
line.long 0 "BLT_Y_HFC14"
hexfld.byte 0 " K70 "
hexfld.byte 1 " K71 "
hexfld.byte 2 " K72 "
hexfld.byte 3 " K73 "
;tree.end

base ad:0x80130d3c
;tree "BLT_Y_HFC15"
group 0--3
line.long 0 "BLT_Y_HFC15"
hexfld.byte 0 " K74 "
hexfld.byte 1 " K75 "
hexfld.byte 2 " K76 "
hexfld.byte 3 " K77 "
;tree.end

base ad:0x80130d90
;tree "BLT_Y_VFC0"
group 0--3
line.long 0 "BLT_Y_VFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

base ad:0x80130d94
;tree "BLT_Y_VFC1"
group 0--3
line.long 0 "BLT_Y_VFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K10 "
hexfld.byte 2 " K11 "
hexfld.byte 3 " K12 "
;tree.end

base ad:0x80130d98
;tree "BLT_Y_VFC2"
group 0--3
line.long 0 "BLT_Y_VFC2"
hexfld.byte 0 " K13 "
hexfld.byte 1 " K14 "
hexfld.byte 2 " K20 "
hexfld.byte 3 " K21 "
;tree.end

base ad:0x80130d9c
;tree "BLT_Y_VFC3"
group 0--3
line.long 0 "BLT_Y_VFC3"
hexfld.byte 0 " K22 "
hexfld.byte 1 " K23 "
hexfld.byte 2 " K24 "
hexfld.byte 3 " K30 "
;tree.end

base ad:0x80130da0
;tree "BLT_Y_VFC4"
group 0--3
line.long 0 "BLT_Y_VFC4"
hexfld.byte 0 " K31 "
hexfld.byte 1 " K32 "
hexfld.byte 2 " K33 "
hexfld.byte 3 " K34 "
;tree.end

base ad:0x80130da4
;tree "BLT_Y_VFC5"
group 0--3
line.long 0 "BLT_Y_VFC5"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

base ad:0x80130da8
;tree "BLT_Y_VFC6"
group 0--3
line.long 0 "BLT_Y_VFC6"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K50 "
hexfld.byte 2 " K51 "
hexfld.byte 3 " K52 "
;tree.end

base ad:0x80130dac
;tree "BLT_Y_VFC7"
group 0--3
line.long 0 "BLT_Y_VFC7"
hexfld.byte 0 " K53 "
hexfld.byte 1 " K54 "
hexfld.byte 2 " K60 "
hexfld.byte 3 " K61 "
;tree.end

base ad:0x80130db0
;tree "BLT_Y_VFC8"
group 0--3
line.long 0 "BLT_Y_VFC8"
hexfld.byte 0 " K62 "
hexfld.byte 1 " K63 "
hexfld.byte 2 " K64 "
hexfld.byte 3 " K70 "
;tree.end

base ad:0x80130db4
;tree "BLT_Y_VFC9"
group 0--3
line.long 0 "BLT_Y_VFC9"
hexfld.byte 0 " K71 "
hexfld.byte 1 " K72 "
hexfld.byte 2 " K73 "
hexfld.byte 3 " K74 "
;tree.end

endif

tree.end

;==============================================================
tree "CLK_RST1"
;==============================================================
base ad:0x8012f000
;tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERCKEN8 "  "0 ,1 "
bitfld.long 0 9. " PERCKEN9 "  "0 ,1 "
bitfld.long 0 10. " PERCKEN10 "  "0 ,1 "
bitfld.long 0 11. " PERCKEN11 "  "0 ,1 "
;tree.end

base ad:0x8012f004
;tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERCKDIS8 "  "0 ,1 "
bitfld.long 0 9. " PERCKDIS9 "  "0 ,1 "
bitfld.long 0 10. " PERCKDIS10 "  "0 ,1 "
bitfld.long 0 11. " PERCKDIS11 "  "0 ,1 "
;tree.end

base ad:0x8012f008
;tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
bitfld.long 0 8. " PERKCKEN8 "  "0 ,1 "
bitfld.long 0 9. " PERKCKEN9 "  "0 ,1 "
bitfld.long 0 10. " PERKCKEN10 "  "0 ,1 "
;tree.end

base ad:0x8012f00c
;tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
bitfld.long 0 8. " PERKCKDIS8 "  "0 ,1 "
bitfld.long 0 9. " PERKCKDIS9 "  "0 ,1 "
bitfld.long 0 10. " PERKCKDIS10 "  "0 ,1 "
;tree.end

base ad:0x8012f010
;tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERCKSR8 "  "0 ,1 "
bitfld.long 0 9. " PERCKSR9 "  "0 ,1 "
bitfld.long 0 10. " PERCKSR10 "  "0 ,1 "
bitfld.long 0 11. " PERCKSR11 "  "0 ,1 "
;tree.end

base ad:0x8012f014
;tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
bitfld.long 0 8. " PERKCKSR8 "  "0 ,1 "
bitfld.long 0 9. " PERKCKSR9 "  "0 ,1 "
bitfld.long 0 10. " PERKCKSR10 "  "0 ,1 "
;tree.end

base ad:0x8012f018
;tree "PRCC_K_SOFTRST_SET"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 0. " K_SOFTRST_SET0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTRST_SET1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_SET2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_SET3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_SET4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_SET5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_SET6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_SET7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTRST_SET8 "  "0 ,1 "
bitfld.long 0 9. " K_SOFTRST_SET9 "  "0 ,1 "
bitfld.long 0 10. " K_SOFTRST_SET10 "  "0 ,1 "
bitfld.long 0 11. " K_SOFTRST_SET11 "  "0 ,1 "
bitfld.long 0 12. " K_SOFTRST_SET12 "  "0 ,1 "
bitfld.long 0 13. " K_SOFTRST_SET13 "  "0 ,1 "
bitfld.long 0 14. " K_SOFTRST_SET14 "  "0 ,1 "
;tree.end

base ad:0x8012f01c
;tree "PRCC_K_SOFTRST_CLR"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 0. " K_SOFTRST_CLR0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTRST_CLR1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_CLR2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_CLR3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_CLR4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_CLR5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_CLR6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_CLR7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTRST_CLR8 "  "0 ,1 "
bitfld.long 0 9. " K_SOFTRST_CLR9 "  "0 ,1 "
bitfld.long 0 10. " K_SOFTRST_CLR10 "  "0 ,1 "
bitfld.long 0 11. " K_SOFTRST_CLR11 "  "0 ,1 "
bitfld.long 0 12. " K_SOFTRST_CLR12 "  "0 ,1 "
bitfld.long 0 13. " K_SOFTRST_CLR13 "  "0 ,1 "
bitfld.long 0 14. " K_SOFTRST_CLR14 "  "0 ,1 "
;tree.end

base ad:0x8012f020
;tree "PRCC_K_RST_STATUS"
group 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 0. " K_RST_STATUS0 "  "0 ,1 "
bitfld.long 0 1. " K_RST_STATUS1 "  "0 ,1 "
bitfld.long 0 2. " K_RST_STATUS2 "  "0 ,1 "
bitfld.long 0 3. " K_RST_STATUS3 "  "0 ,1 "
bitfld.long 0 4. " K_RST_STATUS4 "  "0 ,1 "
bitfld.long 0 5. " K_RST_STATUS5 "  "0 ,1 "
bitfld.long 0 6. " K_RST_STATUS6 "  "0 ,1 "
bitfld.long 0 7. " K_RST_STATUS7 "  "0 ,1 "
bitfld.long 0 8. " K_RST_STATUS8 "  "0 ,1 "
bitfld.long 0 9. " K_RST_STATUS9 "  "0 ,1 "
bitfld.long 0 10. " K_RST_STATUS10 "  "0 ,1 "
bitfld.long 0 11. " K_RST_STATUS11 "  "0 ,1 "
bitfld.long 0 12. " K_RST_STATUS12 "  "0 ,1 "
bitfld.long 0 13. " K_RST_STATUS13 "  "0 ,1 "
;tree.end

base ad:0x8012ffe0
;tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8012ffe4
;tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012ffe8
;tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012ffec
;tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8012fff0
;tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

base ad:0x8012fff4
;tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

base ad:0x8012fff8
;tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

base ad:0x8012fffc
;tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "CLK_RST2"
;==============================================================
base ad:0x8011f000
;tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERCKEN8 "  "0 ,1 "
bitfld.long 0 9. " PERCKEN9 "  "0 ,1 "
bitfld.long 0 10. " PERCKEN10 "  "0 ,1 "
bitfld.long 0 11. " PERCKEN11 "  "0 ,1 "
;tree.end

base ad:0x8011f004
;tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERCKDIS8 "  "0 ,1 "
bitfld.long 0 9. " PERCKDIS9 "  "0 ,1 "
bitfld.long 0 10. " PERCKDIS10 "  "0 ,1 "
bitfld.long 0 11. " PERCKDIS11 "  "0 ,1 "
;tree.end

base ad:0x8011f008
;tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKEN7 "  "0 ,1 "
;tree.end

base ad:0x8011f00c
;tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKDIS7 "  "0 ,1 "
;tree.end

base ad:0x8011f010
;tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERCKSR8 "  "0 ,1 "
bitfld.long 0 9. " PERCKSR9 "  "0 ,1 "
bitfld.long 0 10. " PERCKSR10 "  "0 ,1 "
bitfld.long 0 11. " PERCKSR11 "  "0 ,1 "
;tree.end

base ad:0x8011f014
;tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKSR7 "  "0 ,1 "
;tree.end

base ad:0x8011f018
;tree "PRCC_K_SOFTRST_SET"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 0. " K_SOFTRST_SET0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTRST_SET1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_SET2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_SET3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_SET4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_SET5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_SET6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_SET7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTRST_SET8 "  "0 ,1 "
;tree.end

base ad:0x8011f01c
;tree "PRCC_K_SOFTRST_CLR"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 0. " K_SOFTRST_CLR0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTRST_CLR1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_CLR2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_CLR3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_CLR4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_CLR5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_CLR6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_CLR7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTRST_CLR8 "  "0 ,1 "
;tree.end

base ad:0x8011f020
;tree "PRCC_K_RST_STATUS"
group 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 0. " K_RST_STATUS0 "  "0 ,1 "
bitfld.long 0 1. " K_RST_STATUS1 "  "0 ,1 "
bitfld.long 0 2. " K_RST_STATUS2 "  "0 ,1 "
bitfld.long 0 3. " K_RST_STATUS3 "  "0 ,1 "
bitfld.long 0 4. " K_RST_STATUS4 "  "0 ,1 "
bitfld.long 0 5. " K_RST_STATUS5 "  "0 ,1 "
bitfld.long 0 6. " K_RST_STATUS6 "  "0 ,1 "
bitfld.long 0 7. " K_RST_STATUS7 "  "0 ,1 "
bitfld.long 0 8. " K_RST_STATUS8 "  "0 ,1 "
;tree.end

base ad:0x8011ffe0
;tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8011ffe4
;tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011ffe8
;tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011ffec
;tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8011fff0
;tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

base ad:0x8011fff4
;tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

base ad:0x8011fff8
;tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

base ad:0x8011fffc
;tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "CLK_RST3"
;==============================================================
base ad:0x8000f000
;tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERCKEN8 "  "0 ,1 "
;tree.end

base ad:0x8000f004
;tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERCKDIS8 "  "0 ,1 "
;tree.end

base ad:0x8000f008
;tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKEN7 "  "0 ,1 "
;tree.end

base ad:0x8000f00c
;tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKDIS7 "  "0 ,1 "
;tree.end

base ad:0x8000f010
;tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERCKSR8 "  "0 ,1 "
;tree.end

base ad:0x8000f014
;tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKSR7 "  "0 ,1 "
;tree.end

base ad:0x8000f018
;tree "PRCC_K_SOFTRST_SET"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 1. " K_SOFTRST_SET1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_SET2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_SET3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_SET4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_SET5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_SET6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_SET7 "  "0 ,1 "
;tree.end

base ad:0x8000f01c
;tree "PRCC_K_SOFTRST_CLR"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 1. " K_SOFTRST_CLR1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_CLR2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_CLR3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_CLR4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_CLR5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_CLR6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_CLR7 "  "0 ,1 "
;tree.end

base ad:0x8000f020
;tree "PRCC_K_RST_STATUS"
group 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 1. " K_RST_STATUS1 "  "0 ,1 "
bitfld.long 0 2. " K_RST_STATUS2 "  "0 ,1 "
bitfld.long 0 3. " K_RST_STATUS3 "  "0 ,1 "
bitfld.long 0 4. " K_RST_STATUS4 "  "0 ,1 "
bitfld.long 0 5. " K_RST_STATUS5 "  "0 ,1 "
bitfld.long 0 6. " K_RST_STATUS6 "  "0 ,1 "
bitfld.long 0 7. " K_RST_STATUS7 "  "0 ,1 "
;tree.end

base ad:0x8000ffe0
;tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x8000ffe4
;tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8000ffe8
;tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8000ffec
;tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8000fff0
;tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

base ad:0x8000fff4
;tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

base ad:0x8000fff8
;tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

base ad:0x8000fffc
;tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "CLK_RST5"
;==============================================================
base ad:0xa03ff000
;tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
;tree.end

base ad:0xa03ff004
;tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
;tree.end

base ad:0xa03ff010
;tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
;tree.end

base ad:0xa03fffe0
;tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03fffe4
;tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03fffe8
;tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03fffec
;tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03ffff0
;tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

base ad:0xa03ffff4
;tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

base ad:0xa03ffff8
;tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

base ad:0xa03ffffc
;tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "CLK_RST6"
;==============================================================
base ad:0xa03cf000
;tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
;tree.end

base ad:0xa03cf004
;tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
;tree.end

base ad:0xa03cf008
;tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
;tree.end

base ad:0xa03cf00c
;tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
;tree.end

base ad:0xa03cf010
;tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
;tree.end

base ad:0xa03cf014
;tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
;tree.end

base ad:0xa03cf018
;tree "PRCC_K_SOFTRST_SET"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 0. " K_SOFTRST_SET0 "  "0 ,1 "
;tree.end

base ad:0xa03cf01c
;tree "PRCC_K_SOFTRST_CLR"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 0. " K_SOFTRST_CLR0 "  "0 ,1 "
;tree.end

base ad:0xa03cf020
;tree "PRCC_K_RST_STATUS"
group 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 0. " K_RST_STATUS0 "  "0 ,1 "
;tree.end

base ad:0xa03cffe0
;tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03cffe4
;tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cffe8
;tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cffec
;tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03cfff0
;tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

base ad:0xa03cfff4
;tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

base ad:0xa03cfff8
;tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

base ad:0xa03cfffc
;tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "CR"
;==============================================================
base ad:0xa03c8000
;tree "CR_REG0"
group 0--3
line.long 0 "CR_REG0"
bitfld.long 0 0.--2. " VPIPWM8MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " MSP0WR "  "0 ,1 "
bitfld.long 0 4.--6. " SPARE0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " MSSINTMSK "  "0 ,1 "
bitfld.long 0 8.--12. " MDMTPDATSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " MDMTPCTL "  "0 ,1 "
bitfld.long 0 16. " SXAGPIO "  "0 ,1 "
bitfld.long 0 18.--21. " SBAGD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 22.--25. " SBAGT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 26. " HTIMEN "  "0 ,1 "
bitfld.long 0 28.--31. " MSSHOSTADDROFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c8004
;tree "CR_REG1"
group 0--3
line.long 0 "CR_REG1"
bitfld.long 0 0. " ICN_DEC_ERROR_ITMASK "  "0 ,1 "
bitfld.long 0 1. " ICN_DEC_ERROR_ITCLR "  "0 ,1 "
bitfld.long 0 10. " PRODTESTUICC_DP_OUT "  "0 ,1 "
bitfld.long 0 11. " PRODTESTUICC_DM_OUT "  "0 ,1 "
bitfld.long 0 12. " PRODTESTUICC_IOCTRL_OUT "  "0 ,1 "
bitfld.long 0 13.--31. " SPARE "  " "
;tree.end

base ad:0xa03c8008
;tree "CR_REG2"
group 0--3
line.long 0 "CR_REG2"
bitfld.long 0 0.--3. " KPSKA0MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " KPSKA1MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " KPSKA2MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " KPSKB0MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " KPSKB1MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " KPSKB2MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " KP08MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 27.--29. " KP09MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa03c800c
;tree "CR_REG3"
group 0--3
line.long 0 "CR_REG3"
bitfld.long 0 0.--1. " SVADMACH0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " SVADMACH1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--8. " SVADMACH2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 9.--13. " SVADMACH3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 14. " SVASMSP2SLIMINT "  "0 ,1 "
bitfld.long 0 16.--17. " SIADMACH0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " SIADMACH1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--24. " SIADMACH2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--29. " SIADMACH3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 30. " SIASMSP2SLIMINT "  "0 ,1 "
bitfld.long 0 31. " FSMCFBCLK "  "0 ,1 "
;tree.end

base ad:0xa03c8014
;tree "CR_REG5"
group 0--3
line.long 0 "CR_REG5"
bitfld.long 0 0.--9. " HSISLIM0RX "  " "
bitfld.long 0 10.--19. " HSISLIM0TX "  " "
bitfld.long 0 30. " MSP0SLIM0RX "  "0 ,1 "
bitfld.long 0 31. " MSP0SLIM0TX "  "0 ,1 "
;tree.end

base ad:0xa03c8018
;tree "SLIM_CFG"
group 0--3
line.long 0 "SLIM_CFG"
bitfld.long 0 0.--1. " CLK_LOADREG "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " CLK_BUSKEEP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--8. " CLK_VSAFEBUSKEEP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 9. " CLK_SLIMBUSMODE "  "0 ,1 "
bitfld.long 0 10.--11. " DATA_LOADREG "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " DATA_BUSKEEP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 15.--18. " DATA_VSAFEBUSKEEP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 19. " DATA_SLIMBUSMODE "  "0 ,1 "
bitfld.long 0 20.--26. " CALREQUEST "  " "
;tree.end

base ad:0xa03c801c
;tree "MCSBAG_CLKEN_CR"
group 0--3
line.long 0 "MCSBAG_CLKEN_CR"
bitfld.long 0 0. " PI_CLKGATE_EN "  "0 ,1 "
bitfld.long 0 1. " WPS_CLKGATE_EN "  "0 ,1 "
bitfld.long 0 2.--15. " TMS_CLKGATE_EN "  " "
;tree.end

base ad:0xa03c8020
;tree "CR_XDBG"
group 0--3
line.long 0 "CR_XDBG"
bitfld.long 0 0. " XDBGEN "  "0 ,1 "
bitfld.long 0 1. " EXTBRKEn "  "0 ,1 "
bitfld.long 0 2.--3. " XDBGMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--11. " XDBGSRC "  " "
bitfld.long 0 12.--19. " XDBGSTA "  " "
;tree.end

base ad:0xa03c8024
;tree "CR_XDBG_BRKINEN"
group 0--3
line.long 0 "CR_XDBG_BRKINEN"
hexfld.byte 0 " BRKINEN "
;tree.end

base ad:0xa03c8028
;tree "MCSBAG_CLKEN_TMS_STATUS"
rgroup 0--3
line.long 0 "MCSBAG_CLKEN_TMS_STATUS"
bitfld.long 0 0.--13. " CLKEN_TMS_STATUS "  " "
;tree.end

base ad:0xa03c802c
;tree "CR_USB"
group 0--3
line.long 0 "CR_USB"
bitfld.long 0 0. " XGATE "  "0 ,1 "
;tree.end

base ad:0xa03c8fe0
;tree "CRPeriphID0"
rgroup 0--3
line.long 0 "CRPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03c8fe4
;tree "CRPeriphID1"
rgroup 0--3
line.long 0 "CRPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c8fe8
;tree "CRPeriphID2"
rgroup 0--3
line.long 0 "CRPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c8fec
;tree "CRPeriphID3"
rgroup 0--3
line.long 0 "CRPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03c8ff0
;tree "CRPCellID0"
rgroup 0--3
line.long 0 "CRPCellID0"
hexfld.byte 0 " CRPCellID0 "
;tree.end

base ad:0xa03c8ff4
;tree "CRPCellID1"
rgroup 0--3
line.long 0 "CRPCellID1"
hexfld.byte 0 " CRPCellID1 "
;tree.end

base ad:0xa03c8ff8
;tree "CRPCellID2"
rgroup 0--3
line.long 0 "CRPCellID2"
hexfld.byte 0 " CRPCellID2 "
;tree.end

base ad:0xa03c8ffc
;tree "CRPCellID3"
rgroup 0--3
line.long 0 "CRPCellID3"
hexfld.byte 0 " CRPCellID3 "
;tree.end

tree.end

;==============================================================
tree "CRYP (2 instances)"
;==============================================================
base ad:0xa03ca000
;********************************************
tree "CRYP-0"
;********************************************
base ad:0xa03ca000
;tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGODIR "  "0 ,1 "
bitfld.long 0 3.--5. " ALGOMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--7. " DATATYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " KEYSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " KEYRDEN "  "0 ,1 "
bitfld.long 0 11. " KSE "  "0 ,1 "
bitfld.long 0 12. " START "  "0 ,1 "
bitfld.long 0 13. " INIT "  "0 ,1 "
bitfld.long 0 14. " FFLUSH "  "0 ,1 "
bitfld.long 0 15. " CRYPEN "  "0 ,1 "
bitfld.long 0 16. " SECONDLAST "  "0 ,1 "
bitfld.long 0 20. " ENS "  "0 ,1 "
bitfld.long 0 24. " KEYLOCK "  "0 ,1 "
;tree.end

base ad:0xa03ca004
;tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " IFEM "  "0 ,1 "
bitfld.long 0 1. " IFNF "  "0 ,1 "
bitfld.long 0 2. " OFNE "  "0 ,1 "
bitfld.long 0 3. " OFFU "  "0 ,1 "
bitfld.long 0 4. " BUSY "  "0 ,1 "
;tree.end

base ad:0xa03ca008
;tree "0DIN"
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa03ca00c
;tree "0DINSIZE"
group 0--3
line.long 0 "DINSIZE"
bitfld.long 0 0.--3. " DINSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03ca010
;tree "0DOUT"
rgroup 0--3
line.long 0 "DOUT"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa03ca014
;tree "0DOUTSIZE"
rgroup 0--3
line.long 0 "DOUTSIZE"
bitfld.long 0 0.--3. " DOUTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03ca018
;tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " DMAINEN "  "0 ,1 "
bitfld.long 0 1. " DMAOUTEN "  "0 ,1 "
;tree.end

base ad:0xa03ca01c
;tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " INIM "  "0 ,1 "
bitfld.long 0 1. " OUTIM "  "0 ,1 "
;tree.end

base ad:0xa03ca020
;tree "0RIS"
group 0--3
line.long 0 "RIS"
bitfld.long 0 0. " INRIS "  "0 ,1 "
bitfld.long 0 1. " OUTRIS "  "0 ,1 "
;tree.end

base ad:0xa03ca024
;tree "0MIS"
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " INMIS "  "0 ,1 "
bitfld.long 0 1. " OUTMIS "  "0 ,1 "
;tree.end

base ad:0xa03ca028
;tree "0K1L"
group 0--3
line.long 0 "K1L"
bitfld.long 0 0. " K31 "  "0 ,1 "
bitfld.long 0 1. " K30 "  "0 ,1 "
bitfld.long 0 2. " K29 "  "0 ,1 "
bitfld.long 0 3. " K28 "  "0 ,1 "
bitfld.long 0 4. " K27 "  "0 ,1 "
bitfld.long 0 5. " K26 "  "0 ,1 "
bitfld.long 0 6. " K25 "  "0 ,1 "
bitfld.long 0 7. " K24 "  "0 ,1 "
bitfld.long 0 8. " K23 "  "0 ,1 "
bitfld.long 0 9. " K22 "  "0 ,1 "
bitfld.long 0 10. " K21 "  "0 ,1 "
bitfld.long 0 11. " K20 "  "0 ,1 "
bitfld.long 0 12. " K19 "  "0 ,1 "
bitfld.long 0 13. " K18 "  "0 ,1 "
bitfld.long 0 14. " K17 "  "0 ,1 "
bitfld.long 0 15. " K16 "  "0 ,1 "
bitfld.long 0 16. " K15 "  "0 ,1 "
bitfld.long 0 17. " K14 "  "0 ,1 "
bitfld.long 0 18. " K13 "  "0 ,1 "
bitfld.long 0 19. " K12 "  "0 ,1 "
bitfld.long 0 20. " K11 "  "0 ,1 "
bitfld.long 0 21. " K10 "  "0 ,1 "
bitfld.long 0 22. " K9 "  "0 ,1 "
bitfld.long 0 23. " K8 "  "0 ,1 "
bitfld.long 0 24. " K7 "  "0 ,1 "
bitfld.long 0 25. " K6 "  "0 ,1 "
bitfld.long 0 26. " K5 "  "0 ,1 "
bitfld.long 0 27. " K4 "  "0 ,1 "
bitfld.long 0 28. " K3 "  "0 ,1 "
bitfld.long 0 29. " K2 "  "0 ,1 "
bitfld.long 0 30. " K1 "  "0 ,1 "
bitfld.long 0 31. " K0 "  "0 ,1 "
;tree.end

base ad:0xa03ca02c
;tree "0K1R"
group 0--3
line.long 0 "K1R"
bitfld.long 0 0. " K63 "  "0 ,1 "
bitfld.long 0 1. " K62 "  "0 ,1 "
bitfld.long 0 2. " K61 "  "0 ,1 "
bitfld.long 0 3. " K60 "  "0 ,1 "
bitfld.long 0 4. " K59 "  "0 ,1 "
bitfld.long 0 5. " K58 "  "0 ,1 "
bitfld.long 0 6. " K57 "  "0 ,1 "
bitfld.long 0 7. " K56 "  "0 ,1 "
bitfld.long 0 8. " K55 "  "0 ,1 "
bitfld.long 0 9. " K54 "  "0 ,1 "
bitfld.long 0 10. " K53 "  "0 ,1 "
bitfld.long 0 11. " K52 "  "0 ,1 "
bitfld.long 0 12. " K51 "  "0 ,1 "
bitfld.long 0 13. " K50 "  "0 ,1 "
bitfld.long 0 14. " K49 "  "0 ,1 "
bitfld.long 0 15. " K48 "  "0 ,1 "
bitfld.long 0 16. " K47 "  "0 ,1 "
bitfld.long 0 17. " K46 "  "0 ,1 "
bitfld.long 0 18. " K45 "  "0 ,1 "
bitfld.long 0 19. " K44 "  "0 ,1 "
bitfld.long 0 20. " K43 "  "0 ,1 "
bitfld.long 0 21. " K42 "  "0 ,1 "
bitfld.long 0 22. " K41 "  "0 ,1 "
bitfld.long 0 23. " K40 "  "0 ,1 "
bitfld.long 0 24. " K39 "  "0 ,1 "
bitfld.long 0 25. " K38 "  "0 ,1 "
bitfld.long 0 26. " K37 "  "0 ,1 "
bitfld.long 0 27. " K36 "  "0 ,1 "
bitfld.long 0 28. " K35 "  "0 ,1 "
bitfld.long 0 29. " K34 "  "0 ,1 "
bitfld.long 0 30. " K33 "  "0 ,1 "
bitfld.long 0 31. " K32 "  "0 ,1 "
;tree.end

base ad:0xa03ca030
;tree "0K2L"
group 0--3
line.long 0 "K2L"
bitfld.long 0 0. " K95 "  "0 ,1 "
bitfld.long 0 1. " K94 "  "0 ,1 "
bitfld.long 0 2. " K93 "  "0 ,1 "
bitfld.long 0 3. " K92 "  "0 ,1 "
bitfld.long 0 4. " K91 "  "0 ,1 "
bitfld.long 0 5. " K90 "  "0 ,1 "
bitfld.long 0 6. " K89 "  "0 ,1 "
bitfld.long 0 7. " K88 "  "0 ,1 "
bitfld.long 0 8. " K87 "  "0 ,1 "
bitfld.long 0 9. " K86 "  "0 ,1 "
bitfld.long 0 10. " K85 "  "0 ,1 "
bitfld.long 0 11. " K84 "  "0 ,1 "
bitfld.long 0 12. " K83 "  "0 ,1 "
bitfld.long 0 13. " K82 "  "0 ,1 "
bitfld.long 0 14. " K81 "  "0 ,1 "
bitfld.long 0 15. " K80 "  "0 ,1 "
bitfld.long 0 16. " K79 "  "0 ,1 "
bitfld.long 0 17. " K78 "  "0 ,1 "
bitfld.long 0 18. " K77 "  "0 ,1 "
bitfld.long 0 19. " K76 "  "0 ,1 "
bitfld.long 0 20. " K75 "  "0 ,1 "
bitfld.long 0 21. " K74 "  "0 ,1 "
bitfld.long 0 22. " K73 "  "0 ,1 "
bitfld.long 0 23. " K72 "  "0 ,1 "
bitfld.long 0 24. " K71 "  "0 ,1 "
bitfld.long 0 25. " K70 "  "0 ,1 "
bitfld.long 0 26. " K69 "  "0 ,1 "
bitfld.long 0 27. " K68 "  "0 ,1 "
bitfld.long 0 28. " K67 "  "0 ,1 "
bitfld.long 0 29. " K66 "  "0 ,1 "
bitfld.long 0 30. " K65 "  "0 ,1 "
bitfld.long 0 31. " K64 "  "0 ,1 "
;tree.end

base ad:0xa03ca034
;tree "0K2R"
group 0--3
line.long 0 "K2R"
bitfld.long 0 0. " K127 "  "0 ,1 "
bitfld.long 0 1. " K126 "  "0 ,1 "
bitfld.long 0 2. " K125 "  "0 ,1 "
bitfld.long 0 3. " K124 "  "0 ,1 "
bitfld.long 0 4. " K123 "  "0 ,1 "
bitfld.long 0 5. " K122 "  "0 ,1 "
bitfld.long 0 6. " K121 "  "0 ,1 "
bitfld.long 0 7. " K120 "  "0 ,1 "
bitfld.long 0 8. " K119 "  "0 ,1 "
bitfld.long 0 9. " K118 "  "0 ,1 "
bitfld.long 0 10. " K117 "  "0 ,1 "
bitfld.long 0 11. " K116 "  "0 ,1 "
bitfld.long 0 12. " K115 "  "0 ,1 "
bitfld.long 0 13. " K114 "  "0 ,1 "
bitfld.long 0 14. " K113 "  "0 ,1 "
bitfld.long 0 15. " K112 "  "0 ,1 "
bitfld.long 0 16. " K111 "  "0 ,1 "
bitfld.long 0 17. " K110 "  "0 ,1 "
bitfld.long 0 18. " K109 "  "0 ,1 "
bitfld.long 0 19. " K108 "  "0 ,1 "
bitfld.long 0 20. " K107 "  "0 ,1 "
bitfld.long 0 21. " K106 "  "0 ,1 "
bitfld.long 0 22. " K105 "  "0 ,1 "
bitfld.long 0 23. " K104 "  "0 ,1 "
bitfld.long 0 24. " K103 "  "0 ,1 "
bitfld.long 0 25. " K102 "  "0 ,1 "
bitfld.long 0 26. " K101 "  "0 ,1 "
bitfld.long 0 27. " K100 "  "0 ,1 "
bitfld.long 0 28. " K99 "  "0 ,1 "
bitfld.long 0 29. " K98 "  "0 ,1 "
bitfld.long 0 30. " K97 "  "0 ,1 "
bitfld.long 0 31. " K96 "  "0 ,1 "
;tree.end

base ad:0xa03ca038
;tree "0K3L"
group 0--3
line.long 0 "K3L"
bitfld.long 0 0. " K159 "  "0 ,1 "
bitfld.long 0 1. " K158 "  "0 ,1 "
bitfld.long 0 2. " K157 "  "0 ,1 "
bitfld.long 0 3. " K156 "  "0 ,1 "
bitfld.long 0 4. " K155 "  "0 ,1 "
bitfld.long 0 5. " K154 "  "0 ,1 "
bitfld.long 0 6. " K153 "  "0 ,1 "
bitfld.long 0 7. " K152 "  "0 ,1 "
bitfld.long 0 8. " K151 "  "0 ,1 "
bitfld.long 0 9. " K150 "  "0 ,1 "
bitfld.long 0 10. " K149 "  "0 ,1 "
bitfld.long 0 11. " K148 "  "0 ,1 "
bitfld.long 0 12. " K147 "  "0 ,1 "
bitfld.long 0 13. " K146 "  "0 ,1 "
bitfld.long 0 14. " K145 "  "0 ,1 "
bitfld.long 0 15. " K144 "  "0 ,1 "
bitfld.long 0 16. " K143 "  "0 ,1 "
bitfld.long 0 17. " K142 "  "0 ,1 "
bitfld.long 0 18. " K141 "  "0 ,1 "
bitfld.long 0 19. " K140 "  "0 ,1 "
bitfld.long 0 20. " K139 "  "0 ,1 "
bitfld.long 0 21. " K138 "  "0 ,1 "
bitfld.long 0 22. " K137 "  "0 ,1 "
bitfld.long 0 23. " K136 "  "0 ,1 "
bitfld.long 0 24. " K135 "  "0 ,1 "
bitfld.long 0 25. " K134 "  "0 ,1 "
bitfld.long 0 26. " K133 "  "0 ,1 "
bitfld.long 0 27. " K132 "  "0 ,1 "
bitfld.long 0 28. " K131 "  "0 ,1 "
bitfld.long 0 29. " K130 "  "0 ,1 "
bitfld.long 0 30. " K129 "  "0 ,1 "
bitfld.long 0 31. " K128 "  "0 ,1 "
;tree.end

base ad:0xa03ca03c
;tree "0K3R"
group 0--3
line.long 0 "K3R"
bitfld.long 0 0. " K191 "  "0 ,1 "
bitfld.long 0 1. " K190 "  "0 ,1 "
bitfld.long 0 2. " K189 "  "0 ,1 "
bitfld.long 0 3. " K188 "  "0 ,1 "
bitfld.long 0 4. " K187 "  "0 ,1 "
bitfld.long 0 5. " K186 "  "0 ,1 "
bitfld.long 0 6. " K185 "  "0 ,1 "
bitfld.long 0 7. " K184 "  "0 ,1 "
bitfld.long 0 8. " K183 "  "0 ,1 "
bitfld.long 0 9. " K182 "  "0 ,1 "
bitfld.long 0 10. " K181 "  "0 ,1 "
bitfld.long 0 11. " K180 "  "0 ,1 "
bitfld.long 0 12. " K179 "  "0 ,1 "
bitfld.long 0 13. " K178 "  "0 ,1 "
bitfld.long 0 14. " K177 "  "0 ,1 "
bitfld.long 0 15. " K176 "  "0 ,1 "
bitfld.long 0 16. " K175 "  "0 ,1 "
bitfld.long 0 17. " K174 "  "0 ,1 "
bitfld.long 0 18. " K173 "  "0 ,1 "
bitfld.long 0 19. " K172 "  "0 ,1 "
bitfld.long 0 20. " K171 "  "0 ,1 "
bitfld.long 0 21. " K170 "  "0 ,1 "
bitfld.long 0 22. " K169 "  "0 ,1 "
bitfld.long 0 23. " K168 "  "0 ,1 "
bitfld.long 0 24. " K167 "  "0 ,1 "
bitfld.long 0 25. " K166 "  "0 ,1 "
bitfld.long 0 26. " K165 "  "0 ,1 "
bitfld.long 0 27. " K164 "  "0 ,1 "
bitfld.long 0 28. " K163 "  "0 ,1 "
bitfld.long 0 29. " K162 "  "0 ,1 "
bitfld.long 0 30. " K161 "  "0 ,1 "
bitfld.long 0 31. " K160 "  "0 ,1 "
;tree.end

base ad:0xa03ca040
;tree "0K4L"
group 0--3
line.long 0 "K4L"
bitfld.long 0 0. " K223 "  "0 ,1 "
bitfld.long 0 1. " K222 "  "0 ,1 "
bitfld.long 0 2. " K221 "  "0 ,1 "
bitfld.long 0 3. " K220 "  "0 ,1 "
bitfld.long 0 4. " K219 "  "0 ,1 "
bitfld.long 0 5. " K218 "  "0 ,1 "
bitfld.long 0 6. " K217 "  "0 ,1 "
bitfld.long 0 7. " K216 "  "0 ,1 "
bitfld.long 0 8. " K215 "  "0 ,1 "
bitfld.long 0 9. " K214 "  "0 ,1 "
bitfld.long 0 10. " K213 "  "0 ,1 "
bitfld.long 0 11. " K212 "  "0 ,1 "
bitfld.long 0 12. " K211 "  "0 ,1 "
bitfld.long 0 13. " K210 "  "0 ,1 "
bitfld.long 0 14. " K209 "  "0 ,1 "
bitfld.long 0 15. " K208 "  "0 ,1 "
bitfld.long 0 16. " K207 "  "0 ,1 "
bitfld.long 0 17. " K206 "  "0 ,1 "
bitfld.long 0 18. " K205 "  "0 ,1 "
bitfld.long 0 19. " K204 "  "0 ,1 "
bitfld.long 0 20. " K203 "  "0 ,1 "
bitfld.long 0 21. " K202 "  "0 ,1 "
bitfld.long 0 22. " K201 "  "0 ,1 "
bitfld.long 0 23. " K200 "  "0 ,1 "
bitfld.long 0 24. " K199 "  "0 ,1 "
bitfld.long 0 25. " K198 "  "0 ,1 "
bitfld.long 0 26. " K197 "  "0 ,1 "
bitfld.long 0 27. " K196 "  "0 ,1 "
bitfld.long 0 28. " K195 "  "0 ,1 "
bitfld.long 0 29. " K194 "  "0 ,1 "
bitfld.long 0 30. " K193 "  "0 ,1 "
bitfld.long 0 31. " K192 "  "0 ,1 "
;tree.end

base ad:0xa03ca044
;tree "0K4R"
group 0--3
line.long 0 "K4R"
bitfld.long 0 0. " K255 "  "0 ,1 "
bitfld.long 0 1. " K254 "  "0 ,1 "
bitfld.long 0 2. " K253 "  "0 ,1 "
bitfld.long 0 3. " K252 "  "0 ,1 "
bitfld.long 0 4. " K251 "  "0 ,1 "
bitfld.long 0 5. " K250 "  "0 ,1 "
bitfld.long 0 6. " K249 "  "0 ,1 "
bitfld.long 0 7. " K248 "  "0 ,1 "
bitfld.long 0 8. " K247 "  "0 ,1 "
bitfld.long 0 9. " K246 "  "0 ,1 "
bitfld.long 0 10. " K245 "  "0 ,1 "
bitfld.long 0 11. " K244 "  "0 ,1 "
bitfld.long 0 12. " K243 "  "0 ,1 "
bitfld.long 0 13. " K242 "  "0 ,1 "
bitfld.long 0 14. " K241 "  "0 ,1 "
bitfld.long 0 15. " K240 "  "0 ,1 "
bitfld.long 0 16. " K239 "  "0 ,1 "
bitfld.long 0 17. " K238 "  "0 ,1 "
bitfld.long 0 18. " K237 "  "0 ,1 "
bitfld.long 0 19. " K236 "  "0 ,1 "
bitfld.long 0 20. " K235 "  "0 ,1 "
bitfld.long 0 21. " K234 "  "0 ,1 "
bitfld.long 0 22. " K233 "  "0 ,1 "
bitfld.long 0 23. " K232 "  "0 ,1 "
bitfld.long 0 24. " K231 "  "0 ,1 "
bitfld.long 0 25. " K230 "  "0 ,1 "
bitfld.long 0 26. " K229 "  "0 ,1 "
bitfld.long 0 27. " K228 "  "0 ,1 "
bitfld.long 0 28. " K227 "  "0 ,1 "
bitfld.long 0 29. " K226 "  "0 ,1 "
bitfld.long 0 30. " K225 "  "0 ,1 "
bitfld.long 0 31. " K224 "  "0 ,1 "
;tree.end

base ad:0xa03ca048
;tree "0IV0L"
group 0--3
line.long 0 "IV0L"
bitfld.long 0 0. " IV32 "  "0 ,1 "
bitfld.long 0 1. " IV31 "  "0 ,1 "
bitfld.long 0 2. " IV30 "  "0 ,1 "
bitfld.long 0 3. " IV29 "  "0 ,1 "
bitfld.long 0 4. " IV28 "  "0 ,1 "
bitfld.long 0 5. " IV27 "  "0 ,1 "
bitfld.long 0 6. " IV26 "  "0 ,1 "
bitfld.long 0 7. " IV25 "  "0 ,1 "
bitfld.long 0 8. " IV24 "  "0 ,1 "
bitfld.long 0 9. " IV23 "  "0 ,1 "
bitfld.long 0 10. " IV22 "  "0 ,1 "
bitfld.long 0 11. " IV21 "  "0 ,1 "
bitfld.long 0 12. " IV20 "  "0 ,1 "
bitfld.long 0 13. " IV19 "  "0 ,1 "
bitfld.long 0 14. " IV18 "  "0 ,1 "
bitfld.long 0 15. " IV17 "  "0 ,1 "
bitfld.long 0 16. " IV16 "  "0 ,1 "
bitfld.long 0 17. " IV15 "  "0 ,1 "
bitfld.long 0 18. " IV14 "  "0 ,1 "
bitfld.long 0 19. " IV13 "  "0 ,1 "
bitfld.long 0 20. " IV12 "  "0 ,1 "
bitfld.long 0 21. " IV11 "  "0 ,1 "
bitfld.long 0 22. " IV10 "  "0 ,1 "
bitfld.long 0 23. " IV9 "  "0 ,1 "
bitfld.long 0 24. " IV8 "  "0 ,1 "
bitfld.long 0 25. " IV7 "  "0 ,1 "
bitfld.long 0 26. " IV6 "  "0 ,1 "
bitfld.long 0 27. " IV5 "  "0 ,1 "
bitfld.long 0 28. " IV4 "  "0 ,1 "
bitfld.long 0 29. " IV3 "  "0 ,1 "
bitfld.long 0 30. " IV2 "  "0 ,1 "
bitfld.long 0 31. " IV1 "  "0 ,1 "
;tree.end

base ad:0xa03ca04c
;tree "0IV0R"
group 0--3
line.long 0 "IV0R"
bitfld.long 0 0. " IV64 "  "0 ,1 "
bitfld.long 0 1. " IV63 "  "0 ,1 "
bitfld.long 0 2. " IV62 "  "0 ,1 "
bitfld.long 0 3. " IV61 "  "0 ,1 "
bitfld.long 0 4. " IV60 "  "0 ,1 "
bitfld.long 0 5. " IV59 "  "0 ,1 "
bitfld.long 0 6. " IV58 "  "0 ,1 "
bitfld.long 0 7. " IV57 "  "0 ,1 "
bitfld.long 0 8. " IV56 "  "0 ,1 "
bitfld.long 0 9. " IV55 "  "0 ,1 "
bitfld.long 0 10. " IV54 "  "0 ,1 "
bitfld.long 0 11. " IV53 "  "0 ,1 "
bitfld.long 0 12. " IV52 "  "0 ,1 "
bitfld.long 0 13. " IV51 "  "0 ,1 "
bitfld.long 0 14. " IV50 "  "0 ,1 "
bitfld.long 0 15. " IV49 "  "0 ,1 "
bitfld.long 0 16. " IV48 "  "0 ,1 "
bitfld.long 0 17. " IV47 "  "0 ,1 "
bitfld.long 0 18. " IV46 "  "0 ,1 "
bitfld.long 0 19. " IV45 "  "0 ,1 "
bitfld.long 0 20. " IV44 "  "0 ,1 "
bitfld.long 0 21. " IV43 "  "0 ,1 "
bitfld.long 0 22. " IV42 "  "0 ,1 "
bitfld.long 0 23. " IV41 "  "0 ,1 "
bitfld.long 0 24. " IV40 "  "0 ,1 "
bitfld.long 0 25. " IV39 "  "0 ,1 "
bitfld.long 0 26. " IV38 "  "0 ,1 "
bitfld.long 0 27. " IV37 "  "0 ,1 "
bitfld.long 0 28. " IV36 "  "0 ,1 "
bitfld.long 0 29. " IV35 "  "0 ,1 "
bitfld.long 0 30. " IV34 "  "0 ,1 "
bitfld.long 0 31. " IV33 "  "0 ,1 "
;tree.end

base ad:0xa03ca050
;tree "0IV1L"
group 0--3
line.long 0 "IV1L"
bitfld.long 0 0. " IV96 "  "0 ,1 "
bitfld.long 0 1. " IV95 "  "0 ,1 "
bitfld.long 0 2. " IV94 "  "0 ,1 "
bitfld.long 0 3. " IV93 "  "0 ,1 "
bitfld.long 0 4. " IV92 "  "0 ,1 "
bitfld.long 0 5. " IV91 "  "0 ,1 "
bitfld.long 0 6. " IV90 "  "0 ,1 "
bitfld.long 0 7. " IV89 "  "0 ,1 "
bitfld.long 0 8. " IV88 "  "0 ,1 "
bitfld.long 0 9. " IV87 "  "0 ,1 "
bitfld.long 0 10. " IV86 "  "0 ,1 "
bitfld.long 0 11. " IV85 "  "0 ,1 "
bitfld.long 0 12. " IV84 "  "0 ,1 "
bitfld.long 0 13. " IV83 "  "0 ,1 "
bitfld.long 0 14. " IV82 "  "0 ,1 "
bitfld.long 0 15. " IV81 "  "0 ,1 "
bitfld.long 0 16. " IV80 "  "0 ,1 "
bitfld.long 0 17. " IV79 "  "0 ,1 "
bitfld.long 0 18. " IV78 "  "0 ,1 "
bitfld.long 0 19. " IV77 "  "0 ,1 "
bitfld.long 0 20. " IV76 "  "0 ,1 "
bitfld.long 0 21. " IV75 "  "0 ,1 "
bitfld.long 0 22. " IV74 "  "0 ,1 "
bitfld.long 0 23. " IV73 "  "0 ,1 "
bitfld.long 0 24. " IV72 "  "0 ,1 "
bitfld.long 0 25. " IV71 "  "0 ,1 "
bitfld.long 0 26. " IV70 "  "0 ,1 "
bitfld.long 0 27. " IV69 "  "0 ,1 "
bitfld.long 0 28. " IV68 "  "0 ,1 "
bitfld.long 0 29. " IV67 "  "0 ,1 "
bitfld.long 0 30. " IV66 "  "0 ,1 "
bitfld.long 0 31. " IV65 "  "0 ,1 "
;tree.end

base ad:0xa03ca054
;tree "0IV1R"
group 0--3
line.long 0 "IV1R"
bitfld.long 0 0. " IV128 "  "0 ,1 "
bitfld.long 0 1. " IV127 "  "0 ,1 "
bitfld.long 0 2. " IV126 "  "0 ,1 "
bitfld.long 0 3. " IV125 "  "0 ,1 "
bitfld.long 0 4. " IV124 "  "0 ,1 "
bitfld.long 0 5. " IV123 "  "0 ,1 "
bitfld.long 0 6. " IV122 "  "0 ,1 "
bitfld.long 0 7. " IV121 "  "0 ,1 "
bitfld.long 0 8. " IV120 "  "0 ,1 "
bitfld.long 0 9. " IV119 "  "0 ,1 "
bitfld.long 0 10. " IV118 "  "0 ,1 "
bitfld.long 0 11. " IV117 "  "0 ,1 "
bitfld.long 0 12. " IV116 "  "0 ,1 "
bitfld.long 0 13. " IV115 "  "0 ,1 "
bitfld.long 0 14. " IV114 "  "0 ,1 "
bitfld.long 0 15. " IV113 "  "0 ,1 "
bitfld.long 0 16. " IV112 "  "0 ,1 "
bitfld.long 0 17. " IV111 "  "0 ,1 "
bitfld.long 0 18. " IV110 "  "0 ,1 "
bitfld.long 0 19. " IV109 "  "0 ,1 "
bitfld.long 0 20. " IV108 "  "0 ,1 "
bitfld.long 0 21. " IV107 "  "0 ,1 "
bitfld.long 0 22. " IV106 "  "0 ,1 "
bitfld.long 0 23. " IV105 "  "0 ,1 "
bitfld.long 0 24. " IV104 "  "0 ,1 "
bitfld.long 0 25. " IV103 "  "0 ,1 "
bitfld.long 0 26. " IV102 "  "0 ,1 "
bitfld.long 0 27. " IV101 "  "0 ,1 "
bitfld.long 0 28. " IV100 "  "0 ,1 "
bitfld.long 0 29. " IV99 "  "0 ,1 "
bitfld.long 0 30. " IV98 "  "0 ,1 "
bitfld.long 0 31. " IV97 "  "0 ,1 "
;tree.end

base ad:0xa03ca080
;tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0xa03ca084
;tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMAIUTC "  "0 ,1 "
bitfld.long 0 1. " DMAOUTC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
;tree.end

base ad:0xa03ca088
;tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMAINBREQ "  "0 ,1 "
bitfld.long 0 1. " DMAOUTBREQ "  "0 ,1 "
bitfld.long 0 2. " DMAOUTSREQ "  "0 ,1 "
bitfld.long 0 3. " ININTR "  "0 ,1 "
bitfld.long 0 4. " OUTINTR "  "0 ,1 "
;tree.end

base ad:0xa03cafe0
;tree "0CRYPPeriphID0"
rgroup 0--3
line.long 0 "CRYPPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03cafe4
;tree "0CRYPPeriphID1"
rgroup 0--3
line.long 0 "CRYPPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cafe8
;tree "0CRYPPeriphID2"
rgroup 0--3
line.long 0 "CRYPPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cafec
;tree "0CRYPPeriphID3"
rgroup 0--3
line.long 0 "CRYPPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03caff0
;tree "0CRYPPCellID0"
rgroup 0--3
line.long 0 "CRYPPCellID0"
hexfld.byte 0 " CRYPPCellID0 "
;tree.end

base ad:0xa03caff4
;tree "0CRYPPCellID1"
rgroup 0--3
line.long 0 "CRYPPCellID1"
hexfld.byte 0 " CRYPPCellID1 "
;tree.end

base ad:0xa03caff8
;tree "0CRYPPCellID2"
rgroup 0--3
line.long 0 "CRYPPCellID2"
hexfld.byte 0 " CRYPPCellID2 "
;tree.end

base ad:0xa03caffc
;tree "0CRYPPCellID3"
rgroup 0--3
line.long 0 "CRYPPCellID3"
hexfld.byte 0 " CRYPPCellID3 "
;tree.end

tree.end

base ad:0xa03cb000
;********************************************
tree "CRYP-1"
;********************************************
base ad:0xa03cb000
;tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGODIR "  "0 ,1 "
bitfld.long 0 3.--5. " ALGOMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--7. " DATATYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " KEYSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " KEYRDEN "  "0 ,1 "
bitfld.long 0 11. " KSE "  "0 ,1 "
bitfld.long 0 12. " START "  "0 ,1 "
bitfld.long 0 13. " INIT "  "0 ,1 "
bitfld.long 0 14. " FFLUSH "  "0 ,1 "
bitfld.long 0 15. " CRYPEN "  "0 ,1 "
bitfld.long 0 16. " SECONDLAST "  "0 ,1 "
bitfld.long 0 20. " ENS "  "0 ,1 "
bitfld.long 0 24. " KEYLOCK "  "0 ,1 "
;tree.end

base ad:0xa03cb004
;tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " IFEM "  "0 ,1 "
bitfld.long 0 1. " IFNF "  "0 ,1 "
bitfld.long 0 2. " OFNE "  "0 ,1 "
bitfld.long 0 3. " OFFU "  "0 ,1 "
bitfld.long 0 4. " BUSY "  "0 ,1 "
;tree.end

base ad:0xa03cb008
;tree "1DIN"
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa03cb00c
;tree "1DINSIZE"
group 0--3
line.long 0 "DINSIZE"
bitfld.long 0 0.--3. " DINSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cb010
;tree "1DOUT"
rgroup 0--3
line.long 0 "DOUT"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa03cb014
;tree "1DOUTSIZE"
rgroup 0--3
line.long 0 "DOUTSIZE"
bitfld.long 0 0.--3. " DOUTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cb018
;tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " DMAINEN "  "0 ,1 "
bitfld.long 0 1. " DMAOUTEN "  "0 ,1 "
;tree.end

base ad:0xa03cb01c
;tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " INIM "  "0 ,1 "
bitfld.long 0 1. " OUTIM "  "0 ,1 "
;tree.end

base ad:0xa03cb020
;tree "1RIS"
group 0--3
line.long 0 "RIS"
bitfld.long 0 0. " INRIS "  "0 ,1 "
bitfld.long 0 1. " OUTRIS "  "0 ,1 "
;tree.end

base ad:0xa03cb024
;tree "1MIS"
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " INMIS "  "0 ,1 "
bitfld.long 0 1. " OUTMIS "  "0 ,1 "
;tree.end

base ad:0xa03cb028
;tree "1K1L"
group 0--3
line.long 0 "K1L"
bitfld.long 0 0. " K31 "  "0 ,1 "
bitfld.long 0 1. " K30 "  "0 ,1 "
bitfld.long 0 2. " K29 "  "0 ,1 "
bitfld.long 0 3. " K28 "  "0 ,1 "
bitfld.long 0 4. " K27 "  "0 ,1 "
bitfld.long 0 5. " K26 "  "0 ,1 "
bitfld.long 0 6. " K25 "  "0 ,1 "
bitfld.long 0 7. " K24 "  "0 ,1 "
bitfld.long 0 8. " K23 "  "0 ,1 "
bitfld.long 0 9. " K22 "  "0 ,1 "
bitfld.long 0 10. " K21 "  "0 ,1 "
bitfld.long 0 11. " K20 "  "0 ,1 "
bitfld.long 0 12. " K19 "  "0 ,1 "
bitfld.long 0 13. " K18 "  "0 ,1 "
bitfld.long 0 14. " K17 "  "0 ,1 "
bitfld.long 0 15. " K16 "  "0 ,1 "
bitfld.long 0 16. " K15 "  "0 ,1 "
bitfld.long 0 17. " K14 "  "0 ,1 "
bitfld.long 0 18. " K13 "  "0 ,1 "
bitfld.long 0 19. " K12 "  "0 ,1 "
bitfld.long 0 20. " K11 "  "0 ,1 "
bitfld.long 0 21. " K10 "  "0 ,1 "
bitfld.long 0 22. " K9 "  "0 ,1 "
bitfld.long 0 23. " K8 "  "0 ,1 "
bitfld.long 0 24. " K7 "  "0 ,1 "
bitfld.long 0 25. " K6 "  "0 ,1 "
bitfld.long 0 26. " K5 "  "0 ,1 "
bitfld.long 0 27. " K4 "  "0 ,1 "
bitfld.long 0 28. " K3 "  "0 ,1 "
bitfld.long 0 29. " K2 "  "0 ,1 "
bitfld.long 0 30. " K1 "  "0 ,1 "
bitfld.long 0 31. " K0 "  "0 ,1 "
;tree.end

base ad:0xa03cb02c
;tree "1K1R"
group 0--3
line.long 0 "K1R"
bitfld.long 0 0. " K63 "  "0 ,1 "
bitfld.long 0 1. " K62 "  "0 ,1 "
bitfld.long 0 2. " K61 "  "0 ,1 "
bitfld.long 0 3. " K60 "  "0 ,1 "
bitfld.long 0 4. " K59 "  "0 ,1 "
bitfld.long 0 5. " K58 "  "0 ,1 "
bitfld.long 0 6. " K57 "  "0 ,1 "
bitfld.long 0 7. " K56 "  "0 ,1 "
bitfld.long 0 8. " K55 "  "0 ,1 "
bitfld.long 0 9. " K54 "  "0 ,1 "
bitfld.long 0 10. " K53 "  "0 ,1 "
bitfld.long 0 11. " K52 "  "0 ,1 "
bitfld.long 0 12. " K51 "  "0 ,1 "
bitfld.long 0 13. " K50 "  "0 ,1 "
bitfld.long 0 14. " K49 "  "0 ,1 "
bitfld.long 0 15. " K48 "  "0 ,1 "
bitfld.long 0 16. " K47 "  "0 ,1 "
bitfld.long 0 17. " K46 "  "0 ,1 "
bitfld.long 0 18. " K45 "  "0 ,1 "
bitfld.long 0 19. " K44 "  "0 ,1 "
bitfld.long 0 20. " K43 "  "0 ,1 "
bitfld.long 0 21. " K42 "  "0 ,1 "
bitfld.long 0 22. " K41 "  "0 ,1 "
bitfld.long 0 23. " K40 "  "0 ,1 "
bitfld.long 0 24. " K39 "  "0 ,1 "
bitfld.long 0 25. " K38 "  "0 ,1 "
bitfld.long 0 26. " K37 "  "0 ,1 "
bitfld.long 0 27. " K36 "  "0 ,1 "
bitfld.long 0 28. " K35 "  "0 ,1 "
bitfld.long 0 29. " K34 "  "0 ,1 "
bitfld.long 0 30. " K33 "  "0 ,1 "
bitfld.long 0 31. " K32 "  "0 ,1 "
;tree.end

base ad:0xa03cb030
;tree "1K2L"
group 0--3
line.long 0 "K2L"
bitfld.long 0 0. " K95 "  "0 ,1 "
bitfld.long 0 1. " K94 "  "0 ,1 "
bitfld.long 0 2. " K93 "  "0 ,1 "
bitfld.long 0 3. " K92 "  "0 ,1 "
bitfld.long 0 4. " K91 "  "0 ,1 "
bitfld.long 0 5. " K90 "  "0 ,1 "
bitfld.long 0 6. " K89 "  "0 ,1 "
bitfld.long 0 7. " K88 "  "0 ,1 "
bitfld.long 0 8. " K87 "  "0 ,1 "
bitfld.long 0 9. " K86 "  "0 ,1 "
bitfld.long 0 10. " K85 "  "0 ,1 "
bitfld.long 0 11. " K84 "  "0 ,1 "
bitfld.long 0 12. " K83 "  "0 ,1 "
bitfld.long 0 13. " K82 "  "0 ,1 "
bitfld.long 0 14. " K81 "  "0 ,1 "
bitfld.long 0 15. " K80 "  "0 ,1 "
bitfld.long 0 16. " K79 "  "0 ,1 "
bitfld.long 0 17. " K78 "  "0 ,1 "
bitfld.long 0 18. " K77 "  "0 ,1 "
bitfld.long 0 19. " K76 "  "0 ,1 "
bitfld.long 0 20. " K75 "  "0 ,1 "
bitfld.long 0 21. " K74 "  "0 ,1 "
bitfld.long 0 22. " K73 "  "0 ,1 "
bitfld.long 0 23. " K72 "  "0 ,1 "
bitfld.long 0 24. " K71 "  "0 ,1 "
bitfld.long 0 25. " K70 "  "0 ,1 "
bitfld.long 0 26. " K69 "  "0 ,1 "
bitfld.long 0 27. " K68 "  "0 ,1 "
bitfld.long 0 28. " K67 "  "0 ,1 "
bitfld.long 0 29. " K66 "  "0 ,1 "
bitfld.long 0 30. " K65 "  "0 ,1 "
bitfld.long 0 31. " K64 "  "0 ,1 "
;tree.end

base ad:0xa03cb034
;tree "1K2R"
group 0--3
line.long 0 "K2R"
bitfld.long 0 0. " K127 "  "0 ,1 "
bitfld.long 0 1. " K126 "  "0 ,1 "
bitfld.long 0 2. " K125 "  "0 ,1 "
bitfld.long 0 3. " K124 "  "0 ,1 "
bitfld.long 0 4. " K123 "  "0 ,1 "
bitfld.long 0 5. " K122 "  "0 ,1 "
bitfld.long 0 6. " K121 "  "0 ,1 "
bitfld.long 0 7. " K120 "  "0 ,1 "
bitfld.long 0 8. " K119 "  "0 ,1 "
bitfld.long 0 9. " K118 "  "0 ,1 "
bitfld.long 0 10. " K117 "  "0 ,1 "
bitfld.long 0 11. " K116 "  "0 ,1 "
bitfld.long 0 12. " K115 "  "0 ,1 "
bitfld.long 0 13. " K114 "  "0 ,1 "
bitfld.long 0 14. " K113 "  "0 ,1 "
bitfld.long 0 15. " K112 "  "0 ,1 "
bitfld.long 0 16. " K111 "  "0 ,1 "
bitfld.long 0 17. " K110 "  "0 ,1 "
bitfld.long 0 18. " K109 "  "0 ,1 "
bitfld.long 0 19. " K108 "  "0 ,1 "
bitfld.long 0 20. " K107 "  "0 ,1 "
bitfld.long 0 21. " K106 "  "0 ,1 "
bitfld.long 0 22. " K105 "  "0 ,1 "
bitfld.long 0 23. " K104 "  "0 ,1 "
bitfld.long 0 24. " K103 "  "0 ,1 "
bitfld.long 0 25. " K102 "  "0 ,1 "
bitfld.long 0 26. " K101 "  "0 ,1 "
bitfld.long 0 27. " K100 "  "0 ,1 "
bitfld.long 0 28. " K99 "  "0 ,1 "
bitfld.long 0 29. " K98 "  "0 ,1 "
bitfld.long 0 30. " K97 "  "0 ,1 "
bitfld.long 0 31. " K96 "  "0 ,1 "
;tree.end

base ad:0xa03cb038
;tree "1K3L"
group 0--3
line.long 0 "K3L"
bitfld.long 0 0. " K159 "  "0 ,1 "
bitfld.long 0 1. " K158 "  "0 ,1 "
bitfld.long 0 2. " K157 "  "0 ,1 "
bitfld.long 0 3. " K156 "  "0 ,1 "
bitfld.long 0 4. " K155 "  "0 ,1 "
bitfld.long 0 5. " K154 "  "0 ,1 "
bitfld.long 0 6. " K153 "  "0 ,1 "
bitfld.long 0 7. " K152 "  "0 ,1 "
bitfld.long 0 8. " K151 "  "0 ,1 "
bitfld.long 0 9. " K150 "  "0 ,1 "
bitfld.long 0 10. " K149 "  "0 ,1 "
bitfld.long 0 11. " K148 "  "0 ,1 "
bitfld.long 0 12. " K147 "  "0 ,1 "
bitfld.long 0 13. " K146 "  "0 ,1 "
bitfld.long 0 14. " K145 "  "0 ,1 "
bitfld.long 0 15. " K144 "  "0 ,1 "
bitfld.long 0 16. " K143 "  "0 ,1 "
bitfld.long 0 17. " K142 "  "0 ,1 "
bitfld.long 0 18. " K141 "  "0 ,1 "
bitfld.long 0 19. " K140 "  "0 ,1 "
bitfld.long 0 20. " K139 "  "0 ,1 "
bitfld.long 0 21. " K138 "  "0 ,1 "
bitfld.long 0 22. " K137 "  "0 ,1 "
bitfld.long 0 23. " K136 "  "0 ,1 "
bitfld.long 0 24. " K135 "  "0 ,1 "
bitfld.long 0 25. " K134 "  "0 ,1 "
bitfld.long 0 26. " K133 "  "0 ,1 "
bitfld.long 0 27. " K132 "  "0 ,1 "
bitfld.long 0 28. " K131 "  "0 ,1 "
bitfld.long 0 29. " K130 "  "0 ,1 "
bitfld.long 0 30. " K129 "  "0 ,1 "
bitfld.long 0 31. " K128 "  "0 ,1 "
;tree.end

base ad:0xa03cb03c
;tree "1K3R"
group 0--3
line.long 0 "K3R"
bitfld.long 0 0. " K191 "  "0 ,1 "
bitfld.long 0 1. " K190 "  "0 ,1 "
bitfld.long 0 2. " K189 "  "0 ,1 "
bitfld.long 0 3. " K188 "  "0 ,1 "
bitfld.long 0 4. " K187 "  "0 ,1 "
bitfld.long 0 5. " K186 "  "0 ,1 "
bitfld.long 0 6. " K185 "  "0 ,1 "
bitfld.long 0 7. " K184 "  "0 ,1 "
bitfld.long 0 8. " K183 "  "0 ,1 "
bitfld.long 0 9. " K182 "  "0 ,1 "
bitfld.long 0 10. " K181 "  "0 ,1 "
bitfld.long 0 11. " K180 "  "0 ,1 "
bitfld.long 0 12. " K179 "  "0 ,1 "
bitfld.long 0 13. " K178 "  "0 ,1 "
bitfld.long 0 14. " K177 "  "0 ,1 "
bitfld.long 0 15. " K176 "  "0 ,1 "
bitfld.long 0 16. " K175 "  "0 ,1 "
bitfld.long 0 17. " K174 "  "0 ,1 "
bitfld.long 0 18. " K173 "  "0 ,1 "
bitfld.long 0 19. " K172 "  "0 ,1 "
bitfld.long 0 20. " K171 "  "0 ,1 "
bitfld.long 0 21. " K170 "  "0 ,1 "
bitfld.long 0 22. " K169 "  "0 ,1 "
bitfld.long 0 23. " K168 "  "0 ,1 "
bitfld.long 0 24. " K167 "  "0 ,1 "
bitfld.long 0 25. " K166 "  "0 ,1 "
bitfld.long 0 26. " K165 "  "0 ,1 "
bitfld.long 0 27. " K164 "  "0 ,1 "
bitfld.long 0 28. " K163 "  "0 ,1 "
bitfld.long 0 29. " K162 "  "0 ,1 "
bitfld.long 0 30. " K161 "  "0 ,1 "
bitfld.long 0 31. " K160 "  "0 ,1 "
;tree.end

base ad:0xa03cb040
;tree "1K4L"
group 0--3
line.long 0 "K4L"
bitfld.long 0 0. " K223 "  "0 ,1 "
bitfld.long 0 1. " K222 "  "0 ,1 "
bitfld.long 0 2. " K221 "  "0 ,1 "
bitfld.long 0 3. " K220 "  "0 ,1 "
bitfld.long 0 4. " K219 "  "0 ,1 "
bitfld.long 0 5. " K218 "  "0 ,1 "
bitfld.long 0 6. " K217 "  "0 ,1 "
bitfld.long 0 7. " K216 "  "0 ,1 "
bitfld.long 0 8. " K215 "  "0 ,1 "
bitfld.long 0 9. " K214 "  "0 ,1 "
bitfld.long 0 10. " K213 "  "0 ,1 "
bitfld.long 0 11. " K212 "  "0 ,1 "
bitfld.long 0 12. " K211 "  "0 ,1 "
bitfld.long 0 13. " K210 "  "0 ,1 "
bitfld.long 0 14. " K209 "  "0 ,1 "
bitfld.long 0 15. " K208 "  "0 ,1 "
bitfld.long 0 16. " K207 "  "0 ,1 "
bitfld.long 0 17. " K206 "  "0 ,1 "
bitfld.long 0 18. " K205 "  "0 ,1 "
bitfld.long 0 19. " K204 "  "0 ,1 "
bitfld.long 0 20. " K203 "  "0 ,1 "
bitfld.long 0 21. " K202 "  "0 ,1 "
bitfld.long 0 22. " K201 "  "0 ,1 "
bitfld.long 0 23. " K200 "  "0 ,1 "
bitfld.long 0 24. " K199 "  "0 ,1 "
bitfld.long 0 25. " K198 "  "0 ,1 "
bitfld.long 0 26. " K197 "  "0 ,1 "
bitfld.long 0 27. " K196 "  "0 ,1 "
bitfld.long 0 28. " K195 "  "0 ,1 "
bitfld.long 0 29. " K194 "  "0 ,1 "
bitfld.long 0 30. " K193 "  "0 ,1 "
bitfld.long 0 31. " K192 "  "0 ,1 "
;tree.end

base ad:0xa03cb044
;tree "1K4R"
group 0--3
line.long 0 "K4R"
bitfld.long 0 0. " K255 "  "0 ,1 "
bitfld.long 0 1. " K254 "  "0 ,1 "
bitfld.long 0 2. " K253 "  "0 ,1 "
bitfld.long 0 3. " K252 "  "0 ,1 "
bitfld.long 0 4. " K251 "  "0 ,1 "
bitfld.long 0 5. " K250 "  "0 ,1 "
bitfld.long 0 6. " K249 "  "0 ,1 "
bitfld.long 0 7. " K248 "  "0 ,1 "
bitfld.long 0 8. " K247 "  "0 ,1 "
bitfld.long 0 9. " K246 "  "0 ,1 "
bitfld.long 0 10. " K245 "  "0 ,1 "
bitfld.long 0 11. " K244 "  "0 ,1 "
bitfld.long 0 12. " K243 "  "0 ,1 "
bitfld.long 0 13. " K242 "  "0 ,1 "
bitfld.long 0 14. " K241 "  "0 ,1 "
bitfld.long 0 15. " K240 "  "0 ,1 "
bitfld.long 0 16. " K239 "  "0 ,1 "
bitfld.long 0 17. " K238 "  "0 ,1 "
bitfld.long 0 18. " K237 "  "0 ,1 "
bitfld.long 0 19. " K236 "  "0 ,1 "
bitfld.long 0 20. " K235 "  "0 ,1 "
bitfld.long 0 21. " K234 "  "0 ,1 "
bitfld.long 0 22. " K233 "  "0 ,1 "
bitfld.long 0 23. " K232 "  "0 ,1 "
bitfld.long 0 24. " K231 "  "0 ,1 "
bitfld.long 0 25. " K230 "  "0 ,1 "
bitfld.long 0 26. " K229 "  "0 ,1 "
bitfld.long 0 27. " K228 "  "0 ,1 "
bitfld.long 0 28. " K227 "  "0 ,1 "
bitfld.long 0 29. " K226 "  "0 ,1 "
bitfld.long 0 30. " K225 "  "0 ,1 "
bitfld.long 0 31. " K224 "  "0 ,1 "
;tree.end

base ad:0xa03cb048
;tree "1IV0L"
group 0--3
line.long 0 "IV0L"
bitfld.long 0 0. " IV32 "  "0 ,1 "
bitfld.long 0 1. " IV31 "  "0 ,1 "
bitfld.long 0 2. " IV30 "  "0 ,1 "
bitfld.long 0 3. " IV29 "  "0 ,1 "
bitfld.long 0 4. " IV28 "  "0 ,1 "
bitfld.long 0 5. " IV27 "  "0 ,1 "
bitfld.long 0 6. " IV26 "  "0 ,1 "
bitfld.long 0 7. " IV25 "  "0 ,1 "
bitfld.long 0 8. " IV24 "  "0 ,1 "
bitfld.long 0 9. " IV23 "  "0 ,1 "
bitfld.long 0 10. " IV22 "  "0 ,1 "
bitfld.long 0 11. " IV21 "  "0 ,1 "
bitfld.long 0 12. " IV20 "  "0 ,1 "
bitfld.long 0 13. " IV19 "  "0 ,1 "
bitfld.long 0 14. " IV18 "  "0 ,1 "
bitfld.long 0 15. " IV17 "  "0 ,1 "
bitfld.long 0 16. " IV16 "  "0 ,1 "
bitfld.long 0 17. " IV15 "  "0 ,1 "
bitfld.long 0 18. " IV14 "  "0 ,1 "
bitfld.long 0 19. " IV13 "  "0 ,1 "
bitfld.long 0 20. " IV12 "  "0 ,1 "
bitfld.long 0 21. " IV11 "  "0 ,1 "
bitfld.long 0 22. " IV10 "  "0 ,1 "
bitfld.long 0 23. " IV9 "  "0 ,1 "
bitfld.long 0 24. " IV8 "  "0 ,1 "
bitfld.long 0 25. " IV7 "  "0 ,1 "
bitfld.long 0 26. " IV6 "  "0 ,1 "
bitfld.long 0 27. " IV5 "  "0 ,1 "
bitfld.long 0 28. " IV4 "  "0 ,1 "
bitfld.long 0 29. " IV3 "  "0 ,1 "
bitfld.long 0 30. " IV2 "  "0 ,1 "
bitfld.long 0 31. " IV1 "  "0 ,1 "
;tree.end

base ad:0xa03cb04c
;tree "1IV0R"
group 0--3
line.long 0 "IV0R"
bitfld.long 0 0. " IV64 "  "0 ,1 "
bitfld.long 0 1. " IV63 "  "0 ,1 "
bitfld.long 0 2. " IV62 "  "0 ,1 "
bitfld.long 0 3. " IV61 "  "0 ,1 "
bitfld.long 0 4. " IV60 "  "0 ,1 "
bitfld.long 0 5. " IV59 "  "0 ,1 "
bitfld.long 0 6. " IV58 "  "0 ,1 "
bitfld.long 0 7. " IV57 "  "0 ,1 "
bitfld.long 0 8. " IV56 "  "0 ,1 "
bitfld.long 0 9. " IV55 "  "0 ,1 "
bitfld.long 0 10. " IV54 "  "0 ,1 "
bitfld.long 0 11. " IV53 "  "0 ,1 "
bitfld.long 0 12. " IV52 "  "0 ,1 "
bitfld.long 0 13. " IV51 "  "0 ,1 "
bitfld.long 0 14. " IV50 "  "0 ,1 "
bitfld.long 0 15. " IV49 "  "0 ,1 "
bitfld.long 0 16. " IV48 "  "0 ,1 "
bitfld.long 0 17. " IV47 "  "0 ,1 "
bitfld.long 0 18. " IV46 "  "0 ,1 "
bitfld.long 0 19. " IV45 "  "0 ,1 "
bitfld.long 0 20. " IV44 "  "0 ,1 "
bitfld.long 0 21. " IV43 "  "0 ,1 "
bitfld.long 0 22. " IV42 "  "0 ,1 "
bitfld.long 0 23. " IV41 "  "0 ,1 "
bitfld.long 0 24. " IV40 "  "0 ,1 "
bitfld.long 0 25. " IV39 "  "0 ,1 "
bitfld.long 0 26. " IV38 "  "0 ,1 "
bitfld.long 0 27. " IV37 "  "0 ,1 "
bitfld.long 0 28. " IV36 "  "0 ,1 "
bitfld.long 0 29. " IV35 "  "0 ,1 "
bitfld.long 0 30. " IV34 "  "0 ,1 "
bitfld.long 0 31. " IV33 "  "0 ,1 "
;tree.end

base ad:0xa03cb050
;tree "1IV1L"
group 0--3
line.long 0 "IV1L"
bitfld.long 0 0. " IV96 "  "0 ,1 "
bitfld.long 0 1. " IV95 "  "0 ,1 "
bitfld.long 0 2. " IV94 "  "0 ,1 "
bitfld.long 0 3. " IV93 "  "0 ,1 "
bitfld.long 0 4. " IV92 "  "0 ,1 "
bitfld.long 0 5. " IV91 "  "0 ,1 "
bitfld.long 0 6. " IV90 "  "0 ,1 "
bitfld.long 0 7. " IV89 "  "0 ,1 "
bitfld.long 0 8. " IV88 "  "0 ,1 "
bitfld.long 0 9. " IV87 "  "0 ,1 "
bitfld.long 0 10. " IV86 "  "0 ,1 "
bitfld.long 0 11. " IV85 "  "0 ,1 "
bitfld.long 0 12. " IV84 "  "0 ,1 "
bitfld.long 0 13. " IV83 "  "0 ,1 "
bitfld.long 0 14. " IV82 "  "0 ,1 "
bitfld.long 0 15. " IV81 "  "0 ,1 "
bitfld.long 0 16. " IV80 "  "0 ,1 "
bitfld.long 0 17. " IV79 "  "0 ,1 "
bitfld.long 0 18. " IV78 "  "0 ,1 "
bitfld.long 0 19. " IV77 "  "0 ,1 "
bitfld.long 0 20. " IV76 "  "0 ,1 "
bitfld.long 0 21. " IV75 "  "0 ,1 "
bitfld.long 0 22. " IV74 "  "0 ,1 "
bitfld.long 0 23. " IV73 "  "0 ,1 "
bitfld.long 0 24. " IV72 "  "0 ,1 "
bitfld.long 0 25. " IV71 "  "0 ,1 "
bitfld.long 0 26. " IV70 "  "0 ,1 "
bitfld.long 0 27. " IV69 "  "0 ,1 "
bitfld.long 0 28. " IV68 "  "0 ,1 "
bitfld.long 0 29. " IV67 "  "0 ,1 "
bitfld.long 0 30. " IV66 "  "0 ,1 "
bitfld.long 0 31. " IV65 "  "0 ,1 "
;tree.end

base ad:0xa03cb054
;tree "1IV1R"
group 0--3
line.long 0 "IV1R"
bitfld.long 0 0. " IV128 "  "0 ,1 "
bitfld.long 0 1. " IV127 "  "0 ,1 "
bitfld.long 0 2. " IV126 "  "0 ,1 "
bitfld.long 0 3. " IV125 "  "0 ,1 "
bitfld.long 0 4. " IV124 "  "0 ,1 "
bitfld.long 0 5. " IV123 "  "0 ,1 "
bitfld.long 0 6. " IV122 "  "0 ,1 "
bitfld.long 0 7. " IV121 "  "0 ,1 "
bitfld.long 0 8. " IV120 "  "0 ,1 "
bitfld.long 0 9. " IV119 "  "0 ,1 "
bitfld.long 0 10. " IV118 "  "0 ,1 "
bitfld.long 0 11. " IV117 "  "0 ,1 "
bitfld.long 0 12. " IV116 "  "0 ,1 "
bitfld.long 0 13. " IV115 "  "0 ,1 "
bitfld.long 0 14. " IV114 "  "0 ,1 "
bitfld.long 0 15. " IV113 "  "0 ,1 "
bitfld.long 0 16. " IV112 "  "0 ,1 "
bitfld.long 0 17. " IV111 "  "0 ,1 "
bitfld.long 0 18. " IV110 "  "0 ,1 "
bitfld.long 0 19. " IV109 "  "0 ,1 "
bitfld.long 0 20. " IV108 "  "0 ,1 "
bitfld.long 0 21. " IV107 "  "0 ,1 "
bitfld.long 0 22. " IV106 "  "0 ,1 "
bitfld.long 0 23. " IV105 "  "0 ,1 "
bitfld.long 0 24. " IV104 "  "0 ,1 "
bitfld.long 0 25. " IV103 "  "0 ,1 "
bitfld.long 0 26. " IV102 "  "0 ,1 "
bitfld.long 0 27. " IV101 "  "0 ,1 "
bitfld.long 0 28. " IV100 "  "0 ,1 "
bitfld.long 0 29. " IV99 "  "0 ,1 "
bitfld.long 0 30. " IV98 "  "0 ,1 "
bitfld.long 0 31. " IV97 "  "0 ,1 "
;tree.end

base ad:0xa03cb080
;tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0xa03cb084
;tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMAIUTC "  "0 ,1 "
bitfld.long 0 1. " DMAOUTC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
;tree.end

base ad:0xa03cb088
;tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMAINBREQ "  "0 ,1 "
bitfld.long 0 1. " DMAOUTBREQ "  "0 ,1 "
bitfld.long 0 2. " DMAOUTSREQ "  "0 ,1 "
bitfld.long 0 3. " ININTR "  "0 ,1 "
bitfld.long 0 4. " OUTINTR "  "0 ,1 "
;tree.end

base ad:0xa03cbfe0
;tree "1CRYPPeriphID0"
rgroup 0--3
line.long 0 "CRYPPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03cbfe4
;tree "1CRYPPeriphID1"
rgroup 0--3
line.long 0 "CRYPPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cbfe8
;tree "1CRYPPeriphID2"
rgroup 0--3
line.long 0 "CRYPPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03cbfec
;tree "1CRYPPeriphID3"
rgroup 0--3
line.long 0 "CRYPPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03cbff0
;tree "1CRYPPCellID0"
rgroup 0--3
line.long 0 "CRYPPCellID0"
hexfld.byte 0 " CRYPPCellID0 "
;tree.end

base ad:0xa03cbff4
;tree "1CRYPPCellID1"
rgroup 0--3
line.long 0 "CRYPPCellID1"
hexfld.byte 0 " CRYPPCellID1 "
;tree.end

base ad:0xa03cbff8
;tree "1CRYPPCellID2"
rgroup 0--3
line.long 0 "CRYPPCellID2"
hexfld.byte 0 " CRYPPCellID2 "
;tree.end

base ad:0xa03cbffc
;tree "1CRYPPCellID3"
rgroup 0--3
line.long 0 "CRYPPCellID3"
hexfld.byte 0 " CRYPPCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "CTI"
;==============================================================
base edap:0x80180000
;tree "CTICONTROL"
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
;tree.end

base edap:0x80180010
;tree "CTIINTACK"
wgroup 0--3
line.long 0 "CTIINTACK"
hexfld.byte 0 " INTACK "
;tree.end

base edap:0x80180014
;tree "CTIAPPSET"
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180018
;tree "CTIAPPCLEAR"
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x8018001c
;tree "CTIAPPPULSE"
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180020
;tree "CTIINEN0"
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180024
;tree "CTIINEN1"
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180028
;tree "CTIINEN2"
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x8018002c
;tree "CTIINEN3"
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180030
;tree "CTIINEN4"
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180034
;tree "CTIINEN5"
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180038
;tree "CTIINEN6"
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x8018003c
;tree "CTIINEN7"
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800a0
;tree "CTIOUTEN0"
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800a4
;tree "CTIOUTEN1"
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800a8
;tree "CTIOUTEN2"
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800ac
;tree "CTIOUTEN3"
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800b0
;tree "CTIOUTEN4"
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800b4
;tree "CTIOUTEN5"
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800b8
;tree "CTIOUTEN6"
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x801800bc
;tree "CTIOUTEN7"
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180130
;tree "CTITRIGINSTATUS"
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
hexfld.byte 0 " TRIGINSTATUS "
;tree.end

base edap:0x80180134
;tree "CTITRIGOUTSTATUS"
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
hexfld.byte 0 " TRIGOUTSTATUS "
;tree.end

base edap:0x80180138
;tree "CTICHINSTATUS"
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x8018013c
;tree "CTICHOUTSTATUS"
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180140
;tree "CTIGATE"
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
;tree.end

base edap:0x80180144
;tree "ASICCTL"
group 0--3
line.long 0 "ASICCTL"
hexfld.byte 0 " ASICCTL "
;tree.end

base edap:0x80180edc
;tree "ITCHINACK"
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180ee0
;tree "ITTRIGINACK"
wgroup 0--3
line.long 0 "ITTRIGINACK"
hexfld.byte 0 " CTTRIGINACK "
;tree.end

base edap:0x80180ee4
;tree "ITCHOUT"
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180ee8
;tree "ITTRFLIN"
wgroup 0--3
line.long 0 "ITTRFLIN"
hexfld.byte 0 " CTTRIGOUT "
;tree.end

base edap:0x80180eec
;tree "ITCHOUTACK"
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180ef0
;tree "ITTRIGOUTACK"
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
hexfld.byte 0 " CTTRIGOUTACK "
;tree.end

base edap:0x80180ef4
;tree "ITCHIN"
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180ef8
;tree "ITRIGIN"
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
;tree.end

base edap:0x80180f00
;tree "ITCTRL"
group 0--3
line.long 0 "ITCTRL"
bitfld.long 0 0. " ITCTRL "  "0 ,1 "
;tree.end

base edap:0x80180fa0
;tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180fa4
;tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180fb0
;tree "LAR"
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

base edap:0x80180fb4
;tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

base edap:0x80180fb8
;tree "ASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base edap:0x80180fc8
;tree "DID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
;tree.end

base edap:0x80180fcc
;tree "DTIR"
rgroup 0--3
line.long 0 "DTIR"
hexfld.byte 0 " DTIR "
;tree.end

base edap:0x80180fd0
;tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

base edap:0x80180fd4
;tree "PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

base edap:0x80180fd8
;tree "PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

base edap:0x80180fdc
;tree "PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

base edap:0x80180fe0
;tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

base edap:0x80180fe4
;tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

base edap:0x80180fe8
;tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

base edap:0x80180fec
;tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

base edap:0x80180ff0
;tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

base edap:0x80180ff4
;tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

base edap:0x80180ff8
;tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

base edap:0x80180ffc
;tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

;==============================================================
tree "DBAHN"
;==============================================================
base ad:0x80156000
;tree "DENALI_CTL_00"
group 0--3
line.long 0 "DENALI_CTL_00"
bitfld.long 0 0. " ACTIVE_AGING "  "0 ,1 "
bitfld.long 0 8. " ADDR_CMP_EN "  "0 ,1 "
bitfld.long 0 16. " AP "  "0 ,1 "
bitfld.long 0 24. " AREFRESH "  "0 ,1 "
;tree.end

base ad:0x80156004
;tree "DENALI_CTL_01"
group 0--3
line.long 0 "DENALI_CTL_01"
bitfld.long 0 0. " AUTO_REFRESH_MODE "  "0 ,1 "
bitfld.long 0 8. " AXI0_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 16. " AXI1_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 24. " AXI2_BDW_OVFLOW "  "0 ,1 "
;tree.end

base ad:0x80156008
;tree "DENALI_CTL_02"
group 0--3
line.long 0 "DENALI_CTL_02"
bitfld.long 0 0. " AXI3_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 8. " BANK_SPLIT_EN "  "0 ,1 "
bitfld.long 0 16. " CONCURRENTAP "  "0 ,1 "
bitfld.long 0 24. " DLLLOCKREG "  "0 ,1 "
;tree.end

base ad:0x8015600c
;tree "DENALI_CTL_03"
group 0--3
line.long 0 "DENALI_CTL_03"
bitfld.long 0 0. " DLL_BYPASS_MODE "  "0 ,1 "
bitfld.long 0 8. " DRIVE_DQ_DQ "  "0 ,1 "
bitfld.long 0 16. " ENABLE_QUICK_SREFRESH "  "0 ,1 "
;tree.end

base ad:0x80156010
;tree "DENALI_CTL_04"
group 0--3
line.long 0 "DENALI_CTL_04"
bitfld.long 0 0. " FAST_WRITE "  "0 ,1 "
bitfld.long 0 8. " INTRPTAPBURST "  "0 ,1 "
bitfld.long 0 16. " INTRPTREADA "  "0 ,1 "
bitfld.long 0 24. " INTRPTWRITEA "  "0 ,1 "
;tree.end

base ad:0x80156014
;tree "DENALI_CTL_05"
group 0--3
line.long 0 "DENALI_CTL_05"
bitfld.long 0 0. " NO_CMD_INIT "  "0 ,1 "
bitfld.long 0 8. " PLACEMENT_EN "  "0 ,1 "
bitfld.long 0 16. " POWER_DOWN "  "0 ,1 "
bitfld.long 0 24. " PRIORITY_EN "  "0 ,1 "
;tree.end

base ad:0x80156018
;tree "DENALI_CTL_06"
group 0--3
line.long 0 "DENALI_CTL_06"
bitfld.long 0 0. " PWRUP_SREFRESH_EXIT "  "0 ,1 "
bitfld.long 0 8. " RD2RD_TURN "  "0 ,1 "
bitfld.long 0 16. " REDUC "  "0 ,1 "
bitfld.long 0 24. " REG_DIMM_ENABLE "  "0 ,1 "
;tree.end

base ad:0x8015601c
;tree "DENALI_CTL_07"
group 0--3
line.long 0 "DENALI_CTL_07"
bitfld.long 0 0. " RW_SAME_EN "  "0 ,1 "
bitfld.long 0 8. " SREFRESH "  "0 ,1 "
bitfld.long 0 16. " START "  "0 ,1 "
bitfld.long 0 24. " SWAP_EN "  "0 ,1 "
;tree.end

base ad:0x80156020
;tree "DENALI_CTL_08"
group 0--3
line.long 0 "DENALI_CTL_08"
bitfld.long 0 0. " TRAS_LOCKOUT "  "0 ,1 "
bitfld.long 0 8. " TREF_ENABLE "  "0 ,1 "
bitfld.long 0 16. " WRITEINTERP "  "0 ,1 "
bitfld.long 0 24. " WRITE_MODEREG "  "0 ,1 "
;tree.end

base ad:0x80156024
;tree "DENALI_CTL_09"
group 0--3
line.long 0 "DENALI_CTL_09"
bitfld.long 0 0. " WRLAT "  "0 ,1 "
bitfld.long 0 8.--9. " AXI0_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI0_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI0_W_PRIORITY "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80156028
;tree "DENALI_CTL_10"
group 0--3
line.long 0 "DENALI_CTL_10"
bitfld.long 0 0.--1. " AXI1_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI1_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI1_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI2_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8015602c
;tree "DENALI_CTL_11"
group 0--3
line.long 0 "DENALI_CTL_11"
bitfld.long 0 0.--1. " AXI2_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI2_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI3_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI3_R_PRIORITY "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80156030
;tree "DENALI_CTL_12"
group 0--3
line.long 0 "DENALI_CTL_12"
bitfld.long 0 0.--1. " AXI3_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " CS_MAP "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " LOWPOWER_REFRESH_ENABLE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80156034
;tree "DENALI_CTL_13"
group 0--3
line.long 0 "DENALI_CTL_13"
bitfld.long 0 0.--1. " MAX_CS_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TEMRS "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " WRTPRCT_ENABLE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80156038
;tree "DENALI_CTL_14"
group 0--3
line.long 0 "DENALI_CTL_14"
bitfld.long 0 0.--2. " ARB_CMD_Q_THRESHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " BSTLEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " CASLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " CKE_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8015603c
;tree "DENALI_CTL_15"
group 0--3
line.long 0 "DENALI_CTL_15"
bitfld.long 0 8.--10. " PORT_DATA_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " Q_FULLNESS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TCKE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80156040
;tree "DENALI_CTL_16"
group 0--3
line.long 0 "DENALI_CTL_16"
bitfld.long 0 0.--2. " TDFI_CTRL_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDFI_DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " TDFI_DRAM_CLK_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TRRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80156044
;tree "DENALI_CTL_17"
group 0--3
line.long 0 "DENALI_CTL_17"
bitfld.long 0 0.--3. " TWTR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--28. " CASLAT_LIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x80156048
;tree "DENALI_CTL_18"
group 0--3
line.long 0 "DENALI_CTL_18"
bitfld.long 0 0.--3. " CASLAT_LIN_GATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " COMMAND_AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " INITAREF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAX_COL_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8015604c
;tree "DENALI_CTL_19"
group 0--3
line.long 0 "DENALI_CTL_19"
bitfld.long 0 0.--3. " MAX_ROW_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " PORT_CMD_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_CTRLUPD_MIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156050
;tree "DENALI_CTL_20"
group 0--3
line.long 0 "DENALI_CTL_20"
bitfld.long 0 0.--3. " TDFI_PHY_RDLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TDFI_PHY_WRLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDFI_PHY_WRLAT_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_RDDATA_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156054
;tree "DENALI_CTL_21"
group 0--3
line.long 0 "DENALI_CTL_21"
bitfld.long 0 0.--4. " TDFI_RDDATA_EN_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " TRP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " TWR_INT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--30. " DLL_LOCK "  " "
;tree.end

base ad:0x80156058
;tree "DENALI_CTL_22"
group 0--3
line.long 0 "DENALI_CTL_22"
bitfld.long 0 0.--4. " LOWPOWER_AUTO_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " LOWPOWER_CONTROL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--21. " OUT_OF_RANGE_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24.--28. " TMRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8015605c
;tree "DENALI_CTL_23"
group 0--3
line.long 0 "DENALI_CTL_23"
bitfld.long 0 0.--5. " TRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8.--14. " AXI0_BDW "  " "
bitfld.long 0 16.--22. " AXI0_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI1_BDW "  " "
;tree.end

base ad:0x80156060
;tree "DENALI_CTL_24"
group 0--3
line.long 0 "DENALI_CTL_24"
bitfld.long 0 0.--6. " AXI1_CURRENT_BDW "  " "
bitfld.long 0 8.--14. " AXI2_BDW "  " "
bitfld.long 0 16.--22. " AXI2_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI3_BDW "  " "
;tree.end

base ad:0x80156064
;tree "DENALI_CTL_25"
rgroup 0--3
line.long 0 "DENALI_CTL_25"
bitfld.long 0 0.--6. " AXI3_CURRENT_BDW "  " "
bitfld.long 0 16.--22. " OUT_OF_RANGE_LENGTH "  " "
bitfld.long 0 24.--30. " WRTPRCT_ERROR_LENGTH "  " "
;tree.end

base ad:0x80156068
;tree "DENALI_CTL_26"
group 0--3
line.long 0 "DENALI_CTL_26"
hexfld.byte 2 " TRAS_MIN "
hexfld.byte 3 " TRCD_INT "
;tree.end

base ad:0x8015606c
;tree "DENALI_CTL_27"
group 0--3
line.long 0 "DENALI_CTL_27"
hexfld.byte 0 " TRFC "
bitfld.long 0 8.--17. " OUT_OF_RANGE_SOURCE_ID "  " "
;tree.end

base ad:0x80156070
;tree "DENALI_CTL_28"
rgroup 0--3
line.long 0 "DENALI_CTL_28"
bitfld.long 0 0.--11. " PORT_CMD_ERROR_ID "  " "
bitfld.long 0 16.--27. " PORT_DATA_ERROR_ID "  " "
;tree.end

base ad:0x80156074
;tree "DENALI_CTL_29"
rgroup 0--3
line.long 0 "DENALI_CTL_29"
hexfld.word 0 " TDFI_CTRLUPD_MAX "
hexfld.word 1 " TDFI_PHYUPD_RESP "
;tree.end

base ad:0x80156078
;tree "DENALI_CTL_30"
group 0--3
line.long 0 "DENALI_CTL_30"
hexfld.word 0 " TDFI_PHYUPD_TYPE0 "
hexfld.word 1 " TREF "
;tree.end

base ad:0x8015607c
;tree "DENALI_CTL_31"
rgroup 0--3
line.long 0 "DENALI_CTL_31"
;tree.end

base ad:0x80156080
;tree "DENALI_CTL_32"
group 0--3
line.long 0 "DENALI_CTL_32"
hexfld.word 1 " AXI0_EN_SIZE_LT_WIDTH_INSTR "
;tree.end

base ad:0x80156084
;tree "DENALI_CTL_33"
group 0--3
line.long 0 "DENALI_CTL_33"
hexfld.word 0 " AXI1_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 1 " AXI2_EN_SIZE_LT_WIDTH_INSTR "
;tree.end

base ad:0x80156088
;tree "DENALI_CTL_34"
group 0--3
line.long 0 "DENALI_CTL_34"
hexfld.word 0 " AXI3_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 1 " LOWPOWER_EXTERNAL_CNT "
;tree.end

base ad:0x8015608c
;tree "DENALI_CTL_35"
group 0--3
line.long 0 "DENALI_CTL_35"
hexfld.word 0 " LOWPOWER_INTERNAL_CNT "
hexfld.word 1 " LOWPOWER_POWER_DOWN_CNT "
;tree.end

base ad:0x80156090
;tree "DENALI_CTL_36"
group 0--3
line.long 0 "DENALI_CTL_36"
hexfld.word 0 " LOWPOWER_REFRESH_HOLD "
hexfld.word 1 " LOWPOWER_SELF_REFRESH_CNT "
;tree.end

base ad:0x80156094
;tree "DENALI_CTL_37"
group 0--3
line.long 0 "DENALI_CTL_37"
hexfld.word 0 " TDLL "
hexfld.word 1 " TPDEX "
;tree.end

base ad:0x80156098
;tree "DENALI_CTL_38"
group 0--3
line.long 0 "DENALI_CTL_38"
hexfld.word 0 " TRAS_MAX "
hexfld.word 1 " TXSNR "
;tree.end

base ad:0x8015609c
;tree "DENALI_CTL_39"
group 0--3
line.long 0 "DENALI_CTL_39"
hexfld.word 0 " TXSR "
hexfld.word 1 " VERSION "
;tree.end

base ad:0x801560a0
;tree "DENALI_CTL_40"
group 0--3
line.long 0 "DENALI_CTL_40"
bitfld.long 0 0.--23. " TINIT "  " "
;tree.end

base ad:0x801560a4
;tree "DENALI_CTL_41"
rgroup 0--3
line.long 0 "DENALI_CTL_41"
hexfld.long 0 " OUT_OF_RANGE_ADDR "
;tree.end

base ad:0x801560a8
;tree "DENALI_CTL_42"
rgroup 0--3
line.long 0 "DENALI_CTL_42"
hexfld.long 0 " PORT_CMD_ERROR_ADDR "
;tree.end

base ad:0x801560ac
;tree "DENALI_CTL_43"
rgroup 0--3
line.long 0 "DENALI_CTL_43"
hexfld.long 0 " WRTPRCT_ERROR_ADDRESS "
;tree.end

base ad:0x801560b0
;tree "DENALI_CTL_44"
group 0--3
line.long 0 "DENALI_CTL_44"
hexfld.long 0 " WRTPRCT_LOWER_ADDRESS_0 "
;tree.end

base ad:0x801560b4
;tree "DENALI_CTL_45"
group 0--3
line.long 0 "DENALI_CTL_45"
hexfld.long 0 " WRTPRCT_LOWER_ADDRESS_1 "
;tree.end

base ad:0x801560b8
;tree "DENALI_CTL_46"
group 0--3
line.long 0 "DENALI_CTL_46"
hexfld.long 0 " WRTPRCT_UPPER_ADDRESS_0 "
;tree.end

base ad:0x801560bc
;tree "DENALI_CTL_47"
group 0--3
line.long 0 "DENALI_CTL_47"
hexfld.long 0 " WRTPRCT_UPPER_ADDRESS_1 "
;tree.end

base ad:0x801560ec
;tree "DENALI_CTL_59"
group 0--3
line.long 0 "DENALI_CTL_59"
hexfld.long 0 " PHY_ADD "
;tree.end

base ad:0x801560f0
;tree "DENALI_CTL_60"
group 0--3
line.long 0 "DENALI_CTL_60"
hexfld.long 0 " PHY_CFG "
;tree.end

base ad:0x801560f4
;tree "DENALI_CTL_61"
rgroup 0--3
line.long 0 "DENALI_CTL_61"
hexfld.long 0 " PHY_STS "
;tree.end

base ad:0x801560f8
;tree "DENALI_CTL_62"
rgroup 0--3
line.long 0 "DENALI_CTL_62"
;tree.end

base ad:0x801560fc
;tree "DENALI_CTL_63"
group 0--3
line.long 0 "DENALI_CTL_63"
bitfld.long 0 0.--2. " WRLAT_ADJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " W2R_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " W2R_SAMECS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--27. " DRAM_CLASS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156100
;tree "DENALI_CTL_64"
group 0--3
line.long 0 "DENALI_CTL_64"
bitfld.long 0 0.--4. " RDLAT_ADJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.byte 1 " DLL_RST_ADJ_DLY "
hexfld.byte 2 " TMOD "
;tree.end

base ad:0x80156104
;tree "DENALI_CTL_65"
group 0--3
line.long 0 "DENALI_CTL_65"
;tree.end

base ad:0x80156108
;tree "DENALI_CTL_66"
group 0--3
line.long 0 "DENALI_CTL_66"
;tree.end

base ad:0x8015610c
;tree "DENALI_CTL_67"
group 0--3
line.long 0 "DENALI_CTL_67"
hexfld.word 0 " DLL_RST_DELAY "
;tree.end

base ad:0x80156120
;tree "DENALI_CTL_72"
group 0--3
line.long 0 "DENALI_CTL_72"
hexfld.long 0 " USER_DEF_REG_2 "
;tree.end

base ad:0x80156124
;tree "DENALI_CTL_73"
group 0--3
line.long 0 "DENALI_CTL_73"
bitfld.long 0 26. " DEBUG_DFI_TRIGGER_IS_WRITE "  "0 ,1 "
bitfld.long 0 27. " DENALI_JTAG_CONTROL_ENABLE "  "0 ,1 "
bitfld.long 0 28. " DENALI_JTAG_TRSTN "  "0 ,1 "
bitfld.long 0 29. " DENALI_JTAG_TCK "  "0 ,1 "
bitfld.long 0 30. " DENALI_JTAG_TMS "  "0 ,1 "
bitfld.long 0 31. " DENALI_JTAG_TDI "  "0 ,1 "
;tree.end

base ad:0x80156128
;tree "DENALI_CTL_74"
group 0--3
line.long 0 "DENALI_CTL_74"
hexfld.long 0 " USER_DEF_REG_RO_2 "
;tree.end

base ad:0x8015612c
;tree "DENALI_CTL_75"
rgroup 0--3
line.long 0 "DENALI_CTL_75"
bitfld.long 0 30. " DFI_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 31. " DENALI_JTAG_TDO "  "0 ,1 "
;tree.end

base ad:0x80156130
;tree "DENALI_CTL_76"
rgroup 0--3
line.long 0 "DENALI_CTL_76"
bitfld.long 0 8. " DQS_N_EN "  "0 ,1 "
bitfld.long 0 24. " LPDDR2_S4 "  "0 ,1 "
;tree.end

base ad:0x80156134
;tree "DENALI_CTL_77"
group 0--3
line.long 0 "DENALI_CTL_77"
bitfld.long 0 0.--1. " TDQSCK_MAX "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TDQSCK_MIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--26. " R2R_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80156138
;tree "DENALI_CTL_78"
group 0--3
line.long 0 "DENALI_CTL_78"
bitfld.long 0 0.--1. " TDQSCK_MAX "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TDQSCK_MIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--28. " TCCD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8015613c
;tree "DENALI_CTL_79"
group 0--3
line.long 0 "DENALI_CTL_79"
bitfld.long 0 0.--2. " TRTP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " W2W_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " W2W_SAMECS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--28. " TMRR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x80156140
;tree "DENALI_CTL_80"
group 0--3
line.long 0 "DENALI_CTL_80"
bitfld.long 0 8.--11. " ZQ_ON_SREF_EXIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " ZQ_REQ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--29. " TFAW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80156144
;tree "DENALI_CTL_81"
group 0--3
line.long 0 "DENALI_CTL_81"
hexfld.byte 0 " REFRESH_PER_ZQ "
bitfld.long 0 8.--17. " INT_MASK "  " "
;tree.end

base ad:0x80156148
;tree "DENALI_CTL_82"
group 0--3
line.long 0 "DENALI_CTL_82"
bitfld.long 0 0.--9. " INT_STATUS "  " "
bitfld.long 0 16.--27. " ZQCL "  " "
;tree.end

base ad:0x8015614c
;tree "DENALI_CTL_83"
group 0--3
line.long 0 "DENALI_CTL_83"
bitfld.long 0 0.--11. " ZQCS "  " "
bitfld.long 0 16.--27. " ZQINIT "  " "
;tree.end

base ad:0x80156150
;tree "DENALI_CTL_84"
group 0--3
line.long 0 "DENALI_CTL_84"
bitfld.long 0 0.--11. " ZQRESET "  " "
bitfld.long 0 16.--30. " MR0_DATA_0 "  " "
;tree.end

base ad:0x80156154
;tree "DENALI_CTL_85"
group 0--3
line.long 0 "DENALI_CTL_85"
bitfld.long 0 0.--14. " MR0_DATA_1 "  " "
bitfld.long 0 16.--30. " MR16_DATA_0 "  " "
;tree.end

base ad:0x80156158
;tree "DENALI_CTL_86"
group 0--3
line.long 0 "DENALI_CTL_86"
bitfld.long 0 0.--14. " MR16_DATA_1 "  " "
bitfld.long 0 16.--30. " MR17_DATA_0 "  " "
;tree.end

base ad:0x8015615c
;tree "DENALI_CTL_87"
group 0--3
line.long 0 "DENALI_CTL_87"
bitfld.long 0 0.--14. " MR17_DATA_1 "  " "
bitfld.long 0 16.--30. " MR1_DATA_0 "  " "
;tree.end

base ad:0x80156160
;tree "DENALI_CTL_88"
group 0--3
line.long 0 "DENALI_CTL_88"
bitfld.long 0 0.--14. " MR1_DATA_1 "  " "
bitfld.long 0 16.--30. " MR2_DATA_0 "  " "
;tree.end

base ad:0x80156164
;tree "DENALI_CTL_89"
group 0--3
line.long 0 "DENALI_CTL_89"
bitfld.long 0 0.--14. " MR2_DATA_1 "  " "
bitfld.long 0 16.--30. " MR3_DATA_0 "  " "
;tree.end

base ad:0x80156168
;tree "DENALI_CTL_90"
group 0--3
line.long 0 "DENALI_CTL_90"
bitfld.long 0 0.--14. " MR3_DATA_1 "  " "
hexfld.word 1 " PERIPHERAL_MRR_DATA "
;tree.end

base ad:0x8015616c
;tree "DENALI_CTL_91"
group 0--3
line.long 0 "DENALI_CTL_91"
bitfld.long 0 0.--16. " READ_MODEREG "  " "
;tree.end

base ad:0x80156170
;tree "DENALI_CTL_92"
group 0--3
line.long 0 "DENALI_CTL_92"
bitfld.long 0 0.--23. " TINIT3 "  " "
;tree.end

base ad:0x80156174
;tree "DENALI_CTL_93"
group 0--3
line.long 0 "DENALI_CTL_93"
bitfld.long 0 0.--23. " TINIT4 "  " "
;tree.end

base ad:0x80156178
;tree "DENALI_CTL_94"
group 0--3
line.long 0 "DENALI_CTL_94"
bitfld.long 0 0.--23. " TINIT5 "  " "
bitfld.long 0 24. " CONCURRENTAP_WR_ONLY "  "0 ,1 "
;tree.end

base ad:0x8015617c
;tree "DENALI_CTL_95"
group 0--3
line.long 0 "DENALI_CTL_95"
bitfld.long 0 0. " CONFIG_ERROR "  "0 ,1 "
bitfld.long 0 8. " EIGHT_BANK_MODE_0 "  "0 ,1 "
bitfld.long 0 16. " EIGHT_BANK_MODE_1 "  "0 ,1 "
bitfld.long 0 24. " RESYNC_DLL "  "0 ,1 "
;tree.end

base ad:0x80156180
;tree "DENALI_CTL_96"
group 0--3
line.long 0 "DENALI_CTL_96"
bitfld.long 0 0. " RESYNC_DLL_PER_AREF_EN "  "0 ,1 "
bitfld.long 0 8. " ZQCS_ROTATE "  "0 ,1 "
bitfld.long 0 16. " ZQ_IN_PROGRESS "  "0 ,1 "
bitfld.long 0 24.--26. " ADDR_PINS_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80156184
;tree "DENALI_CTL_97"
group 0--3
line.long 0 "DENALI_CTL_97"
bitfld.long 0 0.--2. " ADDR_PINS_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " COLUMN_SIZE_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " COLUMN_SIZE_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--27. " APREBIT_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156188
;tree "DENALI_CTL_98"
group 0--3
line.long 0 "DENALI_CTL_98"
bitfld.long 0 0.--3. " APREBIT_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--12. " TRP_AB_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " TRP_AB_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8015618c
;tree "DENALI_CTL_99"
group 0--3
line.long 0 "DENALI_CTL_99"
bitfld.long 0 0.--8. " INT_ACK "  " "
hexfld.word 1 " CS_MSK_0 "
;tree.end

base ad:0x80156190
;tree "DENALI_CTL_100"
group 0--3
line.long 0 "DENALI_CTL_100"
hexfld.word 0 " CS_MSK_1 "
hexfld.word 1 " CS_VAL_0 "
;tree.end

base ad:0x80156194
;tree "DENALI_CTL_101"
group 0--3
line.long 0 "DENALI_CTL_101"
hexfld.word 0 " CS_VAL_1 "
bitfld.long 0 16.--18. " TBST_INT_INTERVAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--27. " CKSRE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156198
;tree "DENALI_CTL_102"
group 0--3
line.long 0 "DENALI_CTL_102"
bitfld.long 0 0.--3. " CKSRX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--12. " TCKESR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--29. " TREF_INTERVAL "  " "
;tree.end

base ad:0x8015619c
;tree "DENALI_CTL_103"
group 0--3
line.long 0 "DENALI_CTL_103"
hexfld.word 0 " TDFI_PHYUPD_TYPE1 "
hexfld.word 1 " TDFI_PHYUPD_TYPE2 "
;tree.end

base ad:0x801561a0
;tree "DENALI_CTL_104"
group 0--3
line.long 0 "DENALI_CTL_104"
hexfld.word 0 " TDFI_PHYUPD_TYPE3 "
;tree.end

base ad:0x801561a4
;tree "DENALI_CTL_105"
group 0--3
line.long 0 "DENALI_CTL_105"
hexfld.long 0 " USER_DEF_REG_10 "
;tree.end

base ad:0x801561a8
;tree "DENALI_CTL_106"
group 0--3
line.long 0 "DENALI_CTL_106"
hexfld.long 0 " USER_DEF_REG_11 "
;tree.end

base ad:0x801561ac
;tree "DENALI_CTL_107"
group 0--3
line.long 0 "DENALI_CTL_107"
hexfld.long 0 " USER_DEF_REG_12 "
;tree.end

base ad:0x801561b0
;tree "DENALI_CTL_108"
group 0--3
line.long 0 "DENALI_CTL_108"
hexfld.long 0 " USER_DEF_REG_13 "
;tree.end

base ad:0x801561b4
;tree "DENALI_CTL_109"
group 0--3
line.long 0 "DENALI_CTL_109"
hexfld.long 0 " USER_DEF_REG_14 "
;tree.end

base ad:0x801561b8
;tree "DENALI_CTL_110"
group 0--3
line.long 0 "DENALI_CTL_110"
hexfld.long 0 " USER_DEF_REG_15 "
;tree.end

base ad:0x801561bc
;tree "DENALI_CTL_111"
group 0--3
line.long 0 "DENALI_CTL_111"
hexfld.long 0 " USER_DEF_REG_16 "
;tree.end

base ad:0x801561c0
;tree "DENALI_CTL_112"
group 0--3
line.long 0 "DENALI_CTL_112"
hexfld.long 0 " USER_DEF_REG_17 "
;tree.end

base ad:0x801561c4
;tree "DENALI_CTL_113"
group 0--3
line.long 0 "DENALI_CTL_113"
hexfld.long 0 " USER_DEF_REG_18 "
;tree.end

base ad:0x801561c8
;tree "DENALI_CTL_114"
group 0--3
line.long 0 "DENALI_CTL_114"
hexfld.long 0 " USER_DEF_REG_19 "
;tree.end

base ad:0x801561cc
;tree "DENALI_CTL_115"
group 0--3
line.long 0 "DENALI_CTL_115"
hexfld.long 0 " USER_DEF_REG_20 "
;tree.end

base ad:0x801561d0
;tree "DENALI_CTL_116"
group 0--3
line.long 0 "DENALI_CTL_116"
hexfld.long 0 " USER_DEF_REG_21 "
;tree.end

base ad:0x801561d4
;tree "DENALI_CTL_117"
group 0--3
line.long 0 "DENALI_CTL_117"
hexfld.long 0 " USER_DEF_REG_22 "
;tree.end

base ad:0x801561d8
;tree "DENALI_CTL_118"
group 0--3
line.long 0 "DENALI_CTL_118"
hexfld.long 0 " USER_DEF_REG_23 "
;tree.end

base ad:0x801561dc
;tree "DENALI_CTL_119"
group 0--3
line.long 0 "DENALI_CTL_119"
hexfld.long 0 " USER_DEF_REG_24 "
;tree.end

base ad:0x801561e0
;tree "DENALI_CTL_120"
group 0--3
line.long 0 "DENALI_CTL_120"
hexfld.long 0 " USER_DEF_REG_25 "
;tree.end

base ad:0x801561e4
;tree "DENALI_CTL_121"
group 0--3
line.long 0 "DENALI_CTL_121"
hexfld.long 0 " USER_DEF_REG_26 "
;tree.end

base ad:0x801561e8
;tree "DENALI_CTL_122"
group 0--3
line.long 0 "DENALI_CTL_122"
hexfld.long 0 " USER_DEF_REG_27 "
;tree.end

base ad:0x801561ec
;tree "DENALI_CTL_123"
group 0--3
line.long 0 "DENALI_CTL_123"
hexfld.long 0 " USER_DEF_REG_28 "
;tree.end

base ad:0x801561f0
;tree "DENALI_CTL_124"
group 0--3
line.long 0 "DENALI_CTL_124"
hexfld.long 0 " USER_DEF_REG_29 "
;tree.end

base ad:0x801561f4
;tree "DENALI_CTL_125"
group 0--3
line.long 0 "DENALI_CTL_125"
hexfld.long 0 " USER_DEF_REG_30 "
;tree.end

base ad:0x801561f8
;tree "DENALI_CTL_126"
group 0--3
line.long 0 "DENALI_CTL_126"
hexfld.long 0 " USER_DEF_REG_31 "
;tree.end

base ad:0x801561fc
;tree "DENALI_CTL_127"
group 0--3
line.long 0 "DENALI_CTL_127"
hexfld.long 0 " USER_DEF_REG_4 "
;tree.end

base ad:0x80156200
;tree "DENALI_CTL_128"
group 0--3
line.long 0 "DENALI_CTL_128"
hexfld.long 0 " USER_DEF_REG_5 "
;tree.end

base ad:0x80156204
;tree "DENALI_CTL_129"
group 0--3
line.long 0 "DENALI_CTL_129"
hexfld.long 0 " USER_DEF_REG_6 "
;tree.end

base ad:0x80156208
;tree "DENALI_CTL_130"
group 0--3
line.long 0 "DENALI_CTL_130"
hexfld.long 0 " USER_DEF_REG_7 "
;tree.end

base ad:0x8015620c
;tree "DENALI_CTL_131"
group 0--3
line.long 0 "DENALI_CTL_131"
hexfld.long 0 " USER_DEF_REG_8 "
;tree.end

base ad:0x80156210
;tree "DENALI_CTL_132"
group 0--3
line.long 0 "DENALI_CTL_132"
hexfld.long 0 " USER_DEF_REG_9 "
;tree.end

base ad:0x80156244
;tree "DENALI_CTL_145"
rgroup 0--3
line.long 0 "DENALI_CTL_145"
bitfld.long 0 0. " SECERR_INT_ACK "  "0 ,1 "
bitfld.long 0 4.--5. " SECERR_INT_MASK "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " SECERR_INT_STATUS "  "0 ,1 ,2 ,3 "
hexfld.word 1 " SECERR_COUNTER "
;tree.end

base ad:0x80156248
;tree "DENALI_CTL_146"
rgroup 0--3
line.long 0 "DENALI_CTL_146"
hexfld.long 0 " SECERR_ADDRESS "
;tree.end

base ad:0x8015624c
;tree "DENALI_CTL_147"
rgroup 0--3
line.long 0 "DENALI_CTL_147"
bitfld.long 0 0.--9. " SECERR_ID "  " "
bitfld.long 0 10.--11. " SECERR_PORT "  "0 ,1 ,2 ,3 "
bitfld.long 0 16. " SECERR_TYPE "  "0 ,1 "
hexfld.byte 3 " SECERR_LENGTH "
;tree.end

tree.end

;==============================================================
tree "DMAC"
;==============================================================
base ad:0x801c0000
;tree "GCC"
group 0--3
line.long 0 "GCC"
bitfld.long 0 0. " ENA "  "0 ,1 "
bitfld.long 0 1. " STAT "  "0 ,1 "
bitfld.long 0 8. " SE0 "  "0 ,1 "
bitfld.long 0 9. " DE0 "  "0 ,1 "
bitfld.long 0 10. " SE1 "  "0 ,1 "
bitfld.long 0 11. " DE1 "  "0 ,1 "
bitfld.long 0 12. " SE2 "  "0 ,1 "
bitfld.long 0 13. " DE2 "  "0 ,1 "
bitfld.long 0 14. " SE3 "  "0 ,1 "
bitfld.long 0 15. " DE3 "  "0 ,1 "
;tree.end

base ad:0x801c0004
;tree "PRTYP"
group 0--3
line.long 0 "PRTYP"
bitfld.long 0 0.--1. " CP0TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " CP1TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " CP2TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " CP3TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " CP4TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " CP5TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " CP6TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " CP7TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " CP8TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " CP9TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " CP10TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " CP11TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " CP12TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " CP13TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " CP14TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " CP15TYP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x801c0008
;tree "PRSME"
group 0--3
line.long 0 "PRSME"
bitfld.long 0 0.--1. " PR0SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR2SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR4SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR6SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR8SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR10SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR12SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR14SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR16SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR18SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR20SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR22SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR24SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR26SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR28SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR30SEC "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x801c000c
;tree "PRSMO"
group 0--3
line.long 0 "PRSMO"
bitfld.long 0 0.--1. " PR1SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR3SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR5SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR7SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR9SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR11SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR13SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR15SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR17SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR19SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR21SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR23SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR25SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR27SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR29SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR31SEC "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x801c0010
;tree "PRMSE"
group 0--3
line.long 0 "PRMSE"
bitfld.long 0 0.--1. " PR0MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR2MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR4MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR6MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR8MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR10MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR12MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR14MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR16MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR18MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR20MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR22MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR24MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR26MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR28MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR30MOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x801c0014
;tree "PRMSO"
group 0--3
line.long 0 "PRMSO"
bitfld.long 0 0.--1. " PR1MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR3MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR5MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR7MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR9MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR11MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR13MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR15MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR17MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR19MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR21MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR23MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR25MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR27MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR29MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR31MOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x801c0018
;tree "PRMOE"
group 0--3
line.long 0 "PRMOE"
bitfld.long 0 0.--1. " PR0OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR2OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR4OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR6OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR8OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR10OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR12OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR14OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR16OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR18OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR20OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR22OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR24OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR26OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR28OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR30OPT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x801c001c
;tree "PRMOO"
group 0--3
line.long 0 "PRMOO"
bitfld.long 0 0.--1. " PR1OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR3OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR5OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR7OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR9OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR11OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR13OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR15OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR17OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR19OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR21OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR23OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR25OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR27OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR29OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR31OPT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x801c0020
;tree "LCPA"
group 0--3
line.long 0 "LCPA"
bitfld.long 0 11.--31. " LCPA "  " "
;tree.end

base ad:0x801c0024
;tree "LCLA"
group 0--3
line.long 0 "LCLA"
bitfld.long 0 18.--31. " LCLA "  " "
;tree.end

base ad:0x801c0028
;tree "SLCPA"
group 0--3
line.long 0 "SLCPA"
bitfld.long 0 11.--31. " SLCPA "  " "
;tree.end

base ad:0x801c002c
;tree "SLCLA"
group 0--3
line.long 0 "SLCLA"
bitfld.long 0 18.--31. " SLCLA "  " "
;tree.end

base ad:0x801c0030
;tree "SSEG1"
group 0--3
line.long 0 "SSEG1"
hexfld.word 0 " SSSEL "
hexfld.word 1 " SSDEL "
;tree.end

base ad:0x801c0034
;tree "SSEG2"
group 0--3
line.long 0 "SSEG2"
hexfld.word 0 " SSSEL "
hexfld.word 1 " SSDEL "
;tree.end

base ad:0x801c0038
;tree "SSEG3"
group 0--3
line.long 0 "SSEG3"
hexfld.word 0 " SSSEL "
hexfld.word 1 " SSDEL "
;tree.end

base ad:0x801c003c
;tree "SSEG4"
group 0--3
line.long 0 "SSEG4"
hexfld.word 0 " SSSEL "
hexfld.word 1 " SSDEL "
;tree.end

base ad:0x801c0040
;tree "SCEG1"
group 0--3
line.long 0 "SCEG1"
hexfld.word 0 " SCSEL "
hexfld.word 1 " SCDEL "
;tree.end

base ad:0x801c0044
;tree "SCEG2"
group 0--3
line.long 0 "SCEG2"
hexfld.word 0 " SCSEL "
hexfld.word 1 " SCDEL "
;tree.end

base ad:0x801c0048
;tree "SCEG3"
group 0--3
line.long 0 "SCEG3"
hexfld.word 0 " SCSEL "
hexfld.word 1 " SCDEL "
;tree.end

base ad:0x801c004c
;tree "SCEG4"
group 0--3
line.long 0 "SCEG4"
hexfld.word 0 " SCSEL "
hexfld.word 1 " SCDEL "
;tree.end

base ad:0x801c0050
;tree "ACTIVE"
group 0--3
line.long 0 "ACTIVE"
bitfld.long 0 0.--1. " PR0AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR2AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR4AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR6AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR8AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR10AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR12AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR14AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR16AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR18AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR20AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR22AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR24AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR26AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR28AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR30AS "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x801c0054
;tree "ACTIVO"
group 0--3
line.long 0 "ACTIVO"
bitfld.long 0 0.--1. " PR1AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR3AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR5AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR7AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR9AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR11AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR13AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR15AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR17AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR19AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR21AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR23AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR25AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR27AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR29AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR31AS "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x801c0060
;tree "PCMIS"
group 0--3
line.long 0 "PCMIS"
hexfld.long 0 " PCMIS "
;tree.end

base ad:0x801c0064
;tree "PCICR"
wgroup 0--3
line.long 0 "PCICR"
hexfld.long 0 " PCICR "
;tree.end

base ad:0x801c0068
;tree "PCTIS"
group 0--3
line.long 0 "PCTIS"
hexfld.long 0 " PCTIS "
;tree.end

base ad:0x801c006c
;tree "PCEIS"
group 0--3
line.long 0 "PCEIS"
hexfld.long 0 " PCEIS "
;tree.end

base ad:0x801c0070
;tree "SPCMIS"
group 0--3
line.long 0 "SPCMIS"
hexfld.long 0 " SPCMIS "
;tree.end

base ad:0x801c0074
;tree "SPCICR"
wgroup 0--3
line.long 0 "SPCICR"
hexfld.long 0 " PCICR "
;tree.end

base ad:0x801c0078
;tree "SPCTIS"
group 0--3
line.long 0 "SPCTIS"
hexfld.long 0 " SPCTIS "
;tree.end

base ad:0x801c007c
;tree "SPCEIS"
group 0--3
line.long 0 "SPCEIS"
hexfld.long 0 " SPCEIS "
;tree.end

base ad:0x801c0080
;tree "LCMIS1"
group 0--3
line.long 0 "LCMIS1"
hexfld.long 0 " LCMIS "
;tree.end

base ad:0x801c0084
;tree "LCMIS2"
group 0--3
line.long 0 "LCMIS2"
hexfld.long 0 " LCMIS "
;tree.end

base ad:0x801c0088
;tree "LCMIS3"
group 0--3
line.long 0 "LCMIS3"
hexfld.long 0 " LCMIS "
;tree.end

base ad:0x801c008c
;tree "LCMIS4"
group 0--3
line.long 0 "LCMIS4"
hexfld.long 0 " LCMIS "
;tree.end

base ad:0x801c0090
;tree "LCICR1"
wgroup 0--3
line.long 0 "LCICR1"
hexfld.long 0 " LCICR "
;tree.end

base ad:0x801c0094
;tree "LCICR2"
wgroup 0--3
line.long 0 "LCICR2"
hexfld.long 0 " LCICR "
;tree.end

base ad:0x801c0098
;tree "LCICR3"
wgroup 0--3
line.long 0 "LCICR3"
hexfld.long 0 " LCICR "
;tree.end

base ad:0x801c009c
;tree "LCICR4"
wgroup 0--3
line.long 0 "LCICR4"
hexfld.long 0 " LCICR "
;tree.end

base ad:0x801c00a0
;tree "LCTIS1"
group 0--3
line.long 0 "LCTIS1"
hexfld.long 0 " LCTIS "
;tree.end

base ad:0x801c00a4
;tree "LCTIS2"
group 0--3
line.long 0 "LCTIS2"
hexfld.long 0 " LCTIS "
;tree.end

base ad:0x801c00a8
;tree "LCTIS3"
group 0--3
line.long 0 "LCTIS3"
hexfld.long 0 " LCTIS "
;tree.end

base ad:0x801c00ac
;tree "LCTIS4"
group 0--3
line.long 0 "LCTIS4"
hexfld.long 0 " LCTIS "
;tree.end

base ad:0x801c00b0
;tree "LCEIS1"
group 0--3
line.long 0 "LCEIS1"
hexfld.long 0 " LCEIS "
;tree.end

base ad:0x801c00b4
;tree "LCEIS2"
group 0--3
line.long 0 "LCEIS2"
hexfld.long 0 " LCEIS "
;tree.end

base ad:0x801c00b8
;tree "LCEIS3"
group 0--3
line.long 0 "LCEIS3"
hexfld.long 0 " LCEIS "
;tree.end

base ad:0x801c00bc
;tree "LCEIS4"
group 0--3
line.long 0 "LCEIS4"
hexfld.long 0 " LCEIS "
;tree.end

base ad:0x801c00c0
;tree "SLCMIS1"
group 0--3
line.long 0 "SLCMIS1"
hexfld.long 0 " SLCMIS "
;tree.end

base ad:0x801c00c4
;tree "SLCMIS2"
group 0--3
line.long 0 "SLCMIS2"
hexfld.long 0 " SLCMIS "
;tree.end

base ad:0x801c00c8
;tree "SLCMIS3"
group 0--3
line.long 0 "SLCMIS3"
hexfld.long 0 " SLCMIS "
;tree.end

base ad:0x801c00cc
;tree "SLCMIS4"
group 0--3
line.long 0 "SLCMIS4"
hexfld.long 0 " SLCMIS "
;tree.end

base ad:0x801c00d0
;tree "SLCICR1"
wgroup 0--3
line.long 0 "SLCICR1"
hexfld.long 0 " SLCICR "
;tree.end

base ad:0x801c00d4
;tree "SLCICR2"
wgroup 0--3
line.long 0 "SLCICR2"
hexfld.long 0 " SLCICR "
;tree.end

base ad:0x801c00d8
;tree "SLCICR3"
wgroup 0--3
line.long 0 "SLCICR3"
hexfld.long 0 " SLCICR "
;tree.end

base ad:0x801c00dc
;tree "SLCICR4"
wgroup 0--3
line.long 0 "SLCICR4"
hexfld.long 0 " SLCICR "
;tree.end

base ad:0x801c00e0
;tree "SLCTIS1"
group 0--3
line.long 0 "SLCTIS1"
hexfld.long 0 " SLCTIS "
;tree.end

base ad:0x801c00e4
;tree "SLCTIS2"
group 0--3
line.long 0 "SLCTIS2"
hexfld.long 0 " SLCTIS "
;tree.end

base ad:0x801c00e8
;tree "SLCTIS3"
group 0--3
line.long 0 "SLCTIS3"
hexfld.long 0 " SLCTIS "
;tree.end

base ad:0x801c00ec
;tree "SLCTIS4"
group 0--3
line.long 0 "SLCTIS4"
hexfld.long 0 " SLCTIS "
;tree.end

base ad:0x801c00f0
;tree "SLCEIS1"
group 0--3
line.long 0 "SLCEIS1"
hexfld.long 0 " SLCEIS "
;tree.end

base ad:0x801c00f4
;tree "SLCEIS2"
group 0--3
line.long 0 "SLCEIS2"
hexfld.long 0 " SLCEIS "
;tree.end

base ad:0x801c00f8
;tree "SLCEIS3"
group 0--3
line.long 0 "SLCEIS3"
hexfld.long 0 " SLCEIS "
;tree.end

base ad:0x801c00fc
;tree "SLCEIS4"
group 0--3
line.long 0 "SLCEIS4"
hexfld.long 0 " SLCEIS "
;tree.end

base ad:0x801c0100
;tree "FSESS1"
group 0--3
line.long 0 "FSESS1"
hexfld.long 0 " FSESS1 "
;tree.end

base ad:0x801c0104
;tree "FSESS2"
group 0--3
line.long 0 "FSESS2"
hexfld.long 0 " FSESS2 "
;tree.end

base ad:0x801c0108
;tree "FSEBS1"
group 0--3
line.long 0 "FSEBS1"
hexfld.long 0 " FSEBS1 "
;tree.end

base ad:0x801c010c
;tree "FSEBS2"
group 0--3
line.long 0 "FSEBS2"
hexfld.long 0 " FSEBS2 "
;tree.end

base ad:0x801c0110
;tree "PSEG1"
group 0--3
line.long 0 "PSEG1"
hexfld.word 0 " PSSEL1 "
hexfld.word 1 " PSDEL1 "
;tree.end

base ad:0x801c0114
;tree "PSEG2"
group 0--3
line.long 0 "PSEG2"
hexfld.word 0 " PSSEL2 "
hexfld.word 1 " PSDEL2 "
;tree.end

base ad:0x801c0118
;tree "PSEG3"
group 0--3
line.long 0 "PSEG3"
hexfld.word 0 " PSSEL3 "
hexfld.word 1 " PSDEL3 "
;tree.end

base ad:0x801c011c
;tree "PSEG4"
group 0--3
line.long 0 "PSEG4"
hexfld.word 0 " PSSEL4 "
hexfld.word 1 " PSDEL4 "
;tree.end

base ad:0x801c0120
;tree "PCEG1"
group 0--3
line.long 0 "PCEG1"
hexfld.word 0 " PCSEL1 "
hexfld.word 1 " PCDEL1 "
;tree.end

base ad:0x801c0124
;tree "PCEG2"
group 0--3
line.long 0 "PCEG2"
hexfld.word 0 " PCSEL2 "
hexfld.word 1 " PCDEL2 "
;tree.end

base ad:0x801c0128
;tree "PCEG3"
group 0--3
line.long 0 "PCEG3"
hexfld.word 0 " PCSEL3 "
hexfld.word 1 " PCDEL3 "
;tree.end

base ad:0x801c012c
;tree "PCEG4"
group 0--3
line.long 0 "PCEG4"
hexfld.word 0 " PCSEL4 "
hexfld.word 1 " PCDEL4 "
;tree.end

base ad:0x801c0130
;tree "RSEG1"
group 0--3
line.long 0 "RSEG1"
hexfld.word 0 " RSSEL1 "
hexfld.word 1 " RSDEL1 "
;tree.end

base ad:0x801c0134
;tree "RSEG2"
group 0--3
line.long 0 "RSEG2"
hexfld.word 0 " RSSEL2 "
hexfld.word 1 " RSDEL2 "
;tree.end

base ad:0x801c0138
;tree "RSEG3"
group 0--3
line.long 0 "RSEG3"
hexfld.word 0 " RSSEL3 "
hexfld.word 1 " RSDEL3 "
;tree.end

base ad:0x801c013c
;tree "RSEG4"
group 0--3
line.long 0 "RSEG4"
hexfld.word 0 " RSSEL4 "
hexfld.word 1 " RSDEL4 "
;tree.end

base ad:0x801c0140
;tree "RCEG1"
group 0--3
line.long 0 "RCEG1"
hexfld.word 0 " RCSEL1 "
hexfld.word 1 " RCDEL1 "
;tree.end

base ad:0x801c0144
;tree "RCEG2"
group 0--3
line.long 0 "RCEG2"
hexfld.word 0 " RCSEL2 "
hexfld.word 1 " RCDEL2 "
;tree.end

base ad:0x801c0148
;tree "RCEG3"
group 0--3
line.long 0 "RCEG3"
hexfld.word 0 " RCSEL3 "
hexfld.word 1 " RCDEL3 "
;tree.end

base ad:0x801c014c
;tree "RCEG4"
group 0--3
line.long 0 "RCEG4"
hexfld.word 0 " RCSEL4 "
hexfld.word 1 " RCDEL4 "
;tree.end

base ad:0x801c0fc4
;tree "STTC"
group 0--3
line.long 0 "STTC"
hexfld.long 0 " STTC1 "
;tree.end

base ad:0x801c0fc8
;tree "STFU"
group 0--3
line.long 0 "STFU"
hexfld.word 0 " RESULT "
bitfld.long 0 16.--19. " LCELNB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20. " SD "  "0 ,1 "
bitfld.long 0 21.--25. " PRSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 26.--27. " MSTSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--30. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " ENA "  "0 ,1 "
;tree.end

base ad:0x801c0fcc
;tree "ICFG"
rgroup 0--3
line.long 0 "ICFG"
bitfld.long 0 0.--2. " SCHNB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--4. " MNB "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " DBUFSZ "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " CPSZ "  "0 ,1 "
bitfld.long 0 8. " M1SZ "  "0 ,1 "
bitfld.long 0 9. " M2SZ "  "0 ,1 "
bitfld.long 0 10. " M3SZ "  "0 ,1 "
bitfld.long 0 11. " M4SZ "  "0 ,1 "
bitfld.long 0 12. " PTYP "  "0 ,1 "
bitfld.long 0 16.--19. " MODEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x801c0fd0
;tree "MPLUG0"
rgroup 0--3
line.long 0 "MPLUG0"
hexfld.long 0 " MPLUG0 "
;tree.end

base ad:0x801c0fd4
;tree "MPLUG1"
rgroup 0--3
line.long 0 "MPLUG1"
hexfld.long 0 " MPLUG1 "
;tree.end

base ad:0x801c0fd8
;tree "MPLUG2"
rgroup 0--3
line.long 0 "MPLUG2"
hexfld.long 0 " MPLUG2 "
;tree.end

base ad:0x801c0fdc
;tree "MPLUG3"
rgroup 0--3
line.long 0 "MPLUG3"
hexfld.long 0 " MPLUG3 "
;tree.end

base ad:0x801c0fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PTNUM "
;tree.end

base ad:0x801c0fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PTNUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " DES0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x801c0fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " DES1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x801c0fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " CONFIG "
;tree.end

base ad:0x801c0ff0
;tree "CellID0"
rgroup 0--3
line.long 0 "CellID0"
hexfld.byte 0 " ID0 "
;tree.end

base ad:0x801c0ff4
;tree "CellID1"
rgroup 0--3
line.long 0 "CellID1"
hexfld.byte 0 " ID1 "
;tree.end

base ad:0x801c0ff8
;tree "CellID2"
rgroup 0--3
line.long 0 "CellID2"
hexfld.byte 0 " ID2 "
;tree.end

base ad:0x801c0ffc
;tree "CellID3"
rgroup 0--3
line.long 0 "CellID3"
hexfld.byte 0 " ID3 "
;tree.end

base ad:0x801c0400
;tree "SSCFG0"
group 0--3
line.long 0 "SSCFG0"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0410
;tree "SDCFG0"
group 0--3
line.long 0 "SDCFG0"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0404
;tree "SSELT0"
group 0--3
line.long 0 "SSELT0"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0414
;tree "SDELT0"
group 0--3
line.long 0 "SDELT0"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0408
;tree "SSPTR0"
group 0--3
line.long 0 "SSPTR0"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c0418
;tree "SDPTR0"
group 0--3
line.long 0 "SDPTR0"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c040c
;tree "SSLNK0"
group 0--3
line.long 0 "SSLNK0"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c041c
;tree "SDLNK0"
group 0--3
line.long 0 "SDLNK0"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c0420
;tree "SSCFG1"
group 0--3
line.long 0 "SSCFG1"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0430
;tree "SDCFG1"
group 0--3
line.long 0 "SDCFG1"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0424
;tree "SSELT1"
group 0--3
line.long 0 "SSELT1"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0434
;tree "SDELT1"
group 0--3
line.long 0 "SDELT1"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0428
;tree "SSPTR1"
group 0--3
line.long 0 "SSPTR1"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c0438
;tree "SDPTR1"
group 0--3
line.long 0 "SDPTR1"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c042c
;tree "SSLNK1"
group 0--3
line.long 0 "SSLNK1"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c043c
;tree "SDLNK1"
group 0--3
line.long 0 "SDLNK1"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c0440
;tree "SSCFG2"
group 0--3
line.long 0 "SSCFG2"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0450
;tree "SDCFG2"
group 0--3
line.long 0 "SDCFG2"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0444
;tree "SSELT2"
group 0--3
line.long 0 "SSELT2"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0454
;tree "SDELT2"
group 0--3
line.long 0 "SDELT2"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0448
;tree "SSPTR2"
group 0--3
line.long 0 "SSPTR2"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c0458
;tree "SDPTR2"
group 0--3
line.long 0 "SDPTR2"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c044c
;tree "SSLNK2"
group 0--3
line.long 0 "SSLNK2"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c045c
;tree "SDLNK2"
group 0--3
line.long 0 "SDLNK2"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c0460
;tree "SSCFG3"
group 0--3
line.long 0 "SSCFG3"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0470
;tree "SDCFG3"
group 0--3
line.long 0 "SDCFG3"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0464
;tree "SSELT3"
group 0--3
line.long 0 "SSELT3"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0474
;tree "SDELT3"
group 0--3
line.long 0 "SDELT3"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0468
;tree "SSPTR3"
group 0--3
line.long 0 "SSPTR3"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c0478
;tree "SDPTR3"
group 0--3
line.long 0 "SDPTR3"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c046c
;tree "SSLNK3"
group 0--3
line.long 0 "SSLNK3"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c047c
;tree "SDLNK3"
group 0--3
line.long 0 "SDLNK3"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c0480
;tree "SSCFG4"
group 0--3
line.long 0 "SSCFG4"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0490
;tree "SDCFG4"
group 0--3
line.long 0 "SDCFG4"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0484
;tree "SSELT4"
group 0--3
line.long 0 "SSELT4"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0494
;tree "SDELT4"
group 0--3
line.long 0 "SDELT4"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0488
;tree "SSPTR4"
group 0--3
line.long 0 "SSPTR4"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c0498
;tree "SDPTR4"
group 0--3
line.long 0 "SDPTR4"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c048c
;tree "SSLNK4"
group 0--3
line.long 0 "SSLNK4"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c049c
;tree "SDLNK4"
group 0--3
line.long 0 "SDLNK4"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c04a0
;tree "SSCFG5"
group 0--3
line.long 0 "SSCFG5"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c04b0
;tree "SDCFG5"
group 0--3
line.long 0 "SDCFG5"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c04a4
;tree "SSELT5"
group 0--3
line.long 0 "SSELT5"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c04b4
;tree "SDELT5"
group 0--3
line.long 0 "SDELT5"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c04a8
;tree "SSPTR5"
group 0--3
line.long 0 "SSPTR5"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c04b8
;tree "SDPTR5"
group 0--3
line.long 0 "SDPTR5"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c04ac
;tree "SSLNK5"
group 0--3
line.long 0 "SSLNK5"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c04bc
;tree "SDLNK5"
group 0--3
line.long 0 "SDLNK5"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c04c0
;tree "SSCFG6"
group 0--3
line.long 0 "SSCFG6"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c04d0
;tree "SDCFG6"
group 0--3
line.long 0 "SDCFG6"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c04c4
;tree "SSELT6"
group 0--3
line.long 0 "SSELT6"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c04d4
;tree "SDELT6"
group 0--3
line.long 0 "SDELT6"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c04c8
;tree "SSPTR6"
group 0--3
line.long 0 "SSPTR6"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c04d8
;tree "SDPTR6"
group 0--3
line.long 0 "SDPTR6"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c04cc
;tree "SSLNK6"
group 0--3
line.long 0 "SSLNK6"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c04dc
;tree "SDLNK6"
group 0--3
line.long 0 "SDLNK6"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c04e0
;tree "SSCFG7"
group 0--3
line.long 0 "SSCFG7"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c04f0
;tree "SDCFG7"
group 0--3
line.long 0 "SDCFG7"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c04e4
;tree "SSELT7"
group 0--3
line.long 0 "SSELT7"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c04f4
;tree "SDELT7"
group 0--3
line.long 0 "SDELT7"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c04e8
;tree "SSPTR7"
group 0--3
line.long 0 "SSPTR7"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c04f8
;tree "SDPTR7"
group 0--3
line.long 0 "SDPTR7"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c04ec
;tree "SSLNK7"
group 0--3
line.long 0 "SSLNK7"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c04fc
;tree "SDLNK7"
group 0--3
line.long 0 "SDLNK7"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

base ad:0x801c0800
;tree "ESCFG0"
group 0--3
line.long 0 "ESCFG0"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0820
;tree "EDCFG0"
group 0--3
line.long 0 "EDCFG0"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0804
;tree "ESELT0"
group 0--3
line.long 0 "ESELT0"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0824
;tree "EDELT0"
group 0--3
line.long 0 "EDELT0"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0808
;tree "ESPTR0"
group 0--3
line.long 0 "ESPTR0"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c0828
;tree "EDPTR0"
group 0--3
line.long 0 "EDPTR0"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c080c
;tree "ESLNK0"
group 0--3
line.long 0 "ESLNK0"
hexfld.long 0 " EXC "
;tree.end

base ad:0x801c082c
;tree "EDLNK0"
group 0--3
line.long 0 "EDLNK0"
hexfld.long 0 " EXC "
;tree.end

base ad:0x801c0810
;tree "ESEXC0"
group 0--3
line.long 0 "ESEXC0"
hexfld.word 0 " EXC "
;tree.end

base ad:0x801c0830
;tree "EDEXC0"
group 0--3
line.long 0 "EDEXC0"
hexfld.word 0 " EXC "
;tree.end

base ad:0x801c0814
;tree "ESFRM0"
group 0--3
line.long 0 "ESFRM0"
hexfld.word 0 " FIDX "
hexfld.word 1 " FCNT "
;tree.end

base ad:0x801c0834
;tree "EDFRM0"
group 0--3
line.long 0 "EDFRM0"
hexfld.word 0 " FIDX "
hexfld.word 1 " FCNT "
;tree.end

base ad:0x801c0818
;tree "ESRLD0"
group 0--3
line.long 0 "ESRLD0"
hexfld.word 0 " FRLD "
hexfld.word 1 " ERLD "
;tree.end

base ad:0x801c0838
;tree "EDRLD0"
group 0--3
line.long 0 "EDRLD0"
hexfld.word 0 " FRLD "
hexfld.word 1 " ERLD "
;tree.end

base ad:0x801c081c
;tree "ESBLK0"
group 0--3
line.long 0 "ESBLK0"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

base ad:0x801c083c
;tree "EDBLK0"
group 0--3
line.long 0 "EDBLK0"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

base ad:0x801c0840
;tree "ESCFG1"
group 0--3
line.long 0 "ESCFG1"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0860
;tree "EDCFG1"
group 0--3
line.long 0 "EDCFG1"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0844
;tree "ESELT1"
group 0--3
line.long 0 "ESELT1"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0864
;tree "EDELT1"
group 0--3
line.long 0 "EDELT1"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0848
;tree "ESPTR1"
group 0--3
line.long 0 "ESPTR1"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c0868
;tree "EDPTR1"
group 0--3
line.long 0 "EDPTR1"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c084c
;tree "ESLNK1"
group 0--3
line.long 0 "ESLNK1"
hexfld.long 0 " EXC "
;tree.end

base ad:0x801c086c
;tree "EDLNK1"
group 0--3
line.long 0 "EDLNK1"
hexfld.long 0 " EXC "
;tree.end

base ad:0x801c0850
;tree "ESEXC1"
group 0--3
line.long 0 "ESEXC1"
hexfld.word 0 " EXC "
;tree.end

base ad:0x801c0870
;tree "EDEXC1"
group 0--3
line.long 0 "EDEXC1"
hexfld.word 0 " EXC "
;tree.end

base ad:0x801c0854
;tree "ESFRM1"
group 0--3
line.long 0 "ESFRM1"
hexfld.word 0 " FIDX "
hexfld.word 1 " FCNT "
;tree.end

base ad:0x801c0874
;tree "EDFRM1"
group 0--3
line.long 0 "EDFRM1"
hexfld.word 0 " FIDX "
hexfld.word 1 " FCNT "
;tree.end

base ad:0x801c0858
;tree "ESRLD1"
group 0--3
line.long 0 "ESRLD1"
hexfld.word 0 " FRLD "
hexfld.word 1 " ERLD "
;tree.end

base ad:0x801c0878
;tree "EDRLD1"
group 0--3
line.long 0 "EDRLD1"
hexfld.word 0 " FRLD "
hexfld.word 1 " ERLD "
;tree.end

base ad:0x801c085c
;tree "ESBLK1"
group 0--3
line.long 0 "ESBLK1"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

base ad:0x801c087c
;tree "EDBLK1"
group 0--3
line.long 0 "EDBLK1"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

base ad:0x801c0880
;tree "ESCFG2"
group 0--3
line.long 0 "ESCFG2"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c08a0
;tree "EDCFG2"
group 0--3
line.long 0 "EDCFG2"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c0884
;tree "ESELT2"
group 0--3
line.long 0 "ESELT2"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c08a4
;tree "EDELT2"
group 0--3
line.long 0 "EDELT2"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c0888
;tree "ESPTR2"
group 0--3
line.long 0 "ESPTR2"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c08a8
;tree "EDPTR2"
group 0--3
line.long 0 "EDPTR2"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c088c
;tree "ESLNK2"
group 0--3
line.long 0 "ESLNK2"
hexfld.long 0 " EXC "
;tree.end

base ad:0x801c08ac
;tree "EDLNK2"
group 0--3
line.long 0 "EDLNK2"
hexfld.long 0 " EXC "
;tree.end

base ad:0x801c0890
;tree "ESEXC2"
group 0--3
line.long 0 "ESEXC2"
hexfld.word 0 " EXC "
;tree.end

base ad:0x801c08b0
;tree "EDEXC2"
group 0--3
line.long 0 "EDEXC2"
hexfld.word 0 " EXC "
;tree.end

base ad:0x801c0894
;tree "ESFRM2"
group 0--3
line.long 0 "ESFRM2"
hexfld.word 0 " FIDX "
hexfld.word 1 " FCNT "
;tree.end

base ad:0x801c08b4
;tree "EDFRM2"
group 0--3
line.long 0 "EDFRM2"
hexfld.word 0 " FIDX "
hexfld.word 1 " FCNT "
;tree.end

base ad:0x801c0898
;tree "ESRLD2"
group 0--3
line.long 0 "ESRLD2"
hexfld.word 0 " FRLD "
hexfld.word 1 " ERLD "
;tree.end

base ad:0x801c08b8
;tree "EDRLD2"
group 0--3
line.long 0 "EDRLD2"
hexfld.word 0 " FRLD "
hexfld.word 1 " ERLD "
;tree.end

base ad:0x801c089c
;tree "ESBLK2"
group 0--3
line.long 0 "ESBLK2"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

base ad:0x801c08bc
;tree "EDBLK2"
group 0--3
line.long 0 "EDBLK2"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

base ad:0x801c08c0
;tree "ESCFG3"
group 0--3
line.long 0 "ESCFG3"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c08e0
;tree "EDCFG3"
group 0--3
line.long 0 "EDCFG3"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

base ad:0x801c08c4
;tree "ESELT3"
group 0--3
line.long 0 "ESELT3"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c08e4
;tree "EDELT3"
group 0--3
line.long 0 "EDELT3"
hexfld.word 0 " EIDX "
hexfld.word 1 " ECNT "
;tree.end

base ad:0x801c08c8
;tree "ESPTR3"
group 0--3
line.long 0 "ESPTR3"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c08e8
;tree "EDPTR3"
group 0--3
line.long 0 "EDPTR3"
hexfld.long 0 " PTR "
;tree.end

base ad:0x801c08cc
;tree "ESLNK3"
group 0--3
line.long 0 "ESLNK3"
hexfld.long 0 " EXC "
;tree.end

base ad:0x801c08ec
;tree "EDLNK3"
group 0--3
line.long 0 "EDLNK3"
hexfld.long 0 " EXC "
;tree.end

base ad:0x801c08d0
;tree "ESEXC3"
group 0--3
line.long 0 "ESEXC3"
hexfld.word 0 " EXC "
;tree.end

base ad:0x801c08f0
;tree "EDEXC3"
group 0--3
line.long 0 "EDEXC3"
hexfld.word 0 " EXC "
;tree.end

base ad:0x801c08d4
;tree "ESFRM3"
group 0--3
line.long 0 "ESFRM3"
hexfld.word 0 " FIDX "
hexfld.word 1 " FCNT "
;tree.end

base ad:0x801c08f4
;tree "EDFRM3"
group 0--3
line.long 0 "EDFRM3"
hexfld.word 0 " FIDX "
hexfld.word 1 " FCNT "
;tree.end

base ad:0x801c08d8
;tree "ESRLD3"
group 0--3
line.long 0 "ESRLD3"
hexfld.word 0 " FRLD "
hexfld.word 1 " ERLD "
;tree.end

base ad:0x801c08f8
;tree "EDRLD3"
group 0--3
line.long 0 "EDRLD3"
hexfld.word 0 " FRLD "
hexfld.word 1 " ERLD "
;tree.end

base ad:0x801c08dc
;tree "ESBLK3"
group 0--3
line.long 0 "ESBLK3"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

base ad:0x801c08fc
;tree "EDBLK3"
group 0--3
line.long 0 "EDBLK3"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

tree.end

;==============================================================
tree "DMC"
;==============================================================
base ad:0x80156000
;tree "CTL_00"
group 0--3
line.long 0 "CTL_00"
bitfld.long 0 0. " ACTIVE_AGING "  "0 ,1 "
bitfld.long 0 8. " ADDR_CMP_EN "  "0 ,1 "
bitfld.long 0 16. " AP "  "0 ,1 "
bitfld.long 0 24. " AREFRESH "  "0 ,1 "
;tree.end

base ad:0x80156004
;tree "CTL_01"
group 0--3
line.long 0 "CTL_01"
bitfld.long 0 0. " AUTO_REFRESH_MODE "  "0 ,1 "
bitfld.long 0 8. " AXI0_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 16. " AXI1_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 24. " AXI2_BDW_OVFLOW "  "0 ,1 "
;tree.end

base ad:0x80156008
;tree "CTL_02"
group 0--3
line.long 0 "CTL_02"
bitfld.long 0 0. " AXI3_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 8. " BANK_SPLIT_EN "  "0 ,1 "
bitfld.long 0 16. " CONCURRENTAP "  "0 ,1 "
bitfld.long 0 20. " DLLLOCKREG "  "0 ,1 "
;tree.end

base ad:0x8015600C
;tree "CTL_03"
group 0--3
line.long 0 "CTL_03"
bitfld.long 0 8. " DRIVE_DQ_DQ "  "0 ,1 "
bitfld.long 0 16. " ENABLE_QUICK_SREFRESH "  "0 ,1 "
;tree.end

base ad:0x80156010
;tree "CTL_04"
group 0--3
line.long 0 "CTL_04"
bitfld.long 0 0. " FAST_WRITE "  "0 ,1 "
bitfld.long 0 8. " INTRPTAPBURST "  "0 ,1 "
bitfld.long 0 16. " INTRPTREADA "  "0 ,1 "
bitfld.long 0 24. " INTRPTWRITEA "  "0 ,1 "
;tree.end

base ad:0x80156014
;tree "CTL_05"
group 0--3
line.long 0 "CTL_05"
bitfld.long 0 0. " NO_CMD_INIT "  "0 ,1 "
bitfld.long 0 8. " PLACEMENT_EN "  "0 ,1 "
bitfld.long 0 16. " POWER_DOWN "  "0 ,1 "
bitfld.long 0 24. " PRIORITY_EN "  "0 ,1 "
;tree.end

base ad:0x80156018
;tree "CTL_06"
group 0--3
line.long 0 "CTL_06"
bitfld.long 0 0. " PWRUP_SREFRESH_EXIT "  "0 ,1 "
bitfld.long 0 8. " RD2RD_TURN "  "0 ,1 "
bitfld.long 0 16. " REDUC "  "0 ,1 "
bitfld.long 0 24. " REG_DIMM_ENABLE "  "0 ,1 "
;tree.end

base ad:0x8015601C
;tree "CTL_07"
group 0--3
line.long 0 "CTL_07"
bitfld.long 0 0. " RW_SAME_EN "  "0 ,1 "
bitfld.long 0 8. " SREFRESH "  "0 ,1 "
bitfld.long 0 16. " START "  "0 ,1 "
bitfld.long 0 24. " SWAP_EN "  "0 ,1 "
;tree.end

base ad:0x80156020
;tree "CTL_08"
group 0--3
line.long 0 "CTL_08"
bitfld.long 0 0. " TRAS_LOCKOUT "  "0 ,1 "
bitfld.long 0 8. " TREF_ENABLE "  "0 ,1 "
bitfld.long 0 16. " WRITEINTERP "  "0 ,1 "
bitfld.long 0 24. " WRITE_MODEREG "  "0 ,1 "
;tree.end

base ad:0x80156024
;tree "CTL_09"
group 0--3
line.long 0 "CTL_09"
bitfld.long 0 0. " WRLAT "  "0 ,1 "
bitfld.long 0 8.--9. " AXI0_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI0_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI0_W_PRIORITY "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80156028
;tree "CTL_10"
group 0--3
line.long 0 "CTL_10"
bitfld.long 0 0.--1. " AXI1_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI1_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI1_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI2_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8015602C
;tree "CTL_11"
group 0--3
line.long 0 "CTL_11"
bitfld.long 0 0.--1. " AXI2_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI2_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI3_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI3_R_PRIORITY "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80156030
;tree "CTL_12"
group 0--3
line.long 0 "CTL_12"
bitfld.long 0 0.--1. " AXI3_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " CS_MAP "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " LOWPOWER_REFRESH_ENABLE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80156034
;tree "CTL_13"
group 0--3
line.long 0 "CTL_13"
bitfld.long 0 0.--1. " MAX_CS_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TEMRS "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " WRTPRCT_ENABLE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80156038
;tree "CTL_14"
group 0--3
line.long 0 "CTL_14"
bitfld.long 0 0.--2. " ARB_CMD_Q_THRESHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " BSTLEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " CASLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " CKE_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8015603C
;tree "CTL_15"
group 0--3
line.long 0 "CTL_15"
bitfld.long 0 0.--2. " COLUMN_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " PORT_DATA_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " Q_FULLNESS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TCKE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80156040
;tree "CTL_16"
group 0--3
line.long 0 "CTL_16"
bitfld.long 0 0.--2. " TDFI_CTRL_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDFI_DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " TDFI_DRAM_CLK_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TRRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80156044
;tree "CTL_17"
group 0--3
line.long 0 "CTL_17"
bitfld.long 0 0.--3. " TWTR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " CASLAT_LIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156048
;tree "CTL_18"
group 0--3
line.long 0 "CTL_18"
bitfld.long 0 0.--3. " CASLAT_LIN_GATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " COMMAND_AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " INITAREF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAX_COL_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8015604C
;tree "CTL_19"
group 0--3
line.long 0 "CTL_19"
bitfld.long 0 0.--3. " MAX_ROW_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " PORT_CMD_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_CTRLUPD_MIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156050
;tree "CTL_20"
group 0--3
line.long 0 "CTL_20"
bitfld.long 0 0.--3. " TDFI_PHY_RDLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TDFI_PHY_WRLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDFI_PHY_WRLAT_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_RDDATA_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156054
;tree "CTL_21"
group 0--3
line.long 0 "CTL_21"
bitfld.long 0 0.--3. " TDFI_RDDATA_EN_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TRP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TWR_INT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--28. " DLL_LOCK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x80156058
;tree "CTL_22"
group 0--3
line.long 0 "CTL_22"
bitfld.long 0 0.--4. " LOWPOWER_AUTO_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " LOWPOWER_CONTROL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " OUT_OF_RANGE_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--28. " TMRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8015605C
;tree "CTL_23"
group 0--3
line.long 0 "CTL_23"
bitfld.long 0 0.--4. " TRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--14. " AXI0_BDW "  " "
bitfld.long 0 16.--22. " AXI0_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI1_BDW "  " "
;tree.end

base ad:0x80156060
;tree "CTL_24"
group 0--3
line.long 0 "CTL_24"
bitfld.long 0 0.--6. " AXI1_CURRENT_BDW "  " "
bitfld.long 0 8.--14. " AXI2_BDW "  " "
bitfld.long 0 16.--22. " AXI2_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI3_BDW "  " "
;tree.end

base ad:0x80156064
;tree "CTL_25"
group 0--3
line.long 0 "CTL_25"
bitfld.long 0 0.--6. " AXI3_CURRENT_BDW "  " "
bitfld.long 0 16.--22. " OUT_OF_RANGE_LENGTH "  " "
bitfld.long 0 24.--30. " WRTPRCT_ERROR_LENGTH "  " "
;tree.end

base ad:0x80156068
;tree "CTL_26"
group 0--3
line.long 0 "CTL_26"
hexfld.byte 2 " TRAS_MIN "
hexfld.byte 3 " TRCD_INT "
;tree.end

base ad:0x8015606C
;tree "CTL_27"
group 0--3
line.long 0 "CTL_27"
hexfld.byte 0 " TRFC "
bitfld.long 0 8.--17. " OUT_OF_RANGE_SOURCE_ID "  " "
;tree.end

base ad:0x80156070
;tree "CTL_28"
rgroup 0--3
line.long 0 "CTL_28"
bitfld.long 0 0.--9. " PORT_CMD_ERROR_ID "  " "
bitfld.long 0 16.--25. " PORT_DATA_ERROR_ID "  " "
;tree.end

base ad:0x80156074
;tree "CTL_29"
rgroup 0--3
line.long 0 "CTL_29"
hexfld.word 0 " TDFI_CTRLUPD_MAX "
hexfld.word 1 " TDFI_PHYUPD_RESP "
;tree.end

base ad:0x80156078
;tree "CTL_30"
group 0--3
line.long 0 "CTL_30"
hexfld.word 0 " TDFI_PHYUPD_TYPE0 "
hexfld.word 1 " TRF "
;tree.end

base ad:0x8015607C
;tree "CTL_31"
group 0--3
line.long 0 "CTL_31"
hexfld.long 0 " CTL_31 "
;tree.end

base ad:0x80156080
;tree "CTL_32"
group 0--3
line.long 0 "CTL_32"
hexfld.word 1 " AXI0_EN_SIZE_LT_WIDTH_INSTR "
;tree.end

base ad:0x80156084
;tree "CTL_33"
group 0--3
line.long 0 "CTL_33"
hexfld.word 0 " AXI2_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 1 " AXI2_EN_SIZE_LT_WIDTH_INSTR "
;tree.end

base ad:0x80156088
;tree "CTL_34"
group 0--3
line.long 0 "CTL_34"
hexfld.word 0 " AXI3_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 1 " LOWPOWER_EXTERNAL_CNT "
;tree.end

base ad:0x8015608C
;tree "CTL_35"
group 0--3
line.long 0 "CTL_35"
hexfld.word 0 " LOWPOWER_INTERNAL_CNT "
hexfld.word 1 " LOWPOWER_POWER_DOWN_CNT "
;tree.end

base ad:0x80156090
;tree "CTL_36"
group 0--3
line.long 0 "CTL_36"
hexfld.word 0 " LOWPOWER_REFRESH_HOLD "
hexfld.word 1 " LOWPOWER_SELF_REFRESH "
;tree.end

base ad:0x80156094
;tree "CTL_37"
group 0--3
line.long 0 "CTL_37"
hexfld.word 0 " TDLL "
hexfld.word 1 " TPDEX "
;tree.end

base ad:0x80156098
;tree "CTL_38"
group 0--3
line.long 0 "CTL_38"
hexfld.word 0 " TRAS_MAX "
hexfld.word 1 " TXSNR "
;tree.end

base ad:0x8015609C
;tree "CTL_39"
group 0--3
line.long 0 "CTL_39"
hexfld.word 0 " TXSR "
hexfld.word 1 " VERSION "
;tree.end

base ad:0x801560A0
;tree "CTL_40"
group 0--3
line.long 0 "CTL_40"
bitfld.long 0 0.--23. " TINIT "  " "
;tree.end

base ad:0x801560A4
;tree "CTL_41"
rgroup 0--3
line.long 0 "CTL_41"
hexfld.long 0 " OUT_OF_RANGE_ADDR "
;tree.end

base ad:0x801560A8
;tree "CTL_42"
rgroup 0--3
line.long 0 "CTL_42"
hexfld.long 0 " PORT_CMD-ERROR_ADDR "
;tree.end

base ad:0x801560AC
;tree "CTL_43"
rgroup 0--3
line.long 0 "CTL_43"
hexfld.long 0 " WRTPRCT_CMD-ERROR_ADDR "
;tree.end

base ad:0x801560B0
;tree "CTL_44"
group 0--3
line.long 0 "CTL_44"
hexfld.long 0 " WRTPRCT_LOWER_ADRESS_0 "
;tree.end

base ad:0x801560B4
;tree "CTL_45"
group 0--3
line.long 0 "CTL_45"
hexfld.long 0 " WRTPRCT_LOWER_ADRESS_1 "
;tree.end

base ad:0x801560B8
;tree "CTL_46"
group 0--3
line.long 0 "CTL_46"
hexfld.long 0 " WRTPRCT_UPPER_ADRESS_0 "
;tree.end

base ad:0x801560BC
;tree "CTL_47"
group 0--3
line.long 0 "CTL_47"
hexfld.long 0 " WRTPRCT_UPPER_ADRESS_1 "
;tree.end

base ad:0x801560EC
;tree "CTL_59"
group 0--3
line.long 0 "CTL_59"
hexfld.long 0 " PHY_ADD "
;tree.end

base ad:0x801560F0
;tree "CTL_60"
group 0--3
line.long 0 "CTL_60"
hexfld.long 0 " PHY_CFG "
;tree.end

base ad:0x801560F4
;tree "CTL_61"
rgroup 0--3
line.long 0 "CTL_61"
hexfld.long 0 " PHY_STS "
;tree.end

base ad:0x801560F8
;tree "CTL_62"
rgroup 0--3
line.long 0 "CTL_62"
;tree.end

base ad:0x801560FC
;tree "CTL_63"
group 0--3
line.long 0 "CTL_63"
bitfld.long 0 0. " WRLAT_ADJ "  "0 ,1 "
bitfld.long 0 8.--9. " W2R_DIFFCS_DLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " W2R_SAMECS_DLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--27. " DRAM_CLASS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156100
;tree "CTL_64"
group 0--3
line.long 0 "CTL_64"
bitfld.long 0 0.--3. " RDLAT_ADJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DLL_RST_ADJ_DLY "
hexfld.byte 2 " TMOD "
;tree.end

base ad:0x80156104
;tree "CTL_65"
group 0--3
line.long 0 "CTL_65"
hexfld.long 0 " CTL_65 "
;tree.end

base ad:0x80156108
;tree "CTL_66"
group 0--3
line.long 0 "CTL_66"
hexfld.long 0 " CTL_66 "
;tree.end

base ad:0x8015610C
;tree "CTL_67"
group 0--3
line.long 0 "CTL_67"
hexfld.word 0 " DLL_RST_DELAY "
;tree.end

base ad:0x80156120
;tree "CTL_72"
group 0--3
line.long 0 "CTL_72"
hexfld.long 0 " USER_DEF_REG_2 "
;tree.end

base ad:0x80156124
;tree "CTL_73"
group 0--3
line.long 0 "CTL_73"
bitfld.long 0 26. " DEBUG_DFI_TRIGGER_IS_WRITE "  "0 ,1 "
bitfld.long 0 27. " DMC_JTAG_CONTROL_ENABLE "  "0 ,1 "
bitfld.long 0 28. " DMC_JTAG_TRSTN "  "0 ,1 "
bitfld.long 0 29. " DMC_JTAG_TCK "  "0 ,1 "
bitfld.long 0 30. " DMC_JTAG_TMS "  "0 ,1 "
bitfld.long 0 31. " DMC_JTAG_TDI "  "0 ,1 "
;tree.end

base ad:0x80156128
;tree "CTL_74"
group 0--3
line.long 0 "CTL_74"
hexfld.long 0 " USER_DEF_REG_RO_2 "
;tree.end

base ad:0x8015612C
;tree "CTL_75"
rgroup 0--3
line.long 0 "CTL_75"
bitfld.long 0 30. " DDR_PHY_DFI_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 31. " DMC_JTAG_TDO "  "0 ,1 "
;tree.end

base ad:0x80156130
;tree "CTL_76"
rgroup 0--3
line.long 0 "CTL_76"
bitfld.long 0 8. " DQS_N_EN "  "0 ,1 "
bitfld.long 0 24. " LPDDR2_S4 "  "0 ,1 "
;tree.end

base ad:0x80156134
;tree "CTL_77"
group 0--3
line.long 0 "CTL_77"
bitfld.long 0 0.--1. " TDQSCK_MAX "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TDQSCK_MIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--26. " R2R_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80156138
;tree "CTL_78"
group 0--3
line.long 0 "CTL_78"
bitfld.long 0 0.--1. " TDQSCK_MAX "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TDQSCK_MIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--28. " TCCD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8015613C
;tree "CTL_79"
group 0--3
line.long 0 "CTL_79"
bitfld.long 0 0.--2. " TMRR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " W2W_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " W2W_SAMECS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--28. " TMRR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x80156140
;tree "CTL_80"
group 0--3
line.long 0 "CTL_80"
bitfld.long 0 8.--11. " ZQ_ON_SREF_EXIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " ZQ_REQ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--29. " TFAW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80156144
;tree "CTL_81"
group 0--3
line.long 0 "CTL_81"
hexfld.byte 0 " REFRESH_PER_ZQ "
bitfld.long 0 8.--17. " INIT_MASK "  " "
;tree.end

base ad:0x80156148
;tree "CTL_82"
group 0--3
line.long 0 "CTL_82"
bitfld.long 0 0.--9. " INIT_STATUS "  " "
bitfld.long 0 16.--27. " ZQCL "  " "
;tree.end

base ad:0x8015614C
;tree "CTL_83"
group 0--3
line.long 0 "CTL_83"
bitfld.long 0 0.--11. " ZQCS "  " "
bitfld.long 0 16.--27. " ZQINIT "  " "
;tree.end

base ad:0x80156150
;tree "CTL_84"
group 0--3
line.long 0 "CTL_84"
bitfld.long 0 0.--11. " ZQRESET "  " "
bitfld.long 0 16.--29. " MR0_DATA_0 "  " "
;tree.end

base ad:0x80156154
;tree "CTL_85"
group 0--3
line.long 0 "CTL_85"
bitfld.long 0 0.--13. " MR0_DATA_1 "  " "
bitfld.long 0 16.--29. " MR16_DATA_0 "  " "
;tree.end

base ad:0x80156158
;tree "CTL_86"
group 0--3
line.long 0 "CTL_86"
bitfld.long 0 0.--13. " MR16_DATA_1 "  " "
bitfld.long 0 16.--29. " MR17_DATA_0 "  " "
;tree.end

base ad:0x8015615C
;tree "CTL_87"
group 0--3
line.long 0 "CTL_87"
bitfld.long 0 0.--13. " MR17_DATA_1 "  " "
bitfld.long 0 16.--29. " MR1_DATA_0 "  " "
;tree.end

base ad:0x80156160
;tree "CTL_88"
group 0--3
line.long 0 "CTL_88"
bitfld.long 0 0.--13. " MR1_DATA_1 "  " "
bitfld.long 0 16.--29. " MR2_DATA_0 "  " "
;tree.end

base ad:0x80156164
;tree "CTL_89"
group 0--3
line.long 0 "CTL_89"
bitfld.long 0 0.--13. " MR2_DATA_1 "  " "
bitfld.long 0 16.--29. " MR3_DATA_0 "  " "
;tree.end

base ad:0x80156168
;tree "CTL_90"
group 0--3
line.long 0 "CTL_90"
bitfld.long 0 0.--13. " MR3_DATA_1 "  " "
hexfld.word 1 " PERIPHERAL_MRR_DATA "
;tree.end

base ad:0x8015616C
;tree "CTL_91"
group 0--3
line.long 0 "CTL_91"
hexfld.word 0 " READ_MODEREG "
;tree.end

base ad:0x80156170
;tree "CTL_92"
group 0--3
line.long 0 "CTL_92"
bitfld.long 0 0.--23. " TINIT3 "  " "
;tree.end

base ad:0x80156174
;tree "CTL_93"
group 0--3
line.long 0 "CTL_93"
bitfld.long 0 0.--23. " TINIT4 "  " "
;tree.end

base ad:0x80156178
;tree "CTL_94"
group 0--3
line.long 0 "CTL_94"
bitfld.long 0 0.--23. " TINIT5 "  " "
bitfld.long 0 24. " CONCURRENTAP_WR_ONLY "  "0 ,1 "
;tree.end

base ad:0x8015617C
;tree "CTL_95"
group 0--3
line.long 0 "CTL_95"
bitfld.long 0 0. " CONFIG_ERROR "  "0 ,1 "
bitfld.long 0 8. " EIGHT_BANK_MODE_0 "  "0 ,1 "
bitfld.long 0 16. " EIGHT_BANK_MODE_1 "  "0 ,1 "
bitfld.long 0 24. " RESYNC_DLL "  "0 ,1 "
;tree.end

base ad:0x80156180
;tree "CTL_96"
group 0--3
line.long 0 "CTL_96"
bitfld.long 0 0. " RESYNC_DLL_PER_AREF_EN "  "0 ,1 "
bitfld.long 0 8. " ZQCS_ROTATE "  "0 ,1 "
bitfld.long 0 16. " ZQ_IN_PROGRESS "  "0 ,1 "
bitfld.long 0 24.--26. " ADDR_PINS_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80156184
;tree "CTL_97"
group 0--3
line.long 0 "CTL_97"
bitfld.long 0 0.--1. " ADDR_PINS_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " COLUMN_SIZE_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " COLUMN_SIZE_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--27. " APREBIT_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80156188
;tree "CTL_98"
group 0--3
line.long 0 "CTL_98"
bitfld.long 0 0.--3. " APREBIT_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--12. " TRP_AB_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " TRP_AB_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8015618C
;tree "CTL_99"
group 0--3
line.long 0 "CTL_99"
bitfld.long 0 0.--8. " INT_ACK "  " "
hexfld.word 1 " CS_MSK_0 "
;tree.end

base ad:0x80156190
;tree "CTL_100"
group 0--3
line.long 0 "CTL_100"
hexfld.word 0 " CS_MSK_1 "
hexfld.word 1 " CS_VAL_0 "
;tree.end

base ad:0x80156194
;tree "CTL_101"
group 0--3
line.long 0 "CTL_101"
hexfld.word 0 " CS_VAL_1 "
bitfld.long 0 16.--18. " TBST_INT_INTERVAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--27. " CKSRE "  " "
;tree.end

base ad:0x80156198
;tree "CTL_102"
group 0--3
line.long 0 "CTL_102"
bitfld.long 0 0.--3. " CKSRX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--12. " TCKESR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--29. " TREF_INTERVAL "  " "
;tree.end

base ad:0x8015619C
;tree "CTL_103"
group 0--3
line.long 0 "CTL_103"
hexfld.word 0 " TDFI_PHYUPD_TYPE1 "
hexfld.word 1 " TDFI_PHYUPD_TYPE2 "
;tree.end

base ad:0x801561A0
;tree "CTL_104"
group 0--3
line.long 0 "CTL_104"
hexfld.word 0 " TDFI_PHYUPD_TYPE1 "
;tree.end

base ad:0x801561A4
;tree "CTL_105"
group 0--3
line.long 0 "CTL_105"
hexfld.long 0 " USER_DEF_REG_10 "
;tree.end

base ad:0x801561A8
;tree "CTL_106"
group 0--3
line.long 0 "CTL_106"
hexfld.long 0 " USER_DEF_REG_11 "
;tree.end

base ad:0x801561AC
;tree "CTL_107"
group 0--3
line.long 0 "CTL_107"
hexfld.long 0 " USER_DEF_REG_12 "
;tree.end

base ad:0x801561B0
;tree "CTL_108"
group 0--3
line.long 0 "CTL_108"
hexfld.long 0 " USER_DEF_REG_13 "
;tree.end

base ad:0x801561B4
;tree "CTL_109"
group 0--3
line.long 0 "CTL_109"
hexfld.long 0 " USER_DEF_REG_14 "
;tree.end

base ad:0x801561B8
;tree "CTL_110"
group 0--3
line.long 0 "CTL_110"
hexfld.long 0 " USER_DEF_REG_15 "
;tree.end

base ad:0x801561BC
;tree "CTL_111"
group 0--3
line.long 0 "CTL_111"
hexfld.long 0 " USER_DEF_REG_16 "
;tree.end

base ad:0x801561C0
;tree "CTL_112"
group 0--3
line.long 0 "CTL_112"
hexfld.long 0 " USER_DEF_REG_17 "
;tree.end

base ad:0x801561C4
;tree "CTL_113"
group 0--3
line.long 0 "CTL_113"
hexfld.long 0 " USER_DEF_REG_18 "
;tree.end

base ad:0x801561C8
;tree "CTL_114"
group 0--3
line.long 0 "CTL_114"
hexfld.long 0 " USER_DEF_REG_19 "
;tree.end

base ad:0x801561CC
;tree "CTL_115"
group 0--3
line.long 0 "CTL_115"
hexfld.long 0 " USER_DEF_REG_20 "
;tree.end

base ad:0x801561D0
;tree "CTL_116"
group 0--3
line.long 0 "CTL_116"
hexfld.long 0 " USER_DEF_REG_21 "
;tree.end

base ad:0x801561D4
;tree "CTL_117"
group 0--3
line.long 0 "CTL_117"
hexfld.long 0 " USER_DEF_REG_22 "
;tree.end

base ad:0x801561D8
;tree "CTL_118"
group 0--3
line.long 0 "CTL_118"
hexfld.long 0 " USER_DEF_REG_23 "
;tree.end

base ad:0x801561DC
;tree "CTL_119"
group 0--3
line.long 0 "CTL_119"
hexfld.long 0 " USER_DEF_REG_24 "
;tree.end

base ad:0x801561E0
;tree "CTL_120"
group 0--3
line.long 0 "CTL_120"
hexfld.long 0 " USER_DEF_REG_25 "
;tree.end

base ad:0x801561E4
;tree "CTL_121"
group 0--3
line.long 0 "CTL_121"
hexfld.long 0 " USER_DEF_REG_26 "
;tree.end

base ad:0x801561E8
;tree "CTL_122"
group 0--3
line.long 0 "CTL_122"
hexfld.long 0 " USER_DEF_REG_27 "
;tree.end

base ad:0x801561EC
;tree "CTL_123"
group 0--3
line.long 0 "CTL_123"
hexfld.long 0 " USER_DEF_REG_28 "
;tree.end

base ad:0x801561F0
;tree "CTL_124"
group 0--3
line.long 0 "CTL_124"
hexfld.long 0 " USER_DEF_REG_29 "
;tree.end

base ad:0x801561F4
;tree "CTL_125"
group 0--3
line.long 0 "CTL_125"
hexfld.long 0 " USER_DEF_REG_30 "
;tree.end

base ad:0x801561F8
;tree "CTL_126"
group 0--3
line.long 0 "CTL_126"
hexfld.long 0 " USER_DEF_REG_31 "
;tree.end

base ad:0x801561FC
;tree "CTL_127"
group 0--3
line.long 0 "CTL_127"
hexfld.long 0 " USER_DEF_REG_4 "
;tree.end

base ad:0x80156200
;tree "CTL_128"
group 0--3
line.long 0 "CTL_128"
hexfld.long 0 " USER_DEF_REG_5 "
;tree.end

base ad:0x80156204
;tree "CTL_129"
group 0--3
line.long 0 "CTL_129"
hexfld.long 0 " USER_DEF_REG_6 "
;tree.end

base ad:0x80156208
;tree "CTL_130"
group 0--3
line.long 0 "CTL_130"
hexfld.long 0 " USER_DEF_REG_7 "
;tree.end

base ad:0x8015620C
;tree "CTL_131"
group 0--3
line.long 0 "CTL_131"
hexfld.long 0 " USER_DEF_REG_8 "
;tree.end

base ad:0x80156210
;tree "CTL_132"
group 0--3
line.long 0 "CTL_132"
hexfld.long 0 " USER_DEF_REG_9 "
;tree.end

tree.end

;==============================================================
tree "DSI (3 instances)"
;==============================================================
base ad:0xa0353000
;********************************************
tree "DSI-2"
;********************************************
if (((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x8015741c)&0x100000)!=0x100000)||((data.long(ad:0x801571ec)&0x4)!=0x4)||((data.long(ad:0x80157428)&0x400)!=0x0))

base ad:0x80157064
group 0--3
line.long 0 "PRCM_MCDECLK_MGT"
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 20. " DSS_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "

else

base ad:0xa0353000
;tree "2MCTL_INTEGRATION_MODE"
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
;tree.end

base ad:0xa0353004
;tree "2MCTL_MAIN_DATA_CTL"
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF1_MODE "  "0 ,1 "
bitfld.long 0 2. " VID_EN "  "0 ,1 "
bitfld.long 0 3. " TVG_SEL "  "0 ,1 "
bitfld.long 0 4. " TBG_SEL "  "0 ,1 "
bitfld.long 0 5. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 6. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 7. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 8. " READ_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_EN "  "0 ,1 "
bitfld.long 0 10. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 11. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 12. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 13. " DISP_EOT_GEN "  "0 ,1 "
;tree.end

base ad:0xa0353008
;tree "2MCTL_MAIN_PHY_CTL"
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 2. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 3. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 6.--9. " WAIT_BURST_TIME "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10. " CLK_FORCE_STOP "  "0 ,1 "
;tree.end

base ad:0xa035300c
;tree "2MCTL_PLL_CTL"
group 0--3
line.long 0 "MCTL_PLL_CTL"
hexfld.byte 0 " PLL_MULT "
bitfld.long 0 8.--13. " PLL_OUT_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--16. " PLL_IN_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17. " PLL_SEL_DIV2 "  "0 ,1 "
bitfld.long 0 18. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 31. " PLL_MASTER "  "0 ,1 "
;tree.end

base ad:0xa0353010
;tree "2MCTL_LANE_STS"
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " DATLANE1_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " DATLANE2_STATE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0353014
;tree "2MCTL_DPHY_TIMEOUT"
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT"
bitfld.long 0 0.--3. " CLK_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--17. " HSTX_TO_VAL "  " "
bitfld.long 0 18.--31. " LPRX_TO_VAL "  " "
;tree.end

base ad:0xa0353018
;tree "2MCTL_ULPOUT_TIME"
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
;tree.end

base ad:0xa035301c
;tree "2MCTL_DPHY_STATIC"
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6.--11. " UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa0353020
;tree "2MCTL_MAIN_EN"
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 7. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 8. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " IF1_EN "  "0 ,1 "
bitfld.long 0 10. " IF2_EN "  "0 ,1 "
;tree.end

base ad:0xa0353024
;tree "2MCTL_MAIN_STS"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK "  "0 ,1 "
;tree.end

base ad:0xa0353028
;tree "2MCTL_DPHY_ERR"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2 "  "0 ,1 "
;tree.end

base ad:0xa0353030
;tree "2INT_VID_RDDATA"
group 0--3
line.long 0 "INT_VID_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

base ad:0xa0353034
;tree "2INT_VID_GNT"
group 0--3
line.long 0 "INT_VID_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

base ad:0xa0353038
;tree "2INT_CMD_RDDATA"
group 0--3
line.long 0 "INT_CMD_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

base ad:0xa035303c
;tree "2INT_CMD_GNT"
group 0--3
line.long 0 "INT_CMD_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

base ad:0xa0353040
;tree "2INT_INTERRUPT_CTL"
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
;tree.end

base ad:0xa0353050
;tree "2CMD_MODE_CTL"
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " IF2_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 5. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 6. " ARB_MODE "  "0 ,1 "
bitfld.long 0 7. " ARB_PRI "  "0 ,1 "
hexfld.byte 1 " FIL_VALUE "
bitfld.long 0 16.--25. " TE_TIMEOUT "  " "
;tree.end

base ad:0xa0353054
;tree "2CMD_MODE_STS"
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING "  "0 ,1 "
;tree.end

base ad:0xa0353060
;tree "2DIRECT_CMD_SEND"
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
;tree.end

base ad:0xa0353064
;tree "2DIRECT_CMD_MAIN_SETTINGS"
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--15. " CMD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--20. " CMD_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 24.--27. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0353068
;tree "2DIRECT_CMD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 1 " ACK_VAL "
;tree.end

base ad:0xa035306c
;tree "2DIRECT_CMD_RD_INIT"
group 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
hexfld.word 0 " CMD_RD_INIT "
;tree.end

base ad:0xa0353070
;tree "2DIRECT_CMD_WRDAT0"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT0"
hexfld.byte 0 " WRDAT0 "
hexfld.byte 1 " WRDAT1 "
hexfld.byte 2 " WRDAT2 "
hexfld.byte 3 " WRDAT3 "
;tree.end

base ad:0xa0353074
;tree "2DIRECT_CMD_WRDAT1"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT1"
hexfld.byte 0 " WRDAT4 "
hexfld.byte 1 " WRDAT5 "
hexfld.byte 2 " WRDAT6 "
hexfld.byte 3 " WRDAT7 "
;tree.end

base ad:0xa0353078
;tree "2DIRECT_CMD_WRDAT2"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT2"
hexfld.byte 0 " WRDAT8 "
hexfld.byte 1 " WRDAT9 "
hexfld.byte 2 " WRDAT10 "
hexfld.byte 3 " WRDAT11 "
;tree.end

base ad:0xa035307c
;tree "2DIRECT_CMD_WRDAT3"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT3"
hexfld.byte 0 " WRDAT12 "
hexfld.byte 1 " WRDAT13 "
hexfld.byte 2 " WRDAT14 "
hexfld.byte 3 " WRDAT15 "
;tree.end

base ad:0xa0353080
;tree "2DIRECT_CMD_RDDAT"
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
hexfld.byte 0 " RDDAT0 "
hexfld.byte 1 " RDDAT1 "
hexfld.byte 2 " RDDAT2 "
hexfld.byte 3 " RDDAT3 "
;tree.end

base ad:0xa0353084
;tree "2DIRECT_CMD_RD_PROPERTY"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
hexfld.word 0 " RD_SIZE "
bitfld.long 0 16.--17. " RD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
;tree.end

base ad:0xa0353088
;tree "2DIRECT_CMD_RD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
;tree.end

base ad:0xa0353090
;tree "2VID_MAIN_CTL"
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STOP_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " VID_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--11. " HEADER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--13. " VID_PIXEL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " BURST_MODE "  "0 ,1 "
bitfld.long 0 15. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 16. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 17.--18. " REG_BLKLINE_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 19.--20. " REG_BLKEOL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--22. " RECOVERY_MODE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0353094
;tree "2VID_VSIZE"
group 0--3
line.long 0 "VID_VSIZE"
bitfld.long 0 0.--5. " VSA_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " VBP_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--19. " VFP_LENGTH "  " "
bitfld.long 0 20.--30. " VACT_LENGTH "  " "
;tree.end

base ad:0xa0353098
;tree "2VID_HSIZE1"
group 0--3
line.long 0 "VID_HSIZE1"
bitfld.long 0 0.--9. " HSA_LENGTH "  " "
bitfld.long 0 10.--19. " HBP_LENGTH "  " "
bitfld.long 0 20.--30. " HFP_LENGTH "  " "
;tree.end

base ad:0xa035309c
;tree "2VID_HSIZE2"
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--12. " RGB_SIZE "  " "
;tree.end

base ad:0xa03530a0
;tree "2VID_BLKSIZE1"
group 0--3
line.long 0 "VID_BLKSIZE1"
bitfld.long 0 0.--12. " BLKLINE_EVENT_PCK "  " "
bitfld.long 0 13.--25. " BLKEOL_PCK "  " "
;tree.end

base ad:0xa03530a4
;tree "2VID_BLKSIZE2"
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
;tree.end

base ad:0xa03530a8
;tree "2VID_PCK_TIME"
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
;tree.end

base ad:0xa03530ac
;tree "2VID_DPHY_TIME"
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
;tree.end

base ad:0xa03530b0
;tree "2VID_ERR_COLOR"
group 0--3
line.long 0 "VID_ERR_COLOR"
hexfld.byte 0 " COL_RED "
hexfld.byte 1 " COL_GREEN "
hexfld.byte 2 " COL_BLUE "
hexfld.byte 3 " PAD_VAL "
;tree.end

base ad:0xa03530b4
;tree "2VID_VPOS"
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--12. " LINE_VAL "  " "
;tree.end

base ad:0xa03530b8
;tree "2VID_HPOS"
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
;tree.end

base ad:0xa03530bc
;tree "2VID_MODE_STS"
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY "  "0 ,1 "
;tree.end

base ad:0xa03530c0
;tree "2VID_VCA_SETTING1"
group 0--3
line.long 0 "VID_VCA_SETTING1"
hexfld.word 0 " MAX_BURST_LIMIT "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
;tree.end

base ad:0xa03530c4
;tree "2VID_VCA_SETTING2"
group 0--3
line.long 0 "VID_VCA_SETTING2"
hexfld.word 0 " EXACT_BURST_LIMIT "
hexfld.word 1 " MAX_LINE_LIMIT "
;tree.end

base ad:0xa03530c8
;tree "2TVG_CTL"
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " TVG_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa03530cc
;tree "2TVG_IMG_SIZE"
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--12. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--26. " TVG_NBLINE "  " "
;tree.end

base ad:0xa03530d0
;tree "2TVG_COLOR1"
group 0--3
line.long 0 "TVG_COLOR1"
hexfld.byte 0 " COL1_RED "
hexfld.byte 1 " COL1_GREEN "
hexfld.byte 2 " COL1_BLUE "
;tree.end

base ad:0xa03530d4
;tree "2TVG_COLOR2"
group 0--3
line.long 0 "TVG_COLOR2"
hexfld.byte 0 " COL2_RED "
hexfld.byte 1 " COL2_GREEN "
hexfld.byte 2 " COL2_BLUE "
;tree.end

base ad:0xa03530d8
;tree "2TVG_STS"
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
;tree.end

base ad:0xa03530e0
;tree "2TBG_CTL"
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa03530e4
;tree "2TBG_SETTING"
group 0--3
line.long 0 "TBG_SETTING"
hexfld.word 0 " TBG_DATA "
bitfld.long 0 16.--27. " TBG_CPT "  " "
;tree.end

base ad:0xa03530e8
;tree "2TBG_STS"
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
;tree.end

base ad:0xa03530f0
;tree "2MCTL_MAIN_STS_CTL"
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 21. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " CRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " VRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03530f4
;tree "2CMD_MODE_STS_CTL"
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SDI1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SDI2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 21. " CSM_RUNNING_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03530f8
;tree "2DIRECT_CMD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03530fc
;tree "2DIRECT_CMD_RD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0353100
;tree "2VID_MODE_STS_CTL"
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGTH_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 26. " VSG_RECOVERY_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0353104
;tree "2TG_STS_CTL"
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0353108
;tree "2MCTL_DPHY_ERR_CTL"
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL"
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 22. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 26. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 27. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 28. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 29. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 30. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 31. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0353110
;tree "2MCTL_MAIN_STS_CLR"
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa0353114
;tree "2CMD_MODE_STS_CLR"
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_CLR "  "0 ,1 "
;tree.end

base ad:0xa0353118
;tree "2DIRECT_CMD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa035311c
;tree "2DIRECT_CMD_RD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa0353120
;tree "2VID_MODE_STS_CLR"
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_CLR "  "0 ,1 "
;tree.end

base ad:0xa0353124
;tree "2TG_STS_CLR"
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
;tree.end

base ad:0xa0353128
;tree "2MCTL_DPHY_ERR_CLR"
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
;tree.end

base ad:0xa0353130
;tree "2MCTL_MAIN_STS_FLAG"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0353134
;tree "2CMD_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0353138
;tree "2DIRECT_CMD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa035313c
;tree "2DIRECT_CMD_RD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0353140
;tree "2VID_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 10. " FLAG_VSG_RECOVERY "  "0 ,1 "
;tree.end

base ad:0xa0353144
;tree "2TG_STS_FLAG"
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0353148
;tree "2MCTL_DPHY_ERR_FLAG"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0353150
;tree "2DPHY_LANES_TRIM"
group 0--3
line.long 0 "DPHY_LANES_TRIM"
bitfld.long 0 0.--1. " DPHY_SKEW_DAT1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DPHY_CD_OFF_DAT1 "  "0 ,1 "
bitfld.long 0 3. " DPHY_HSTX_SLEWRATE_DOWN_DAT1 "  "0 ,1 "
bitfld.long 0 4. " DPHY_HSTX_SLEWRATE_UP_DAT1 "  "0 ,1 "
bitfld.long 0 5. " DPHY_TEST_RESERVED_1_DAT1 "  "0 ,1 "
bitfld.long 0 6.--7. " DPHY_SKEW_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " DPHY_LP_RX_VIL_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " DPHY_LP_TX_SLEWRATE_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " DPHY_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 13. " DPHY_HSTX_SLEWRATE_DOWN_CLK "  "0 ,1 "
bitfld.long 0 14. " DPHY_HSTX_SLEWRATE_UP_CLK "  "0 ,1 "
bitfld.long 0 15. " DPHY_TEST_RESERVED_1_CLK "  "0 ,1 "
bitfld.long 0 16.--17. " DPHY_SKEW_DAT2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " DPHY_HSTX_SLEWRATE_DOWN_DAT2 "  "0 ,1 "
bitfld.long 0 19. " DPHY_HSTX_SLEWRATE_UP_DAT2 "  "0 ,1 "
bitfld.long 0 20. " DPHY_TEST_RESERVED_1_DAT2 "  "0 ,1 "
;tree.end

base ad:0xa0353ff0
;tree "2ID_REG"
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " H "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--19. " PRODUCT_ID "  " "
bitfld.long 0 20.--31. " VENDOR_ID "  " "
;tree.end

base ad:0xa0353ff4
;tree "2IP_CONF"
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " FIFO_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

endif

tree.end

base ad:0xa0352000
;********************************************
tree "DSI-1"
;********************************************
if (((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x8015741c)&0x100000)!=0x100000)||((data.long(ad:0x801571ec)&0x4)!=0x4)||((data.long(ad:0x80157428)&0x400)!=0x0))

base ad:0x80157064
group 0--3
line.long 0 "PRCM_MCDECLK_MGT"
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 20. " DSS_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "

else

base ad:0xa0352000
;tree "1MCTL_INTEGRATION_MODE"
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
;tree.end

base ad:0xa0352004
;tree "1MCTL_MAIN_DATA_CTL"
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF1_MODE "  "0 ,1 "
bitfld.long 0 2. " VID_EN "  "0 ,1 "
bitfld.long 0 3. " TVG_SEL "  "0 ,1 "
bitfld.long 0 4. " TBG_SEL "  "0 ,1 "
bitfld.long 0 5. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 6. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 7. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 8. " READ_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_EN "  "0 ,1 "
bitfld.long 0 10. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 11. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 12. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 13. " DISP_EOT_GEN "  "0 ,1 "
;tree.end

base ad:0xa0352008
;tree "1MCTL_MAIN_PHY_CTL"
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 2. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 3. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 6.--9. " WAIT_BURST_TIME "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10. " CLK_FORCE_STOP "  "0 ,1 "
;tree.end

base ad:0xa035200c
;tree "1MCTL_PLL_CTL"
group 0--3
line.long 0 "MCTL_PLL_CTL"
hexfld.byte 0 " PLL_MULT "
bitfld.long 0 8.--13. " PLL_OUT_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--16. " PLL_IN_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17. " PLL_SEL_DIV2 "  "0 ,1 "
bitfld.long 0 18. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 31. " PLL_MASTER "  "0 ,1 "
;tree.end

base ad:0xa0352010
;tree "1MCTL_LANE_STS"
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " DATLANE1_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " DATLANE2_STATE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0352014
;tree "1MCTL_DPHY_TIMEOUT"
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT"
bitfld.long 0 0.--3. " CLK_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--17. " HSTX_TO_VAL "  " "
bitfld.long 0 18.--31. " LPRX_TO_VAL "  " "
;tree.end

base ad:0xa0352018
;tree "1MCTL_ULPOUT_TIME"
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
;tree.end

base ad:0xa035201c
;tree "1MCTL_DPHY_STATIC"
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6.--11. " UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa0352020
;tree "1MCTL_MAIN_EN"
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 7. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 8. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " IF1_EN "  "0 ,1 "
bitfld.long 0 10. " IF2_EN "  "0 ,1 "
;tree.end

base ad:0xa0352024
;tree "1MCTL_MAIN_STS"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK "  "0 ,1 "
;tree.end

base ad:0xa0352028
;tree "1MCTL_DPHY_ERR"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2 "  "0 ,1 "
;tree.end

base ad:0xa0352030
;tree "1INT_VID_RDDATA"
group 0--3
line.long 0 "INT_VID_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

base ad:0xa0352034
;tree "1INT_VID_GNT"
group 0--3
line.long 0 "INT_VID_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

base ad:0xa0352038
;tree "1INT_CMD_RDDATA"
group 0--3
line.long 0 "INT_CMD_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

base ad:0xa035203c
;tree "1INT_CMD_GNT"
group 0--3
line.long 0 "INT_CMD_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

base ad:0xa0352040
;tree "1INT_INTERRUPT_CTL"
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
;tree.end

base ad:0xa0352050
;tree "1CMD_MODE_CTL"
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " IF2_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 5. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 6. " ARB_MODE "  "0 ,1 "
bitfld.long 0 7. " ARB_PRI "  "0 ,1 "
hexfld.byte 1 " FIL_VALUE "
bitfld.long 0 16.--25. " TE_TIMEOUT "  " "
;tree.end

base ad:0xa0352054
;tree "1CMD_MODE_STS"
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING "  "0 ,1 "
;tree.end

base ad:0xa0352060
;tree "1DIRECT_CMD_SEND"
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
;tree.end

base ad:0xa0352064
;tree "1DIRECT_CMD_MAIN_SETTINGS"
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--15. " CMD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--20. " CMD_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 24.--27. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0352068
;tree "1DIRECT_CMD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 1 " ACK_VAL "
;tree.end

base ad:0xa035206c
;tree "1DIRECT_CMD_RD_INIT"
group 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
hexfld.word 0 " CMD_RD_INIT "
;tree.end

base ad:0xa0352070
;tree "1DIRECT_CMD_WRDAT0"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT0"
hexfld.byte 0 " WRDAT0 "
hexfld.byte 1 " WRDAT1 "
hexfld.byte 2 " WRDAT2 "
hexfld.byte 3 " WRDAT3 "
;tree.end

base ad:0xa0352074
;tree "1DIRECT_CMD_WRDAT1"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT1"
hexfld.byte 0 " WRDAT4 "
hexfld.byte 1 " WRDAT5 "
hexfld.byte 2 " WRDAT6 "
hexfld.byte 3 " WRDAT7 "
;tree.end

base ad:0xa0352078
;tree "1DIRECT_CMD_WRDAT2"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT2"
hexfld.byte 0 " WRDAT8 "
hexfld.byte 1 " WRDAT9 "
hexfld.byte 2 " WRDAT10 "
hexfld.byte 3 " WRDAT11 "
;tree.end

base ad:0xa035207c
;tree "1DIRECT_CMD_WRDAT3"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT3"
hexfld.byte 0 " WRDAT12 "
hexfld.byte 1 " WRDAT13 "
hexfld.byte 2 " WRDAT14 "
hexfld.byte 3 " WRDAT15 "
;tree.end

base ad:0xa0352080
;tree "1DIRECT_CMD_RDDAT"
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
hexfld.byte 0 " RDDAT0 "
hexfld.byte 1 " RDDAT1 "
hexfld.byte 2 " RDDAT2 "
hexfld.byte 3 " RDDAT3 "
;tree.end

base ad:0xa0352084
;tree "1DIRECT_CMD_RD_PROPERTY"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
hexfld.word 0 " RD_SIZE "
bitfld.long 0 16.--17. " RD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
;tree.end

base ad:0xa0352088
;tree "1DIRECT_CMD_RD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
;tree.end

base ad:0xa0352090
;tree "1VID_MAIN_CTL"
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STOP_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " VID_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--11. " HEADER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--13. " VID_PIXEL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " BURST_MODE "  "0 ,1 "
bitfld.long 0 15. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 16. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 17.--18. " REG_BLKLINE_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 19.--20. " REG_BLKEOL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--22. " RECOVERY_MODE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0352094
;tree "1VID_VSIZE"
group 0--3
line.long 0 "VID_VSIZE"
bitfld.long 0 0.--5. " VSA_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " VBP_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--19. " VFP_LENGTH "  " "
bitfld.long 0 20.--30. " VACT_LENGTH "  " "
;tree.end

base ad:0xa0352098
;tree "1VID_HSIZE1"
group 0--3
line.long 0 "VID_HSIZE1"
bitfld.long 0 0.--9. " HSA_LENGTH "  " "
bitfld.long 0 10.--19. " HBP_LENGTH "  " "
bitfld.long 0 20.--30. " HFP_LENGTH "  " "
;tree.end

base ad:0xa035209c
;tree "1VID_HSIZE2"
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--12. " RGB_SIZE "  " "
;tree.end

base ad:0xa03520a0
;tree "1VID_BLKSIZE1"
group 0--3
line.long 0 "VID_BLKSIZE1"
bitfld.long 0 0.--12. " BLKLINE_EVENT_PCK "  " "
bitfld.long 0 13.--25. " BLKEOL_PCK "  " "
;tree.end

base ad:0xa03520a4
;tree "1VID_BLKSIZE2"
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
;tree.end

base ad:0xa03520a8
;tree "1VID_PCK_TIME"
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
;tree.end

base ad:0xa03520ac
;tree "1VID_DPHY_TIME"
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
;tree.end

base ad:0xa03520b0
;tree "1VID_ERR_COLOR"
group 0--3
line.long 0 "VID_ERR_COLOR"
hexfld.byte 0 " COL_RED "
hexfld.byte 1 " COL_GREEN "
hexfld.byte 2 " COL_BLUE "
hexfld.byte 3 " PAD_VAL "
;tree.end

base ad:0xa03520b4
;tree "1VID_VPOS"
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--12. " LINE_VAL "  " "
;tree.end

base ad:0xa03520b8
;tree "1VID_HPOS"
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
;tree.end

base ad:0xa03520bc
;tree "1VID_MODE_STS"
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY "  "0 ,1 "
;tree.end

base ad:0xa03520c0
;tree "1VID_VCA_SETTING1"
group 0--3
line.long 0 "VID_VCA_SETTING1"
hexfld.word 0 " MAX_BURST_LIMIT "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
;tree.end

base ad:0xa03520c4
;tree "1VID_VCA_SETTING2"
group 0--3
line.long 0 "VID_VCA_SETTING2"
hexfld.word 0 " EXACT_BURST_LIMIT "
hexfld.word 1 " MAX_LINE_LIMIT "
;tree.end

base ad:0xa03520c8
;tree "1TVG_CTL"
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " TVG_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa03520cc
;tree "1TVG_IMG_SIZE"
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--12. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--26. " TVG_NBLINE "  " "
;tree.end

base ad:0xa03520d0
;tree "1TVG_COLOR1"
group 0--3
line.long 0 "TVG_COLOR1"
hexfld.byte 0 " COL1_RED "
hexfld.byte 1 " COL1_GREEN "
hexfld.byte 2 " COL1_BLUE "
;tree.end

base ad:0xa03520d4
;tree "1TVG_COLOR2"
group 0--3
line.long 0 "TVG_COLOR2"
hexfld.byte 0 " COL2_RED "
hexfld.byte 1 " COL2_GREEN "
hexfld.byte 2 " COL2_BLUE "
;tree.end

base ad:0xa03520d8
;tree "1TVG_STS"
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
;tree.end

base ad:0xa03520e0
;tree "1TBG_CTL"
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa03520e4
;tree "1TBG_SETTING"
group 0--3
line.long 0 "TBG_SETTING"
hexfld.word 0 " TBG_DATA "
bitfld.long 0 16.--27. " TBG_CPT "  " "
;tree.end

base ad:0xa03520e8
;tree "1TBG_STS"
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
;tree.end

base ad:0xa03520f0
;tree "1MCTL_MAIN_STS_CTL"
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 21. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " CRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " VRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03520f4
;tree "1CMD_MODE_STS_CTL"
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SDI1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SDI2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 21. " CSM_RUNNING_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03520f8
;tree "1DIRECT_CMD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03520fc
;tree "1DIRECT_CMD_RD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0352100
;tree "1VID_MODE_STS_CTL"
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGTH_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 26. " VSG_RECOVERY_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0352104
;tree "1TG_STS_CTL"
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0352108
;tree "1MCTL_DPHY_ERR_CTL"
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL"
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 22. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 26. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 27. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 28. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 29. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 30. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 31. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0352110
;tree "1MCTL_MAIN_STS_CLR"
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa0352114
;tree "1CMD_MODE_STS_CLR"
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_CLR "  "0 ,1 "
;tree.end

base ad:0xa0352118
;tree "1DIRECT_CMD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa035211c
;tree "1DIRECT_CMD_RD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa0352120
;tree "1VID_MODE_STS_CLR"
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_CLR "  "0 ,1 "
;tree.end

base ad:0xa0352124
;tree "1TG_STS_CLR"
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
;tree.end

base ad:0xa0352128
;tree "1MCTL_DPHY_ERR_CLR"
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
;tree.end

base ad:0xa0352130
;tree "1MCTL_MAIN_STS_FLAG"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0352134
;tree "1CMD_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0352138
;tree "1DIRECT_CMD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa035213c
;tree "1DIRECT_CMD_RD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0352140
;tree "1VID_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 10. " FLAG_VSG_RECOVERY "  "0 ,1 "
;tree.end

base ad:0xa0352144
;tree "1TG_STS_FLAG"
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0352148
;tree "1MCTL_DPHY_ERR_FLAG"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0352150
;tree "1DPHY_LANES_TRIM"
group 0--3
line.long 0 "DPHY_LANES_TRIM"
bitfld.long 0 0.--1. " DPHY_SKEW_DAT1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DPHY_CD_OFF_DAT1 "  "0 ,1 "
bitfld.long 0 3. " DPHY_HSTX_SLEWRATE_DOWN_DAT1 "  "0 ,1 "
bitfld.long 0 4. " DPHY_HSTX_SLEWRATE_UP_DAT1 "  "0 ,1 "
bitfld.long 0 5. " DPHY_TEST_RESERVED_1_DAT1 "  "0 ,1 "
bitfld.long 0 6.--7. " DPHY_SKEW_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " DPHY_LP_RX_VIL_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " DPHY_LP_TX_SLEWRATE_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " DPHY_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 13. " DPHY_HSTX_SLEWRATE_DOWN_CLK "  "0 ,1 "
bitfld.long 0 14. " DPHY_HSTX_SLEWRATE_UP_CLK "  "0 ,1 "
bitfld.long 0 15. " DPHY_TEST_RESERVED_1_CLK "  "0 ,1 "
bitfld.long 0 16.--17. " DPHY_SKEW_DAT2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " DPHY_HSTX_SLEWRATE_DOWN_DAT2 "  "0 ,1 "
bitfld.long 0 19. " DPHY_HSTX_SLEWRATE_UP_DAT2 "  "0 ,1 "
bitfld.long 0 20. " DPHY_TEST_RESERVED_1_DAT2 "  "0 ,1 "
;tree.end

base ad:0xa0352ff0
;tree "1ID_REG"
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " H "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--19. " PRODUCT_ID "  " "
bitfld.long 0 20.--31. " VENDOR_ID "  " "
;tree.end

base ad:0xa0352ff4
;tree "1IP_CONF"
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " FIFO_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

endif

tree.end

base ad:0xa0351000
;********************************************
tree "DSI-0"
;********************************************
if (((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x8015741c)&0x100000)!=0x100000)||((data.long(ad:0x801571ec)&0x4)!=0x4)||((data.long(ad:0x80157428)&0x400)!=0x0))

base ad:0x80157064
group 0--3
line.long 0 "PRCM_MCDECLK_MGT"
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 20. " DSS_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "

else

base ad:0xa0351000
;tree "0MCTL_INTEGRATION_MODE"
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
;tree.end

base ad:0xa0351004
;tree "0MCTL_MAIN_DATA_CTL"
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF1_MODE "  "0 ,1 "
bitfld.long 0 2. " VID_EN "  "0 ,1 "
bitfld.long 0 3. " TVG_SEL "  "0 ,1 "
bitfld.long 0 4. " TBG_SEL "  "0 ,1 "
bitfld.long 0 5. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 6. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 7. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 8. " READ_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_EN "  "0 ,1 "
bitfld.long 0 10. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 11. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 12. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 13. " DISP_EOT_GEN "  "0 ,1 "
;tree.end

base ad:0xa0351008
;tree "0MCTL_MAIN_PHY_CTL"
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 2. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 3. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 6.--9. " WAIT_BURST_TIME "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10. " CLK_FORCE_STOP "  "0 ,1 "
;tree.end

base ad:0xa035100c
;tree "0MCTL_PLL_CTL"
group 0--3
line.long 0 "MCTL_PLL_CTL"
hexfld.byte 0 " PLL_MULT "
bitfld.long 0 8.--13. " PLL_OUT_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--16. " PLL_IN_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17. " PLL_SEL_DIV2 "  "0 ,1 "
bitfld.long 0 18. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 31. " PLL_MASTER "  "0 ,1 "
;tree.end

base ad:0xa0351010
;tree "0MCTL_LANE_STS"
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " DATLANE1_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " DATLANE2_STATE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0351014
;tree "0MCTL_DPHY_TIMEOUT"
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT"
bitfld.long 0 0.--3. " CLK_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--17. " HSTX_TO_VAL "  " "
bitfld.long 0 18.--31. " LPRX_TO_VAL "  " "
;tree.end

base ad:0xa0351018
;tree "0MCTL_ULPOUT_TIME"
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
;tree.end

base ad:0xa035101c
;tree "0MCTL_DPHY_STATIC"
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6.--11. " UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa0351020
;tree "0MCTL_MAIN_EN"
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 7. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 8. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " IF1_EN "  "0 ,1 "
bitfld.long 0 10. " IF2_EN "  "0 ,1 "
;tree.end

base ad:0xa0351024
;tree "0MCTL_MAIN_STS"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK "  "0 ,1 "
;tree.end

base ad:0xa0351028
;tree "0MCTL_DPHY_ERR"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2 "  "0 ,1 "
;tree.end

base ad:0xa0351030
;tree "0INT_VID_RDDATA"
group 0--3
line.long 0 "INT_VID_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

base ad:0xa0351034
;tree "0INT_VID_GNT"
group 0--3
line.long 0 "INT_VID_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

base ad:0xa0351038
;tree "0INT_CMD_RDDATA"
group 0--3
line.long 0 "INT_CMD_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

base ad:0xa035103c
;tree "0INT_CMD_GNT"
group 0--3
line.long 0 "INT_CMD_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

base ad:0xa0351040
;tree "0INT_INTERRUPT_CTL"
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
;tree.end

base ad:0xa0351050
;tree "0CMD_MODE_CTL"
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " IF2_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 5. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 6. " ARB_MODE "  "0 ,1 "
bitfld.long 0 7. " ARB_PRI "  "0 ,1 "
hexfld.byte 1 " FIL_VALUE "
bitfld.long 0 16.--25. " TE_TIMEOUT "  " "
;tree.end

base ad:0xa0351054
;tree "0CMD_MODE_STS"
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING "  "0 ,1 "
;tree.end

base ad:0xa0351060
;tree "0DIRECT_CMD_SEND"
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
;tree.end

base ad:0xa0351064
;tree "0DIRECT_CMD_MAIN_SETTINGS"
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--15. " CMD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--20. " CMD_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 24.--27. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0351068
;tree "0DIRECT_CMD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 1 " ACK_VAL "
;tree.end

base ad:0xa035106c
;tree "0DIRECT_CMD_RD_INIT"
group 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
hexfld.word 0 " CMD_RD_INIT "
;tree.end

base ad:0xa0351070
;tree "0DIRECT_CMD_WRDAT0"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT0"
hexfld.byte 0 " WRDAT0 "
hexfld.byte 1 " WRDAT1 "
hexfld.byte 2 " WRDAT2 "
hexfld.byte 3 " WRDAT3 "
;tree.end

base ad:0xa0351074
;tree "0DIRECT_CMD_WRDAT1"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT1"
hexfld.byte 0 " WRDAT4 "
hexfld.byte 1 " WRDAT5 "
hexfld.byte 2 " WRDAT6 "
hexfld.byte 3 " WRDAT7 "
;tree.end

base ad:0xa0351078
;tree "0DIRECT_CMD_WRDAT2"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT2"
hexfld.byte 0 " WRDAT8 "
hexfld.byte 1 " WRDAT9 "
hexfld.byte 2 " WRDAT10 "
hexfld.byte 3 " WRDAT11 "
;tree.end

base ad:0xa035107c
;tree "0DIRECT_CMD_WRDAT3"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT3"
hexfld.byte 0 " WRDAT12 "
hexfld.byte 1 " WRDAT13 "
hexfld.byte 2 " WRDAT14 "
hexfld.byte 3 " WRDAT15 "
;tree.end

base ad:0xa0351080
;tree "0DIRECT_CMD_RDDAT"
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
hexfld.byte 0 " RDDAT0 "
hexfld.byte 1 " RDDAT1 "
hexfld.byte 2 " RDDAT2 "
hexfld.byte 3 " RDDAT3 "
;tree.end

base ad:0xa0351084
;tree "0DIRECT_CMD_RD_PROPERTY"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
hexfld.word 0 " RD_SIZE "
bitfld.long 0 16.--17. " RD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
;tree.end

base ad:0xa0351088
;tree "0DIRECT_CMD_RD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
;tree.end

base ad:0xa0351090
;tree "0VID_MAIN_CTL"
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STOP_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " VID_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--11. " HEADER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--13. " VID_PIXEL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " BURST_MODE "  "0 ,1 "
bitfld.long 0 15. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 16. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 17.--18. " REG_BLKLINE_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 19.--20. " REG_BLKEOL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--22. " RECOVERY_MODE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0351094
;tree "0VID_VSIZE"
group 0--3
line.long 0 "VID_VSIZE"
bitfld.long 0 0.--5. " VSA_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " VBP_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--19. " VFP_LENGTH "  " "
bitfld.long 0 20.--30. " VACT_LENGTH "  " "
;tree.end

base ad:0xa0351098
;tree "0VID_HSIZE1"
group 0--3
line.long 0 "VID_HSIZE1"
bitfld.long 0 0.--9. " HSA_LENGTH "  " "
bitfld.long 0 10.--19. " HBP_LENGTH "  " "
bitfld.long 0 20.--30. " HFP_LENGTH "  " "
;tree.end

base ad:0xa035109c
;tree "0VID_HSIZE2"
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--12. " RGB_SIZE "  " "
;tree.end

base ad:0xa03510a0
;tree "0VID_BLKSIZE1"
group 0--3
line.long 0 "VID_BLKSIZE1"
bitfld.long 0 0.--12. " BLKLINE_EVENT_PCK "  " "
bitfld.long 0 13.--25. " BLKEOL_PCK "  " "
;tree.end

base ad:0xa03510a4
;tree "0VID_BLKSIZE2"
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
;tree.end

base ad:0xa03510a8
;tree "0VID_PCK_TIME"
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
;tree.end

base ad:0xa03510ac
;tree "0VID_DPHY_TIME"
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
;tree.end

base ad:0xa03510b0
;tree "0VID_ERR_COLOR"
group 0--3
line.long 0 "VID_ERR_COLOR"
hexfld.byte 0 " COL_RED "
hexfld.byte 1 " COL_GREEN "
hexfld.byte 2 " COL_BLUE "
hexfld.byte 3 " PAD_VAL "
;tree.end

base ad:0xa03510b4
;tree "0VID_VPOS"
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--12. " LINE_VAL "  " "
;tree.end

base ad:0xa03510b8
;tree "0VID_HPOS"
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
;tree.end

base ad:0xa03510bc
;tree "0VID_MODE_STS"
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY "  "0 ,1 "
;tree.end

base ad:0xa03510c0
;tree "0VID_VCA_SETTING1"
group 0--3
line.long 0 "VID_VCA_SETTING1"
hexfld.word 0 " MAX_BURST_LIMIT "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
;tree.end

base ad:0xa03510c4
;tree "0VID_VCA_SETTING2"
group 0--3
line.long 0 "VID_VCA_SETTING2"
hexfld.word 0 " EXACT_BURST_LIMIT "
hexfld.word 1 " MAX_LINE_LIMIT "
;tree.end

base ad:0xa03510c8
;tree "0TVG_CTL"
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " TVG_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa03510cc
;tree "0TVG_IMG_SIZE"
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--12. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--26. " TVG_NBLINE "  " "
;tree.end

base ad:0xa03510d0
;tree "0TVG_COLOR1"
group 0--3
line.long 0 "TVG_COLOR1"
hexfld.byte 0 " COL1_RED "
hexfld.byte 1 " COL1_GREEN "
hexfld.byte 2 " COL1_BLUE "
;tree.end

base ad:0xa03510d4
;tree "0TVG_COLOR2"
group 0--3
line.long 0 "TVG_COLOR2"
hexfld.byte 0 " COL2_RED "
hexfld.byte 1 " COL2_GREEN "
hexfld.byte 2 " COL2_BLUE "
;tree.end

base ad:0xa03510d8
;tree "0TVG_STS"
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
;tree.end

base ad:0xa03510e0
;tree "0TBG_CTL"
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa03510e4
;tree "0TBG_SETTING"
group 0--3
line.long 0 "TBG_SETTING"
hexfld.word 0 " TBG_DATA "
bitfld.long 0 16.--27. " TBG_CPT "  " "
;tree.end

base ad:0xa03510e8
;tree "0TBG_STS"
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
;tree.end

base ad:0xa03510f0
;tree "0MCTL_MAIN_STS_CTL"
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 21. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " CRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " VRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03510f4
;tree "0CMD_MODE_STS_CTL"
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SDI1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SDI2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 21. " CSM_RUNNING_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03510f8
;tree "0DIRECT_CMD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa03510fc
;tree "0DIRECT_CMD_RD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0351100
;tree "0VID_MODE_STS_CTL"
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGTH_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 26. " VSG_RECOVERY_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0351104
;tree "0TG_STS_CTL"
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0351108
;tree "0MCTL_DPHY_ERR_CTL"
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL"
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 22. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 26. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 27. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 28. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 29. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 30. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 31. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
;tree.end

base ad:0xa0351110
;tree "0MCTL_MAIN_STS_CLR"
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa0351114
;tree "0CMD_MODE_STS_CLR"
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_CLR "  "0 ,1 "
;tree.end

base ad:0xa0351118
;tree "0DIRECT_CMD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa035111c
;tree "0DIRECT_CMD_RD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
;tree.end

base ad:0xa0351120
;tree "0VID_MODE_STS_CLR"
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_CLR "  "0 ,1 "
;tree.end

base ad:0xa0351124
;tree "0TG_STS_CLR"
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
;tree.end

base ad:0xa0351128
;tree "0MCTL_DPHY_ERR_CLR"
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
;tree.end

base ad:0xa0351130
;tree "0MCTL_MAIN_STS_FLAG"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0351134
;tree "0CMD_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0351138
;tree "0DIRECT_CMD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa035113c
;tree "0DIRECT_CMD_RD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0351140
;tree "0VID_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 10. " FLAG_VSG_RECOVERY "  "0 ,1 "
;tree.end

base ad:0xa0351144
;tree "0TG_STS_FLAG"
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0351148
;tree "0MCTL_DPHY_ERR_FLAG"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
;tree.end

base ad:0xa0351150
;tree "0DPHY_LANES_TRIM"
group 0--3
line.long 0 "DPHY_LANES_TRIM"
bitfld.long 0 0.--1. " DPHY_SKEW_DAT1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DPHY_CD_OFF_DAT1 "  "0 ,1 "
bitfld.long 0 3. " DPHY_HSTX_SLEWRATE_DOWN_DAT1 "  "0 ,1 "
bitfld.long 0 4. " DPHY_HSTX_SLEWRATE_UP_DAT1 "  "0 ,1 "
bitfld.long 0 5. " DPHY_TEST_RESERVED_1_DAT1 "  "0 ,1 "
bitfld.long 0 6.--7. " DPHY_SKEW_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " DPHY_LP_RX_VIL_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " DPHY_LP_TX_SLEWRATE_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " DPHY_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 13. " DPHY_HSTX_SLEWRATE_DOWN_CLK "  "0 ,1 "
bitfld.long 0 14. " DPHY_HSTX_SLEWRATE_UP_CLK "  "0 ,1 "
bitfld.long 0 15. " DPHY_TEST_RESERVED_1_CLK "  "0 ,1 "
bitfld.long 0 16.--17. " DPHY_SKEW_DAT2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " DPHY_HSTX_SLEWRATE_DOWN_DAT2 "  "0 ,1 "
bitfld.long 0 19. " DPHY_HSTX_SLEWRATE_UP_DAT2 "  "0 ,1 "
bitfld.long 0 20. " DPHY_TEST_RESERVED_1_DAT2 "  "0 ,1 "
;tree.end

base ad:0xa0351ff0
;tree "0ID_REG"
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " H "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--19. " PRODUCT_ID "  " "
bitfld.long 0 20.--31. " VENDOR_ID "  " "
;tree.end

base ad:0xa0351ff4
;tree "0IP_CONF"
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " FIFO_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

endif

tree.end

tree.end

;==============================================================
tree "ETB11"
;==============================================================
base eapb:0x801b4004
;tree "RAM_Depth"
rgroup 0--3
line.long 0 "RAM_Depth"
hexfld.long 0 " RDP "
;tree.end

base eapb:0x801b400c
;tree "Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " FULL "  "0 ,1 "
bitfld.long 0 1. " TRIGGERED "  "0 ,1 "
bitfld.long 0 2. " ACQCOMP "  "0 ,1 "
bitfld.long 0 3. " FTEMPTY "  "0 ,1 "
;tree.end

base eapb:0x801b4010
;tree "RAM_Data"
group 0--3
line.long 0 "RAM_Data"
hexfld.long 0 " RAM_READ_DATA "
;tree.end

base eapb:0x801b4014
;tree "RAM_Read_Pointer"
group 0--3
line.long 0 "RAM_Read_Pointer"
bitfld.long 0 0.--1. " RAM_Read_Pointer "  "0 ,1 ,2 ,3 "
;tree.end

base eapb:0x801b4018
;tree "RAM_Write_Pointer"
group 0--3
line.long 0 "RAM_Write_Pointer"
bitfld.long 0 0.--1. " RAM_Write_Pointer "  "0 ,1 ,2 ,3 "
;tree.end

base eapb:0x801b401c
;tree "Trigger_Counter"
group 0--3
line.long 0 "Trigger_Counter"
bitfld.long 0 0.--1. " Trigger_Counter "  "0 ,1 ,2 ,3 "
;tree.end

base eapb:0x801b4020
;tree "Control"
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " TRACECAPTEN "  "0 ,1 "
;tree.end

base eapb:0x801b4024
;tree "RAM_WRITE"
wgroup 0--3
line.long 0 "RAM_WRITE"
hexfld.long 0 " RAM_WRITE_DATA "
;tree.end

base eapb:0x801b4300
;tree "FFSR"
rgroup 0--3
line.long 0 "FFSR"
bitfld.long 0 0. " FLINPROG "  "0 ,1 "
bitfld.long 0 1. " FTSTOPPED "  "0 ,1 "
;tree.end

base eapb:0x801b4304
;tree "DESCRIPTION"
group 0--3
line.long 0 "DESCRIPTION"
bitfld.long 0 0. " ENFTC "  "0 ,1 "
bitfld.long 0 1. " ENFCONT "  "0 ,1 "
bitfld.long 0 4. " FONFLIN "  "0 ,1 "
bitfld.long 0 5. " FONTRIG "  "0 ,1 "
bitfld.long 0 6. " FONMAN "  "0 ,1 "
bitfld.long 0 8. " TRIGIN "  "0 ,1 "
bitfld.long 0 9. " TRIGEVT "  "0 ,1 "
bitfld.long 0 10. " TRGFL "  "0 ,1 "
bitfld.long 0 12. " STOPFL "  "0 ,1 "
bitfld.long 0 13. " STOPTRIG "  "0 ,1 "
;tree.end

base eapb:0x801b4ee0
;tree "ITMISCOP0"
group 0--3
line.long 0 "ITMISCOP0"
bitfld.long 0 0. " ACQCOMP "  "0 ,1 "
bitfld.long 0 1. " FULL "  "0 ,1 "
;tree.end

base eapb:0x801b4ee4
;tree "ITTRFLINACK"
group 0--3
line.long 0 "ITTRFLINACK"
bitfld.long 0 0. " TRIGNACK "  "0 ,1 "
bitfld.long 0 1. " FLUSHINACK "  "0 ,1 "
;tree.end

base eapb:0x801b4ee8
;tree "ITTRFLIN"
group 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0. " TRIGIN "  "0 ,1 "
bitfld.long 0 1. " FLUSHIN "  "0 ,1 "
;tree.end

base eapb:0x801b4eec
;tree "ITATBDATA0"
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ATDATA[0] "  "0 ,1 "
bitfld.long 0 1. " ATDATA[7] "  "0 ,1 "
bitfld.long 0 2. " ATDATA[15] "  "0 ,1 "
bitfld.long 0 3. " ATDATA[23] "  "0 ,1 "
bitfld.long 0 4. " ATDATA[31] "  "0 ,1 "
;tree.end

base eapb:0x801b4ef0
;tree "ITATBCTR2"
group 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ATREADYS "  "0 ,1 "
bitfld.long 0 1. " AFVALIDS "  "0 ,1 "
;tree.end

base eapb:0x801b4ef4
;tree "ITATBCTR1"
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0.--6. " ATID "  " "
;tree.end

base eapb:0x801b4ef8
;tree "ITATBCTR0"
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ATVALID "  "0 ,1 "
bitfld.long 0 1. " AFREADY "  "0 ,1 "
bitfld.long 0 8.--9. " ATBYTES "  "0 ,1 ,2 ,3 "
;tree.end

base eapb:0x801b4f00
;tree "IMCR"
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " IMCR "  "0 ,1 "
;tree.end

base eapb:0x801b4fa0
;tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0. " CTSR "  "0 ,1 "
;tree.end

base eapb:0x801b4fa4
;tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0. " CTCR "  "0 ,1 "
;tree.end

base eapb:0x801b4fb0
;tree "LAR"
group 0--3
line.long 0 "LAR"
bitfld.long 0 0. " LAR "  "0 ,1 "
;tree.end

base eapb:0x801b4fb4
;tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0. " LSR "  "0 ,1 "
;tree.end

base eapb:0x801b4fb8
;tree "ASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0. " ASR "  "0 ,1 "
;tree.end

base eapb:0x801b4fc8
;tree "DID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0. " DID "  "0 ,1 "
;tree.end

base eapb:0x801b4fcc
;tree "DTIR"
rgroup 0--3
line.long 0 "DTIR"
bitfld.long 0 0. " DTIR "  "0 ,1 "
;tree.end

base eapb:0x801b4fd0
;tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0. " PERIPHERAL_ID4 "  "0 ,1 "
;tree.end

base eapb:0x801b4fd4
;tree "PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

base eapb:0x801b4fd8
;tree "PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

base eapb:0x801b4fdc
;tree "PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

base eapb:0x801b4fe0
;tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0. " PERIPHERAL_ID0 "  "0 ,1 "
;tree.end

base eapb:0x801b4fe4
;tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0. " PERIPHERAL_ID1 "  "0 ,1 "
;tree.end

base eapb:0x801b4fe8
;tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0. " PERIPHERAL_ID2 "  "0 ,1 "
;tree.end

base eapb:0x801b4fec
;tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0. " PERIPHERAL_ID3 "  "0 ,1 "
;tree.end

base eapb:0x801b4ff0
;tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

base eapb:0x801b4ff4
;tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0. " COMPONENT_ID1 "  "0 ,1 "
;tree.end

base eapb:0x801b4ff8
;tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0. " COMPONENT_ID2 "  "0 ,1 "
;tree.end

base eapb:0x801b4ffc
;tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0. " COMPONENT_ID3 "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "FSMC"
;==============================================================
base ad:0x80000000
;tree "FSMC_BCR0"
group 0--3
line.long 0 "FSMC_BCR0"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
;tree.end

base ad:0x80000008
;tree "FSMC_BCR1"
group 0--3
line.long 0 "FSMC_BCR1"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
;tree.end

base ad:0x80000010
;tree "FSMC_BCR2"
group 0--3
line.long 0 "FSMC_BCR2"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
;tree.end

base ad:0x80000018
;tree "FSMC_BCR3"
group 0--3
line.long 0 "FSMC_BCR3"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
;tree.end

base ad:0x80000004
;tree "FSMC_BTR0"
group 0--3
line.long 0 "FSMC_BTR0"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8000000c
;tree "FSMC_BTR1"
group 0--3
line.long 0 "FSMC_BTR1"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80000014
;tree "FSMC_BTR2"
group 0--3
line.long 0 "FSMC_BTR2"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8000001c
;tree "FSMC_BTR3"
group 0--3
line.long 0 "FSMC_BTR3"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80000040
;tree "FSMC_PCR0"
group 0--3
line.long 0 "FSMC_PCR0"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80000060
;tree "FSMC_PCR1"
group 0--3
line.long 0 "FSMC_PCR1"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80000080
;tree "FSMC_PCR2"
group 0--3
line.long 0 "FSMC_PCR2"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x800000a0
;tree "FSMC_PCR3"
group 0--3
line.long 0 "FSMC_PCR3"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80000044
;tree "FSMC_SR0"
group 0--3
line.long 0 "FSMC_SR0"
bitfld.long 0 6. " FEMPT "  "0 ,1 "
;tree.end

base ad:0x80000064
;tree "FSMC_SR1"
group 0--3
line.long 0 "FSMC_SR1"
bitfld.long 0 6. " FEMPT "  "0 ,1 "
;tree.end

base ad:0x80000048
;tree "FSMC_PMEM0"
group 0--3
line.long 0 "FSMC_PMEM0"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x80000068
;tree "FSMC_PMEM1"
group 0--3
line.long 0 "FSMC_PMEM1"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x80000088
;tree "FSMC_PMEM2"
group 0--3
line.long 0 "FSMC_PMEM2"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x800000a8
;tree "FSMC_PMEM3"
group 0--3
line.long 0 "FSMC_PMEM3"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x8000004c
;tree "FSMC_PATT0"
group 0--3
line.long 0 "FSMC_PATT0"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x8000006c
;tree "FSMC_PATT1"
group 0--3
line.long 0 "FSMC_PATT1"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x8000008c
;tree "FSMC_PATT2"
group 0--3
line.long 0 "FSMC_PATT2"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x800000ac
;tree "FSMC_PATT3"
group 0--3
line.long 0 "FSMC_PATT3"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x80000050
;tree "FSMC_PIO0"
group 0--3
line.long 0 "FSMC_PIO0"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x80000070
;tree "FSMC_PIO1"
group 0--3
line.long 0 "FSMC_PIO1"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

base ad:0x80000054
;tree "FSMC_ECCR0"
group 0--3
line.long 0 "FSMC_ECCR0"
bitfld.long 0 0.--23. " ECC "  " "
;tree.end

base ad:0x80000074
;tree "FSMC_ECCR1"
group 0--3
line.long 0 "FSMC_ECCR1"
bitfld.long 0 0.--23. " ECC "  " "
;tree.end

base ad:0x800000c0
;tree "FSMC_ITCR"
group 0--3
line.long 0 "FSMC_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x800000c4
;tree "FSMC_ITIP0"
group 0--3
line.long 0 "FSMC_ITIP0"
hexfld.long 0 " PCDAI "
;tree.end

base ad:0x800000c8
;tree "FSMC_ITIP1"
group 0--3
line.long 0 "FSMC_ITIP1"
bitfld.long 0 0. " SMFBCLK "  "0 ,1 "
bitfld.long 0 1. " SMWAITn "  "0 ,1 "
bitfld.long 0 2.--3. " SMPCIRQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SMPIOIS16n "  "0 ,1 "
bitfld.long 0 7.--8. " SMPCD "  "0 ,1 ,2 ,3 "
bitfld.long 0 11.--12. " ExtDefWidth "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x800000cc
;tree "FSMC_ITOP0"
group 0--3
line.long 0 "FSMC_ITOP0"
hexfld.long 0 " PCDAO "
;tree.end

base ad:0x800000d0
;tree "FSMC_ITOP1"
group 0--3
line.long 0 "FSMC_ITOP1"
bitfld.long 0 0.--25. " SMAD "  " "
bitfld.long 0 26. " PC0INTR "  "0 ,1 "
bitfld.long 0 27. " PC1INTR "  "0 ,1 "
bitfld.long 0 30. " SMOEN "  "0 ,1 "
bitfld.long 0 31. " SWWEN "  "0 ,1 "
;tree.end

base ad:0x800000d4
;tree "FSMC_ITOP2"
group 0--3
line.long 0 "FSMC_ITOP2"
bitfld.long 0 0. " SMPREGN "  "0 ,1 "
bitfld.long 0 1. " SMPRST0N "  "0 ,1 "
bitfld.long 0 2. " SMPRST1N "  "0 ,1 "
bitfld.long 0 5. " SMPCDIRN "  "0 ,1 "
bitfld.long 0 6. " SMPC1EN "  "0 ,1 "
bitfld.long 0 7. " SMPC2EN "  "0 ,1 "
bitfld.long 0 8. " SMPIORN "  "0 ,1 "
bitfld.long 0 9. " SMPIOWN "  "0 ,1 "
bitfld.long 0 10. " SMADVN "  "0 ,1 "
bitfld.long 0 11. " SMCKO "  "0 ,1 "
bitfld.long 0 12. " SMBE0n "  "0 ,1 "
bitfld.long 0 13. " SMBE1n "  "0 ,1 "
bitfld.long 0 14. " SMBE2n "  "0 ,1 "
bitfld.long 0 15. " SMBE3n "  "0 ,1 "
bitfld.long 0 16. " SMPS0N "  "0 ,1 "
bitfld.long 0 17. " SMPS1N "  "0 ,1 "
;tree.end

base ad:0x800000d8
;tree "FSMC_ITOP3"
group 0--3
line.long 0 "FSMC_ITOP3"
bitfld.long 0 0. " SMCS0N "  "0 ,1 "
bitfld.long 0 1. " SMCS1N "  "0 ,1 "
bitfld.long 0 2. " SMCS2N "  "0 ,1 "
bitfld.long 0 3. " SMCS3N "  "0 ,1 "
bitfld.long 0 4. " SMFWP0N "  "0 ,1 "
bitfld.long 0 5. " SMFWP1N "  "0 ,1 "
bitfld.long 0 6. " SMFWP2N "  "0 ,1 "
bitfld.long 0 7. " SMFWP3N "  "0 ,1 "
bitfld.long 0 8. " SMFRST0N "  "0 ,1 "
bitfld.long 0 9. " SMFRST1N "  "0 ,1 "
bitfld.long 0 10. " SMFRST2N "  "0 ,1 "
bitfld.long 0 11. " SMFRST3N "  "0 ,1 "
;tree.end

base ad:0x80000100
;tree "FSMC_BWTR0"
group 0--3
line.long 0 "FSMC_BWTR0"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80000108
;tree "FSMC_BWTR1"
group 0--3
line.long 0 "FSMC_BWTR1"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80000110
;tree "FSMC_BWTR2"
group 0--3
line.long 0 "FSMC_BWTR2"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80000fe0
;tree "FSMC_PeriphID0"
rgroup 0--3
line.long 0 "FSMC_PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80000fe4
;tree "FSMC_PeriphID1"
rgroup 0--3
line.long 0 "FSMC_PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80000fe8
;tree "FSMC_PeriphID2"
rgroup 0--3
line.long 0 "FSMC_PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80000fec
;tree "FSMC_PeriphID3"
rgroup 0--3
line.long 0 "FSMC_PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80000ff0
;tree "FSMC_PCellID0"
rgroup 0--3
line.long 0 "FSMC_PCellID0"
bitfld.long 0 0. " _PCellID0 "  "0 ,1 "
;tree.end

base ad:0x80000ff4
;tree "FSMC_PCellID1"
rgroup 0--3
line.long 0 "FSMC_PCellID1"
bitfld.long 0 0. " _BCRPCellID1 "  "0 ,1 "
;tree.end

base ad:0x80000ff8
;tree "FSMC_PCellID2"
rgroup 0--3
line.long 0 "FSMC_PCellID2"
bitfld.long 0 0. " _BCRPCellID2 "  "0 ,1 "
;tree.end

base ad:0x80000ffc
;tree "FSMC_PCellID3"
rgroup 0--3
line.long 0 "FSMC_PCellID3"
bitfld.long 0 0. " _BCRPCellID3 "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "GIC"
;==============================================================
base ad:0xa0410100
;tree "CPU_ICR"
group 0--3
line.long 0 "CPU_ICR"
bitfld.long 0 0. " CPUICREN "  "0 ,1 "
bitfld.long 0 1. " CPUICRENNS "  "0 ,1 "
bitfld.long 0 2. " CPUICRACKCTL "  "0 ,1 "
bitfld.long 0 3. " CPUICRFIQEN "  "0 ,1 "
bitfld.long 0 4. " CPUICRSBPR "  "0 ,1 "
;tree.end

base ad:0xa0410104
;tree "PMR"
group 0--3
line.long 0 "PMR"
bitfld.long 0 3.--7. " PMRPRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0410108
;tree "BPR"
group 0--3
line.long 0 "BPR"
bitfld.long 0 0.--2. " BPRBP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa041010c
;tree "IAR"
rgroup 0--3
line.long 0 "IAR"
bitfld.long 0 0.--9. " IARACKINTID "  " "
bitfld.long 0 10.--12. " IARSOURCECPUID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0410110
;tree "EOIR"
wgroup 0--3
line.long 0 "EOIR"
bitfld.long 0 0.--9. " EOIREOIINTID "  " "
bitfld.long 0 10.--12. " EOIRSOURCECPUID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0410114
;tree "RPR"
rgroup 0--3
line.long 0 "RPR"
hexfld.byte 0 " RPRPRIORITY "
;tree.end

base ad:0xa0410118
;tree "HPIR"
rgroup 0--3
line.long 0 "HPIR"
bitfld.long 0 0.--9. " HPIRPENDINTID "  " "
bitfld.long 0 10.--12. " HPIRSOURCECPUID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa041011c
;tree "ANSBPR"
group 0--3
line.long 0 "ANSBPR"
bitfld.long 0 0.--2. " ANSBPRBP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa04101fc
;tree "CPU_IIIR"
rgroup 0--3
line.long 0 "CPU_IIIR"
bitfld.long 0 0.--11. " CPUIIIRIMPLEMENTOR "  " "
bitfld.long 0 12.--15. " CPUIIIRRN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " CPUIIIRAV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--31. " CPUIIIRPN "  " "
;tree.end

base ad:0xa0411000
;tree "IDCR"
group 0--3
line.long 0 "IDCR"
bitfld.long 0 0. " IDCEN "  "0 ,1 "
bitfld.long 0 1. " IDCENS "  "0 ,1 "
;tree.end

base ad:0xa0411004
;tree "ICTR"
rgroup 0--3
line.long 0 "ICTR"
bitfld.long 0 0.--4. " ICTITLN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " ICTCPUN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " ICTDOM "  "0 ,1 "
bitfld.long 0 11.--15. " ICTLSPI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411008
;tree "DIIR"
rgroup 0--3
line.long 0 "DIIR"
bitfld.long 0 0.--11. " DIIIMPL "  " "
bitfld.long 0 12.--23. " DIIRN "  " "
hexfld.byte 3 " DIIIMPL_DEFINED "
;tree.end

base ad:0xa0411080
;tree "IS0R"
group 0--3
line.long 0 "IS0R"
hexfld.long 0 " IS0 "
;tree.end

base ad:0xa0411084
;tree "IS1R"
group 0--3
line.long 0 "IS1R"
hexfld.long 0 " IS1 "
;tree.end

base ad:0xa0411088
;tree "IS2R"
group 0--3
line.long 0 "IS2R"
hexfld.long 0 " IS2 "
;tree.end

base ad:0xa041108c
;tree "IS3R"
group 0--3
line.long 0 "IS3R"
hexfld.long 0 " IS3 "
;tree.end

base ad:0xa0411090
;tree "IS4R"
group 0--3
line.long 0 "IS4R"
hexfld.long 0 " IS4 "
;tree.end

base ad:0xa0411094
;tree "IS5R"
group 0--3
line.long 0 "IS5R"
hexfld.long 0 " IS5 "
;tree.end

base ad:0xa0411098
;tree "IS6R"
group 0--3
line.long 0 "IS6R"
hexfld.long 0 " IS6 "
;tree.end

base ad:0xa041109c
;tree "IS7R"
group 0--3
line.long 0 "IS7R"
hexfld.long 0 " IS7 "
;tree.end

base ad:0xa04110a0
;tree "IS8R"
group 0--3
line.long 0 "IS8R"
hexfld.long 0 " IS8 "
;tree.end

base ad:0xa04110a4
;tree "IS9R"
group 0--3
line.long 0 "IS9R"
hexfld.long 0 " IS9 "
;tree.end

base ad:0xa04110a8
;tree "IS10R"
group 0--3
line.long 0 "IS10R"
hexfld.long 0 " IS10 "
;tree.end

base ad:0xa04110ac
;tree "IS11R"
group 0--3
line.long 0 "IS11R"
hexfld.long 0 " IS11 "
;tree.end

base ad:0xa04110b0
;tree "IS12R"
group 0--3
line.long 0 "IS12R"
hexfld.long 0 " IS12 "
;tree.end

base ad:0xa04110b4
;tree "IS13R"
group 0--3
line.long 0 "IS13R"
hexfld.long 0 " IS13 "
;tree.end

base ad:0xa04110b8
;tree "IS14R"
group 0--3
line.long 0 "IS14R"
hexfld.long 0 " IS14 "
;tree.end

base ad:0xa04110bc
;tree "IS15R"
group 0--3
line.long 0 "IS15R"
hexfld.long 0 " IS15 "
;tree.end

base ad:0xa04110c0
;tree "IS16R"
group 0--3
line.long 0 "IS16R"
hexfld.long 0 " IS16 "
;tree.end

base ad:0xa04110c4
;tree "IS17R"
group 0--3
line.long 0 "IS17R"
hexfld.long 0 " IS17 "
;tree.end

base ad:0xa04110c8
;tree "IS18R"
group 0--3
line.long 0 "IS18R"
hexfld.long 0 " IS18 "
;tree.end

base ad:0xa04110cc
;tree "IS19R"
group 0--3
line.long 0 "IS19R"
hexfld.long 0 " IS19 "
;tree.end

base ad:0xa04110d0
;tree "IS20R"
group 0--3
line.long 0 "IS20R"
hexfld.long 0 " IS20 "
;tree.end

base ad:0xa04110d4
;tree "IS21R"
group 0--3
line.long 0 "IS21R"
hexfld.long 0 " IS21 "
;tree.end

base ad:0xa04110d8
;tree "IS22R"
group 0--3
line.long 0 "IS22R"
hexfld.long 0 " IS22 "
;tree.end

base ad:0xa04110dc
;tree "IS23R"
group 0--3
line.long 0 "IS23R"
hexfld.long 0 " IS23 "
;tree.end

base ad:0xa04110e0
;tree "IS24R"
group 0--3
line.long 0 "IS24R"
hexfld.long 0 " IS24 "
;tree.end

base ad:0xa04110e4
;tree "IS25R"
group 0--3
line.long 0 "IS25R"
hexfld.long 0 " IS25 "
;tree.end

base ad:0xa04110e8
;tree "IS26R"
group 0--3
line.long 0 "IS26R"
hexfld.long 0 " IS26 "
;tree.end

base ad:0xa04110ec
;tree "IS27R"
group 0--3
line.long 0 "IS27R"
hexfld.long 0 " IS27 "
;tree.end

base ad:0xa04110f0
;tree "IS28R"
group 0--3
line.long 0 "IS28R"
hexfld.long 0 " IS28 "
;tree.end

base ad:0xa04110f4
;tree "IS29R"
group 0--3
line.long 0 "IS29R"
hexfld.long 0 " IS29 "
;tree.end

base ad:0xa04110f8
;tree "IS30R"
group 0--3
line.long 0 "IS30R"
hexfld.long 0 " IS30 "
;tree.end

base ad:0xa04110fc
;tree "IS31R"
group 0--3
line.long 0 "IS31R"
hexfld.long 0 " IS31 "
;tree.end

base ad:0xa0411100
;tree "ES0R"
group 0--3
line.long 0 "ES0R"
hexfld.long 0 " ES0 "
;tree.end

base ad:0xa0411104
;tree "ES1R"
group 0--3
line.long 0 "ES1R"
hexfld.long 0 " ES1 "
;tree.end

base ad:0xa0411108
;tree "ES2R"
group 0--3
line.long 0 "ES2R"
hexfld.long 0 " ES2 "
;tree.end

base ad:0xa041110c
;tree "ES3R"
group 0--3
line.long 0 "ES3R"
hexfld.long 0 " ES3 "
;tree.end

base ad:0xa0411110
;tree "ES4R"
group 0--3
line.long 0 "ES4R"
hexfld.long 0 " ES4 "
;tree.end

base ad:0xa0411114
;tree "ES5R"
group 0--3
line.long 0 "ES5R"
hexfld.long 0 " ES5 "
;tree.end

base ad:0xa0411118
;tree "ES6R"
group 0--3
line.long 0 "ES6R"
hexfld.long 0 " ES6 "
;tree.end

base ad:0xa041111c
;tree "ES7R"
group 0--3
line.long 0 "ES7R"
hexfld.long 0 " ES7 "
;tree.end

base ad:0xa0411120
;tree "ES8R"
group 0--3
line.long 0 "ES8R"
hexfld.long 0 " ES8 "
;tree.end

base ad:0xa0411124
;tree "ES9R"
group 0--3
line.long 0 "ES9R"
hexfld.long 0 " ES9 "
;tree.end

base ad:0xa0411128
;tree "ES10R"
group 0--3
line.long 0 "ES10R"
hexfld.long 0 " ES10 "
;tree.end

base ad:0xa041112c
;tree "ES11R"
group 0--3
line.long 0 "ES11R"
hexfld.long 0 " ES11 "
;tree.end

base ad:0xa0411130
;tree "ES12R"
group 0--3
line.long 0 "ES12R"
hexfld.long 0 " ES12 "
;tree.end

base ad:0xa0411134
;tree "ES13R"
group 0--3
line.long 0 "ES13R"
hexfld.long 0 " ES13 "
;tree.end

base ad:0xa0411138
;tree "ES14R"
group 0--3
line.long 0 "ES14R"
hexfld.long 0 " ES14 "
;tree.end

base ad:0xa041113c
;tree "ES15R"
group 0--3
line.long 0 "ES15R"
hexfld.long 0 " ES15 "
;tree.end

base ad:0xa0411140
;tree "ES16R"
group 0--3
line.long 0 "ES16R"
hexfld.long 0 " ES16 "
;tree.end

base ad:0xa0411144
;tree "ES17R"
group 0--3
line.long 0 "ES17R"
hexfld.long 0 " ES17 "
;tree.end

base ad:0xa0411148
;tree "ES18R"
group 0--3
line.long 0 "ES18R"
hexfld.long 0 " ES18 "
;tree.end

base ad:0xa041114c
;tree "ES19R"
group 0--3
line.long 0 "ES19R"
hexfld.long 0 " ES19 "
;tree.end

base ad:0xa0411150
;tree "ES20R"
group 0--3
line.long 0 "ES20R"
hexfld.long 0 " ES20 "
;tree.end

base ad:0xa0411154
;tree "ES21R"
group 0--3
line.long 0 "ES21R"
hexfld.long 0 " ES21 "
;tree.end

base ad:0xa0411158
;tree "ES22R"
group 0--3
line.long 0 "ES22R"
hexfld.long 0 " ES22 "
;tree.end

base ad:0xa041115c
;tree "ES23R"
group 0--3
line.long 0 "ES23R"
hexfld.long 0 " ES23 "
;tree.end

base ad:0xa0411160
;tree "ES24R"
group 0--3
line.long 0 "ES24R"
hexfld.long 0 " ES24 "
;tree.end

base ad:0xa0411164
;tree "ES25R"
group 0--3
line.long 0 "ES25R"
hexfld.long 0 " ES25 "
;tree.end

base ad:0xa0411168
;tree "ES26R"
group 0--3
line.long 0 "ES26R"
hexfld.long 0 " ES26 "
;tree.end

base ad:0xa041116c
;tree "ES27R"
group 0--3
line.long 0 "ES27R"
hexfld.long 0 " ES27 "
;tree.end

base ad:0xa0411170
;tree "ES28R"
group 0--3
line.long 0 "ES28R"
hexfld.long 0 " ES28 "
;tree.end

base ad:0xa0411174
;tree "ES29R"
group 0--3
line.long 0 "ES29R"
hexfld.long 0 " ES29 "
;tree.end

base ad:0xa0411178
;tree "ES30R"
group 0--3
line.long 0 "ES30R"
hexfld.long 0 " ES30 "
;tree.end

base ad:0xa041117c
;tree "ES31R"
group 0--3
line.long 0 "ES31R"
hexfld.long 0 " ES31 "
;tree.end

base ad:0xa0411180
;tree "EC0R"
group 0--3
line.long 0 "EC0R"
hexfld.long 0 " EC0 "
;tree.end

base ad:0xa0411184
;tree "EC1R"
group 0--3
line.long 0 "EC1R"
hexfld.long 0 " EC1 "
;tree.end

base ad:0xa0411188
;tree "EC2R"
group 0--3
line.long 0 "EC2R"
hexfld.long 0 " EC2 "
;tree.end

base ad:0xa041118c
;tree "EC3R"
group 0--3
line.long 0 "EC3R"
hexfld.long 0 " EC3 "
;tree.end

base ad:0xa0411190
;tree "EC4R"
group 0--3
line.long 0 "EC4R"
hexfld.long 0 " EC4 "
;tree.end

base ad:0xa0411194
;tree "EC5R"
group 0--3
line.long 0 "EC5R"
hexfld.long 0 " EC5 "
;tree.end

base ad:0xa0411198
;tree "EC6R"
group 0--3
line.long 0 "EC6R"
hexfld.long 0 " EC6 "
;tree.end

base ad:0xa041119c
;tree "EC7R"
group 0--3
line.long 0 "EC7R"
hexfld.long 0 " EC7 "
;tree.end

base ad:0xa04111a0
;tree "EC8R"
group 0--3
line.long 0 "EC8R"
hexfld.long 0 " EC8 "
;tree.end

base ad:0xa04111a4
;tree "EC9R"
group 0--3
line.long 0 "EC9R"
hexfld.long 0 " EC9 "
;tree.end

base ad:0xa04111a8
;tree "EC10R"
group 0--3
line.long 0 "EC10R"
hexfld.long 0 " EC10 "
;tree.end

base ad:0xa04111ac
;tree "EC11R"
group 0--3
line.long 0 "EC11R"
hexfld.long 0 " EC11 "
;tree.end

base ad:0xa04111b0
;tree "EC12R"
group 0--3
line.long 0 "EC12R"
hexfld.long 0 " EC12 "
;tree.end

base ad:0xa04111b4
;tree "EC13R"
group 0--3
line.long 0 "EC13R"
hexfld.long 0 " EC13 "
;tree.end

base ad:0xa04111b8
;tree "EC14R"
group 0--3
line.long 0 "EC14R"
hexfld.long 0 " EC14 "
;tree.end

base ad:0xa04111bc
;tree "EC15R"
group 0--3
line.long 0 "EC15R"
hexfld.long 0 " EC15 "
;tree.end

base ad:0xa04111c0
;tree "EC16R"
group 0--3
line.long 0 "EC16R"
hexfld.long 0 " EC16 "
;tree.end

base ad:0xa04111c4
;tree "EC17R"
group 0--3
line.long 0 "EC17R"
hexfld.long 0 " EC17 "
;tree.end

base ad:0xa04111c8
;tree "EC18R"
group 0--3
line.long 0 "EC18R"
hexfld.long 0 " EC18 "
;tree.end

base ad:0xa04111cc
;tree "EC19R"
group 0--3
line.long 0 "EC19R"
hexfld.long 0 " EC19 "
;tree.end

base ad:0xa04111d0
;tree "EC20R"
group 0--3
line.long 0 "EC20R"
hexfld.long 0 " EC20 "
;tree.end

base ad:0xa04111d4
;tree "EC21R"
group 0--3
line.long 0 "EC21R"
hexfld.long 0 " EC21 "
;tree.end

base ad:0xa04111d8
;tree "EC22R"
group 0--3
line.long 0 "EC22R"
hexfld.long 0 " EC22 "
;tree.end

base ad:0xa04111dc
;tree "EC23R"
group 0--3
line.long 0 "EC23R"
hexfld.long 0 " EC23 "
;tree.end

base ad:0xa04111e0
;tree "EC24R"
group 0--3
line.long 0 "EC24R"
hexfld.long 0 " EC24 "
;tree.end

base ad:0xa04111e4
;tree "EC25R"
group 0--3
line.long 0 "EC25R"
hexfld.long 0 " EC25 "
;tree.end

base ad:0xa04111e8
;tree "EC26R"
group 0--3
line.long 0 "EC26R"
hexfld.long 0 " EC26 "
;tree.end

base ad:0xa04111ec
;tree "EC27R"
group 0--3
line.long 0 "EC27R"
hexfld.long 0 " EC27 "
;tree.end

base ad:0xa04111f0
;tree "EC28R"
group 0--3
line.long 0 "EC28R"
hexfld.long 0 " EC28 "
;tree.end

base ad:0xa04111f4
;tree "EC29R"
group 0--3
line.long 0 "EC29R"
hexfld.long 0 " EC29 "
;tree.end

base ad:0xa04111f8
;tree "EC30R"
group 0--3
line.long 0 "EC30R"
hexfld.long 0 " EC30 "
;tree.end

base ad:0xa04111fc
;tree "EC31R"
group 0--3
line.long 0 "EC31R"
hexfld.long 0 " EC31 "
;tree.end

base ad:0xa0411200
;tree "PS0R"
group 0--3
line.long 0 "PS0R"
hexfld.long 0 " PS0 "
;tree.end

base ad:0xa0411204
;tree "PS1R"
group 0--3
line.long 0 "PS1R"
hexfld.long 0 " PS1 "
;tree.end

base ad:0xa0411208
;tree "PS2R"
group 0--3
line.long 0 "PS2R"
hexfld.long 0 " PS2 "
;tree.end

base ad:0xa041120c
;tree "PS3R"
group 0--3
line.long 0 "PS3R"
hexfld.long 0 " PS3 "
;tree.end

base ad:0xa0411210
;tree "PS4R"
group 0--3
line.long 0 "PS4R"
hexfld.long 0 " PS4 "
;tree.end

base ad:0xa0411214
;tree "PS5R"
group 0--3
line.long 0 "PS5R"
hexfld.long 0 " PS5 "
;tree.end

base ad:0xa0411218
;tree "PS6R"
group 0--3
line.long 0 "PS6R"
hexfld.long 0 " PS6 "
;tree.end

base ad:0xa041121c
;tree "PS7R"
group 0--3
line.long 0 "PS7R"
hexfld.long 0 " PS7 "
;tree.end

base ad:0xa0411220
;tree "PS8R"
group 0--3
line.long 0 "PS8R"
hexfld.long 0 " PS8 "
;tree.end

base ad:0xa0411224
;tree "PS9R"
group 0--3
line.long 0 "PS9R"
hexfld.long 0 " PS9 "
;tree.end

base ad:0xa0411228
;tree "PS10R"
group 0--3
line.long 0 "PS10R"
hexfld.long 0 " PS10 "
;tree.end

base ad:0xa041122c
;tree "PS11R"
group 0--3
line.long 0 "PS11R"
hexfld.long 0 " PS11 "
;tree.end

base ad:0xa0411230
;tree "PS12R"
group 0--3
line.long 0 "PS12R"
hexfld.long 0 " PS12 "
;tree.end

base ad:0xa0411234
;tree "PS13R"
group 0--3
line.long 0 "PS13R"
hexfld.long 0 " PS13 "
;tree.end

base ad:0xa0411238
;tree "PS14R"
group 0--3
line.long 0 "PS14R"
hexfld.long 0 " PS14 "
;tree.end

base ad:0xa041123c
;tree "PS15R"
group 0--3
line.long 0 "PS15R"
hexfld.long 0 " PS15 "
;tree.end

base ad:0xa0411240
;tree "PS16R"
group 0--3
line.long 0 "PS16R"
hexfld.long 0 " PS16 "
;tree.end

base ad:0xa0411244
;tree "PS17R"
group 0--3
line.long 0 "PS17R"
hexfld.long 0 " PS17 "
;tree.end

base ad:0xa0411248
;tree "PS18R"
group 0--3
line.long 0 "PS18R"
hexfld.long 0 " PS18 "
;tree.end

base ad:0xa041124c
;tree "PS19R"
group 0--3
line.long 0 "PS19R"
hexfld.long 0 " PS19 "
;tree.end

base ad:0xa0411250
;tree "PS20R"
group 0--3
line.long 0 "PS20R"
hexfld.long 0 " PS20 "
;tree.end

base ad:0xa0411254
;tree "PS21R"
group 0--3
line.long 0 "PS21R"
hexfld.long 0 " PS21 "
;tree.end

base ad:0xa0411258
;tree "PS22R"
group 0--3
line.long 0 "PS22R"
hexfld.long 0 " PS22 "
;tree.end

base ad:0xa041125c
;tree "PS23R"
group 0--3
line.long 0 "PS23R"
hexfld.long 0 " PS23 "
;tree.end

base ad:0xa0411260
;tree "PS24R"
group 0--3
line.long 0 "PS24R"
hexfld.long 0 " PS24 "
;tree.end

base ad:0xa0411264
;tree "PS25R"
group 0--3
line.long 0 "PS25R"
hexfld.long 0 " PS25 "
;tree.end

base ad:0xa0411268
;tree "PS26R"
group 0--3
line.long 0 "PS26R"
hexfld.long 0 " PS26 "
;tree.end

base ad:0xa041126c
;tree "PS27R"
group 0--3
line.long 0 "PS27R"
hexfld.long 0 " PS27 "
;tree.end

base ad:0xa0411270
;tree "PS28R"
group 0--3
line.long 0 "PS28R"
hexfld.long 0 " PS28 "
;tree.end

base ad:0xa0411274
;tree "PS29R"
group 0--3
line.long 0 "PS29R"
hexfld.long 0 " PS29 "
;tree.end

base ad:0xa0411278
;tree "PS30R"
group 0--3
line.long 0 "PS30R"
hexfld.long 0 " PS30 "
;tree.end

base ad:0xa041127c
;tree "PS31R"
group 0--3
line.long 0 "PS31R"
hexfld.long 0 " PS31 "
;tree.end

base ad:0xa0411280
;tree "PC0R"
group 0--3
line.long 0 "PC0R"
hexfld.long 0 " PC0 "
;tree.end

base ad:0xa0411284
;tree "PC1R"
group 0--3
line.long 0 "PC1R"
hexfld.long 0 " PC1 "
;tree.end

base ad:0xa0411288
;tree "PC2R"
group 0--3
line.long 0 "PC2R"
hexfld.long 0 " PC2 "
;tree.end

base ad:0xa041128c
;tree "PC3R"
group 0--3
line.long 0 "PC3R"
hexfld.long 0 " PC3 "
;tree.end

base ad:0xa0411290
;tree "PC4R"
group 0--3
line.long 0 "PC4R"
hexfld.long 0 " PC4 "
;tree.end

base ad:0xa0411294
;tree "PC5R"
group 0--3
line.long 0 "PC5R"
hexfld.long 0 " PC5 "
;tree.end

base ad:0xa0411298
;tree "PC6R"
group 0--3
line.long 0 "PC6R"
hexfld.long 0 " PC6 "
;tree.end

base ad:0xa041129c
;tree "PC7R"
group 0--3
line.long 0 "PC7R"
hexfld.long 0 " PC7 "
;tree.end

base ad:0xa04112a0
;tree "PC8R"
group 0--3
line.long 0 "PC8R"
hexfld.long 0 " PC8 "
;tree.end

base ad:0xa04112a4
;tree "PC9R"
group 0--3
line.long 0 "PC9R"
hexfld.long 0 " PC9 "
;tree.end

base ad:0xa04112a8
;tree "PC10R"
group 0--3
line.long 0 "PC10R"
hexfld.long 0 " PC10 "
;tree.end

base ad:0xa04112ac
;tree "PC11R"
group 0--3
line.long 0 "PC11R"
hexfld.long 0 " PC11 "
;tree.end

base ad:0xa04112b0
;tree "PC12R"
group 0--3
line.long 0 "PC12R"
hexfld.long 0 " PC12 "
;tree.end

base ad:0xa04112b4
;tree "PC13R"
group 0--3
line.long 0 "PC13R"
hexfld.long 0 " PC13 "
;tree.end

base ad:0xa04112b8
;tree "PC14R"
group 0--3
line.long 0 "PC14R"
hexfld.long 0 " PC14 "
;tree.end

base ad:0xa04112bc
;tree "PC15R"
group 0--3
line.long 0 "PC15R"
hexfld.long 0 " PC15 "
;tree.end

base ad:0xa04112c0
;tree "PC16R"
group 0--3
line.long 0 "PC16R"
hexfld.long 0 " PC16 "
;tree.end

base ad:0xa04112c4
;tree "PC17R"
group 0--3
line.long 0 "PC17R"
hexfld.long 0 " PC17 "
;tree.end

base ad:0xa04112c8
;tree "PC18R"
group 0--3
line.long 0 "PC18R"
hexfld.long 0 " PC18 "
;tree.end

base ad:0xa04112cc
;tree "PC19R"
group 0--3
line.long 0 "PC19R"
hexfld.long 0 " PC19 "
;tree.end

base ad:0xa04112d0
;tree "PC20R"
group 0--3
line.long 0 "PC20R"
hexfld.long 0 " PC20 "
;tree.end

base ad:0xa04112d4
;tree "PC21R"
group 0--3
line.long 0 "PC21R"
hexfld.long 0 " PC21 "
;tree.end

base ad:0xa04112d8
;tree "PC22R"
group 0--3
line.long 0 "PC22R"
hexfld.long 0 " PC22 "
;tree.end

base ad:0xa04112dc
;tree "PC23R"
group 0--3
line.long 0 "PC23R"
hexfld.long 0 " PC23 "
;tree.end

base ad:0xa04112e0
;tree "PC24R"
group 0--3
line.long 0 "PC24R"
hexfld.long 0 " PC24 "
;tree.end

base ad:0xa04112e4
;tree "PC25R"
group 0--3
line.long 0 "PC25R"
hexfld.long 0 " PC25 "
;tree.end

base ad:0xa04112e8
;tree "PC26R"
group 0--3
line.long 0 "PC26R"
hexfld.long 0 " PC26 "
;tree.end

base ad:0xa04112ec
;tree "PC27R"
group 0--3
line.long 0 "PC27R"
hexfld.long 0 " PC27 "
;tree.end

base ad:0xa04112f0
;tree "PC28R"
group 0--3
line.long 0 "PC28R"
hexfld.long 0 " PC28 "
;tree.end

base ad:0xa04112f4
;tree "PC29R"
group 0--3
line.long 0 "PC29R"
hexfld.long 0 " PC29 "
;tree.end

base ad:0xa04112f8
;tree "PC30R"
group 0--3
line.long 0 "PC30R"
hexfld.long 0 " PC30 "
;tree.end

base ad:0xa04112fc
;tree "PC31R"
group 0--3
line.long 0 "PC31R"
hexfld.long 0 " PC31 "
;tree.end

base ad:0xa0411300
;tree "AS0R"
rgroup 0--3
line.long 0 "AS0R"
hexfld.long 0 " AS0 "
;tree.end

base ad:0xa0411304
;tree "AS1R"
rgroup 0--3
line.long 0 "AS1R"
hexfld.long 0 " AS1 "
;tree.end

base ad:0xa0411308
;tree "AS2R"
rgroup 0--3
line.long 0 "AS2R"
hexfld.long 0 " AS2 "
;tree.end

base ad:0xa041130c
;tree "AS3R"
rgroup 0--3
line.long 0 "AS3R"
hexfld.long 0 " AS3 "
;tree.end

base ad:0xa0411310
;tree "AS4R"
rgroup 0--3
line.long 0 "AS4R"
hexfld.long 0 " AS4 "
;tree.end

base ad:0xa0411314
;tree "AS5R"
rgroup 0--3
line.long 0 "AS5R"
hexfld.long 0 " AS5 "
;tree.end

base ad:0xa0411318
;tree "AS6R"
rgroup 0--3
line.long 0 "AS6R"
hexfld.long 0 " AS6 "
;tree.end

base ad:0xa041131c
;tree "AS7R"
rgroup 0--3
line.long 0 "AS7R"
hexfld.long 0 " AS7 "
;tree.end

base ad:0xa0411320
;tree "AS8R"
rgroup 0--3
line.long 0 "AS8R"
hexfld.long 0 " AS8 "
;tree.end

base ad:0xa0411324
;tree "AS9R"
rgroup 0--3
line.long 0 "AS9R"
hexfld.long 0 " AS9 "
;tree.end

base ad:0xa0411328
;tree "AS10R"
rgroup 0--3
line.long 0 "AS10R"
hexfld.long 0 " AS10 "
;tree.end

base ad:0xa041132c
;tree "AS11R"
rgroup 0--3
line.long 0 "AS11R"
hexfld.long 0 " AS11 "
;tree.end

base ad:0xa0411330
;tree "AS12R"
rgroup 0--3
line.long 0 "AS12R"
hexfld.long 0 " AS12 "
;tree.end

base ad:0xa0411334
;tree "AS13R"
rgroup 0--3
line.long 0 "AS13R"
hexfld.long 0 " AS13 "
;tree.end

base ad:0xa0411338
;tree "AS14R"
rgroup 0--3
line.long 0 "AS14R"
hexfld.long 0 " AS14 "
;tree.end

base ad:0xa041133c
;tree "AS15R"
rgroup 0--3
line.long 0 "AS15R"
hexfld.long 0 " AS15 "
;tree.end

base ad:0xa0411340
;tree "AS16R"
rgroup 0--3
line.long 0 "AS16R"
hexfld.long 0 " AS16 "
;tree.end

base ad:0xa0411344
;tree "AS17R"
rgroup 0--3
line.long 0 "AS17R"
hexfld.long 0 " AS17 "
;tree.end

base ad:0xa0411348
;tree "AS18R"
rgroup 0--3
line.long 0 "AS18R"
hexfld.long 0 " AS18 "
;tree.end

base ad:0xa041134c
;tree "AS19R"
rgroup 0--3
line.long 0 "AS19R"
hexfld.long 0 " AS19 "
;tree.end

base ad:0xa0411350
;tree "AS20R"
rgroup 0--3
line.long 0 "AS20R"
hexfld.long 0 " AS20 "
;tree.end

base ad:0xa0411354
;tree "AS21R"
rgroup 0--3
line.long 0 "AS21R"
hexfld.long 0 " AS21 "
;tree.end

base ad:0xa0411358
;tree "AS22R"
rgroup 0--3
line.long 0 "AS22R"
hexfld.long 0 " AS22 "
;tree.end

base ad:0xa041135c
;tree "AS23R"
rgroup 0--3
line.long 0 "AS23R"
hexfld.long 0 " AS23 "
;tree.end

base ad:0xa0411360
;tree "AS24R"
rgroup 0--3
line.long 0 "AS24R"
hexfld.long 0 " AS24 "
;tree.end

base ad:0xa0411364
;tree "AS25R"
rgroup 0--3
line.long 0 "AS25R"
hexfld.long 0 " AS25 "
;tree.end

base ad:0xa0411368
;tree "AS26R"
rgroup 0--3
line.long 0 "AS26R"
hexfld.long 0 " AS26 "
;tree.end

base ad:0xa041136c
;tree "AS27R"
rgroup 0--3
line.long 0 "AS27R"
hexfld.long 0 " AS27 "
;tree.end

base ad:0xa0411370
;tree "AS28R"
rgroup 0--3
line.long 0 "AS28R"
hexfld.long 0 " AS28 "
;tree.end

base ad:0xa0411374
;tree "AS29R"
rgroup 0--3
line.long 0 "AS29R"
hexfld.long 0 " AS29 "
;tree.end

base ad:0xa0411378
;tree "AS30R"
rgroup 0--3
line.long 0 "AS30R"
hexfld.long 0 " AS30 "
;tree.end

base ad:0xa041137c
;tree "AS31R"
rgroup 0--3
line.long 0 "AS31R"
hexfld.long 0 " AS31 "
;tree.end

base ad:0xa0411400
;tree "PL0R"
group 0--3
line.long 0 "PL0R"
bitfld.long 0 3.--7. " PL0IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL0IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL0IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL0IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411404
;tree "PL1R"
group 0--3
line.long 0 "PL1R"
bitfld.long 0 3.--7. " PL1IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL1IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL1IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL1IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411408
;tree "PL2R"
group 0--3
line.long 0 "PL2R"
bitfld.long 0 3.--7. " PL2IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL2IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL2IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL2IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041140c
;tree "PL3R"
group 0--3
line.long 0 "PL3R"
bitfld.long 0 3.--7. " PL3IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL3IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL3IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL3IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411410
;tree "PL4R"
group 0--3
line.long 0 "PL4R"
bitfld.long 0 3.--7. " PL4IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL4IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL4IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL4IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411414
;tree "PL5R"
group 0--3
line.long 0 "PL5R"
bitfld.long 0 3.--7. " PL5IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL5IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL5IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL5IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411418
;tree "PL6R"
group 0--3
line.long 0 "PL6R"
bitfld.long 0 3.--7. " PL6IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL6IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL6IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL6IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041141c
;tree "PL7R"
group 0--3
line.long 0 "PL7R"
bitfld.long 0 3.--7. " PL7IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL7IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL7IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL7IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411420
;tree "PL8R"
group 0--3
line.long 0 "PL8R"
bitfld.long 0 3.--7. " PL8IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL8IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL8IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL8IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411424
;tree "PL9R"
group 0--3
line.long 0 "PL9R"
bitfld.long 0 3.--7. " PL9IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL9IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL9IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL9IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411428
;tree "PL10R"
group 0--3
line.long 0 "PL10R"
bitfld.long 0 3.--7. " PL10IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL10IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL10IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL10IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041142c
;tree "PL11R"
group 0--3
line.long 0 "PL11R"
bitfld.long 0 3.--7. " PL11IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL11IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL11IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL11IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411430
;tree "PL12R"
group 0--3
line.long 0 "PL12R"
bitfld.long 0 3.--7. " PL12IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL12IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL12IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL12IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411434
;tree "PL13R"
group 0--3
line.long 0 "PL13R"
bitfld.long 0 3.--7. " PL13IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL13IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL13IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL13IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411438
;tree "PL14R"
group 0--3
line.long 0 "PL14R"
bitfld.long 0 3.--7. " PL14IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL14IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL14IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL14IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041143c
;tree "PL15R"
group 0--3
line.long 0 "PL15R"
bitfld.long 0 3.--7. " PL15IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL15IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL15IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL15IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411440
;tree "PL16R"
group 0--3
line.long 0 "PL16R"
bitfld.long 0 3.--7. " PL16IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL16IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL16IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL16IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411444
;tree "PL17R"
group 0--3
line.long 0 "PL17R"
bitfld.long 0 3.--7. " PL17IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL17IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL17IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL17IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411448
;tree "PL18R"
group 0--3
line.long 0 "PL18R"
bitfld.long 0 3.--7. " PL18IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL18IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL18IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL18IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041144c
;tree "PL19R"
group 0--3
line.long 0 "PL19R"
bitfld.long 0 3.--7. " PL19IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL19IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL19IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL19IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411450
;tree "PL20R"
group 0--3
line.long 0 "PL20R"
bitfld.long 0 3.--7. " PL20IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL20IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL20IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL20IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411454
;tree "PL21R"
group 0--3
line.long 0 "PL21R"
bitfld.long 0 3.--7. " PL21IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL21IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL21IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL21IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411458
;tree "PL22R"
group 0--3
line.long 0 "PL22R"
bitfld.long 0 3.--7. " PL22IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL22IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL22IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL22IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041145c
;tree "PL23R"
group 0--3
line.long 0 "PL23R"
bitfld.long 0 3.--7. " PL23IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL23IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL23IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL23IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411460
;tree "PL24R"
group 0--3
line.long 0 "PL24R"
bitfld.long 0 3.--7. " PL24IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL24IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL24IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL24IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411464
;tree "PL25R"
group 0--3
line.long 0 "PL25R"
bitfld.long 0 3.--7. " PL25IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL25IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL25IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL25IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411468
;tree "PL26R"
group 0--3
line.long 0 "PL26R"
bitfld.long 0 3.--7. " PL26IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL26IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL26IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL26IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041146c
;tree "PL27R"
group 0--3
line.long 0 "PL27R"
bitfld.long 0 3.--7. " PL27IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL27IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL27IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL27IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411470
;tree "PL28R"
group 0--3
line.long 0 "PL28R"
bitfld.long 0 3.--7. " PL28IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL28IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL28IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL28IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411474
;tree "PL29R"
group 0--3
line.long 0 "PL29R"
bitfld.long 0 3.--7. " PL29IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL29IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL29IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL29IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411478
;tree "PL30R"
group 0--3
line.long 0 "PL30R"
bitfld.long 0 3.--7. " PL30IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL30IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL30IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL30IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa041147c
;tree "PL31R"
group 0--3
line.long 0 "PL31R"
bitfld.long 0 3.--7. " PL31IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL31IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL31IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL31IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0411800
;tree "SPIT0R"
group 0--3
line.long 0 "SPIT0R"
hexfld.byte 0 " SPIT0INTIDNP0 "
hexfld.byte 1 " SPIT0INTIDNP1 "
hexfld.byte 2 " SPIT0INTIDNP2 "
hexfld.byte 3 " SPIT0INTIDNP3 "
;tree.end

base ad:0xa0411804
;tree "SPIT1R"
group 0--3
line.long 0 "SPIT1R"
hexfld.byte 0 " SPIT1INTIDNP0 "
hexfld.byte 1 " SPIT1INTIDNP1 "
hexfld.byte 2 " SPIT1INTIDNP2 "
hexfld.byte 3 " SPIT1INTIDNP3 "
;tree.end

base ad:0xa0411808
;tree "SPIT2R"
group 0--3
line.long 0 "SPIT2R"
hexfld.byte 0 " SPIT2INTIDNP0 "
hexfld.byte 1 " SPIT2INTIDNP1 "
hexfld.byte 2 " SPIT2INTIDNP2 "
hexfld.byte 3 " SPIT2INTIDNP3 "
;tree.end

base ad:0xa041180c
;tree "SPIT3R"
group 0--3
line.long 0 "SPIT3R"
hexfld.byte 0 " SPIT3INTIDNP0 "
hexfld.byte 1 " SPIT3INTIDNP1 "
hexfld.byte 2 " SPIT3INTIDNP2 "
hexfld.byte 3 " SPIT3INTIDNP3 "
;tree.end

base ad:0xa0411810
;tree "SPIT4R"
group 0--3
line.long 0 "SPIT4R"
hexfld.byte 0 " SPIT4INTIDNP0 "
hexfld.byte 1 " SPIT4INTIDNP1 "
hexfld.byte 2 " SPIT4INTIDNP2 "
hexfld.byte 3 " SPIT4INTIDNP3 "
;tree.end

base ad:0xa0411814
;tree "SPIT5R"
group 0--3
line.long 0 "SPIT5R"
hexfld.byte 0 " SPIT5INTIDNP0 "
hexfld.byte 1 " SPIT5INTIDNP1 "
hexfld.byte 2 " SPIT5INTIDNP2 "
hexfld.byte 3 " SPIT5INTIDNP3 "
;tree.end

base ad:0xa0411818
;tree "SPIT6R"
group 0--3
line.long 0 "SPIT6R"
hexfld.byte 0 " SPIT6INTIDNP0 "
hexfld.byte 1 " SPIT6INTIDNP1 "
hexfld.byte 2 " SPIT6INTIDNP2 "
hexfld.byte 3 " SPIT6INTIDNP3 "
;tree.end

base ad:0xa041181c
;tree "SPIT7R"
group 0--3
line.long 0 "SPIT7R"
hexfld.byte 0 " SPIT7INTIDNP0 "
hexfld.byte 1 " SPIT7INTIDNP1 "
hexfld.byte 2 " SPIT7INTIDNP2 "
hexfld.byte 3 " SPIT7INTIDNP3 "
;tree.end

base ad:0xa0411820
;tree "SPIT8R"
group 0--3
line.long 0 "SPIT8R"
hexfld.byte 0 " SPIT8INTIDNP0 "
hexfld.byte 1 " SPIT8INTIDNP1 "
hexfld.byte 2 " SPIT8INTIDNP2 "
hexfld.byte 3 " SPIT8INTIDNP3 "
;tree.end

base ad:0xa0411824
;tree "SPIT9R"
group 0--3
line.long 0 "SPIT9R"
hexfld.byte 0 " SPIT9INTIDNP0 "
hexfld.byte 1 " SPIT9INTIDNP1 "
hexfld.byte 2 " SPIT9INTIDNP2 "
hexfld.byte 3 " SPIT9INTIDNP3 "
;tree.end

base ad:0xa0411828
;tree "SPIT10R"
group 0--3
line.long 0 "SPIT10R"
hexfld.byte 0 " SPIT10INTIDNP0 "
hexfld.byte 1 " SPIT10INTIDNP1 "
hexfld.byte 2 " SPIT10INTIDNP2 "
hexfld.byte 3 " SPIT10INTIDNP3 "
;tree.end

base ad:0xa041182c
;tree "SPIT11R"
group 0--3
line.long 0 "SPIT11R"
hexfld.byte 0 " SPIT11INTIDNP0 "
hexfld.byte 1 " SPIT11INTIDNP1 "
hexfld.byte 2 " SPIT11INTIDNP2 "
hexfld.byte 3 " SPIT11INTIDNP3 "
;tree.end

base ad:0xa0411830
;tree "SPIT12R"
group 0--3
line.long 0 "SPIT12R"
hexfld.byte 0 " SPIT12INTIDNP0 "
hexfld.byte 1 " SPIT12INTIDNP1 "
hexfld.byte 2 " SPIT12INTIDNP2 "
hexfld.byte 3 " SPIT12INTIDNP3 "
;tree.end

base ad:0xa0411834
;tree "SPIT13R"
group 0--3
line.long 0 "SPIT13R"
hexfld.byte 0 " SPIT13INTIDNP0 "
hexfld.byte 1 " SPIT13INTIDNP1 "
hexfld.byte 2 " SPIT13INTIDNP2 "
hexfld.byte 3 " SPIT13INTIDNP3 "
;tree.end

base ad:0xa0411838
;tree "SPIT14R"
group 0--3
line.long 0 "SPIT14R"
hexfld.byte 0 " SPIT14INTIDNP0 "
hexfld.byte 1 " SPIT14INTIDNP1 "
hexfld.byte 2 " SPIT14INTIDNP2 "
hexfld.byte 3 " SPIT14INTIDNP3 "
;tree.end

base ad:0xa041183c
;tree "SPIT15R"
group 0--3
line.long 0 "SPIT15R"
hexfld.byte 0 " SPIT15INTIDNP0 "
hexfld.byte 1 " SPIT15INTIDNP1 "
hexfld.byte 2 " SPIT15INTIDNP2 "
hexfld.byte 3 " SPIT15INTIDNP3 "
;tree.end

base ad:0xa0411840
;tree "SPIT16R"
group 0--3
line.long 0 "SPIT16R"
hexfld.byte 0 " SPIT16INTIDNP0 "
hexfld.byte 1 " SPIT16INTIDNP1 "
hexfld.byte 2 " SPIT16INTIDNP2 "
hexfld.byte 3 " SPIT16INTIDNP3 "
;tree.end

base ad:0xa0411844
;tree "SPIT17R"
group 0--3
line.long 0 "SPIT17R"
hexfld.byte 0 " SPIT17INTIDNP0 "
hexfld.byte 1 " SPIT17INTIDNP1 "
hexfld.byte 2 " SPIT17INTIDNP2 "
hexfld.byte 3 " SPIT17INTIDNP3 "
;tree.end

base ad:0xa0411848
;tree "SPIT18R"
group 0--3
line.long 0 "SPIT18R"
hexfld.byte 0 " SPIT18INTIDNP0 "
hexfld.byte 1 " SPIT18INTIDNP1 "
hexfld.byte 2 " SPIT18INTIDNP2 "
hexfld.byte 3 " SPIT18INTIDNP3 "
;tree.end

base ad:0xa041184c
;tree "SPIT19R"
group 0--3
line.long 0 "SPIT19R"
hexfld.byte 0 " SPIT19INTIDNP0 "
hexfld.byte 1 " SPIT19INTIDNP1 "
hexfld.byte 2 " SPIT19INTIDNP2 "
hexfld.byte 3 " SPIT19INTIDNP3 "
;tree.end

base ad:0xa0411850
;tree "SPIT20R"
group 0--3
line.long 0 "SPIT20R"
hexfld.byte 0 " SPIT20INTIDNP0 "
hexfld.byte 1 " SPIT20INTIDNP1 "
hexfld.byte 2 " SPIT20INTIDNP2 "
hexfld.byte 3 " SPIT20INTIDNP3 "
;tree.end

base ad:0xa0411854
;tree "SPIT21R"
group 0--3
line.long 0 "SPIT21R"
hexfld.byte 0 " SPIT21INTIDNP0 "
hexfld.byte 1 " SPIT21INTIDNP1 "
hexfld.byte 2 " SPIT21INTIDNP2 "
hexfld.byte 3 " SPIT21INTIDNP3 "
;tree.end

base ad:0xa0411858
;tree "SPIT22R"
group 0--3
line.long 0 "SPIT22R"
hexfld.byte 0 " SPIT22INTIDNP0 "
hexfld.byte 1 " SPIT22INTIDNP1 "
hexfld.byte 2 " SPIT22INTIDNP2 "
hexfld.byte 3 " SPIT22INTIDNP3 "
;tree.end

base ad:0xa041185c
;tree "SPIT23R"
group 0--3
line.long 0 "SPIT23R"
hexfld.byte 0 " SPIT23INTIDNP0 "
hexfld.byte 1 " SPIT23INTIDNP1 "
hexfld.byte 2 " SPIT23INTIDNP2 "
hexfld.byte 3 " SPIT23INTIDNP3 "
;tree.end

base ad:0xa0411860
;tree "SPIT24R"
group 0--3
line.long 0 "SPIT24R"
hexfld.byte 0 " SPIT24INTIDNP0 "
hexfld.byte 1 " SPIT24INTIDNP1 "
hexfld.byte 2 " SPIT24INTIDNP2 "
hexfld.byte 3 " SPIT24INTIDNP3 "
;tree.end

base ad:0xa0411864
;tree "SPIT25R"
group 0--3
line.long 0 "SPIT25R"
hexfld.byte 0 " SPIT25INTIDNP0 "
hexfld.byte 1 " SPIT25INTIDNP1 "
hexfld.byte 2 " SPIT25INTIDNP2 "
hexfld.byte 3 " SPIT25INTIDNP3 "
;tree.end

base ad:0xa0411868
;tree "SPIT26R"
group 0--3
line.long 0 "SPIT26R"
hexfld.byte 0 " SPIT26INTIDNP0 "
hexfld.byte 1 " SPIT26INTIDNP1 "
hexfld.byte 2 " SPIT26INTIDNP2 "
hexfld.byte 3 " SPIT26INTIDNP3 "
;tree.end

base ad:0xa041186c
;tree "SPIT27R"
group 0--3
line.long 0 "SPIT27R"
hexfld.byte 0 " SPIT27INTIDNP0 "
hexfld.byte 1 " SPIT27INTIDNP1 "
hexfld.byte 2 " SPIT27INTIDNP2 "
hexfld.byte 3 " SPIT27INTIDNP3 "
;tree.end

base ad:0xa0411870
;tree "SPIT28R"
group 0--3
line.long 0 "SPIT28R"
hexfld.byte 0 " SPIT28INTIDNP0 "
hexfld.byte 1 " SPIT28INTIDNP1 "
hexfld.byte 2 " SPIT28INTIDNP2 "
hexfld.byte 3 " SPIT28INTIDNP3 "
;tree.end

base ad:0xa0411874
;tree "SPIT29R"
group 0--3
line.long 0 "SPIT29R"
hexfld.byte 0 " SPIT29INTIDNP0 "
hexfld.byte 1 " SPIT29INTIDNP1 "
hexfld.byte 2 " SPIT29INTIDNP2 "
hexfld.byte 3 " SPIT29INTIDNP3 "
;tree.end

base ad:0xa0411878
;tree "SPIT30R"
group 0--3
line.long 0 "SPIT30R"
hexfld.byte 0 " SPIT30INTIDNP0 "
hexfld.byte 1 " SPIT30INTIDNP1 "
hexfld.byte 2 " SPIT30INTIDNP2 "
hexfld.byte 3 " SPIT30INTIDNP3 "
;tree.end

base ad:0xa041187c
;tree "SPIT31R"
group 0--3
line.long 0 "SPIT31R"
hexfld.byte 0 " SPIT31INTIDNP0 "
hexfld.byte 1 " SPIT31INTIDNP1 "
hexfld.byte 2 " SPIT31INTIDNP2 "
hexfld.byte 3 " SPIT31INTIDNP3 "
;tree.end

base ad:0xa0411880
;tree "SPIT32R"
group 0--3
line.long 0 "SPIT32R"
hexfld.byte 0 " SPIT32INTIDNP0 "
hexfld.byte 1 " SPIT32INTIDNP1 "
hexfld.byte 2 " SPIT32INTIDNP2 "
hexfld.byte 3 " SPIT32INTIDNP3 "
;tree.end

base ad:0xa0411884
;tree "SPIT33R"
group 0--3
line.long 0 "SPIT33R"
hexfld.byte 0 " SPIT33INTIDNP0 "
hexfld.byte 1 " SPIT33INTIDNP1 "
hexfld.byte 2 " SPIT33INTIDNP2 "
hexfld.byte 3 " SPIT33INTIDNP3 "
;tree.end

base ad:0xa0411888
;tree "SPIT34R"
group 0--3
line.long 0 "SPIT34R"
hexfld.byte 0 " SPIT34INTIDNP0 "
hexfld.byte 1 " SPIT34INTIDNP1 "
hexfld.byte 2 " SPIT34INTIDNP2 "
hexfld.byte 3 " SPIT34INTIDNP3 "
;tree.end

base ad:0xa041188c
;tree "SPIT35R"
group 0--3
line.long 0 "SPIT35R"
hexfld.byte 0 " SPIT35INTIDNP0 "
hexfld.byte 1 " SPIT35INTIDNP1 "
hexfld.byte 2 " SPIT35INTIDNP2 "
hexfld.byte 3 " SPIT35INTIDNP3 "
;tree.end

base ad:0xa0411890
;tree "SPIT36R"
group 0--3
line.long 0 "SPIT36R"
hexfld.byte 0 " SPIT36INTIDNP0 "
hexfld.byte 1 " SPIT36INTIDNP1 "
hexfld.byte 2 " SPIT36INTIDNP2 "
hexfld.byte 3 " SPIT36INTIDNP3 "
;tree.end

base ad:0xa0411894
;tree "SPIT37R"
group 0--3
line.long 0 "SPIT37R"
hexfld.byte 0 " SPIT37INTIDNP0 "
hexfld.byte 1 " SPIT37INTIDNP1 "
hexfld.byte 2 " SPIT37INTIDNP2 "
hexfld.byte 3 " SPIT37INTIDNP3 "
;tree.end

base ad:0xa0411898
;tree "SPIT38R"
group 0--3
line.long 0 "SPIT38R"
hexfld.byte 0 " SPIT38INTIDNP0 "
hexfld.byte 1 " SPIT38INTIDNP1 "
hexfld.byte 2 " SPIT38INTIDNP2 "
hexfld.byte 3 " SPIT38INTIDNP3 "
;tree.end

base ad:0xa041189c
;tree "SPIT39R"
group 0--3
line.long 0 "SPIT39R"
hexfld.byte 0 " SPIT39INTIDNP0 "
hexfld.byte 1 " SPIT39INTIDNP1 "
hexfld.byte 2 " SPIT39INTIDNP2 "
hexfld.byte 3 " SPIT39INTIDNP3 "
;tree.end

base ad:0xa0411c00
;tree "IC0R"
group 0--3
line.long 0 "IC0R"
hexfld.long 0 " IC0 "
;tree.end

base ad:0xa0411c04
;tree "IC1R"
group 0--3
line.long 0 "IC1R"
hexfld.long 0 " IC1 "
;tree.end

base ad:0xa0411c08
;tree "IC2R"
group 0--3
line.long 0 "IC2R"
hexfld.long 0 " IC2 "
;tree.end

base ad:0xa0411c0c
;tree "IC3R"
group 0--3
line.long 0 "IC3R"
hexfld.long 0 " IC3 "
;tree.end

base ad:0xa0411c10
;tree "IC4R"
group 0--3
line.long 0 "IC4R"
hexfld.long 0 " IC4 "
;tree.end

base ad:0xa0411c14
;tree "IC5R"
group 0--3
line.long 0 "IC5R"
hexfld.long 0 " IC5 "
;tree.end

base ad:0xa0411c18
;tree "IC6R"
group 0--3
line.long 0 "IC6R"
hexfld.long 0 " IC6 "
;tree.end

base ad:0xa0411c1c
;tree "IC7R"
group 0--3
line.long 0 "IC7R"
hexfld.long 0 " IC7 "
;tree.end

base ad:0xa0411c20
;tree "IC8R"
group 0--3
line.long 0 "IC8R"
hexfld.long 0 " IC8 "
;tree.end

base ad:0xa0411c24
;tree "IC9R"
group 0--3
line.long 0 "IC9R"
hexfld.long 0 " IC9 "
;tree.end

base ad:0xa0411d00
;tree "PPISR"
rgroup 0--3
line.long 0 "PPISR"
bitfld.long 0 12.--15. " PPISS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0411d04
;tree "SPIS0R"
rgroup 0--3
line.long 0 "SPIS0R"
hexfld.long 0 " SPIS0 "
;tree.end

base ad:0xa0411d08
;tree "SPIS1R"
rgroup 0--3
line.long 0 "SPIS1R"
hexfld.long 0 " SPIS1 "
;tree.end

base ad:0xa0411d0c
;tree "SPIS2R"
rgroup 0--3
line.long 0 "SPIS2R"
hexfld.long 0 " SPIS2 "
;tree.end

base ad:0xa0411d10
;tree "SPIS3R"
rgroup 0--3
line.long 0 "SPIS3R"
hexfld.long 0 " SPIS3 "
;tree.end

base ad:0xa0411d14
;tree "SPIS4R"
rgroup 0--3
line.long 0 "SPIS4R"
hexfld.long 0 " SPIS4 "
;tree.end

base ad:0xa0411d18
;tree "SPIS5R"
rgroup 0--3
line.long 0 "SPIS5R"
hexfld.long 0 " SPIS5 "
;tree.end

base ad:0xa0411d1c
;tree "SPIS6R"
rgroup 0--3
line.long 0 "SPIS6R"
hexfld.long 0 " SPIS6 "
;tree.end

base ad:0xa0411d20
;tree "SPIS7R"
rgroup 0--3
line.long 0 "SPIS7R"
hexfld.long 0 " SPIS7 "
;tree.end

base ad:0xa0411d24
;tree "SPIS8R"
rgroup 0--3
line.long 0 "SPIS8R"
hexfld.long 0 " SPIS8 "
;tree.end

base ad:0xa0411d28
;tree "SPIS9R"
rgroup 0--3
line.long 0 "SPIS9R"
hexfld.long 0 " SPIS9 "
;tree.end

base ad:0xa0411d2c
;tree "SPIS10R"
rgroup 0--3
line.long 0 "SPIS10R"
hexfld.long 0 " SPIS10 "
;tree.end

base ad:0xa0411d30
;tree "SPIS11R"
rgroup 0--3
line.long 0 "SPIS11R"
hexfld.long 0 " SPIS11 "
;tree.end

base ad:0xa0411d34
;tree "SPIS12R"
rgroup 0--3
line.long 0 "SPIS12R"
hexfld.long 0 " SPIS12 "
;tree.end

base ad:0xa0411d38
;tree "SPIS13R"
rgroup 0--3
line.long 0 "SPIS13R"
hexfld.long 0 " SPIS13 "
;tree.end

base ad:0xa0411d3c
;tree "SPIS14R"
rgroup 0--3
line.long 0 "SPIS14R"
hexfld.long 0 " SPIS14 "
;tree.end

base ad:0xa0411d40
;tree "SPIS15R"
rgroup 0--3
line.long 0 "SPIS15R"
hexfld.long 0 " SPIS15 "
;tree.end

base ad:0xa0411d44
;tree "SPIS16R"
rgroup 0--3
line.long 0 "SPIS16R"
hexfld.long 0 " SPIS16 "
;tree.end

base ad:0xa0411d48
;tree "SPIS17R"
rgroup 0--3
line.long 0 "SPIS17R"
hexfld.long 0 " SPIS17 "
;tree.end

base ad:0xa0411d4c
;tree "SPIS18R"
rgroup 0--3
line.long 0 "SPIS18R"
hexfld.long 0 " SPIS18 "
;tree.end

base ad:0xa0411d50
;tree "SPIS19R"
rgroup 0--3
line.long 0 "SPIS19R"
hexfld.long 0 " SPIS19 "
;tree.end

base ad:0xa0411d54
;tree "SPIS20R"
rgroup 0--3
line.long 0 "SPIS20R"
hexfld.long 0 " SPIS20 "
;tree.end

base ad:0xa0411d58
;tree "SPIS21R"
rgroup 0--3
line.long 0 "SPIS21R"
hexfld.long 0 " SPIS21 "
;tree.end

base ad:0xa0411d5c
;tree "SPIS22R"
rgroup 0--3
line.long 0 "SPIS22R"
hexfld.long 0 " SPIS22 "
;tree.end

base ad:0xa0411d60
;tree "SPIS23R"
rgroup 0--3
line.long 0 "SPIS23R"
hexfld.long 0 " SPIS23 "
;tree.end

base ad:0xa0411d64
;tree "SPIS24R"
rgroup 0--3
line.long 0 "SPIS24R"
hexfld.long 0 " SPIS24 "
;tree.end

base ad:0xa0411d68
;tree "SPIS25R"
rgroup 0--3
line.long 0 "SPIS25R"
hexfld.long 0 " SPIS25 "
;tree.end

base ad:0xa0411d6c
;tree "SPIS26R"
rgroup 0--3
line.long 0 "SPIS26R"
hexfld.long 0 " SPIS26 "
;tree.end

base ad:0xa0411d70
;tree "SPIS27R"
rgroup 0--3
line.long 0 "SPIS27R"
hexfld.long 0 " SPIS27 "
;tree.end

base ad:0xa0411d74
;tree "SPIS28R"
rgroup 0--3
line.long 0 "SPIS28R"
hexfld.long 0 " SPIS28 "
;tree.end

base ad:0xa0411d78
;tree "SPIS29R"
rgroup 0--3
line.long 0 "SPIS29R"
hexfld.long 0 " SPIS29 "
;tree.end

base ad:0xa0411d7c
;tree "SPIS30R"
rgroup 0--3
line.long 0 "SPIS30R"
hexfld.long 0 " SPIS30 "
;tree.end

base ad:0xa0411f00
;tree "STIR"
wgroup 0--3
line.long 0 "STIR"
bitfld.long 0 0.--3. " STIINTID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 15. " STISATT "  "0 ,1 "
hexfld.byte 2 " STICPUTL "
bitfld.long 0 24.--25. " STITLF "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0411fe0
;tree "PPLI0R"
rgroup 0--3
line.long 0 "PPLI0R"
bitfld.long 0 0.--11. " PPLI0PN "  " "
bitfld.long 0 12.--18. " PPLI0JEP106 "  " "
bitfld.long 0 19. " PPLI0JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI0REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI0MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI0REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0411fe4
;tree "PPLI1R"
rgroup 0--3
line.long 0 "PPLI1R"
bitfld.long 0 0.--11. " PPLI1PN "  " "
bitfld.long 0 12.--18. " PPLI1JEP106 "  " "
bitfld.long 0 19. " PPLI1JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI1REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI1MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI1REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0411fe8
;tree "PPLI2R"
rgroup 0--3
line.long 0 "PPLI2R"
bitfld.long 0 0.--11. " PPLI2PN "  " "
bitfld.long 0 12.--18. " PPLI2JEP106 "  " "
bitfld.long 0 19. " PPLI2JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI2REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI2MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI2REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0411fec
;tree "PPLI3R"
rgroup 0--3
line.long 0 "PPLI3R"
bitfld.long 0 0.--11. " PPLI3PN "  " "
bitfld.long 0 12.--18. " PPLI3JEP106 "  " "
bitfld.long 0 19. " PPLI3JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI3REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI3MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI3REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0411ff0
;tree "PCI0R"
rgroup 0--3
line.long 0 "PCI0R"
hexfld.byte 0 " PCI0CID0 "
hexfld.byte 1 " PCI0CID1 "
hexfld.byte 2 " PCI0CID2 "
hexfld.byte 3 " PCI0CID3 "
;tree.end

base ad:0xa0411ff4
;tree "PCI1R"
rgroup 0--3
line.long 0 "PCI1R"
hexfld.byte 0 " PCI1CID0 "
hexfld.byte 1 " PCI1CID1 "
hexfld.byte 2 " PCI1CID2 "
hexfld.byte 3 " PCI1CID3 "
;tree.end

base ad:0xa0411ff8
;tree "PCI2R"
rgroup 0--3
line.long 0 "PCI2R"
hexfld.byte 0 " PCI2CID0 "
hexfld.byte 1 " PCI2CID1 "
hexfld.byte 2 " PCI2CID2 "
hexfld.byte 3 " PCI2CID3 "
;tree.end

base ad:0xa0411ffc
;tree "PCI3R"
rgroup 0--3
line.long 0 "PCI3R"
hexfld.byte 0 " PCI3CID0 "
hexfld.byte 1 " PCI3CID1 "
hexfld.byte 2 " PCI3CID2 "
hexfld.byte 3 " PCI3CID3 "
;tree.end

tree.end

;==============================================================
tree "GPIO0"
;==============================================================
if ((data.long(ad:0x8012f010)&0x200)!=0x200)

base ad:0x8012f000
group 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 9. " PERCKEN9 "  "0 ,1 "

base ad:0x8012f010
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 9. " PERCKSR9 "  "0 ,1 "

else

base ad:0x8012e000
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8012e004
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8012e008
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8012e00c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8012e010
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8012e014
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8012e018
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8012e01c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8012e020
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8012e024
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8012e028
;tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

base ad:0x8012e040
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8012e044
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8012e048
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8012e04c
;tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8012e050
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8012e054
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8012e058
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

base ad:0x8012e7e0
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8012e7e4
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " GPIOINTR "  "0 ,1 "
bitfld.long 0 1. " GPIOWKUP "  "0 ,1 "
;tree.end

base ad:0x8012e7e8
;tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012efe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x8012efe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012efec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8012eff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " GPIOPCellID0 "
;tree.end

base ad:0x8012eff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " GPIOPCellID1 "
;tree.end

base ad:0x8012eff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " GPIOPCellID2 "
;tree.end

base ad:0x8012effc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " GPIOPCellID3 "
;tree.end

endif

tree.end

;==============================================================
tree "GPIO1"
;==============================================================
if ((data.long(ad:0x8012f010)&0x200)!=0x200)

base ad:0x8012f000
group 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 9. " PERCKEN9 "  "0 ,1 "

base ad:0x8012f010
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 9. " PERCKSR9 "  "0 ,1 "

else

base ad:0x8012e080
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8012e084
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8012e088
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8012e08c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8012e090
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8012e094
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8012e098
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8012e09c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8012e0a0
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8012e0a4
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8012e0a8
;tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

base ad:0x8012e0c0
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8012e0c4
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8012e0c8
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8012e0cc
;tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8012e0d0
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8012e0d4
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8012e0d8
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

endif

tree.end

;==============================================================
tree "GPIO2"
;==============================================================
base ad:0x8000e000
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8000e004
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8000e008
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8000e00c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8000e010
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8000e014
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8000e018
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8000e01c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8000e020
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8000e024
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8000e028
;tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

base ad:0x8000e040
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8000e044
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8000e048
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8000e04c
;tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8000e050
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8000e054
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8000e058
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

base ad:0x8000e7e0
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8000e7e4
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " GPIOINTR "  "0 ,1 "
bitfld.long 0 1. " GPIOWKUP "  "0 ,1 "
;tree.end

base ad:0x8000e7e8
;tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8000efe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x8000efe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8000efe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8000efec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8000eff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " GPIOPCellID0 "
;tree.end

base ad:0x8000eff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " GPIOPCellID1 "
;tree.end

base ad:0x8000eff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " GPIOPCellID2 "
;tree.end

base ad:0x8000effc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " GPIOPCellID3 "
;tree.end

tree.end

;==============================================================
tree "GPIO3"
;==============================================================
base ad:0x8000e080
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8000e084
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8000e088
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8000e08c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8000e090
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8000e094
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8000e098
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8000e09c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8000e0a0
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8000e0a4
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8000e0a8
;tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

base ad:0x8000e0c0
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8000e0c4
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8000e0c8
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8000e0cc
;tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8000e0d0
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8000e0d4
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8000e0d8
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

tree.end

;==============================================================
tree "GPIO4"
;==============================================================
base ad:0x8000e100
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8000e104
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8000e108
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8000e10c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8000e110
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8000e114
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8000e118
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8000e11c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8000e120
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8000e124
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8000e128
;tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

base ad:0x8000e140
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8000e144
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8000e148
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8000e14c
;tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8000e150
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8000e154
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8000e158
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

tree.end

;==============================================================
tree "GPIO5"
;==============================================================
base ad:0x8000e180
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8000e184
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8000e188
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8000e18c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8000e190
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8000e194
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8000e198
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8000e19c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8000e1a0
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8000e1a4
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8000e1a8
;tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

base ad:0x8000e1c0
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8000e1c4
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8000e1c8
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8000e1cc
;tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8000e1d0
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8000e1d4
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8000e1d8
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

tree.end

;==============================================================
tree "GPIO6"
;==============================================================
if ((data.long(ad:0x8011f010)&0x800)!=0x800)

base ad:0x8011f000
group 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 11. " PERCKEN11 "  "0 ,1 "

base ad:0x8011f010
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 11. " PERCKEN11 "  "0 ,1 "

else

base ad:0x8011e000
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8011e004
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8011e008
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8011e00c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8011e010
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8011e014
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8011e018
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8011e01c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8011e020
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8011e024
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8011e028
;tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

base ad:0x8011e040
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8011e044
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8011e048
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8011e04c
;tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8011e050
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8011e054
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8011e058
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

base ad:0x8011e7e0
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8011e7e4
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " GPIOINTR "  "0 ,1 "
bitfld.long 0 1. " GPIOWKUP "  "0 ,1 "
;tree.end

base ad:0x8011e7e8
;tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8011efe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x8011efe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011efe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011efec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8011eff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " GPIOPCellID0 "
;tree.end

base ad:0x8011eff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " GPIOPCellID1 "
;tree.end

base ad:0x8011eff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " GPIOPCellID2 "
;tree.end

base ad:0x8011effc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " GPIOPCellID3 "
;tree.end

endif

tree.end

;==============================================================
tree "GPIO7"
;==============================================================
if ((data.long(ad:0x8011f010)&0x800)!=0x800)

base ad:0x8011f000
group 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 11. " PERCKEN11 "  "0 ,1 "

base ad:0x8011f010
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 11. " PERCKEN11 "  "0 ,1 "

else

base ad:0x8011e080
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0x8011e084
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0x8011e088
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0x8011e08c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0x8011e090
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0x8011e094
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0x8011e098
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0x8011e09c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0x8011e0a0
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0x8011e0a4
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0x8011e0a8
;tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

base ad:0x8011e0c0
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0x8011e0c4
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0x8011e0c8
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0x8011e0cc
;tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0x8011e0d0
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0x8011e0d4
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0x8011e0d8
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

endif

tree.end

;==============================================================
tree "GPIO8"
;==============================================================
base ad:0xa03fe000
;tree "DAT"
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

base ad:0xa03fe004
;tree "DATS"
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

base ad:0xa03fe008
;tree "DATC"
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

base ad:0xa03fe00c
;tree "PDIS"
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

base ad:0xa03fe010
;tree "DIR"
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

base ad:0xa03fe014
;tree "DIRS"
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

base ad:0xa03fe018
;tree "DIRC"
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

base ad:0xa03fe01c
;tree "SLPM"
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

base ad:0xa03fe020
;tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

base ad:0xa03fe024
;tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

base ad:0xa03fe028
;tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

base ad:0xa03fe040
;tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

base ad:0xa03fe044
;tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

base ad:0xa03fe048
;tree "IS"
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

base ad:0xa03fe04c
;tree "IC"
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

base ad:0xa03fe050
;tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

base ad:0xa03fe054
;tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

base ad:0xa03fe058
;tree "WKS"
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

base ad:0xa03fe7e0
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0xa03fe7e4
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " GPIOINTR "  "0 ,1 "
bitfld.long 0 1. " GPIOWKUP "  "0 ,1 "
;tree.end

base ad:0xa03fe7e8
;tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa03fefe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0xa03fefe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03fefe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03fefec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03feff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " GPIOPCellID0 "
;tree.end

base ad:0xa03feff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " GPIOPCellID1 "
;tree.end

base ad:0xa03feff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " GPIOPCellID2 "
;tree.end

base ad:0xa03feffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " GPIOPCellID3 "
;tree.end

tree.end

;==============================================================
tree "HAMACI_MMDSP"
;==============================================================
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x8015741c)&0x28000)!=0x28000)||((data.long(ad:0x801571ec)&0x600)!=0x600)||((data.long(ad:0x80157428)&0x300)!=0x0))

base ad:0x8015700c
group 0--3
line.long 0 "PRCM_SIAMMDSPCLK_MGT"
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SIA_PHY_EN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 15. " SIA_L_VOK "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

else

base ad:0xa023a800
;tree "DMA0_CTRL"
group 0--3
line.long 0 "DMA0_CTRL"
bitfld.long 0 0.--12. " value "  " "
;tree.end

base ad:0xa023a804
;tree "DMA0_INT_BASE"
group 0--3
line.long 0 "DMA0_INT_BASE"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a808
;tree "DMA0_INT_LENGTH"
group 0--3
line.long 0 "DMA0_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a80c
;tree "DMA0_EXT_BASEH"
group 0--3
line.long 0 "DMA0_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023a810
;tree "DMA0_EXT_BASEL"
group 0--3
line.long 0 "DMA0_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a814
;tree "DMA0_COUNT"
rgroup 0--3
line.long 0 "DMA0_COUNT"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a818
;tree "DMA0_EXT_LENGTH"
group 0--3
line.long 0 "DMA0_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a81c
;tree "DMA_IT_STATUS"
rgroup 0--3
line.long 0 "DMA_IT_STATUS"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023a820
;tree "DMA1_CTRL"
group 0--3
line.long 0 "DMA1_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

base ad:0xa023a824
;tree "DMA1_INT_BASE"
group 0--3
line.long 0 "DMA1_INT_BASE"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a828
;tree "DMA1_INT_LENGTH"
group 0--3
line.long 0 "DMA1_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a82c
;tree "DMA1_EXT_BASEH"
group 0--3
line.long 0 "DMA1_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023a830
;tree "DMA1_EXT_BASEL"
group 0--3
line.long 0 "DMA1_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a834
;tree "DMA1_COUNT"
rgroup 0--3
line.long 0 "DMA1_COUNT"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a838
;tree "DMA1_EXT_LENGTH"
group 0--3
line.long 0 "DMA1_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a840
;tree "DMA2_CTRL"
group 0--3
line.long 0 "DMA2_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

base ad:0xa023a844
;tree "DMA2_INT_BASE"
group 0--3
line.long 0 "DMA2_INT_BASE"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a848
;tree "DMA2_INT_LENGTH"
group 0--3
line.long 0 "DMA2_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a84c
;tree "DMA2_EXT_BASEH"
group 0--3
line.long 0 "DMA2_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023a850
;tree "DMA2_EXT_BASEL"
group 0--3
line.long 0 "DMA2_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a854
;tree "DMA2_COUNT"
rgroup 0--3
line.long 0 "DMA2_COUNT"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a858
;tree "DMA2_EXT_LENGTH"
group 0--3
line.long 0 "DMA2_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a860
;tree "DMA3_CTRL"
group 0--3
line.long 0 "DMA3_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

base ad:0xa023a864
;tree "DMA3_INT_BASE"
group 0--3
line.long 0 "DMA3_INT_BASE"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a868
;tree "DMA3_INT_LENGTH"
group 0--3
line.long 0 "DMA3_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a86c
;tree "DMA3_EXT_BASEH"
group 0--3
line.long 0 "DMA3_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023a870
;tree "DMA3_EXT_BASEL"
group 0--3
line.long 0 "DMA3_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a874
;tree "DMA3_COUNT"
rgroup 0--3
line.long 0 "DMA3_COUNT"
hexfld.word 0 " value "
;tree.end

base ad:0xa023a878
;tree "DMA3_EXT_LENGTH"
group 0--3
line.long 0 "DMA3_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa023b014
;tree "Dcache_mode"
group 0--3
line.long 0 "Dcache_mode"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023b018
;tree "Dcache_control"
group 0--3
line.long 0 "Dcache_control"
bitfld.long 0 0.--4. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa023b01c
;tree "Dcache_way"
group 0--3
line.long 0 "Dcache_way"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa023b020
;tree "Dcache_line"
group 0--3
line.long 0 "Dcache_line"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023b024
;tree "Dcache_command"
wgroup 0--3
line.long 0 "Dcache_command"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa023b028
;tree "Dcache_status"
rgroup 0--3
line.long 0 "Dcache_status"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023b02c
;tree "Dcache_cptrl1l"
rgroup 0--3
line.long 0 "Dcache_cptrl1l"
hexfld.word 0 " value "
;tree.end

base ad:0xa023b030
;tree "Dcache_cptrl1h"
rgroup 0--3
line.long 0 "Dcache_cptrl1h"
hexfld.word 0 " value "
;tree.end

base ad:0xa023b034
;tree "Dcache_cptrl2l"
rgroup 0--3
line.long 0 "Dcache_cptrl2l"
hexfld.word 0 " value "
;tree.end

base ad:0xa023b038
;tree "Dcache_cptrl2h"
rgroup 0--3
line.long 0 "Dcache_cptrl2h"
hexfld.word 0 " value "
;tree.end

base ad:0xa023b03c
;tree "Dcache_cptrl3l"
rgroup 0--3
line.long 0 "Dcache_cptrl3l"
hexfld.word 0 " value "
;tree.end

base ad:0xa023b040
;tree "Dcache_cptrl3h"
rgroup 0--3
line.long 0 "Dcache_cptrl3h"
hexfld.word 0 " value "
;tree.end

base ad:0xa023b044
;tree "Dcache_cptrsel"
group 0--3
line.long 0 "Dcache_cptrsel"
bitfld.long 0 0.--11. " value "  " "
;tree.end

base ad:0xa023c000
;tree "IO_BIT0"
group 0--3
line.long 0 "IO_BIT0"
bitfld.long 0 0. " IO_bit0 "  "0 ,1 "
;tree.end

base ad:0xa023c008
;tree "IO_BIT1"
group 0--3
line.long 0 "IO_BIT1"
bitfld.long 0 0. " IO_bit1 "  "0 ,1 "
;tree.end

base ad:0xa023c010
;tree "IO_BIT2"
group 0--3
line.long 0 "IO_BIT2"
bitfld.long 0 0. " IO_bit2 "  "0 ,1 "
;tree.end

base ad:0xa023c018
;tree "IO_BIT3"
group 0--3
line.long 0 "IO_BIT3"
bitfld.long 0 0. " IO_bit3 "  "0 ,1 "
;tree.end

base ad:0xa023c020
;tree "IO_BIT4"
group 0--3
line.long 0 "IO_BIT4"
bitfld.long 0 0. " IO_bit4 "  "0 ,1 "
;tree.end

base ad:0xa023c028
;tree "IO_BIT5"
group 0--3
line.long 0 "IO_BIT5"
bitfld.long 0 0. " IO_bit5 "  "0 ,1 "
;tree.end

base ad:0xa023c030
;tree "IO_BIT6"
group 0--3
line.long 0 "IO_BIT6"
bitfld.long 0 0. " IO_bit6 "  "0 ,1 "
;tree.end

base ad:0xa023c038
;tree "IO_BIT7"
group 0--3
line.long 0 "IO_BIT7"
bitfld.long 0 0. " IO_bit7 "  "0 ,1 "
;tree.end

base ad:0xa023c040
;tree "IO_BIT8"
group 0--3
line.long 0 "IO_BIT8"
bitfld.long 0 0. " IO_bit8 "  "0 ,1 "
;tree.end

base ad:0xa023c048
;tree "IO_BIT9"
group 0--3
line.long 0 "IO_BIT9"
bitfld.long 0 0. " IO_bit9 "  "0 ,1 "
;tree.end

base ad:0xa023c050
;tree "IO_BITA"
group 0--3
line.long 0 "IO_BITA"
bitfld.long 0 0. " IO_bitA "  "0 ,1 "
;tree.end

base ad:0xa023c058
;tree "IO_BITB"
group 0--3
line.long 0 "IO_BITB"
bitfld.long 0 0. " IO_bitB "  "0 ,1 "
;tree.end

base ad:0xa023c060
;tree "IO_BITC"
group 0--3
line.long 0 "IO_BITC"
bitfld.long 0 0. " IO_bitC "  "0 ,1 "
;tree.end

base ad:0xa023c068
;tree "IO_BITD"
group 0--3
line.long 0 "IO_BITD"
bitfld.long 0 0. " IO_bitD "  "0 ,1 "
;tree.end

base ad:0xa023c070
;tree "IO_BITE"
group 0--3
line.long 0 "IO_BITE"
bitfld.long 0 0. " IO_bitE "  "0 ,1 "
;tree.end

base ad:0xa023c078
;tree "IO_BITF"
group 0--3
line.long 0 "IO_BITF"
bitfld.long 0 0. " IO_bitF "  "0 ,1 "
;tree.end

base ad:0xa023c080
;tree "IO_LSB"
group 0--3
line.long 0 "IO_LSB"
bitfld.long 0 0. " IO_lsb "  "0 ,1 "
;tree.end

base ad:0xa023c088
;tree "IO_MSB"
group 0--3
line.long 0 "IO_MSB"
bitfld.long 0 0. " IO_msb "  "0 ,1 "
;tree.end

base ad:0xa023c090
;tree "IO_ALL"
group 0--3
line.long 0 "IO_ALL"
bitfld.long 0 0. " IO_all "  "0 ,1 "
;tree.end

base ad:0xa023c098
;tree "IO_EN"
group 0--3
line.long 0 "IO_EN"
bitfld.long 0 0. " IO_en "  "0 ,1 "
;tree.end

base ad:0xa023c0c0
;tree "TIMER_MOD0_MSB"
group 0--3
line.long 0 "TIMER_MOD0_MSB"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023c0c8
;tree "TIMER_MOD0_LSB"
group 0--3
line.long 0 "TIMER_MOD0_LSB"
hexfld.word 0 " value "
;tree.end

base ad:0xa023c0d0
;tree "TIMER_MOD1_MSB"
group 0--3
line.long 0 "TIMER_MOD1_MSB"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023c0d8
;tree "TIMER_MOD1_LSB"
group 0--3
line.long 0 "TIMER_MOD1_LSB"
hexfld.word 0 " value "
;tree.end

base ad:0xa023c0e0
;tree "TIMER_MOD2_MSB"
group 0--3
line.long 0 "TIMER_MOD2_MSB"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023c0e8
;tree "TIMER_MOD2_LSB"
group 0--3
line.long 0 "TIMER_MOD2_LSB"
hexfld.word 0 " value "
;tree.end

base ad:0xa023c820
;tree "SEM0"
group 0--3
line.long 0 "SEM0"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023c828
;tree "SEM1"
group 0--3
line.long 0 "SEM1"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023c830
;tree "SEM2"
group 0--3
line.long 0 "SEM2"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023c838
;tree "SEM3"
group 0--3
line.long 0 "SEM3"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023c840
;tree "SEM4"
group 0--3
line.long 0 "SEM4"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023c848
;tree "SEM5"
group 0--3
line.long 0 "SEM5"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023c850
;tree "SEM6"
group 0--3
line.long 0 "SEM6"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023c858
;tree "SEM7"
group 0--3
line.long 0 "SEM7"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023c8a0
;tree "HAMACI_IPEN"
group 0--3
line.long 0 "HAMACI_IPEN"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023c8a8
;tree "HAMACI_ITIP_0"
group 0--3
line.long 0 "HAMACI_ITIP_0"
hexfld.word 0 " value "
;tree.end

base ad:0xa023c8ac
;tree "HAMACI_ITIP_1"
group 0--3
line.long 0 "HAMACI_ITIP_1"
hexfld.word 0 " value "
;tree.end

base ad:0xa023c8b0
;tree "HAMACI_ITIP_2"
group 0--3
line.long 0 "HAMACI_ITIP_2"
hexfld.word 0 " value "
;tree.end

base ad:0xa023c8b4
;tree "HAMACI_ITIP_3"
group 0--3
line.long 0 "HAMACI_ITIP_3"
bitfld.long 0 0. " ITEXT11 "  "0 ,1 "
bitfld.long 0 1. " ITEXT12 "  "0 ,1 "
bitfld.long 0 2. " XDMA_LBREQ0 "  "0 ,1 "
bitfld.long 0 3. " XDMA_LBREQ1 "  "0 ,1 "
bitfld.long 0 4. " XDMA_LBREQ2 "  "0 ,1 "
bitfld.long 0 5. " XDMA_LBREQ3 "  "0 ,1 "
bitfld.long 0 6. " XDMA_LSREQ0 "  "0 ,1 "
bitfld.long 0 7. " XDMA_LSREQ1 "  "0 ,1 "
bitfld.long 0 8. " XDMA_LSREQ2 "  "0 ,1 "
bitfld.long 0 9. " XDMA_LSREQ3 "  "0 ,1 "
bitfld.long 0 10. " XDMA_BREQ0 "  "0 ,1 "
bitfld.long 0 11. " XDMA_BREQ1 "  "0 ,1 "
bitfld.long 0 12. " XDMA_BREQ2 "  "0 ,1 "
bitfld.long 0 13. " XDMA_BREQ3 "  "0 ,1 "
bitfld.long 0 14. " XDMA_SREQ0 "  "0 ,1 "
bitfld.long 0 15. " XDMA_SREQ1 "  "0 ,1 "
;tree.end

base ad:0xa023c914
;tree "HAMACI_ITIP_4"
group 0--3
line.long 0 "HAMACI_ITIP_4"
bitfld.long 0 0. " XDMA_SREQ2 "  "0 ,1 "
bitfld.long 0 1. " XDMA_SREQ3 "  "0 ,1 "
;tree.end

base ad:0xa023c8b8
;tree "HAMACI_ITOP0"
group 0--3
line.long 0 "HAMACI_ITOP0"
hexfld.word 0 " value "
;tree.end

base ad:0xa023c8bc
;tree "HAMACI_ITOP1"
group 0--3
line.long 0 "HAMACI_ITOP1"
hexfld.word 0 " value "
;tree.end

base ad:0xa023c8c0
;tree "HAMACI_ITOP2"
group 0--3
line.long 0 "HAMACI_ITOP2"
hexfld.word 0 " value "
;tree.end

base ad:0xa023c8c4
;tree "HAMACI_ITOP3"
group 0--3
line.long 0 "HAMACI_ITOP3"
hexfld.word 0 " value "
;tree.end

base ad:0xa023c918
;tree "HAMACI_ITOP4"
group 0--3
line.long 0 "HAMACI_ITOP4"
bitfld.long 0 0.--13. " value "  " "
;tree.end

base ad:0xa023cfc0
;tree "ID0"
rgroup 0--3
line.long 0 "ID0"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023cfc8
;tree "ID1"
rgroup 0--3
line.long 0 "ID1"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023cfd0
;tree "ID2"
rgroup 0--3
line.long 0 "ID2"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023cfd8
;tree "ID3"
rgroup 0--3
line.long 0 "ID3"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023cfe0
;tree "IDP0"
rgroup 0--3
line.long 0 "IDP0"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023cfe8
;tree "IDP1"
rgroup 0--3
line.long 0 "IDP1"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023cff0
;tree "IDP2"
rgroup 0--3
line.long 0 "IDP2"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023cff8
;tree "IDP3"
rgroup 0--3
line.long 0 "IDP3"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023d000
;tree "ARM_DMA0_SREQ"
group 0--3
line.long 0 "ARM_DMA0_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d004
;tree "ARM_DMA0_BREQ"
group 0--3
line.long 0 "ARM_DMA0_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d008
;tree "ARM_DMA0_LSREQ"
group 0--3
line.long 0 "ARM_DMA0_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d00c
;tree "ARM_DMA0_LBREQ"
group 0--3
line.long 0 "ARM_DMA0_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d010
;tree "ARM_DMA0_MASKIT"
group 0--3
line.long 0 "ARM_DMA0_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d014
;tree "ARM_DMA0_IT"
rgroup 0--3
line.long 0 "ARM_DMA0_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d018
;tree "ARM_DMA0_AUTO"
group 0--3
line.long 0 "ARM_DMA0_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023d01c
;tree "ARM_DMA0_LAUTO"
group 0--3
line.long 0 "ARM_DMA0_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa023d040
;tree "ARM_DMA1_SREQ"
group 0--3
line.long 0 "ARM_DMA1_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d044
;tree "ARM_DMA1_BREQ"
group 0--3
line.long 0 "ARM_DMA1_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d048
;tree "ARM_DMA1_LSREQ"
group 0--3
line.long 0 "ARM_DMA1_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d04c
;tree "ARM_DMA1_LBREQ"
group 0--3
line.long 0 "ARM_DMA1_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d050
;tree "ARM_DMA1_MASKIT"
group 0--3
line.long 0 "ARM_DMA1_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d054
;tree "ARM_DMA1_IT"
rgroup 0--3
line.long 0 "ARM_DMA1_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d058
;tree "ARM_DMA1_AUTO"
group 0--3
line.long 0 "ARM_DMA1_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023d05c
;tree "ARM_DMA1_LAUTO"
group 0--3
line.long 0 "ARM_DMA1_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa023d080
;tree "ARM_DMA2_SREQ"
group 0--3
line.long 0 "ARM_DMA2_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d084
;tree "ARM_DMA2_BREQ"
group 0--3
line.long 0 "ARM_DMA2_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d088
;tree "ARM_DMA2_LSREQ"
group 0--3
line.long 0 "ARM_DMA2_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d08c
;tree "ARM_DMA2_LBREQ"
group 0--3
line.long 0 "ARM_DMA2_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d090
;tree "ARM_DMA2_MASKIT"
group 0--3
line.long 0 "ARM_DMA2_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d094
;tree "ARM_DMA2_IT"
rgroup 0--3
line.long 0 "ARM_DMA2_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d098
;tree "ARM_DMA2_AUTO"
group 0--3
line.long 0 "ARM_DMA2_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023d09c
;tree "ARM_DMA2_LAUTO"
group 0--3
line.long 0 "ARM_DMA2_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa023d0c0
;tree "ARM_DMA3_SREQ"
group 0--3
line.long 0 "ARM_DMA3_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d0c4
;tree "ARM_DMA3_BREQ"
group 0--3
line.long 0 "ARM_DMA3_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d0c8
;tree "ARM_DMA3_LSREQ"
group 0--3
line.long 0 "ARM_DMA3_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d0cc
;tree "ARM_DMA3_LBREQ"
group 0--3
line.long 0 "ARM_DMA3_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d0d0
;tree "ARM_DMA3_MASKIT"
group 0--3
line.long 0 "ARM_DMA3_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d0d4
;tree "ARM_DMA3_IT"
rgroup 0--3
line.long 0 "ARM_DMA3_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d0d8
;tree "ARM_DMA3_AUTO"
group 0--3
line.long 0 "ARM_DMA3_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023d0dc
;tree "ARM_DMA3_LAUTO"
group 0--3
line.long 0 "ARM_DMA3_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa023d100
;tree "ARM_DMA4_SREQ"
group 0--3
line.long 0 "ARM_DMA4_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d104
;tree "ARM_DMA4_BREQ"
group 0--3
line.long 0 "ARM_DMA4_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d108
;tree "ARM_DMA4_LSREQ"
group 0--3
line.long 0 "ARM_DMA4_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d10c
;tree "ARM_DMA4_LBREQ"
group 0--3
line.long 0 "ARM_DMA4_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d110
;tree "ARM_DMA4_MASKIT"
group 0--3
line.long 0 "ARM_DMA4_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d114
;tree "ARM_DMA4_IT"
rgroup 0--3
line.long 0 "ARM_DMA4_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d118
;tree "ARM_DMA4_AUTO"
group 0--3
line.long 0 "ARM_DMA4_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023d11c
;tree "ARM_DMA4_LAUTO"
group 0--3
line.long 0 "ARM_DMA4_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa023d140
;tree "ARM_DMA5_SREQ"
group 0--3
line.long 0 "ARM_DMA5_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d144
;tree "ARM_DMA5_BREQ"
group 0--3
line.long 0 "ARM_DMA5_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d148
;tree "ARM_DMA5_LSREQ"
group 0--3
line.long 0 "ARM_DMA5_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d14c
;tree "ARM_DMA5_LBREQ"
group 0--3
line.long 0 "ARM_DMA5_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d150
;tree "ARM_DMA5_MASKIT"
group 0--3
line.long 0 "ARM_DMA5_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d154
;tree "ARM_DMA5_IT"
rgroup 0--3
line.long 0 "ARM_DMA5_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d158
;tree "ARM_DMA5_AUTO"
group 0--3
line.long 0 "ARM_DMA5_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023d15c
;tree "ARM_DMA5_LAUTO"
group 0--3
line.long 0 "ARM_DMA5_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa023d180
;tree "ARM_DMA6_SREQ"
group 0--3
line.long 0 "ARM_DMA6_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d184
;tree "ARM_DMA6_BREQ"
group 0--3
line.long 0 "ARM_DMA6_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d188
;tree "ARM_DMA6_LSREQ"
group 0--3
line.long 0 "ARM_DMA6_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d18c
;tree "ARM_DMA6_LBREQ"
group 0--3
line.long 0 "ARM_DMA6_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d190
;tree "ARM_DMA6_MASKIT"
group 0--3
line.long 0 "ARM_DMA6_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d194
;tree "ARM_DMA6_IT"
rgroup 0--3
line.long 0 "ARM_DMA6_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d198
;tree "ARM_DMA6_AUTO"
group 0--3
line.long 0 "ARM_DMA6_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023d19c
;tree "ARM_DMA6_LAUTO"
group 0--3
line.long 0 "ARM_DMA6_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa023d1c0
;tree "ARM_DMA7_SREQ"
group 0--3
line.long 0 "ARM_DMA7_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d1c4
;tree "ARM_DMA7_BREQ"
group 0--3
line.long 0 "ARM_DMA7_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d1c8
;tree "ARM_DMA7_LSREQ"
group 0--3
line.long 0 "ARM_DMA7_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d1cc
;tree "ARM_DMA7_LBREQ"
group 0--3
line.long 0 "ARM_DMA7_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d1d0
;tree "ARM_DMA7_MASKIT"
group 0--3
line.long 0 "ARM_DMA7_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d1d4
;tree "ARM_DMA7_IT"
rgroup 0--3
line.long 0 "ARM_DMA7_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023d1d8
;tree "ARM_DMA7_AUTO"
group 0--3
line.long 0 "ARM_DMA7_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa023d1dc
;tree "ARM_DMA7_LAUTO"
group 0--3
line.long 0 "ARM_DMA7_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa023d800
;tree "EMU_UNIT_MASKIT"
group 0--3
line.long 0 "EMU_UNIT_MASKIT"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa023d820
;tree "CONFIG_DATA_MEM"
group 0--3
line.long 0 "CONFIG_DATA_MEM"
bitfld.long 0 0.--13. " value "  " "
;tree.end

base ad:0xa023d828
;tree "COMPATIBILITY_REGISTER"
group 0--3
line.long 0 "COMPATIBILITY_REGISTER"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa023e000
;tree "AHB_IF_CONFIG"
group 0--3
line.long 0 "AHB_IF_CONFIG"
bitfld.long 0 0.--3. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa023e004
;tree "AHB_IF_MODE"
group 0--3
line.long 0 "AHB_IF_MODE"
bitfld.long 0 0.--3. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa023e008
;tree "AHB_IF_STATUS"
rgroup 0--3
line.long 0 "AHB_IF_STATUS"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa023e00c
;tree "AHB_IF_SECURITY"
group 0--3
line.long 0 "AHB_IF_SECURITY"
bitfld.long 0 0.--4. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa023f800
;tree "ITREMAP_REG0"
group 0--3
line.long 0 "ITREMAP_REG0"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f808
;tree "ITREMAP_REG1"
group 0--3
line.long 0 "ITREMAP_REG1"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f810
;tree "ITREMAP_REG2"
group 0--3
line.long 0 "ITREMAP_REG2"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f818
;tree "ITREMAP_REG3"
group 0--3
line.long 0 "ITREMAP_REG3"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f820
;tree "ITREMAP_REG4"
group 0--3
line.long 0 "ITREMAP_REG4"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f828
;tree "ITREMAP_REG5"
group 0--3
line.long 0 "ITREMAP_REG5"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f830
;tree "ITREMAP_REG6"
group 0--3
line.long 0 "ITREMAP_REG6"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f838
;tree "ITREMAP_REG7"
group 0--3
line.long 0 "ITREMAP_REG7"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f840
;tree "ITREMAP_REG8"
group 0--3
line.long 0 "ITREMAP_REG8"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f848
;tree "ITREMAP_REG9"
group 0--3
line.long 0 "ITREMAP_REG9"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f850
;tree "ITREMAP_REG10"
group 0--3
line.long 0 "ITREMAP_REG10"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f858
;tree "ITREMAP_REG11"
group 0--3
line.long 0 "ITREMAP_REG11"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f860
;tree "ITREMAP_REG12"
group 0--3
line.long 0 "ITREMAP_REG12"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f868
;tree "ITREMAP_REG13"
group 0--3
line.long 0 "ITREMAP_REG13"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f870
;tree "ITREMAP_REG14"
group 0--3
line.long 0 "ITREMAP_REG14"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f878
;tree "ITREMAP_REG15"
group 0--3
line.long 0 "ITREMAP_REG15"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f880
;tree "ITREMAP_REG16"
group 0--3
line.long 0 "ITREMAP_REG16"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f888
;tree "ITREMAP_REG17"
group 0--3
line.long 0 "ITREMAP_REG17"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f890
;tree "ITREMAP_REG18"
group 0--3
line.long 0 "ITREMAP_REG18"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f898
;tree "ITREMAP_REG19"
group 0--3
line.long 0 "ITREMAP_REG19"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f8a0
;tree "ITREMAP_REG20"
group 0--3
line.long 0 "ITREMAP_REG20"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f8a8
;tree "ITREMAP_REG21"
group 0--3
line.long 0 "ITREMAP_REG21"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f8b0
;tree "ITREMAP_REG22"
group 0--3
line.long 0 "ITREMAP_REG22"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f8b8
;tree "ITREMAP_REG23"
group 0--3
line.long 0 "ITREMAP_REG23"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f8c0
;tree "ITREMAP_REG24"
group 0--3
line.long 0 "ITREMAP_REG24"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f8c8
;tree "ITREMAP_REG25"
group 0--3
line.long 0 "ITREMAP_REG25"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f8d0
;tree "ITREMAP_REG26"
group 0--3
line.long 0 "ITREMAP_REG26"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f8d8
;tree "ITREMAP_REG27"
group 0--3
line.long 0 "ITREMAP_REG27"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f8e0
;tree "ITREMAP_REG28"
group 0--3
line.long 0 "ITREMAP_REG28"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f8e8
;tree "ITREMAP_REG29"
group 0--3
line.long 0 "ITREMAP_REG29"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f8f0
;tree "ITREMAP_REG30"
group 0--3
line.long 0 "ITREMAP_REG30"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f8f8
;tree "ITREMAP_REG31"
group 0--3
line.long 0 "ITREMAP_REG31"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023f900
;tree "ITMSK_L_REG"
group 0--3
line.long 0 "ITMSK_L_REG"
hexfld.word 0 " value "
;tree.end

base ad:0xa023f908
;tree "ITMSK_H_REG"
group 0--3
line.long 0 "ITMSK_H_REG"
hexfld.word 0 " value "
;tree.end

base ad:0xa023f938
;tree "ITMEMO_L_REG"
group 0--3
line.long 0 "ITMEMO_L_REG"
hexfld.word 0 " value "
;tree.end

base ad:0xa023f940
;tree "ITMEMO_H_REG"
group 0--3
line.long 0 "ITMEMO_H_REG"
hexfld.word 0 " value "
;tree.end

base ad:0xa023fa00
;tree "ITREMAP1_REG0"
group 0--3
line.long 0 "ITREMAP1_REG0"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa08
;tree "ITREMAP1_REG1"
group 0--3
line.long 0 "ITREMAP1_REG1"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa10
;tree "ITREMAP1_REG2"
group 0--3
line.long 0 "ITREMAP1_REG2"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa18
;tree "ITREMAP1_REG3"
group 0--3
line.long 0 "ITREMAP1_REG3"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa20
;tree "ITREMAP1_REG4"
group 0--3
line.long 0 "ITREMAP1_REG4"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa28
;tree "ITREMAP1_REG5"
group 0--3
line.long 0 "ITREMAP1_REG5"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa30
;tree "ITREMAP1_REG6"
group 0--3
line.long 0 "ITREMAP1_REG6"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa38
;tree "ITREMAP1_REG7"
group 0--3
line.long 0 "ITREMAP1_REG7"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa40
;tree "ITREMAP1_REG8"
group 0--3
line.long 0 "ITREMAP1_REG8"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa48
;tree "ITREMAP1_REG9"
group 0--3
line.long 0 "ITREMAP1_REG9"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa50
;tree "ITREMAP1_REG10"
group 0--3
line.long 0 "ITREMAP1_REG10"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa58
;tree "ITREMAP1_REG11"
group 0--3
line.long 0 "ITREMAP1_REG11"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa60
;tree "ITREMAP1_REG12"
group 0--3
line.long 0 "ITREMAP1_REG12"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa68
;tree "ITREMAP1_REG13"
group 0--3
line.long 0 "ITREMAP1_REG13"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa70
;tree "ITREMAP1_REG14"
group 0--3
line.long 0 "ITREMAP1_REG14"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa78
;tree "ITREMAP1_REG15"
group 0--3
line.long 0 "ITREMAP1_REG15"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa80
;tree "ITREMAP1_REG16"
group 0--3
line.long 0 "ITREMAP1_REG16"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa88
;tree "ITREMAP1_REG17"
group 0--3
line.long 0 "ITREMAP1_REG17"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa90
;tree "ITREMAP1_REG18"
group 0--3
line.long 0 "ITREMAP1_REG18"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fa98
;tree "ITREMAP1_REG19"
group 0--3
line.long 0 "ITREMAP1_REG19"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023faa0
;tree "ITREMAP1_REG20"
group 0--3
line.long 0 "ITREMAP1_REG20"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023faa8
;tree "ITREMAP1_REG21"
group 0--3
line.long 0 "ITREMAP1_REG21"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fab0
;tree "ITREMAP1_REG22"
group 0--3
line.long 0 "ITREMAP1_REG22"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fab8
;tree "ITREMAP1_REG23"
group 0--3
line.long 0 "ITREMAP1_REG23"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fac0
;tree "ITREMAP1_REG24"
group 0--3
line.long 0 "ITREMAP1_REG24"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fac8
;tree "ITREMAP1_REG25"
group 0--3
line.long 0 "ITREMAP1_REG25"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fad0
;tree "ITREMAP1_REG26"
group 0--3
line.long 0 "ITREMAP1_REG26"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fad8
;tree "ITREMAP1_REG27"
group 0--3
line.long 0 "ITREMAP1_REG27"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fae0
;tree "ITREMAP1_REG28"
group 0--3
line.long 0 "ITREMAP1_REG28"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023fae8
;tree "ITREMAP1_REG29"
group 0--3
line.long 0 "ITREMAP1_REG29"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023faf0
;tree "ITREMAP1_REG30"
group 0--3
line.long 0 "ITREMAP1_REG30"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa023faf8
;tree "ITREMAP1_REG31"
group 0--3
line.long 0 "ITREMAP1_REG31"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

endif

tree.end

;==============================================================
tree "HAMACV_MMDSP"
;==============================================================
if (((data.long(ad:0x80157008)&0x1100)!=0x1100)||((data.long(ad:0x8015741c)&0x1400)!=0x1400)||((data.long(ad:0x801571ec)&0x30)!=0x30)||((data.long(ad:0x80157428)&0xC0)!=0x0))

base ad:0x80157008
group 0--3
line.long 0 "PRCM_SVAMMDSPCLK_MGT"
bitfld.long 0 8. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SVA_PHY_EN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 10. " SVA_L_VOK "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_CLAMP "  "0 ,1 "

else

base ad:0xA0158804
sgroup "CKG_CKEN"
constx 0 %l 0xFFFFFFFF
setx 0 %l 0
line.long 0 "CKG_CKEN"
base ad:0xA0158804
group 0--3
line.long 0 "CKG_CKEN"

if ((data.long(ad:0xA0158804)&0x7FFFFFFF)==0x7FFF0000)

base ad:0xa013a800
;tree "DMA0_CTRL"
group 0--3
line.long 0 "DMA0_CTRL"
bitfld.long 0 0.--12. " value "  " "
;tree.end

base ad:0xa013a804
;tree "DMA0_INT_BASE"
group 0--3
line.long 0 "DMA0_INT_BASE"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a808
;tree "DMA0_INT_LENGTH"
group 0--3
line.long 0 "DMA0_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a80c
;tree "DMA0_EXT_BASEH"
group 0--3
line.long 0 "DMA0_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013a810
;tree "DMA0_EXT_BASEL"
group 0--3
line.long 0 "DMA0_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a814
;tree "DMA0_COUNT"
rgroup 0--3
line.long 0 "DMA0_COUNT"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a818
;tree "DMA0_EXT_LENGTH"
group 0--3
line.long 0 "DMA0_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a81c
;tree "DMA_IT_STATUS"
rgroup 0--3
line.long 0 "DMA_IT_STATUS"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013a820
;tree "DMA1_CTRL"
group 0--3
line.long 0 "DMA1_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

base ad:0xa013a824
;tree "DMA1_INT_BASE"
group 0--3
line.long 0 "DMA1_INT_BASE"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a828
;tree "DMA1_INT_LENGTH"
group 0--3
line.long 0 "DMA1_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a82c
;tree "DMA1_EXT_BASEH"
group 0--3
line.long 0 "DMA1_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013a830
;tree "DMA1_EXT_BASEL"
group 0--3
line.long 0 "DMA1_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a834
;tree "DMA1_COUNT"
rgroup 0--3
line.long 0 "DMA1_COUNT"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a838
;tree "DMA1_EXT_LENGTH"
group 0--3
line.long 0 "DMA1_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a840
;tree "DMA2_CTRL"
group 0--3
line.long 0 "DMA2_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

base ad:0xa013a844
;tree "DMA2_INT_BASE"
group 0--3
line.long 0 "DMA2_INT_BASE"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a848
;tree "DMA2_INT_LENGTH"
group 0--3
line.long 0 "DMA2_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a84c
;tree "DMA2_EXT_BASEH"
group 0--3
line.long 0 "DMA2_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013a850
;tree "DMA2_EXT_BASEL"
group 0--3
line.long 0 "DMA2_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a854
;tree "DMA2_COUNT"
rgroup 0--3
line.long 0 "DMA2_COUNT"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a858
;tree "DMA2_EXT_LENGTH"
group 0--3
line.long 0 "DMA2_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a860
;tree "DMA3_CTRL"
group 0--3
line.long 0 "DMA3_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

base ad:0xa013a864
;tree "DMA3_INT_BASE"
group 0--3
line.long 0 "DMA3_INT_BASE"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a868
;tree "DMA3_INT_LENGTH"
group 0--3
line.long 0 "DMA3_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a86c
;tree "DMA3_EXT_BASEH"
group 0--3
line.long 0 "DMA3_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013a870
;tree "DMA3_EXT_BASEL"
group 0--3
line.long 0 "DMA3_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a874
;tree "DMA3_COUNT"
rgroup 0--3
line.long 0 "DMA3_COUNT"
hexfld.word 0 " value "
;tree.end

base ad:0xa013a878
;tree "DMA3_EXT_LENGTH"
group 0--3
line.long 0 "DMA3_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

base ad:0xa013b014
;tree "Dcache_mode"
group 0--3
line.long 0 "Dcache_mode"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013b018
;tree "Dcache_control"
group 0--3
line.long 0 "Dcache_control"
bitfld.long 0 0.--4. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa013b01c
;tree "Dcache_way"
group 0--3
line.long 0 "Dcache_way"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa013b020
;tree "Dcache_line"
group 0--3
line.long 0 "Dcache_line"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013b024
;tree "Dcache_command"
wgroup 0--3
line.long 0 "Dcache_command"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa013b028
;tree "Dcache_status"
rgroup 0--3
line.long 0 "Dcache_status"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013b02c
;tree "Dcache_cptrl1l"
rgroup 0--3
line.long 0 "Dcache_cptrl1l"
hexfld.word 0 " value "
;tree.end

base ad:0xa013b030
;tree "Dcache_cptrl1h"
rgroup 0--3
line.long 0 "Dcache_cptrl1h"
hexfld.word 0 " value "
;tree.end

base ad:0xa013b034
;tree "Dcache_cptrl2l"
rgroup 0--3
line.long 0 "Dcache_cptrl2l"
hexfld.word 0 " value "
;tree.end

base ad:0xa013b038
;tree "Dcache_cptrl2h"
rgroup 0--3
line.long 0 "Dcache_cptrl2h"
hexfld.word 0 " value "
;tree.end

base ad:0xa013b03c
;tree "Dcache_cptrl3l"
rgroup 0--3
line.long 0 "Dcache_cptrl3l"
hexfld.word 0 " value "
;tree.end

base ad:0xa013b040
;tree "Dcache_cptrl3h"
rgroup 0--3
line.long 0 "Dcache_cptrl3h"
hexfld.word 0 " value "
;tree.end

base ad:0xa013b044
;tree "Dcache_cptrsel"
group 0--3
line.long 0 "Dcache_cptrsel"
bitfld.long 0 0.--11. " value "  " "
;tree.end

base ad:0xa013c000
;tree "IO_BIT0"
group 0--3
line.long 0 "IO_BIT0"
bitfld.long 0 0. " IO_bit0 "  "0 ,1 "
;tree.end

base ad:0xa013c008
;tree "IO_BIT1"
group 0--3
line.long 0 "IO_BIT1"
bitfld.long 0 0. " IO_bit1 "  "0 ,1 "
;tree.end

base ad:0xa013c010
;tree "IO_BIT2"
group 0--3
line.long 0 "IO_BIT2"
bitfld.long 0 0. " IO_bit2 "  "0 ,1 "
;tree.end

base ad:0xa013c018
;tree "IO_BIT3"
group 0--3
line.long 0 "IO_BIT3"
bitfld.long 0 0. " IO_bit3 "  "0 ,1 "
;tree.end

base ad:0xa013c020
;tree "IO_BIT4"
group 0--3
line.long 0 "IO_BIT4"
bitfld.long 0 0. " IO_bit4 "  "0 ,1 "
;tree.end

base ad:0xa013c028
;tree "IO_BIT5"
group 0--3
line.long 0 "IO_BIT5"
bitfld.long 0 0. " IO_bit5 "  "0 ,1 "
;tree.end

base ad:0xa013c030
;tree "IO_BIT6"
group 0--3
line.long 0 "IO_BIT6"
bitfld.long 0 0. " IO_bit6 "  "0 ,1 "
;tree.end

base ad:0xa013c038
;tree "IO_BIT7"
group 0--3
line.long 0 "IO_BIT7"
bitfld.long 0 0. " IO_bit7 "  "0 ,1 "
;tree.end

base ad:0xa013c040
;tree "IO_BIT8"
group 0--3
line.long 0 "IO_BIT8"
bitfld.long 0 0. " IO_bit8 "  "0 ,1 "
;tree.end

base ad:0xa013c048
;tree "IO_BIT9"
group 0--3
line.long 0 "IO_BIT9"
bitfld.long 0 0. " IO_bit9 "  "0 ,1 "
;tree.end

base ad:0xa013c050
;tree "IO_BITA"
group 0--3
line.long 0 "IO_BITA"
bitfld.long 0 0. " IO_bitA "  "0 ,1 "
;tree.end

base ad:0xa013c058
;tree "IO_BITB"
group 0--3
line.long 0 "IO_BITB"
bitfld.long 0 0. " IO_bitB "  "0 ,1 "
;tree.end

base ad:0xa013c060
;tree "IO_BITC"
group 0--3
line.long 0 "IO_BITC"
bitfld.long 0 0. " IO_bitC "  "0 ,1 "
;tree.end

base ad:0xa013c068
;tree "IO_BITD"
group 0--3
line.long 0 "IO_BITD"
bitfld.long 0 0. " IO_bitD "  "0 ,1 "
;tree.end

base ad:0xa013c070
;tree "IO_BITE"
group 0--3
line.long 0 "IO_BITE"
bitfld.long 0 0. " IO_bitE "  "0 ,1 "
;tree.end

base ad:0xa013c078
;tree "IO_BITF"
group 0--3
line.long 0 "IO_BITF"
bitfld.long 0 0. " IO_bitF "  "0 ,1 "
;tree.end

base ad:0xa013c080
;tree "IO_LSB"
group 0--3
line.long 0 "IO_LSB"
bitfld.long 0 0. " IO_lsb "  "0 ,1 "
;tree.end

base ad:0xa013c088
;tree "IO_MSB"
group 0--3
line.long 0 "IO_MSB"
bitfld.long 0 0. " IO_msb "  "0 ,1 "
;tree.end

base ad:0xa013c090
;tree "IO_ALL"
group 0--3
line.long 0 "IO_ALL"
bitfld.long 0 0. " IO_all "  "0 ,1 "
;tree.end

base ad:0xa013c098
;tree "IO_EN"
group 0--3
line.long 0 "IO_EN"
bitfld.long 0 0. " IO_en "  "0 ,1 "
;tree.end

base ad:0xa013c0c0
;tree "TIMER_MOD0_MSB"
group 0--3
line.long 0 "TIMER_MOD0_MSB"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013c0c8
;tree "TIMER_MOD0_LSB"
group 0--3
line.long 0 "TIMER_MOD0_LSB"
hexfld.word 0 " value "
;tree.end

base ad:0xa013c0d0
;tree "TIMER_MOD1_MSB"
group 0--3
line.long 0 "TIMER_MOD1_MSB"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013c0d8
;tree "TIMER_MOD1_LSB"
group 0--3
line.long 0 "TIMER_MOD1_LSB"
hexfld.word 0 " value "
;tree.end

base ad:0xa013c0e0
;tree "TIMER_MOD2_MSB"
group 0--3
line.long 0 "TIMER_MOD2_MSB"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013c0e8
;tree "TIMER_MOD2_LSB"
group 0--3
line.long 0 "TIMER_MOD2_LSB"
hexfld.word 0 " value "
;tree.end

base ad:0xa013c820
;tree "SEM0"
group 0--3
line.long 0 "SEM0"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013c828
;tree "SEM1"
group 0--3
line.long 0 "SEM1"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013c830
;tree "SEM2"
group 0--3
line.long 0 "SEM2"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013c838
;tree "SEM3"
group 0--3
line.long 0 "SEM3"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013c840
;tree "SEM4"
group 0--3
line.long 0 "SEM4"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013c848
;tree "SEM5"
group 0--3
line.long 0 "SEM5"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013c850
;tree "SEM6"
group 0--3
line.long 0 "SEM6"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013c858
;tree "SEM7"
group 0--3
line.long 0 "SEM7"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013c8a0
;tree "HAMACV_IPEN"
group 0--3
line.long 0 "HAMACV_IPEN"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013c8a8
;tree "HAMACV_ITIP_0"
group 0--3
line.long 0 "HAMACV_ITIP_0"
hexfld.word 0 " value "
;tree.end

base ad:0xa013c8ac
;tree "HAMACV_ITIP_1"
group 0--3
line.long 0 "HAMACV_ITIP_1"
hexfld.word 0 " value "
;tree.end

base ad:0xa013c8b0
;tree "HAMACV_ITIP_2"
group 0--3
line.long 0 "HAMACV_ITIP_2"
hexfld.word 0 " value "
;tree.end

base ad:0xa013c8b4
;tree "HAMACV_ITIP_3"
group 0--3
line.long 0 "HAMACV_ITIP_3"
bitfld.long 0 0. " ITEXT11 "  "0 ,1 "
bitfld.long 0 1. " ITEXT12 "  "0 ,1 "
bitfld.long 0 2. " XDMA_LBREQ0 "  "0 ,1 "
bitfld.long 0 3. " XDMA_LBREQ1 "  "0 ,1 "
bitfld.long 0 4. " XDMA_LBREQ2 "  "0 ,1 "
bitfld.long 0 5. " XDMA_LBREQ3 "  "0 ,1 "
bitfld.long 0 6. " XDMA_LSREQ0 "  "0 ,1 "
bitfld.long 0 7. " XDMA_LSREQ1 "  "0 ,1 "
bitfld.long 0 8. " XDMA_LSREQ2 "  "0 ,1 "
bitfld.long 0 9. " XDMA_LSREQ3 "  "0 ,1 "
bitfld.long 0 10. " XDMA_BREQ0 "  "0 ,1 "
bitfld.long 0 11. " XDMA_BREQ1 "  "0 ,1 "
bitfld.long 0 12. " XDMA_BREQ2 "  "0 ,1 "
bitfld.long 0 13. " XDMA_BREQ3 "  "0 ,1 "
bitfld.long 0 14. " XDMA_SREQ0 "  "0 ,1 "
bitfld.long 0 15. " XDMA_SREQ1 "  "0 ,1 "
;tree.end

base ad:0xa013c914
;tree "HAMACV_ITIP_4"
group 0--3
line.long 0 "HAMACV_ITIP_4"
bitfld.long 0 0. " XDMA_SREQ2 "  "0 ,1 "
bitfld.long 0 1. " XDMA_SREQ3 "  "0 ,1 "
;tree.end

base ad:0xa013c8b8
;tree "HAMACV_ITOP0"
group 0--3
line.long 0 "HAMACV_ITOP0"
hexfld.word 0 " value "
;tree.end

base ad:0xa013c8bc
;tree "HAMACV_ITOP1"
group 0--3
line.long 0 "HAMACV_ITOP1"
hexfld.word 0 " value "
;tree.end

base ad:0xa013c8c0
;tree "HAMACV_ITOP2"
group 0--3
line.long 0 "HAMACV_ITOP2"
hexfld.word 0 " value "
;tree.end

base ad:0xa013c8c4
;tree "HAMACV_ITOP3"
group 0--3
line.long 0 "HAMACV_ITOP3"
hexfld.word 0 " value "
;tree.end

base ad:0xa013c918
;tree "HAMACV_ITOP4"
group 0--3
line.long 0 "HAMACV_ITOP4"
bitfld.long 0 0.--13. " value "  " "
;tree.end

base ad:0xa013cfc0
;tree "ID0"
rgroup 0--3
line.long 0 "ID0"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013cfc8
;tree "ID1"
rgroup 0--3
line.long 0 "ID1"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013cfd0
;tree "ID2"
rgroup 0--3
line.long 0 "ID2"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013cfd8
;tree "ID3"
rgroup 0--3
line.long 0 "ID3"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013cfe0
;tree "IDP0"
rgroup 0--3
line.long 0 "IDP0"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013cfe8
;tree "IDP1"
rgroup 0--3
line.long 0 "IDP1"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013cff0
;tree "IDP2"
rgroup 0--3
line.long 0 "IDP2"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013cff8
;tree "IDP3"
rgroup 0--3
line.long 0 "IDP3"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013d000
;tree "ARM_DMA0_SREQ"
group 0--3
line.long 0 "ARM_DMA0_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d004
;tree "ARM_DMA0_BREQ"
group 0--3
line.long 0 "ARM_DMA0_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d008
;tree "ARM_DMA0_LSREQ"
group 0--3
line.long 0 "ARM_DMA0_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d00c
;tree "ARM_DMA0_LBREQ"
group 0--3
line.long 0 "ARM_DMA0_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d010
;tree "ARM_DMA0_MASKIT"
group 0--3
line.long 0 "ARM_DMA0_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d014
;tree "ARM_DMA0_IT"
rgroup 0--3
line.long 0 "ARM_DMA0_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d018
;tree "ARM_DMA0_AUTO"
group 0--3
line.long 0 "ARM_DMA0_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013d01c
;tree "ARM_DMA0_LAUTO"
group 0--3
line.long 0 "ARM_DMA0_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa013d040
;tree "ARM_DMA1_SREQ"
group 0--3
line.long 0 "ARM_DMA1_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d044
;tree "ARM_DMA1_BREQ"
group 0--3
line.long 0 "ARM_DMA1_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d048
;tree "ARM_DMA1_LSREQ"
group 0--3
line.long 0 "ARM_DMA1_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d04c
;tree "ARM_DMA1_LBREQ"
group 0--3
line.long 0 "ARM_DMA1_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d050
;tree "ARM_DMA1_MASKIT"
group 0--3
line.long 0 "ARM_DMA1_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d054
;tree "ARM_DMA1_IT"
rgroup 0--3
line.long 0 "ARM_DMA1_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d058
;tree "ARM_DMA1_AUTO"
group 0--3
line.long 0 "ARM_DMA1_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013d05c
;tree "ARM_DMA1_LAUTO"
group 0--3
line.long 0 "ARM_DMA1_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa013d080
;tree "ARM_DMA2_SREQ"
group 0--3
line.long 0 "ARM_DMA2_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d084
;tree "ARM_DMA2_BREQ"
group 0--3
line.long 0 "ARM_DMA2_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d088
;tree "ARM_DMA2_LSREQ"
group 0--3
line.long 0 "ARM_DMA2_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d08c
;tree "ARM_DMA2_LBREQ"
group 0--3
line.long 0 "ARM_DMA2_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d090
;tree "ARM_DMA2_MASKIT"
group 0--3
line.long 0 "ARM_DMA2_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d094
;tree "ARM_DMA2_IT"
rgroup 0--3
line.long 0 "ARM_DMA2_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d098
;tree "ARM_DMA2_AUTO"
group 0--3
line.long 0 "ARM_DMA2_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013d09c
;tree "ARM_DMA2_LAUTO"
group 0--3
line.long 0 "ARM_DMA2_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa013d0c0
;tree "ARM_DMA3_SREQ"
group 0--3
line.long 0 "ARM_DMA3_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d0c4
;tree "ARM_DMA3_BREQ"
group 0--3
line.long 0 "ARM_DMA3_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d0c8
;tree "ARM_DMA3_LSREQ"
group 0--3
line.long 0 "ARM_DMA3_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d0cc
;tree "ARM_DMA3_LBREQ"
group 0--3
line.long 0 "ARM_DMA3_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d0d0
;tree "ARM_DMA3_MASKIT"
group 0--3
line.long 0 "ARM_DMA3_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d0d4
;tree "ARM_DMA3_IT"
rgroup 0--3
line.long 0 "ARM_DMA3_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d0d8
;tree "ARM_DMA3_AUTO"
group 0--3
line.long 0 "ARM_DMA3_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013d0dc
;tree "ARM_DMA3_LAUTO"
group 0--3
line.long 0 "ARM_DMA3_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa013d100
;tree "ARM_DMA4_SREQ"
group 0--3
line.long 0 "ARM_DMA4_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d104
;tree "ARM_DMA4_BREQ"
group 0--3
line.long 0 "ARM_DMA4_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d108
;tree "ARM_DMA4_LSREQ"
group 0--3
line.long 0 "ARM_DMA4_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d10c
;tree "ARM_DMA4_LBREQ"
group 0--3
line.long 0 "ARM_DMA4_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d110
;tree "ARM_DMA4_MASKIT"
group 0--3
line.long 0 "ARM_DMA4_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d114
;tree "ARM_DMA4_IT"
rgroup 0--3
line.long 0 "ARM_DMA4_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d118
;tree "ARM_DMA4_AUTO"
group 0--3
line.long 0 "ARM_DMA4_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013d11c
;tree "ARM_DMA4_LAUTO"
group 0--3
line.long 0 "ARM_DMA4_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa013d140
;tree "ARM_DMA5_SREQ"
group 0--3
line.long 0 "ARM_DMA5_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d144
;tree "ARM_DMA5_BREQ"
group 0--3
line.long 0 "ARM_DMA5_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d148
;tree "ARM_DMA5_LSREQ"
group 0--3
line.long 0 "ARM_DMA5_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d14c
;tree "ARM_DMA5_LBREQ"
group 0--3
line.long 0 "ARM_DMA5_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d150
;tree "ARM_DMA5_MASKIT"
group 0--3
line.long 0 "ARM_DMA5_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d154
;tree "ARM_DMA5_IT"
rgroup 0--3
line.long 0 "ARM_DMA5_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d158
;tree "ARM_DMA5_AUTO"
group 0--3
line.long 0 "ARM_DMA5_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013d15c
;tree "ARM_DMA5_LAUTO"
group 0--3
line.long 0 "ARM_DMA5_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa013d180
;tree "ARM_DMA6_SREQ"
group 0--3
line.long 0 "ARM_DMA6_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d184
;tree "ARM_DMA6_BREQ"
group 0--3
line.long 0 "ARM_DMA6_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d188
;tree "ARM_DMA6_LSREQ"
group 0--3
line.long 0 "ARM_DMA6_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d18c
;tree "ARM_DMA6_LBREQ"
group 0--3
line.long 0 "ARM_DMA6_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d190
;tree "ARM_DMA6_MASKIT"
group 0--3
line.long 0 "ARM_DMA6_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d194
;tree "ARM_DMA6_IT"
rgroup 0--3
line.long 0 "ARM_DMA6_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d198
;tree "ARM_DMA6_AUTO"
group 0--3
line.long 0 "ARM_DMA6_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013d19c
;tree "ARM_DMA6_LAUTO"
group 0--3
line.long 0 "ARM_DMA6_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa013d1c0
;tree "ARM_DMA7_SREQ"
group 0--3
line.long 0 "ARM_DMA7_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d1c4
;tree "ARM_DMA7_BREQ"
group 0--3
line.long 0 "ARM_DMA7_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d1c8
;tree "ARM_DMA7_LSREQ"
group 0--3
line.long 0 "ARM_DMA7_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d1cc
;tree "ARM_DMA7_LBREQ"
group 0--3
line.long 0 "ARM_DMA7_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d1d0
;tree "ARM_DMA7_MASKIT"
group 0--3
line.long 0 "ARM_DMA7_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d1d4
;tree "ARM_DMA7_IT"
rgroup 0--3
line.long 0 "ARM_DMA7_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013d1d8
;tree "ARM_DMA7_AUTO"
group 0--3
line.long 0 "ARM_DMA7_AUTO"
hexfld.byte 0 " value "
;tree.end

base ad:0xa013d1dc
;tree "ARM_DMA7_LAUTO"
group 0--3
line.long 0 "ARM_DMA7_LAUTO"
hexfld.word 0 " value "
;tree.end

base ad:0xa013d800
;tree "EMU_UNIT_MASKIT"
group 0--3
line.long 0 "EMU_UNIT_MASKIT"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

base ad:0xa013d820
;tree "CONFIG_DATA_MEM"
group 0--3
line.long 0 "CONFIG_DATA_MEM"
bitfld.long 0 0.--13. " value "  " "
;tree.end

base ad:0xa013d828
;tree "COMPATIBILITY_REGISTER"
group 0--3
line.long 0 "COMPATIBILITY_REGISTER"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa013e000
;tree "AHB_IF_CONFIG"
group 0--3
line.long 0 "AHB_IF_CONFIG"
bitfld.long 0 0.--3. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa013e004
;tree "AHB_IF_MODE"
group 0--3
line.long 0 "AHB_IF_MODE"
bitfld.long 0 0.--3. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa013e008
;tree "AHB_IF_STATUS"
rgroup 0--3
line.long 0 "AHB_IF_STATUS"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa013e00c
;tree "AHB_IF_SECURITY"
group 0--3
line.long 0 "AHB_IF_SECURITY"
bitfld.long 0 0.--4. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa013f800
;tree "ITREMAP_REG0"
group 0--3
line.long 0 "ITREMAP_REG0"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f808
;tree "ITREMAP_REG1"
group 0--3
line.long 0 "ITREMAP_REG1"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f810
;tree "ITREMAP_REG2"
group 0--3
line.long 0 "ITREMAP_REG2"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f818
;tree "ITREMAP_REG3"
group 0--3
line.long 0 "ITREMAP_REG3"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f820
;tree "ITREMAP_REG4"
group 0--3
line.long 0 "ITREMAP_REG4"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f828
;tree "ITREMAP_REG5"
group 0--3
line.long 0 "ITREMAP_REG5"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f830
;tree "ITREMAP_REG6"
group 0--3
line.long 0 "ITREMAP_REG6"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f838
;tree "ITREMAP_REG7"
group 0--3
line.long 0 "ITREMAP_REG7"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f840
;tree "ITREMAP_REG8"
group 0--3
line.long 0 "ITREMAP_REG8"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f848
;tree "ITREMAP_REG9"
group 0--3
line.long 0 "ITREMAP_REG9"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f850
;tree "ITREMAP_REG10"
group 0--3
line.long 0 "ITREMAP_REG10"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f858
;tree "ITREMAP_REG11"
group 0--3
line.long 0 "ITREMAP_REG11"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f860
;tree "ITREMAP_REG12"
group 0--3
line.long 0 "ITREMAP_REG12"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f868
;tree "ITREMAP_REG13"
group 0--3
line.long 0 "ITREMAP_REG13"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f870
;tree "ITREMAP_REG14"
group 0--3
line.long 0 "ITREMAP_REG14"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f878
;tree "ITREMAP_REG15"
group 0--3
line.long 0 "ITREMAP_REG15"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f880
;tree "ITREMAP_REG16"
group 0--3
line.long 0 "ITREMAP_REG16"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f888
;tree "ITREMAP_REG17"
group 0--3
line.long 0 "ITREMAP_REG17"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f890
;tree "ITREMAP_REG18"
group 0--3
line.long 0 "ITREMAP_REG18"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f898
;tree "ITREMAP_REG19"
group 0--3
line.long 0 "ITREMAP_REG19"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f8a0
;tree "ITREMAP_REG20"
group 0--3
line.long 0 "ITREMAP_REG20"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f8a8
;tree "ITREMAP_REG21"
group 0--3
line.long 0 "ITREMAP_REG21"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f8b0
;tree "ITREMAP_REG22"
group 0--3
line.long 0 "ITREMAP_REG22"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f8b8
;tree "ITREMAP_REG23"
group 0--3
line.long 0 "ITREMAP_REG23"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f8c0
;tree "ITREMAP_REG24"
group 0--3
line.long 0 "ITREMAP_REG24"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f8c8
;tree "ITREMAP_REG25"
group 0--3
line.long 0 "ITREMAP_REG25"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f8d0
;tree "ITREMAP_REG26"
group 0--3
line.long 0 "ITREMAP_REG26"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f8d8
;tree "ITREMAP_REG27"
group 0--3
line.long 0 "ITREMAP_REG27"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f8e0
;tree "ITREMAP_REG28"
group 0--3
line.long 0 "ITREMAP_REG28"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f8e8
;tree "ITREMAP_REG29"
group 0--3
line.long 0 "ITREMAP_REG29"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f8f0
;tree "ITREMAP_REG30"
group 0--3
line.long 0 "ITREMAP_REG30"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f8f8
;tree "ITREMAP_REG31"
group 0--3
line.long 0 "ITREMAP_REG31"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013f900
;tree "ITMSK_L_REG"
group 0--3
line.long 0 "ITMSK_L_REG"
hexfld.word 0 " value "
;tree.end

base ad:0xa013f908
;tree "ITMSK_H_REG"
group 0--3
line.long 0 "ITMSK_H_REG"
hexfld.word 0 " value "
;tree.end

base ad:0xa013f938
;tree "ITMEMO_L_REG"
group 0--3
line.long 0 "ITMEMO_L_REG"
hexfld.word 0 " value "
;tree.end

base ad:0xa013f940
;tree "ITMEMO_H_REG"
group 0--3
line.long 0 "ITMEMO_H_REG"
hexfld.word 0 " value "
;tree.end

base ad:0xa013fa00
;tree "ITREMAP1_REG0"
group 0--3
line.long 0 "ITREMAP1_REG0"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa08
;tree "ITREMAP1_REG1"
group 0--3
line.long 0 "ITREMAP1_REG1"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa10
;tree "ITREMAP1_REG2"
group 0--3
line.long 0 "ITREMAP1_REG2"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa18
;tree "ITREMAP1_REG3"
group 0--3
line.long 0 "ITREMAP1_REG3"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa20
;tree "ITREMAP1_REG4"
group 0--3
line.long 0 "ITREMAP1_REG4"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa28
;tree "ITREMAP1_REG5"
group 0--3
line.long 0 "ITREMAP1_REG5"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa30
;tree "ITREMAP1_REG6"
group 0--3
line.long 0 "ITREMAP1_REG6"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa38
;tree "ITREMAP1_REG7"
group 0--3
line.long 0 "ITREMAP1_REG7"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa40
;tree "ITREMAP1_REG8"
group 0--3
line.long 0 "ITREMAP1_REG8"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa48
;tree "ITREMAP1_REG9"
group 0--3
line.long 0 "ITREMAP1_REG9"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa50
;tree "ITREMAP1_REG10"
group 0--3
line.long 0 "ITREMAP1_REG10"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa58
;tree "ITREMAP1_REG11"
group 0--3
line.long 0 "ITREMAP1_REG11"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa60
;tree "ITREMAP1_REG12"
group 0--3
line.long 0 "ITREMAP1_REG12"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa68
;tree "ITREMAP1_REG13"
group 0--3
line.long 0 "ITREMAP1_REG13"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa70
;tree "ITREMAP1_REG14"
group 0--3
line.long 0 "ITREMAP1_REG14"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa78
;tree "ITREMAP1_REG15"
group 0--3
line.long 0 "ITREMAP1_REG15"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa80
;tree "ITREMAP1_REG16"
group 0--3
line.long 0 "ITREMAP1_REG16"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa88
;tree "ITREMAP1_REG17"
group 0--3
line.long 0 "ITREMAP1_REG17"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa90
;tree "ITREMAP1_REG18"
group 0--3
line.long 0 "ITREMAP1_REG18"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fa98
;tree "ITREMAP1_REG19"
group 0--3
line.long 0 "ITREMAP1_REG19"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013faa0
;tree "ITREMAP1_REG20"
group 0--3
line.long 0 "ITREMAP1_REG20"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013faa8
;tree "ITREMAP1_REG21"
group 0--3
line.long 0 "ITREMAP1_REG21"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fab0
;tree "ITREMAP1_REG22"
group 0--3
line.long 0 "ITREMAP1_REG22"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fab8
;tree "ITREMAP1_REG23"
group 0--3
line.long 0 "ITREMAP1_REG23"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fac0
;tree "ITREMAP1_REG24"
group 0--3
line.long 0 "ITREMAP1_REG24"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fac8
;tree "ITREMAP1_REG25"
group 0--3
line.long 0 "ITREMAP1_REG25"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fad0
;tree "ITREMAP1_REG26"
group 0--3
line.long 0 "ITREMAP1_REG26"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fad8
;tree "ITREMAP1_REG27"
group 0--3
line.long 0 "ITREMAP1_REG27"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fae0
;tree "ITREMAP1_REG28"
group 0--3
line.long 0 "ITREMAP1_REG28"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013fae8
;tree "ITREMAP1_REG29"
group 0--3
line.long 0 "ITREMAP1_REG29"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013faf0
;tree "ITREMAP1_REG30"
group 0--3
line.long 0 "ITREMAP1_REG30"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa013faf8
;tree "ITREMAP1_REG31"
group 0--3
line.long 0 "ITREMAP1_REG31"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

endif

endif

tree.end

;==============================================================
tree "HASH (2 instances)"
;==============================================================
base ad:0xa03c1000
;********************************************
tree "HASH-0"
;********************************************
base ad:0xa03c1000
;tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SECn "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " INIT "  "0 ,1 "
bitfld.long 0 3. " DMAE "  "0 ,1 "
bitfld.long 0 4.--5. " DATAFORM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " MODE "  "0 ,1 "
bitfld.long 0 7. " ALGO "  "0 ,1 "
bitfld.long 0 8.--11. " NBW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " DINF "  "0 ,1 "
bitfld.long 0 16. " LKEY "  "0 ,1 "
;tree.end

base ad:0xa03c1004
;tree "0DIN"
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa03c1008
;tree "0STR"
group 0--3
line.long 0 "STR"
bitfld.long 0 0.--4. " NBLW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " DCAL "  "0 ,1 "
;tree.end

base ad:0xa03c100c
;tree "0H0"
group 0--3
line.long 0 "H0"
hexfld.long 0 " H0 "
;tree.end

base ad:0xa03c1010
;tree "0H1"
group 0--3
line.long 0 "H1"
hexfld.long 0 " H1 "
;tree.end

base ad:0xa03c1014
;tree "0H2"
group 0--3
line.long 0 "H2"
hexfld.long 0 " H2 "
;tree.end

base ad:0xa03c1018
;tree "0H3"
group 0--3
line.long 0 "H3"
hexfld.long 0 " H3 "
;tree.end

base ad:0xa03c101c
;tree "0H4"
group 0--3
line.long 0 "H4"
hexfld.long 0 " H4 "
;tree.end

base ad:0xa03c1020
;tree "0H5"
group 0--3
line.long 0 "H5"
hexfld.long 0 " H5 "
;tree.end

base ad:0xa03c1024
;tree "0H6"
group 0--3
line.long 0 "H6"
hexfld.long 0 " H6 "
;tree.end

base ad:0xa03c1028
;tree "0H7"
group 0--3
line.long 0 "H7"
hexfld.long 0 " H7 "
;tree.end

base ad:0xa03c1100
;tree "0CSR0"
group 0--3
line.long 0 "CSR0"
hexfld.long 0 " W0 "
;tree.end

base ad:0xa03c1104
;tree "0CSR1"
group 0--3
line.long 0 "CSR1"
hexfld.long 0 " W1 "
;tree.end

base ad:0xa03c1108
;tree "0CSR2"
group 0--3
line.long 0 "CSR2"
hexfld.long 0 " W2 "
;tree.end

base ad:0xa03c110c
;tree "0CSR3"
group 0--3
line.long 0 "CSR3"
hexfld.long 0 " W3 "
;tree.end

base ad:0xa03c1110
;tree "0CSR4"
group 0--3
line.long 0 "CSR4"
hexfld.long 0 " W4 "
;tree.end

base ad:0xa03c1114
;tree "0CSR5"
group 0--3
line.long 0 "CSR5"
hexfld.long 0 " W5 "
;tree.end

base ad:0xa03c1118
;tree "0CSR6"
group 0--3
line.long 0 "CSR6"
hexfld.long 0 " W6 "
;tree.end

base ad:0xa03c111c
;tree "0CSR7"
group 0--3
line.long 0 "CSR7"
hexfld.long 0 " W7 "
;tree.end

base ad:0xa03c1120
;tree "0CSR8"
group 0--3
line.long 0 "CSR8"
hexfld.long 0 " W8 "
;tree.end

base ad:0xa03c1124
;tree "0CSR9"
group 0--3
line.long 0 "CSR9"
hexfld.long 0 " W9 "
;tree.end

base ad:0xa03c1128
;tree "0CSR10"
group 0--3
line.long 0 "CSR10"
hexfld.long 0 " W10 "
;tree.end

base ad:0xa03c112c
;tree "0CSR11"
group 0--3
line.long 0 "CSR11"
hexfld.long 0 " W11 "
;tree.end

base ad:0xa03c1130
;tree "0CSR12"
group 0--3
line.long 0 "CSR12"
hexfld.long 0 " W12 "
;tree.end

base ad:0xa03c1134
;tree "0CSR13"
group 0--3
line.long 0 "CSR13"
hexfld.long 0 " W13 "
;tree.end

base ad:0xa03c1138
;tree "0CSR14"
group 0--3
line.long 0 "CSR14"
hexfld.long 0 " W14 "
;tree.end

base ad:0xa03c113c
;tree "0CSR15"
group 0--3
line.long 0 "CSR15"
hexfld.long 0 " W15 "
;tree.end

base ad:0xa03c1140
;tree "0CSR16"
group 0--3
line.long 0 "CSR16"
hexfld.long 0 " W16 "
;tree.end

base ad:0xa03c1144
;tree "0CSR17"
group 0--3
line.long 0 "CSR17"
hexfld.long 0 " W17 "
;tree.end

base ad:0xa03c1148
;tree "0CSR18"
group 0--3
line.long 0 "CSR18"
hexfld.long 0 " W18 "
;tree.end

base ad:0xa03c114c
;tree "0CSR19"
group 0--3
line.long 0 "CSR19"
hexfld.long 0 " W19 "
;tree.end

base ad:0xa03c1150
;tree "0CSR20"
group 0--3
line.long 0 "CSR20"
hexfld.long 0 " W20 "
;tree.end

base ad:0xa03c1154
;tree "0CSR21"
group 0--3
line.long 0 "CSR21"
hexfld.long 0 " W21 "
;tree.end

base ad:0xa03c1158
;tree "0CSR22"
group 0--3
line.long 0 "CSR22"
hexfld.long 0 " W22 "
;tree.end

base ad:0xa03c115c
;tree "0CSR23"
group 0--3
line.long 0 "CSR23"
hexfld.long 0 " W23 "
;tree.end

base ad:0xa03c1160
;tree "0CSR24"
group 0--3
line.long 0 "CSR24"
hexfld.long 0 " W24 "
;tree.end

base ad:0xa03c1164
;tree "0CSR25"
group 0--3
line.long 0 "CSR25"
hexfld.long 0 " W25 "
;tree.end

base ad:0xa03c1168
;tree "0CSR26"
group 0--3
line.long 0 "CSR26"
hexfld.long 0 " W26 "
;tree.end

base ad:0xa03c116c
;tree "0CSR27"
group 0--3
line.long 0 "CSR27"
hexfld.long 0 " W27 "
;tree.end

base ad:0xa03c1170
;tree "0CSR28"
group 0--3
line.long 0 "CSR28"
hexfld.long 0 " W28 "
;tree.end

base ad:0xa03c1174
;tree "0CSR29"
group 0--3
line.long 0 "CSR29"
hexfld.long 0 " W29 "
;tree.end

base ad:0xa03c1178
;tree "0CSR30"
group 0--3
line.long 0 "CSR30"
hexfld.long 0 " W30 "
;tree.end

base ad:0xa03c117c
;tree "0CSR31"
group 0--3
line.long 0 "CSR31"
hexfld.long 0 " W31 "
;tree.end

base ad:0xa03c1180
;tree "0CSR32"
group 0--3
line.long 0 "CSR32"
hexfld.long 0 " W32 "
;tree.end

base ad:0xa03c1184
;tree "0CSR33"
group 0--3
line.long 0 "CSR33"
hexfld.long 0 " W33 "
;tree.end

base ad:0xa03c1188
;tree "0CSR34"
group 0--3
line.long 0 "CSR34"
hexfld.long 0 " W34 "
;tree.end

base ad:0xa03c118c
;tree "0CSR35"
group 0--3
line.long 0 "CSR35"
hexfld.long 0 " W35 "
;tree.end

base ad:0xa03c1190
;tree "0CSR36"
group 0--3
line.long 0 "CSR36"
hexfld.long 0 " W36 "
;tree.end

base ad:0xa03c1194
;tree "0CSR37"
group 0--3
line.long 0 "CSR37"
hexfld.long 0 " W37 "
;tree.end

base ad:0xa03c1198
;tree "0CSR38"
group 0--3
line.long 0 "CSR38"
hexfld.long 0 " W38 "
;tree.end

base ad:0xa03c119c
;tree "0CSR39"
group 0--3
line.long 0 "CSR39"
hexfld.long 0 " W39 "
;tree.end

base ad:0xa03c11a0
;tree "0CSR40"
group 0--3
line.long 0 "CSR40"
hexfld.long 0 " W40 "
;tree.end

base ad:0xa03c11a4
;tree "0CSR41"
group 0--3
line.long 0 "CSR41"
hexfld.long 0 " W41 "
;tree.end

base ad:0xa03c11a8
;tree "0CSR42"
group 0--3
line.long 0 "CSR42"
hexfld.long 0 " W42 "
;tree.end

base ad:0xa03c11ac
;tree "0CSR43"
group 0--3
line.long 0 "CSR43"
hexfld.long 0 " W43 "
;tree.end

base ad:0xa03c11b0
;tree "0CSR44"
group 0--3
line.long 0 "CSR44"
hexfld.long 0 " W44 "
;tree.end

base ad:0xa03c11b4
;tree "0CSR45"
group 0--3
line.long 0 "CSR45"
hexfld.long 0 " W45 "
;tree.end

base ad:0xa03c11b8
;tree "0CSR46"
group 0--3
line.long 0 "CSR46"
hexfld.long 0 " W46 "
;tree.end

base ad:0xa03c11bc
;tree "0CSR47"
group 0--3
line.long 0 "CSR47"
hexfld.long 0 " W47 "
;tree.end

base ad:0xa03c11c0
;tree "0CSR48"
group 0--3
line.long 0 "CSR48"
hexfld.long 0 " W48 "
;tree.end

base ad:0xa03c11c4
;tree "0CSR49"
group 0--3
line.long 0 "CSR49"
hexfld.long 0 " W49 "
;tree.end

base ad:0xa03c11c8
;tree "0CSR50"
group 0--3
line.long 0 "CSR50"
hexfld.long 0 " W50 "
;tree.end

base ad:0xa03c11cc
;tree "0CSR51"
group 0--3
line.long 0 "CSR51"
hexfld.long 0 " W51 "
;tree.end

base ad:0xa03c10f8
;tree "0CSFULL"
group 0--3
line.long 0 "CSFULL"
hexfld.long 0 " W40 "
;tree.end

base ad:0xa03c10fc
;tree "0CSDATAIN"
group 0--3
line.long 0 "CSDATAIN"
hexfld.long 0 " W41 "
;tree.end

base ad:0xa03c1080
;tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0xa03c1084
;tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR "  "0 ,1 "
bitfld.long 0 1. " DMATC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
;tree.end

base ad:0xa03c1088
;tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMABREQ "  "0 ,1 "
;tree.end

base ad:0xa03c1fe0
;tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03c1fe4
;tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c1fe8
;tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c1fec
;tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03c1ff0
;tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

base ad:0xa03c1ff4
;tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

base ad:0xa03c1ff8
;tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

base ad:0xa03c1ffc
;tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

base ad:0xa03c2000
;********************************************
tree "HASH-1"
;********************************************
base ad:0xa03c2000
;tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SECn "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " INIT "  "0 ,1 "
bitfld.long 0 3. " DMAE "  "0 ,1 "
bitfld.long 0 4.--5. " DATAFORM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " MODE "  "0 ,1 "
bitfld.long 0 7. " ALGO "  "0 ,1 "
bitfld.long 0 8.--11. " NBW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " DINF "  "0 ,1 "
bitfld.long 0 16. " LKEY "  "0 ,1 "
;tree.end

base ad:0xa03c2004
;tree "1DIN"
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa03c2008
;tree "1STR"
group 0--3
line.long 0 "STR"
bitfld.long 0 0.--4. " NBLW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " DCAL "  "0 ,1 "
;tree.end

base ad:0xa03c200c
;tree "1H0"
group 0--3
line.long 0 "H0"
hexfld.long 0 " H0 "
;tree.end

base ad:0xa03c2010
;tree "1H1"
group 0--3
line.long 0 "H1"
hexfld.long 0 " H1 "
;tree.end

base ad:0xa03c2014
;tree "1H2"
group 0--3
line.long 0 "H2"
hexfld.long 0 " H2 "
;tree.end

base ad:0xa03c2018
;tree "1H3"
group 0--3
line.long 0 "H3"
hexfld.long 0 " H3 "
;tree.end

base ad:0xa03c201c
;tree "1H4"
group 0--3
line.long 0 "H4"
hexfld.long 0 " H4 "
;tree.end

base ad:0xa03c2020
;tree "1H5"
group 0--3
line.long 0 "H5"
hexfld.long 0 " H5 "
;tree.end

base ad:0xa03c2024
;tree "1H6"
group 0--3
line.long 0 "H6"
hexfld.long 0 " H6 "
;tree.end

base ad:0xa03c2028
;tree "1H7"
group 0--3
line.long 0 "H7"
hexfld.long 0 " H7 "
;tree.end

base ad:0xa03c2100
;tree "1CSR0"
group 0--3
line.long 0 "CSR0"
hexfld.long 0 " W0 "
;tree.end

base ad:0xa03c2104
;tree "1CSR1"
group 0--3
line.long 0 "CSR1"
hexfld.long 0 " W1 "
;tree.end

base ad:0xa03c2108
;tree "1CSR2"
group 0--3
line.long 0 "CSR2"
hexfld.long 0 " W2 "
;tree.end

base ad:0xa03c210c
;tree "1CSR3"
group 0--3
line.long 0 "CSR3"
hexfld.long 0 " W3 "
;tree.end

base ad:0xa03c2110
;tree "1CSR4"
group 0--3
line.long 0 "CSR4"
hexfld.long 0 " W4 "
;tree.end

base ad:0xa03c2114
;tree "1CSR5"
group 0--3
line.long 0 "CSR5"
hexfld.long 0 " W5 "
;tree.end

base ad:0xa03c2118
;tree "1CSR6"
group 0--3
line.long 0 "CSR6"
hexfld.long 0 " W6 "
;tree.end

base ad:0xa03c211c
;tree "1CSR7"
group 0--3
line.long 0 "CSR7"
hexfld.long 0 " W7 "
;tree.end

base ad:0xa03c2120
;tree "1CSR8"
group 0--3
line.long 0 "CSR8"
hexfld.long 0 " W8 "
;tree.end

base ad:0xa03c2124
;tree "1CSR9"
group 0--3
line.long 0 "CSR9"
hexfld.long 0 " W9 "
;tree.end

base ad:0xa03c2128
;tree "1CSR10"
group 0--3
line.long 0 "CSR10"
hexfld.long 0 " W10 "
;tree.end

base ad:0xa03c212c
;tree "1CSR11"
group 0--3
line.long 0 "CSR11"
hexfld.long 0 " W11 "
;tree.end

base ad:0xa03c2130
;tree "1CSR12"
group 0--3
line.long 0 "CSR12"
hexfld.long 0 " W12 "
;tree.end

base ad:0xa03c2134
;tree "1CSR13"
group 0--3
line.long 0 "CSR13"
hexfld.long 0 " W13 "
;tree.end

base ad:0xa03c2138
;tree "1CSR14"
group 0--3
line.long 0 "CSR14"
hexfld.long 0 " W14 "
;tree.end

base ad:0xa03c213c
;tree "1CSR15"
group 0--3
line.long 0 "CSR15"
hexfld.long 0 " W15 "
;tree.end

base ad:0xa03c2140
;tree "1CSR16"
group 0--3
line.long 0 "CSR16"
hexfld.long 0 " W16 "
;tree.end

base ad:0xa03c2144
;tree "1CSR17"
group 0--3
line.long 0 "CSR17"
hexfld.long 0 " W17 "
;tree.end

base ad:0xa03c2148
;tree "1CSR18"
group 0--3
line.long 0 "CSR18"
hexfld.long 0 " W18 "
;tree.end

base ad:0xa03c214c
;tree "1CSR19"
group 0--3
line.long 0 "CSR19"
hexfld.long 0 " W19 "
;tree.end

base ad:0xa03c2150
;tree "1CSR20"
group 0--3
line.long 0 "CSR20"
hexfld.long 0 " W20 "
;tree.end

base ad:0xa03c2154
;tree "1CSR21"
group 0--3
line.long 0 "CSR21"
hexfld.long 0 " W21 "
;tree.end

base ad:0xa03c2158
;tree "1CSR22"
group 0--3
line.long 0 "CSR22"
hexfld.long 0 " W22 "
;tree.end

base ad:0xa03c215c
;tree "1CSR23"
group 0--3
line.long 0 "CSR23"
hexfld.long 0 " W23 "
;tree.end

base ad:0xa03c2160
;tree "1CSR24"
group 0--3
line.long 0 "CSR24"
hexfld.long 0 " W24 "
;tree.end

base ad:0xa03c2164
;tree "1CSR25"
group 0--3
line.long 0 "CSR25"
hexfld.long 0 " W25 "
;tree.end

base ad:0xa03c2168
;tree "1CSR26"
group 0--3
line.long 0 "CSR26"
hexfld.long 0 " W26 "
;tree.end

base ad:0xa03c216c
;tree "1CSR27"
group 0--3
line.long 0 "CSR27"
hexfld.long 0 " W27 "
;tree.end

base ad:0xa03c2170
;tree "1CSR28"
group 0--3
line.long 0 "CSR28"
hexfld.long 0 " W28 "
;tree.end

base ad:0xa03c2174
;tree "1CSR29"
group 0--3
line.long 0 "CSR29"
hexfld.long 0 " W29 "
;tree.end

base ad:0xa03c2178
;tree "1CSR30"
group 0--3
line.long 0 "CSR30"
hexfld.long 0 " W30 "
;tree.end

base ad:0xa03c217c
;tree "1CSR31"
group 0--3
line.long 0 "CSR31"
hexfld.long 0 " W31 "
;tree.end

base ad:0xa03c2180
;tree "1CSR32"
group 0--3
line.long 0 "CSR32"
hexfld.long 0 " W32 "
;tree.end

base ad:0xa03c2184
;tree "1CSR33"
group 0--3
line.long 0 "CSR33"
hexfld.long 0 " W33 "
;tree.end

base ad:0xa03c2188
;tree "1CSR34"
group 0--3
line.long 0 "CSR34"
hexfld.long 0 " W34 "
;tree.end

base ad:0xa03c218c
;tree "1CSR35"
group 0--3
line.long 0 "CSR35"
hexfld.long 0 " W35 "
;tree.end

base ad:0xa03c2190
;tree "1CSR36"
group 0--3
line.long 0 "CSR36"
hexfld.long 0 " W36 "
;tree.end

base ad:0xa03c2194
;tree "1CSR37"
group 0--3
line.long 0 "CSR37"
hexfld.long 0 " W37 "
;tree.end

base ad:0xa03c2198
;tree "1CSR38"
group 0--3
line.long 0 "CSR38"
hexfld.long 0 " W38 "
;tree.end

base ad:0xa03c219c
;tree "1CSR39"
group 0--3
line.long 0 "CSR39"
hexfld.long 0 " W39 "
;tree.end

base ad:0xa03c21a0
;tree "1CSR40"
group 0--3
line.long 0 "CSR40"
hexfld.long 0 " W40 "
;tree.end

base ad:0xa03c21a4
;tree "1CSR41"
group 0--3
line.long 0 "CSR41"
hexfld.long 0 " W41 "
;tree.end

base ad:0xa03c21a8
;tree "1CSR42"
group 0--3
line.long 0 "CSR42"
hexfld.long 0 " W42 "
;tree.end

base ad:0xa03c21ac
;tree "1CSR43"
group 0--3
line.long 0 "CSR43"
hexfld.long 0 " W43 "
;tree.end

base ad:0xa03c21b0
;tree "1CSR44"
group 0--3
line.long 0 "CSR44"
hexfld.long 0 " W44 "
;tree.end

base ad:0xa03c21b4
;tree "1CSR45"
group 0--3
line.long 0 "CSR45"
hexfld.long 0 " W45 "
;tree.end

base ad:0xa03c21b8
;tree "1CSR46"
group 0--3
line.long 0 "CSR46"
hexfld.long 0 " W46 "
;tree.end

base ad:0xa03c21bc
;tree "1CSR47"
group 0--3
line.long 0 "CSR47"
hexfld.long 0 " W47 "
;tree.end

base ad:0xa03c21c0
;tree "1CSR48"
group 0--3
line.long 0 "CSR48"
hexfld.long 0 " W48 "
;tree.end

base ad:0xa03c21c4
;tree "1CSR49"
group 0--3
line.long 0 "CSR49"
hexfld.long 0 " W49 "
;tree.end

base ad:0xa03c21c8
;tree "1CSR50"
group 0--3
line.long 0 "CSR50"
hexfld.long 0 " W50 "
;tree.end

base ad:0xa03c21cc
;tree "1CSR51"
group 0--3
line.long 0 "CSR51"
hexfld.long 0 " W51 "
;tree.end

base ad:0xa03c20f8
;tree "1CSFULL"
group 0--3
line.long 0 "CSFULL"
hexfld.long 0 " W40 "
;tree.end

base ad:0xa03c20fc
;tree "1CSDATAIN"
group 0--3
line.long 0 "CSDATAIN"
hexfld.long 0 " W41 "
;tree.end

base ad:0xa03c2080
;tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0xa03c2084
;tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR "  "0 ,1 "
bitfld.long 0 1. " DMATC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
;tree.end

base ad:0xa03c2088
;tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMABREQ "  "0 ,1 "
;tree.end

base ad:0xa03c2fe0
;tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03c2fe4
;tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c2fe8
;tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c2fec
;tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03c2ff0
;tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

base ad:0xa03c2ff4
;tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

base ad:0xa03c2ff8
;tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

base ad:0xa03c2ffc
;tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "HSEM"
;==============================================================
base ad:0x80140000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PROT2 "  "0 ,1 "
;tree.end

base ad:0x80140008
;tree "R0"
group 0--3
line.long 0 "R0"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014000c
;tree "R1"
group 0--3
line.long 0 "R1"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140010
;tree "R2"
group 0--3
line.long 0 "R2"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140014
;tree "R3"
group 0--3
line.long 0 "R3"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140018
;tree "R4"
group 0--3
line.long 0 "R4"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014001c
;tree "R5"
group 0--3
line.long 0 "R5"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140020
;tree "R6"
group 0--3
line.long 0 "R6"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140024
;tree "R7"
group 0--3
line.long 0 "R7"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140028
;tree "R8"
group 0--3
line.long 0 "R8"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014002c
;tree "R9"
group 0--3
line.long 0 "R9"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140030
;tree "R10"
group 0--3
line.long 0 "R10"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140034
;tree "R11"
group 0--3
line.long 0 "R11"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140038
;tree "R12"
group 0--3
line.long 0 "R12"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014003c
;tree "R13"
group 0--3
line.long 0 "R13"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140040
;tree "R14"
group 0--3
line.long 0 "R14"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140044
;tree "R15"
group 0--3
line.long 0 "R15"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140048
;tree "R16"
group 0--3
line.long 0 "R16"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014004c
;tree "R17"
group 0--3
line.long 0 "R17"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140050
;tree "R18"
group 0--3
line.long 0 "R18"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140054
;tree "R19"
group 0--3
line.long 0 "R19"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140058
;tree "R20"
group 0--3
line.long 0 "R20"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014005c
;tree "R21"
group 0--3
line.long 0 "R21"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140060
;tree "R22"
group 0--3
line.long 0 "R22"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140064
;tree "R23"
group 0--3
line.long 0 "R23"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140068
;tree "R24"
group 0--3
line.long 0 "R24"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014006c
;tree "R25"
group 0--3
line.long 0 "R25"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140070
;tree "R26"
group 0--3
line.long 0 "R26"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140074
;tree "R27"
group 0--3
line.long 0 "R27"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140078
;tree "R28"
group 0--3
line.long 0 "R28"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8014007c
;tree "R29"
group 0--3
line.long 0 "R29"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140080
;tree "R30"
group 0--3
line.long 0 "R30"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140084
;tree "R31"
group 0--3
line.long 0 "R31"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80140090
;tree "ICRALL"
wgroup 0--3
line.long 0 "ICRALL"
bitfld.long 0 0. " HSEMICALL0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICALL1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICALL2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICALL3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICALL4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICALL5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICALL6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICALL7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICALL8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICALL9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICALL10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICALL11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICALL12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICALL13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICALL14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICALL15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICALL16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICALL17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICALL18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICALL19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICALL20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICALL21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICALL22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICALL23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICALL24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICALL25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICALL26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICALL27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICALL28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICALL29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICALL30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICALL31 "  "0 ,1 "
;tree.end

base ad:0x801400a0
;tree "IMSCA"
group 0--3
line.long 0 "IMSCA"
bitfld.long 0 0. " HSEMIMA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMA31 "  "0 ,1 "
;tree.end

base ad:0x801400a4
;tree "RISA"
rgroup 0--3
line.long 0 "RISA"
bitfld.long 0 0. " HSEMRISA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISA31 "  "0 ,1 "
;tree.end

base ad:0x801400a8
;tree "MISA"
rgroup 0--3
line.long 0 "MISA"
bitfld.long 0 0. " HSEMMISA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISA31 "  "0 ,1 "
;tree.end

base ad:0x801400ac
;tree "ICRA"
wgroup 0--3
line.long 0 "ICRA"
bitfld.long 0 0. " HSEMICA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICA31 "  "0 ,1 "
;tree.end

base ad:0x801400b0
;tree "IMSCB"
group 0--3
line.long 0 "IMSCB"
bitfld.long 0 0. " HSEMIMB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMB31 "  "0 ,1 "
;tree.end

base ad:0x801400b4
;tree "RISB"
rgroup 0--3
line.long 0 "RISB"
bitfld.long 0 0. " HSEMRISB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISB31 "  "0 ,1 "
;tree.end

base ad:0x801400b8
;tree "MISB"
rgroup 0--3
line.long 0 "MISB"
bitfld.long 0 0. " HSEMMISB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISB31 "  "0 ,1 "
;tree.end

base ad:0x801400bc
;tree "ICRB"
wgroup 0--3
line.long 0 "ICRB"
bitfld.long 0 0. " HSEMICB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICB31 "  "0 ,1 "
;tree.end

base ad:0x801400c0
;tree "IMSCC"
group 0--3
line.long 0 "IMSCC"
bitfld.long 0 0. " HSEMIMC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMC31 "  "0 ,1 "
;tree.end

base ad:0x801400c4
;tree "RISC"
rgroup 0--3
line.long 0 "RISC"
bitfld.long 0 0. " HSEMRISC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISC31 "  "0 ,1 "
;tree.end

base ad:0x801400c8
;tree "MISC"
rgroup 0--3
line.long 0 "MISC"
bitfld.long 0 0. " HSEMMISC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISC31 "  "0 ,1 "
;tree.end

base ad:0x801400cc
;tree "ICRC"
wgroup 0--3
line.long 0 "ICRC"
bitfld.long 0 0. " HSEMICC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICC31 "  "0 ,1 "
;tree.end

base ad:0x801400d0
;tree "IMSCD"
group 0--3
line.long 0 "IMSCD"
bitfld.long 0 0. " HSEMIMD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMD31 "  "0 ,1 "
;tree.end

base ad:0x801400d4
;tree "RISD"
rgroup 0--3
line.long 0 "RISD"
bitfld.long 0 0. " HSEMRISD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISD31 "  "0 ,1 "
;tree.end

base ad:0x801400d8
;tree "MISD"
rgroup 0--3
line.long 0 "MISD"
bitfld.long 0 0. " HSEMMISD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISD31 "  "0 ,1 "
;tree.end

base ad:0x801400dc
;tree "ICRD"
wgroup 0--3
line.long 0 "ICRD"
bitfld.long 0 0. " HSEMICD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMID20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICD31 "  "0 ,1 "
;tree.end

base ad:0x801400e0
;tree "IMSCE"
group 0--3
line.long 0 "IMSCE"
bitfld.long 0 0. " HSEMIME0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIME1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIME2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIME3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIME4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIME5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIME6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIME7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIME8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIME9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIME10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIME11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIME12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIME13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIME14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIME15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIME16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIME17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIME18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIME19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIME20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIME21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIME22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIME23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIME24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIME25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIME26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIME27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIME28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIME29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIME30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIME31 "  "0 ,1 "
;tree.end

base ad:0x801400e4
;tree "RISE"
rgroup 0--3
line.long 0 "RISE"
bitfld.long 0 0. " HSEMRISE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISE31 "  "0 ,1 "
;tree.end

base ad:0x801400e8
;tree "MISE"
rgroup 0--3
line.long 0 "MISE"
bitfld.long 0 0. " HSEMMISE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISE31 "  "0 ,1 "
;tree.end

base ad:0x801400ec
;tree "ICRE"
wgroup 0--3
line.long 0 "ICRE"
bitfld.long 0 0. " HSEMICE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICE31 "  "0 ,1 "
;tree.end

base ad:0x80140100
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80140108
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " HSEMINTRA "  "0 ,1 "
bitfld.long 0 1. " HSEMINTRB "  "0 ,1 "
bitfld.long 0 2. " HSEMINTRC "  "0 ,1 "
bitfld.long 0 3. " HSEMINTRD "  "0 ,1 "
bitfld.long 0 4. " HSEMINTRE "  "0 ,1 "
;tree.end

base ad:0x80140fe0
;tree "HSEMPeriphID0"
rgroup 0--3
line.long 0 "HSEMPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80140fe4
;tree "HSEMPeriphID1"
rgroup 0--3
line.long 0 "HSEMPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80140fe8
;tree "HSEMPeriphID2"
rgroup 0--3
line.long 0 "HSEMPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80140fec
;tree "HSEMPeriphID3"
rgroup 0--3
line.long 0 "HSEMPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80140ff0
;tree "HSEMPCellID0"
rgroup 0--3
line.long 0 "HSEMPCellID0"
hexfld.byte 0 " HSEMPCellID0 "
;tree.end

base ad:0x80140ff4
;tree "HSEMPCellID1"
rgroup 0--3
line.long 0 "HSEMPCellID1"
hexfld.byte 0 " HSEMPCellID1 "
;tree.end

base ad:0x80140ff8
;tree "HSEMPCellID2"
rgroup 0--3
line.long 0 "HSEMPCellID2"
hexfld.byte 0 " HSEMPCellID2 "
;tree.end

base ad:0x80140ffc
;tree "HSEMPCellID3"
rgroup 0--3
line.long 0 "HSEMPCellID3"
hexfld.byte 0 " HSEMPCellID3 "
;tree.end

tree.end

;==============================================================
tree "HSI2C (5 instances)"
;==============================================================
base ad:0x80122000
;********************************************
tree "HSI2C-1"
;********************************************
base ad:0x80122000
;tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " FS "  "0 ,1 "
;tree.end

base ad:0x80122004
;tree "1SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 1 " SLSU "
;tree.end

base ad:0x80122008
;tree "1HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8012200c
;tree "1MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

base ad:0x80122010
;tree "1TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

base ad:0x80122014
;tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

base ad:0x80122018
;tree "1RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

base ad:0x8012201c
;tree "1TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80122020
;tree "1RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80122024
;tree "1DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

base ad:0x80122028
;tree "1BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 1 " BRCNT1 "
;tree.end

base ad:0x8012202c
;tree "1IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

base ad:0x80122030
;tree "1RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

base ad:0x80122034
;tree "1MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

base ad:0x80122038
;tree "1ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

base ad:0x8012203c
;tree "1I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

base ad:0x80122040
;tree "1I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

base ad:0x80122044
;tree "1I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

base ad:0x80122048
;tree "1I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

base ad:0x8012204c
;tree "1I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

base ad:0x80122050
;tree "1I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x80122054
;tree "1I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80122058
;tree "1I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x8012205c
;tree "1I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80122fe0
;tree "1PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80122fe4
;tree "1PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80122fe8
;tree "1PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80122fec
;tree "1PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80122ff0
;tree "1PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

base ad:0x80122ff4
;tree "1PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

base ad:0x80122ff8
;tree "1PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

base ad:0x80122ffc
;tree "1PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

base ad:0x80128000
;********************************************
tree "HSI2C-2"
;********************************************
base ad:0x80128000
;tree "2CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " FS "  "0 ,1 "
;tree.end

base ad:0x80128004
;tree "2SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 1 " SLSU "
;tree.end

base ad:0x80128008
;tree "2HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8012800c
;tree "2MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

base ad:0x80128010
;tree "2TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

base ad:0x80128014
;tree "2SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

base ad:0x80128018
;tree "2RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

base ad:0x8012801c
;tree "2TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80128020
;tree "2RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80128024
;tree "2DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

base ad:0x80128028
;tree "2BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 1 " BRCNT1 "
;tree.end

base ad:0x8012802c
;tree "2IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

base ad:0x80128030
;tree "2RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

base ad:0x80128034
;tree "2MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

base ad:0x80128038
;tree "2ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

base ad:0x8012803c
;tree "2I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

base ad:0x80128040
;tree "2I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

base ad:0x80128044
;tree "2I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

base ad:0x80128048
;tree "2I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

base ad:0x8012804c
;tree "2I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

base ad:0x80128050
;tree "2I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x80128054
;tree "2I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80128058
;tree "2I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x8012805c
;tree "2I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80128fe0
;tree "2PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80128fe4
;tree "2PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80128fe8
;tree "2PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80128fec
;tree "2PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80128ff0
;tree "2PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

base ad:0x80128ff4
;tree "2PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

base ad:0x80128ff8
;tree "2PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

base ad:0x80128ffc
;tree "2PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

base ad:0x8012a000
;********************************************
tree "HSI2C-4"
;********************************************
base ad:0x8012a000
;tree "4CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " FS "  "0 ,1 "
;tree.end

base ad:0x8012a004
;tree "4SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 1 " SLSU "
;tree.end

base ad:0x8012a008
;tree "4HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8012a00c
;tree "4MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

base ad:0x8012a010
;tree "4TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

base ad:0x8012a014
;tree "4SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

base ad:0x8012a018
;tree "4RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

base ad:0x8012a01c
;tree "4TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012a020
;tree "4RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012a024
;tree "4DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

base ad:0x8012a028
;tree "4BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 1 " BRCNT1 "
;tree.end

base ad:0x8012a02c
;tree "4IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

base ad:0x8012a030
;tree "4RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

base ad:0x8012a034
;tree "4MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

base ad:0x8012a038
;tree "4ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

base ad:0x8012a03c
;tree "4I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

base ad:0x8012a040
;tree "4I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

base ad:0x8012a044
;tree "4I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

base ad:0x8012a048
;tree "4I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

base ad:0x8012a04c
;tree "4I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

base ad:0x8012a050
;tree "4I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x8012a054
;tree "4I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x8012a058
;tree "4I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x8012a05c
;tree "4I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x8012afe0
;tree "4PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x8012afe4
;tree "4PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012afe8
;tree "4PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012afec
;tree "4PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8012aff0
;tree "4PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

base ad:0x8012aff4
;tree "4PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

base ad:0x8012aff8
;tree "4PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

base ad:0x8012affc
;tree "4PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

base ad:0x80110000
;********************************************
tree "HSI2C-3"
;********************************************
base ad:0x80110000
;tree "3CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " FS "  "0 ,1 "
;tree.end

base ad:0x80110004
;tree "3SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 1 " SLSU "
;tree.end

base ad:0x80110008
;tree "3HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8011000c
;tree "3MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

base ad:0x80110010
;tree "3TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

base ad:0x80110014
;tree "3SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

base ad:0x80110018
;tree "3RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

base ad:0x8011001c
;tree "3TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80110020
;tree "3RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80110024
;tree "3DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

base ad:0x80110028
;tree "3BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 1 " BRCNT1 "
;tree.end

base ad:0x8011002c
;tree "3IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

base ad:0x80110030
;tree "3RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

base ad:0x80110034
;tree "3MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

base ad:0x80110038
;tree "3ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

base ad:0x8011003c
;tree "3I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

base ad:0x80110040
;tree "3I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

base ad:0x80110044
;tree "3I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

base ad:0x80110048
;tree "3I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

base ad:0x8011004c
;tree "3I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

base ad:0x80110050
;tree "3I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x80110054
;tree "3I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80110058
;tree "3I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x8011005c
;tree "3I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80110fe0
;tree "3PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80110fe4
;tree "3PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80110fe8
;tree "3PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80110fec
;tree "3PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80110ff0
;tree "3PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

base ad:0x80110ff4
;tree "3PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

base ad:0x80110ff8
;tree "3PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

base ad:0x80110ffc
;tree "3PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

base ad:0x80004000
;********************************************
tree "HSI2C-0"
;********************************************
base ad:0x80004000
;tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " FS "  "0 ,1 "
;tree.end

base ad:0x80004004
;tree "0SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 1 " SLSU "
;tree.end

base ad:0x80004008
;tree "0HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8000400c
;tree "0MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

base ad:0x80004010
;tree "0TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

base ad:0x80004014
;tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

base ad:0x80004018
;tree "0RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

base ad:0x8000401c
;tree "0TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80004020
;tree "0RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80004024
;tree "0DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

base ad:0x80004028
;tree "0BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 1 " BRCNT1 "
;tree.end

base ad:0x8000402c
;tree "0IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

base ad:0x80004030
;tree "0RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

base ad:0x80004034
;tree "0MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

base ad:0x80004038
;tree "0ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

base ad:0x8000403c
;tree "0I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

base ad:0x80004040
;tree "0I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

base ad:0x80004044
;tree "0I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

base ad:0x80004048
;tree "0I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

base ad:0x8000404c
;tree "0I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

base ad:0x80004050
;tree "0I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x80004054
;tree "0I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80004058
;tree "0I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

base ad:0x8000405c
;tree "0I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

base ad:0x80004fe0
;tree "0PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80004fe4
;tree "0PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80004fe8
;tree "0PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80004fec
;tree "0PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80004ff0
;tree "0PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

base ad:0x80004ff4
;tree "0PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

base ad:0x80004ff8
;tree "0PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

base ad:0x80004ffc
;tree "0PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "HSI2CMODEM"
;==============================================================
base ad:0xb7e02000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7e02004
;tree "SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 1 " SLSU "
;tree.end

base ad:0xb7e02008
;tree "HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xb7e0200c
;tree "MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

base ad:0xb7e02010
;tree "TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

base ad:0xb7e02014
;tree "SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

base ad:0xb7e02018
;tree "RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

base ad:0xb7e0201c
;tree "TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7e02020
;tree "RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7e02024
;tree "DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

base ad:0xb7e02028
;tree "BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 1 " BRCNT1 "
;tree.end

base ad:0xb7e0202c
;tree "IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

base ad:0xb7e02030
;tree "RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

base ad:0xb7e02034
;tree "MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

base ad:0xb7e02038
;tree "ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

base ad:0xb7e0203c
;tree "I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

base ad:0xb7e02040
;tree "I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

base ad:0xb7e02044
;tree "I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

base ad:0xb7e02fe0
;tree "PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0xb7e02fe4
;tree "PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7e02fe8
;tree "PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7e02fec
;tree "PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xb7e02ff0
;tree "PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

base ad:0xb7e02ff4
;tree "PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

base ad:0xb7e02ff8
;tree "PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

base ad:0xb7e02ffc
;tree "PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

;==============================================================
tree "HSI2CMODEMR4"
;==============================================================
base ad:0x17e02000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x17e02004
;tree "SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 1 " SLSU "
;tree.end

base ad:0x17e02008
;tree "HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x17e0200c
;tree "MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

base ad:0x17e02010
;tree "TFR"
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

base ad:0x17e02014
;tree "SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

base ad:0x17e02018
;tree "RFR"
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

base ad:0x17e0201c
;tree "TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x17e02020
;tree "RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x17e02024
;tree "DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

base ad:0x17e02028
;tree "BRCR"
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 1 " BRCNT1 "
;tree.end

base ad:0x17e0202c
;tree "IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

base ad:0x17e02030
;tree "RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

base ad:0x17e02034
;tree "MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

base ad:0x17e02038
;tree "ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

base ad:0x17e0203c
;tree "I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

base ad:0x17e02040
;tree "I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

base ad:0x17e02044
;tree "I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

base ad:0x17e02fe0
;tree "PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x17e02fe4
;tree "PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x17e02fe8
;tree "PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x17e02fec
;tree "PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x17e02ff0
;tree "PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

base ad:0x17e02ff4
;tree "PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

base ad:0x17e02ff8
;tree "PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

base ad:0x17e02ffc
;tree "PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

;==============================================================
tree "HSIR"
;==============================================================
base ad:0x8011b000
;tree "ID"
group 0--3
line.long 0 "ID"
hexfld.long 0 " ID "
;tree.end

bitfld.long 0 2. " FAILSAFE "  "0 ,1 "
bitfld.long 0 0.--1. " PIPELINED "  "0 ,1 ,2 ,3 "
bitfld.long 0 1. " FRAME "  "0 ,1 "
bitfld.long 0 0. " STREAM "  "0 ,1 "
base ad:0x8011b004
;tree "MODE"
group 0--3
line.long 0 "MODE"
bitfld.long 0 0.--2. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

bitfld.long 0 0.--1. " SYNC "  "0 ,1 ,2 ,3 "
bitfld.long 0 1. " FLUSH "  "0 ,1 "
bitfld.long 0 0. " RECEIVING "  "0 ,1 "
base ad:0x8011b008
;tree "RXSTATE"
group 0--3
line.long 0 "RXSTATE"
bitfld.long 0 0.--1. " RXSTATE "  "0 ,1 ,2 ,3 "
;tree.end

bitfld.long 0 0. " NOTEMPTY "  "0 ,1 "
base ad:0x8011b00c
;tree "BUFSTATE"
group 0--3
line.long 0 "BUFSTATE"
bitfld.long 0 0. " BUFSTATE0 "  "0 ,1 "
bitfld.long 0 1. " BUFSTATE1 "  "0 ,1 "
bitfld.long 0 2. " BUFSTATE2 "  "0 ,1 "
bitfld.long 0 3. " BUFSTATE3 "  "0 ,1 "
bitfld.long 0 4. " BUFSTATE4 "  "0 ,1 "
bitfld.long 0 5. " BUFSTATE5 "  "0 ,1 "
bitfld.long 0 6. " BUFSTATE6 "  "0 ,1 "
bitfld.long 0 7. " BUFSTATE7 "  "0 ,1 "
;tree.end

base ad:0x8011b010
;tree "THRESHOLD"
group 0--3
line.long 0 "THRESHOLD"
bitfld.long 0 0.--5. " THRESHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8011b018
;tree "DETECTOR"
group 0--3
line.long 0 "DETECTOR"
bitfld.long 0 0. " DETECTOR "  "0 ,1 "
;tree.end

base ad:0x8011b01c
;tree "EXCEPTION"
group 0--3
line.long 0 "EXCEPTION"
bitfld.long 0 0. " TIMEOUT "  "0 ,1 "
bitfld.long 0 1. " OVERRUN "  "0 ,1 "
bitfld.long 0 2. " BREAK "  "0 ,1 "
;tree.end

base ad:0x8011b020
;tree "ACKNOWLEDGE"
wgroup 0--3
line.long 0 "ACKNOWLEDGE"
bitfld.long 0 0. " ACKTIMEOUT "  "0 ,1 "
bitfld.long 0 1. " ACKOVERRUN "  "0 ,1 "
bitfld.long 0 2. " ACKBREAK "  "0 ,1 "
;tree.end

base ad:0x8011b024
;tree "CHANNELS"
group 0--3
line.long 0 "CHANNELS"
bitfld.long 0 0.--3. " CHANNELS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011b028
;tree "REALTIME"
group 0--3
line.long 0 "REALTIME"
bitfld.long 0 0. " REALTIME0 "  "0 ,1 "
bitfld.long 0 1. " REALTIME1 "  "0 ,1 "
bitfld.long 0 2. " REALTIME2 "  "0 ,1 "
bitfld.long 0 3. " REALTIME3 "  "0 ,1 "
bitfld.long 0 4. " REALTIME4 "  "0 ,1 "
bitfld.long 0 5. " REALTIME5 "  "0 ,1 "
bitfld.long 0 6. " REALTIME6 "  "0 ,1 "
bitfld.long 0 7. " REALTIME7 "  "0 ,1 "
;tree.end

base ad:0x8011b02c
;tree "OVERRUN"
group 0--3
line.long 0 "OVERRUN"
bitfld.long 0 0. " OVERRUN0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUN1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUN2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUN3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUN4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUN5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUN6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUN7 "  "0 ,1 "
;tree.end

base ad:0x8011b030
;tree "OVERRUNACK"
rgroup 0--3
line.long 0 "OVERRUNACK"
bitfld.long 0 0. " OVERRUNACK0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUNACK1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUNACK2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUNACK3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUNACK4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUNACK5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUNACK6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUNACK7 "  "0 ,1 "
;tree.end

base ad:0x8011b034
;tree "PREAMBLE"
group 0--3
line.long 0 "PREAMBLE"
bitfld.long 0 0.--23. " PREAMBLE "  " "
;tree.end

base ad:0x8011b038
;tree "PIPEGAUGE"
group 0--3
line.long 0 "PIPEGAUGE"
bitfld.long 0 0.--1. " PIPEGAUGE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8011b03c
;tree "STATICCONFID"
group 0--3
line.long 0 "STATICCONFID"
bitfld.long 0 0.--2. " LOG2MAXCHANNELS_C "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--6. " LOG2BUFFERSIZE_C "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 7.--10. " LOG2QUEUELENGH_C "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 11.--13. " LOG2CHIPSIZE_C "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8011b080
;tree "BUFFER0"
group 0--3
line.long 0 "BUFFER0"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b084
;tree "BUFFER1"
group 0--3
line.long 0 "BUFFER1"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b088
;tree "BUFFER2"
group 0--3
line.long 0 "BUFFER2"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b08c
;tree "BUFFER3"
group 0--3
line.long 0 "BUFFER3"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b090
;tree "BUFFER4"
group 0--3
line.long 0 "BUFFER4"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b094
;tree "BUFFER5"
group 0--3
line.long 0 "BUFFER5"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b098
;tree "BUFFER6"
group 0--3
line.long 0 "BUFFER6"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b09c
;tree "BUFFER7"
group 0--3
line.long 0 "BUFFER7"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011b0c0
;tree "FRAMELEN0"
group 0--3
line.long 0 "FRAMELEN0"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0c4
;tree "FRAMELEN1"
group 0--3
line.long 0 "FRAMELEN1"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0c8
;tree "FRAMELEN2"
group 0--3
line.long 0 "FRAMELEN2"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0cc
;tree "FRAMELEN3"
group 0--3
line.long 0 "FRAMELEN3"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0d0
;tree "FRAMELEN4"
group 0--3
line.long 0 "FRAMELEN4"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0d4
;tree "FRAMELEN5"
group 0--3
line.long 0 "FRAMELEN5"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0d8
;tree "FRAMELEN6"
group 0--3
line.long 0 "FRAMELEN6"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b0dc
;tree "FRAMELEN7"
group 0--3
line.long 0 "FRAMELEN7"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b100
;tree "BASE0"
group 0--3
line.long 0 "BASE0"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b104
;tree "BASE1"
group 0--3
line.long 0 "BASE1"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b108
;tree "BASE2"
group 0--3
line.long 0 "BASE2"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b10c
;tree "BASE3"
group 0--3
line.long 0 "BASE3"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b110
;tree "BASE4"
group 0--3
line.long 0 "BASE4"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b114
;tree "BASE5"
group 0--3
line.long 0 "BASE5"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b118
;tree "BASE6"
group 0--3
line.long 0 "BASE6"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b11c
;tree "BASE7"
group 0--3
line.long 0 "BASE7"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b140
;tree "SPAN0"
group 0--3
line.long 0 "SPAN0"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b144
;tree "SPAN1"
group 0--3
line.long 0 "SPAN1"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b148
;tree "SPAN2"
group 0--3
line.long 0 "SPAN2"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b14c
;tree "SPAN3"
group 0--3
line.long 0 "SPAN3"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b150
;tree "SPAN4"
group 0--3
line.long 0 "SPAN4"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b154
;tree "SPAN5"
group 0--3
line.long 0 "SPAN5"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b158
;tree "SPAN6"
group 0--3
line.long 0 "SPAN6"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b15c
;tree "SPAN7"
group 0--3
line.long 0 "SPAN7"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b180
;tree "GAUGE0"
group 0--3
line.long 0 "GAUGE0"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b184
;tree "GAUGE1"
group 0--3
line.long 0 "GAUGE1"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b188
;tree "GAUGE2"
group 0--3
line.long 0 "GAUGE2"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b18c
;tree "GAUGE3"
group 0--3
line.long 0 "GAUGE3"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b190
;tree "GAUGE4"
group 0--3
line.long 0 "GAUGE4"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b194
;tree "GAUGE5"
group 0--3
line.long 0 "GAUGE5"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b198
;tree "GAUGE6"
group 0--3
line.long 0 "GAUGE6"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b19c
;tree "GAUGE7"
group 0--3
line.long 0 "GAUGE7"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1c0
;tree "WATERMARK0"
group 0--3
line.long 0 "WATERMARK0"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1c4
;tree "WATERMARK1"
group 0--3
line.long 0 "WATERMARK1"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1c8
;tree "WATERMARK2"
group 0--3
line.long 0 "WATERMARK2"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1cc
;tree "WATERMARK3"
group 0--3
line.long 0 "WATERMARK3"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1d0
;tree "WATERMARK4"
group 0--3
line.long 0 "WATERMARK4"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1d4
;tree "WATERMARK5"
group 0--3
line.long 0 "WATERMARK5"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1d8
;tree "WATERMARK6"
group 0--3
line.long 0 "WATERMARK6"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1dc
;tree "WATERMARK7"
group 0--3
line.long 0 "WATERMARK7"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011b1e0
;tree "FRAMEBURSTCNT"
group 0--3
line.long 0 "FRAMEBURSTCNT"
hexfld.byte 0 " FRAMEBURSTCNT "
;tree.end

base ad:0x8011b200
;tree "DMAEN"
group 0--3
line.long 0 "DMAEN"
bitfld.long 0 0. " DMAEN0 "  "0 ,1 "
bitfld.long 0 1. " DMAEN1 "  "0 ,1 "
bitfld.long 0 2. " DMAEN2 "  "0 ,1 "
bitfld.long 0 3. " DMAEN3 "  "0 ,1 "
bitfld.long 0 4. " DMAEN4 "  "0 ,1 "
bitfld.long 0 5. " DMAEN5 "  "0 ,1 "
bitfld.long 0 6. " DMAEN6 "  "0 ,1 "
bitfld.long 0 7. " DMAEN7 "  "0 ,1 "
;tree.end

base ad:0x8011b204
;tree "WMARKMIS"
rgroup 0--3
line.long 0 "WMARKMIS"
bitfld.long 0 0. " WATERMIS0 "  "0 ,1 "
bitfld.long 0 1. " WATERMIS1 "  "0 ,1 "
bitfld.long 0 2. " WATERMIS2 "  "0 ,1 "
bitfld.long 0 3. " WATERMIS3 "  "0 ,1 "
bitfld.long 0 4. " WATERMIS4 "  "0 ,1 "
bitfld.long 0 5. " WATERMIS5 "  "0 ,1 "
bitfld.long 0 6. " WATERMIS6 "  "0 ,1 "
bitfld.long 0 7. " WATERMIS7 "  "0 ,1 "
;tree.end

base ad:0x8011b208
;tree "WMARKIM"
group 0--3
line.long 0 "WMARKIM"
bitfld.long 0 0. " WMARKIM0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIM1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIM2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIM3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIM4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIM5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIM6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIM7 "  "0 ,1 "
;tree.end

base ad:0x8011b20c
;tree "WMARKIC"
wgroup 0--3
line.long 0 "WMARKIC"
bitfld.long 0 0. " WMARKIC0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIC1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIC2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIC3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIC4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIC5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIC6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIC7 "  "0 ,1 "
;tree.end

base ad:0x8011b210
;tree "WMARKID"
group 0--3
line.long 0 "WMARKID"
bitfld.long 0 0. " WMARKID0 "  "0 ,1 "
bitfld.long 0 1. " WMARKID1 "  "0 ,1 "
bitfld.long 0 2. " WMARKID2 "  "0 ,1 "
bitfld.long 0 3. " WMARKID3 "  "0 ,1 "
bitfld.long 0 4. " WMARKID4 "  "0 ,1 "
bitfld.long 0 5. " WMARKID5 "  "0 ,1 "
bitfld.long 0 6. " WMARKID6 "  "0 ,1 "
bitfld.long 0 7. " WMARKID7 "  "0 ,1 "
;tree.end

base ad:0x8011b214
;tree "OVERRUNMIS"
rgroup 0--3
line.long 0 "OVERRUNMIS"
bitfld.long 0 0. " OVERRUNMIS0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUNMIS1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUNMIS2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUNMIS3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUNMIS4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUNMIS5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUNMIS6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUNMIS7 "  "0 ,1 "
;tree.end

base ad:0x8011b218
;tree "OVERRUNIM"
group 0--3
line.long 0 "OVERRUNIM"
bitfld.long 0 0. " OVERRUNIM0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUNIM1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUNIM2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUNIM3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUNIM4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUNIM5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUNIM6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUNIM7 "  "0 ,1 "
;tree.end

base ad:0x8011b21c
;tree "EXCEPMIS"
rgroup 0--3
line.long 0 "EXCEPMIS"
bitfld.long 0 0. " TIMEOUTMIS "  "0 ,1 "
bitfld.long 0 1. " OVERRUNMIS "  "0 ,1 "
bitfld.long 0 2. " BREAKMIS "  "0 ,1 "
;tree.end

base ad:0x8011b224
;tree "WMARKIS"
group 0--3
line.long 0 "WMARKIS"
bitfld.long 0 0. " MARKIS0 "  "0 ,1 "
bitfld.long 0 1. " MARKIS1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIS2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIS3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIS4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIS5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIS6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIS7 "  "0 ,1 "
;tree.end

base ad:0x8011b220
;tree "EXCEPIM"
group 0--3
line.long 0 "EXCEPIM"
bitfld.long 0 0. " TIMEOUTIM "  "0 ,1 "
bitfld.long 0 1. " OVERRUNIM "  "0 ,1 "
bitfld.long 0 2. " BREAKIM "  "0 ,1 "
;tree.end

base ad:0x8011bd00
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8011bd04
;tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR0 "  "0 ,1 "
bitfld.long 0 1. " DMACLR1 "  "0 ,1 "
bitfld.long 0 2. " DMACLR2 "  "0 ,1 "
bitfld.long 0 3. " DMACLR3 "  "0 ,1 "
bitfld.long 0 4. " DMACLR4 "  "0 ,1 "
bitfld.long 0 5. " DMACLR5 "  "0 ,1 "
bitfld.long 0 6. " DMACLR6 "  "0 ,1 "
bitfld.long 0 7. " DMACLR7 "  "0 ,1 "
bitfld.long 0 16. " DATA "  "0 ,1 "
bitfld.long 0 17. " FLAG "  "0 ,1 "
;tree.end

base ad:0x8011bd08
;tree "ITOP1"
group 0--3
line.long 0 "ITOP1"
hexfld.byte 0 " DMABREQ "
hexfld.byte 2 " DMASREQ "
;tree.end

base ad:0x8011bd0c
;tree "ITOP2"
group 0--3
line.long 0 "ITOP2"
bitfld.long 0 0. " WMARKD0INT "  "0 ,1 "
bitfld.long 0 1. " WMARKD1INT "  "0 ,1 "
bitfld.long 0 2. " EXCEPINT "  "0 ,1 "
bitfld.long 0 16. " READY "  "0 ,1 "
;tree.end

base ad:0x8011bd10
;tree "ITOP3"
group 0--3
line.long 0 "ITOP3"
hexfld.byte 0 " OVERRUNINT "
;tree.end

base ad:0x8011bfe0
;tree "PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " PARTMUMBER0 "
;tree.end

base ad:0x8011bfe4
;tree "PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " PARTNUMBER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " DESIGNER0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011bfe8
;tree "PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " DESIGNER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " REVISION "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011bfec
;tree "PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " CONFIGURATION "
;tree.end

base ad:0x8011bff0
;tree "PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " PCELLID0 "
;tree.end

base ad:0x8011bff4
;tree "PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " PCELLID1 "
;tree.end

base ad:0x8011bff8
;tree "PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " PCELLID2 "
;tree.end

base ad:0x8011bffc
;tree "PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " PCELLID3 "
;tree.end

tree.end

;==============================================================
tree "HSIT"
;==============================================================
base ad:0x8011c000
;tree "ID"
group 0--3
line.long 0 "ID"
hexfld.long 0 " ID "
;tree.end

bitfld.long 0 1. " FRAME "  "0 ,1 "
bitfld.long 0 0. " STREAM "  "0 ,1 "
base ad:0x8011c004
;tree "MODE"
group 0--3
line.long 0 "MODE"
bitfld.long 0 0.--1. " MODE "  "0 ,1 ,2 ,3 "
;tree.end

bitfld.long 0 0.--2. " HALT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 2. " FLUSH "  "0 ,1 "
bitfld.long 0 0.--2. " BREAK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 1. " TRANSMIT "  "0 ,1 "
bitfld.long 0 0. " START "  "0 ,1 "
base ad:0x8011c008
;tree "TXSTATE"
group 0--3
line.long 0 "TXSTATE"
bitfld.long 0 0.--2. " TXSTATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

bitfld.long 0 2. " READY "  "0 ,1 "
bitfld.long 0 1. " FLAG "  "0 ,1 "
bitfld.long 0 0. " DATA "  "0 ,1 "
base ad:0x8011c00c
;tree "IOSTATE"
group 0--3
line.long 0 "IOSTATE"
bitfld.long 0 0. " DSTATE "  "0 ,1 "
bitfld.long 0 1. " FSTATE "  "0 ,1 "
bitfld.long 0 2. " RSTATE "  "0 ,1 "
;tree.end

bitfld.long 0 0. " FULL "  "0 ,1 "
base ad:0x8011c010
;tree "BUFSTATE"
group 0--3
line.long 0 "BUFSTATE"
bitfld.long 0 0. " BUFSTATE0 "  "0 ,1 "
bitfld.long 0 1. " BUFSTATE1 "  "0 ,1 "
bitfld.long 0 2. " BUFSTATE2 "  "0 ,1 "
bitfld.long 0 3. " BUFSTATE3 "  "0 ,1 "
bitfld.long 0 4. " BUFSTATE4 "  "0 ,1 "
bitfld.long 0 5. " BUFSTATE5 "  "0 ,1 "
bitfld.long 0 6. " BUFSTATE6 "  "0 ,1 "
bitfld.long 0 7. " BUFSTATE7 "  "0 ,1 "
;tree.end

base ad:0x8011c014
;tree "DIVISOR"
group 0--3
line.long 0 "DIVISOR"
bitfld.long 0 0.--23. " DIVISOR "  " "
;tree.end

base ad:0x8011c01c
;tree "BREAK"
group 0--3
line.long 0 "BREAK"
bitfld.long 0 0. " BREAK "  "0 ,1 "
;tree.end

base ad:0x8011c020
;tree "CHANNELS"
group 0--3
line.long 0 "CHANNELS"
bitfld.long 0 0.--3. " CHANNELS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011c024
;tree "FLUSHBITS"
group 0--3
line.long 0 "FLUSHBITS"
bitfld.long 0 0.--5. " FLUSHBITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8011c028
;tree "PRIORITY"
group 0--3
line.long 0 "PRIORITY"
bitfld.long 0 0. " PRIORITY0 "  "0 ,1 "
bitfld.long 0 1. " PRIORITY1 "  "0 ,1 "
bitfld.long 0 2. " PRIORITY2 "  "0 ,1 "
bitfld.long 0 3. " PRIORITY3 "  "0 ,1 "
bitfld.long 0 4. " PRIORITY4 "  "0 ,1 "
bitfld.long 0 5. " PRIORITY5 "  "0 ,1 "
bitfld.long 0 6. " PRIORITY6 "  "0 ,1 "
bitfld.long 0 7. " PRIORITY7 "  "0 ,1 "
;tree.end

base ad:0x8011c02c
;tree "STATICCONFID"
group 0--3
line.long 0 "STATICCONFID"
bitfld.long 0 0.--2. " LOG2MAXCHANNELS_C "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--6. " LOG2BUFFERSIZE_C "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011c034
;tree "DATASWAP"
group 0--3
line.long 0 "DATASWAP"
bitfld.long 0 0.--1. " DATASWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8011c080
;tree "FRAMELEN0"
group 0--3
line.long 0 "FRAMELEN0"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c084
;tree "FRAMELEN1"
group 0--3
line.long 0 "FRAMELEN1"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c088
;tree "FRAMELEN2"
group 0--3
line.long 0 "FRAMELEN2"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c08c
;tree "FRAMELEN3"
group 0--3
line.long 0 "FRAMELEN3"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c090
;tree "FRAMELEN4"
group 0--3
line.long 0 "FRAMELEN4"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c094
;tree "FRAMELEN5"
group 0--3
line.long 0 "FRAMELEN5"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c098
;tree "FRAMELEN6"
group 0--3
line.long 0 "FRAMELEN6"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c09c
;tree "FRAMELEN7"
group 0--3
line.long 0 "FRAMELEN7"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c0c0
;tree "BUFFER0"
group 0--3
line.long 0 "BUFFER0"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0c4
;tree "BUFFER1"
group 0--3
line.long 0 "BUFFER1"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0c8
;tree "BUFFER2"
group 0--3
line.long 0 "BUFFER2"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0cc
;tree "BUFFER3"
group 0--3
line.long 0 "BUFFER3"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0d0
;tree "BUFFER4"
group 0--3
line.long 0 "BUFFER4"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0d4
;tree "BUFFER5"
group 0--3
line.long 0 "BUFFER5"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0d8
;tree "BUFFER6"
group 0--3
line.long 0 "BUFFER6"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c0dc
;tree "BUFFER7"
group 0--3
line.long 0 "BUFFER7"
hexfld.long 0 " BUFFER "
;tree.end

base ad:0x8011c100
;tree "BASE0"
group 0--3
line.long 0 "BASE0"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c104
;tree "BASE1"
group 0--3
line.long 0 "BASE1"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c108
;tree "BASE2"
group 0--3
line.long 0 "BASE2"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c10c
;tree "BASE3"
group 0--3
line.long 0 "BASE3"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c110
;tree "BASE4"
group 0--3
line.long 0 "BASE4"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c114
;tree "BASE5"
group 0--3
line.long 0 "BASE5"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c118
;tree "BASE6"
group 0--3
line.long 0 "BASE6"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c11c
;tree "BASE7"
group 0--3
line.long 0 "BASE7"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c140
;tree "SPAN0"
group 0--3
line.long 0 "SPAN0"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c144
;tree "SPAN1"
group 0--3
line.long 0 "SPAN1"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c148
;tree "SPAN2"
group 0--3
line.long 0 "SPAN2"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c14c
;tree "SPAN3"
group 0--3
line.long 0 "SPAN3"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c150
;tree "SPAN4"
group 0--3
line.long 0 "SPAN4"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c154
;tree "SPAN5"
group 0--3
line.long 0 "SPAN5"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c158
;tree "SPAN6"
group 0--3
line.long 0 "SPAN6"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c15c
;tree "SPAN7"
group 0--3
line.long 0 "SPAN7"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c180
;tree "GAUGE0"
group 0--3
line.long 0 "GAUGE0"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c184
;tree "GAUGE1"
group 0--3
line.long 0 "GAUGE1"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c188
;tree "GAUGE2"
group 0--3
line.long 0 "GAUGE2"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c18c
;tree "GAUGE3"
group 0--3
line.long 0 "GAUGE3"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c190
;tree "GAUGE4"
group 0--3
line.long 0 "GAUGE4"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c194
;tree "GAUGE5"
group 0--3
line.long 0 "GAUGE5"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c198
;tree "GAUGE6"
group 0--3
line.long 0 "GAUGE6"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c19c
;tree "GAUGE7"
group 0--3
line.long 0 "GAUGE7"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1c0
;tree "WATERMARK0"
group 0--3
line.long 0 "WATERMARK0"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1c4
;tree "WATERMARK1"
group 0--3
line.long 0 "WATERMARK1"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1c8
;tree "WATERMARK2"
group 0--3
line.long 0 "WATERMARK2"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1cc
;tree "WATERMARK3"
group 0--3
line.long 0 "WATERMARK3"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1d0
;tree "WATERMARK4"
group 0--3
line.long 0 "WATERMARK4"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1d4
;tree "WATERMARK5"
group 0--3
line.long 0 "WATERMARK5"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1d8
;tree "WATERMARK6"
group 0--3
line.long 0 "WATERMARK6"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c1dc
;tree "WATERMARK7"
group 0--3
line.long 0 "WATERMARK7"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8011c200
;tree "DMAEN"
group 0--3
line.long 0 "DMAEN"
bitfld.long 0 0. " DMAEN0 "  "0 ,1 "
bitfld.long 0 1. " DMAEN1 "  "0 ,1 "
bitfld.long 0 2. " DMAEN2 "  "0 ,1 "
bitfld.long 0 3. " DMAEN3 "  "0 ,1 "
bitfld.long 0 4. " DMAEN4 "  "0 ,1 "
bitfld.long 0 5. " DMAEN5 "  "0 ,1 "
bitfld.long 0 6. " DMAEN6 "  "0 ,1 "
bitfld.long 0 7. " DMAEN7 "  "0 ,1 "
;tree.end

base ad:0x8011c204
;tree "WMARKMIS"
rgroup 0--3
line.long 0 "WMARKMIS"
bitfld.long 0 0. " WMARKMIS0 "  "0 ,1 "
bitfld.long 0 1. " WMARKMIS1 "  "0 ,1 "
bitfld.long 0 2. " WMARKMIS2 "  "0 ,1 "
bitfld.long 0 3. " WMARKMIS3 "  "0 ,1 "
bitfld.long 0 4. " WMARKMIS4 "  "0 ,1 "
bitfld.long 0 5. " WMARKMIS5 "  "0 ,1 "
bitfld.long 0 6. " WMARKMIS6 "  "0 ,1 "
bitfld.long 0 7. " WMARKMIS7 "  "0 ,1 "
;tree.end

base ad:0x8011c208
;tree "WMARKIM"
group 0--3
line.long 0 "WMARKIM"
bitfld.long 0 0. " WMARKIM0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIM1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIM2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIM3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIM4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIM5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIM6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIM7 "  "0 ,1 "
;tree.end

base ad:0x8011c20c
;tree "WMARKIC"
wgroup 0--3
line.long 0 "WMARKIC"
bitfld.long 0 0. " WMARKIC0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIC1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIC2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIC3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIC4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIC5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIC6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIC7 "  "0 ,1 "
;tree.end

base ad:0x8011c210
;tree "WMARKID"
group 0--3
line.long 0 "WMARKID"
bitfld.long 0 0. " WMARKID0 "  "0 ,1 "
bitfld.long 0 1. " WMARKID1 "  "0 ,1 "
bitfld.long 0 2. " WMARKID2 "  "0 ,1 "
bitfld.long 0 3. " WMARKID3 "  "0 ,1 "
bitfld.long 0 4. " WMARKID4 "  "0 ,1 "
bitfld.long 0 5. " WMARKID5 "  "0 ,1 "
bitfld.long 0 6. " WMARKID6 "  "0 ,1 "
bitfld.long 0 7. " WMARKID7 "  "0 ,1 "
;tree.end

base ad:0x8011c214
;tree "WMARKIS"
group 0--3
line.long 0 "WMARKIS"
bitfld.long 0 0. " WMARKIS0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIS1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIS2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIS3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIS4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIS5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIS6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIS7 "  "0 ,1 "
;tree.end

base ad:0x8011cd00
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x8011cd04
;tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR0 "  "0 ,1 "
bitfld.long 0 1. " DMACLR1 "  "0 ,1 "
bitfld.long 0 2. " DMACLR2 "  "0 ,1 "
bitfld.long 0 3. " DMACLR3 "  "0 ,1 "
bitfld.long 0 4. " DMACLR4 "  "0 ,1 "
bitfld.long 0 5. " DMACLR5 "  "0 ,1 "
bitfld.long 0 6. " DMACLR6 "  "0 ,1 "
bitfld.long 0 7. " DMACLR7 "  "0 ,1 "
bitfld.long 0 16. " READY "  "0 ,1 "
;tree.end

base ad:0x8011cd08
;tree "ITOP1"
group 0--3
line.long 0 "ITOP1"
hexfld.byte 0 " DMABREQ "
hexfld.byte 2 " DMASREQ "
;tree.end

base ad:0x8011cd0c
;tree "ITOP2"
group 0--3
line.long 0 "ITOP2"
bitfld.long 0 0. " WMARKD0INT "  "0 ,1 "
bitfld.long 0 1. " WMARKD1INT "  "0 ,1 "
bitfld.long 0 16. " DATA "  "0 ,1 "
bitfld.long 0 17. " FLAG "  "0 ,1 "
;tree.end

base ad:0x8011cfe0
;tree "PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " PARTNUMBER0 "
;tree.end

base ad:0x8011cfe4
;tree "PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " PARTNUMBER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " DESIGNER0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011cfe8
;tree "PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " DESIGNER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " REVISION "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011cfec
;tree "PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " CONFIGURATION "
;tree.end

base ad:0x8011cff0
;tree "PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " PCELLID0 "
;tree.end

base ad:0x8011cff4
;tree "PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " PCELLID1 "
;tree.end

base ad:0x8011cff8
;tree "PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " PCELLID2 "
;tree.end

base ad:0x8011cffc
;tree "PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " PCELLID3 "
;tree.end

tree.end

;==============================================================
tree "ICN"
;==============================================================
base ad:0x81000000
;tree "NODE_HIBW1_ESRAM_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000004
;tree "NODE_HIBW1_ESRAM_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000008
;tree "NODE_HIBW1_ESRAM_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000024
;tree "NODE_HIBW1_ESRAM_IN_0_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000028
;tree "NODE_HIBW1_ESRAM_IN_0_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8100002c
;tree "NODE_HIBW1_ESRAM_IN_0_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000030
;tree "NODE_HIBW1_ESRAM_IN_1_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000034
;tree "NODE_HIBW1_ESRAM_IN_1_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000038
;tree "NODE_HIBW1_ESRAM_IN_1_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8100003c
;tree "NODE_HIBW1_ESRAM_IN_2_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_2_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000040
;tree "NODE_HIBW1_ESRAM_IN_2_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_2_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000044
;tree "NODE_HIBW1_ESRAM_IN_2_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_2_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000400
;tree "NODE_HIBW1_DDR_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000404
;tree "NODE_HIBW1_DDR_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000408
;tree "NODE_HIBW1_DDR_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000424
;tree "NODE_HIBW1_DDR_IN_0_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000428
;tree "NODE_HIBW1_DDR_IN_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8100042c
;tree "NODE_HIBW1_DDR_IN_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000430
;tree "NODE_HIBW1_DDR_OUT_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--3. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x81000800
;tree "NODE_HIBW2_ESRAM_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000804
;tree "NODE_HIBW2_ESRAM_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000818
;tree "NODE_HIBW2_ESRAM_IN_0_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8100081c
;tree "NODE_HIBW2_ESRAM_IN_0_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000820
;tree "NODE_HIBW2_ESRAM_IN_0_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000824
;tree "NODE_HIBW2_ESRAM_IN_1_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000828
;tree "NODE_HIBW2_ESRAM_IN_1_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8100082c
;tree "NODE_HIBW2_ESRAM_IN_1_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000c00
;tree "NODE_HIBW2_DDR_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000c04
;tree "NODE_HIBW2_DDR_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000c08
;tree "NODE_HIBW2_DDR_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81000c24
;tree "NODE_HIBW2_DDR_IN_0_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000c28
;tree "NODE_HIBW2_DDR_IN_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000c2c
;tree "NODE_HIBW2_DDR_IN_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81000c30
;tree "NODE_HIBW2_DDR_OUT_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--3. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x81001000
;tree "NODE_ESRAM0_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001004
;tree "NODE_ESRAM0_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001008
;tree "NODE_ESRAM0_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x8100100c
;tree "NODE_ESRAM0_IN_3_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_3_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001030
;tree "NODE_ESRAM0_IN_0_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001034
;tree "NODE_ESRAM0_IN_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001038
;tree "NODE_ESRAM0_IN_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8100103c
;tree "NODE_ESRAM0_IN_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_3_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001400
;tree "NODE_ESRAM1_2_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001404
;tree "NODE_ESRAM1_2_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001408
;tree "NODE_ESRAM1_2_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x8100140c
;tree "NODE_ESRAM1_2_IN_3_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_3_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001430
;tree "NODE_ESRAM1_2_IN_0_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001434
;tree "NODE_ESRAM1_2_IN_0_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001438
;tree "NODE_ESRAM1_2_IN_1_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8100143c
;tree "NODE_ESRAM1_2_IN_1_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001440
;tree "NODE_ESRAM1_2_IN_2_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_2_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001444
;tree "NODE_ESRAM1_2_IN_2_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_2_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001448
;tree "NODE_ESRAM1_2_IN_3_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_3_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8100144c
;tree "NODE_ESRAM1_2_IN_3_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_3_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001800
;tree "NODE_ESRAM3_4_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001804
;tree "NODE_ESRAM3_4_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001808
;tree "NODE_ESRAM3_4_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x8100180c
;tree "NODE_ESRAM3_4_IN_3_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_3_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
;tree.end

base ad:0x81001830
;tree "NODE_ESRAM3_4_IN_0_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001834
;tree "NODE_ESRAM3_4_IN_0_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001838
;tree "NODE_ESRAM3_4_IN_1_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8100183c
;tree "NODE_ESRAM3_4_IN_1_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001840
;tree "NODE_ESRAM3_4_IN_2_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_2_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001844
;tree "NODE_ESRAM3_4_IN_2_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_2_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x81001848
;tree "NODE_ESRAM3_4_IN_3_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_3_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8100184c
;tree "NODE_ESRAM3_4_IN_3_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_3_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

tree.end

;==============================================================
tree "MCDE"
;==============================================================
if (((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x8015741c)&0x100000)!=0x100000)||((data.long(ad:0x801571ec)&0x4)!=0x4)||((data.long(ad:0x80157428)&0x400)!=0x0))

base ad:0x80157064
group 0--3
line.long 0 "PRCM_MCDECLK_MGT"
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 20. " DSS_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "

else

base ad:0xa0350000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 15. " IFIFOCTRLEN "  "0 ,1 "
bitfld.long 0 30. " AUTOCLKG_EN "  "0 ,1 "
bitfld.long 0 31. " MCDEEN "  "0 ,1 "
;tree.end

base ad:0xa0350004
;tree "CONF0"
group 0--3
line.long 0 "CONF0"
bitfld.long 0 0. " SYNCMUX0 "  "0 ,1 "
bitfld.long 0 1. " SYNCMUX1 "  "0 ,1 "
bitfld.long 0 2. " SYNCMUX2 "  "0 ,1 "
bitfld.long 0 3. " SYNCMUX3 "  "0 ,1 "
bitfld.long 0 4. " SYNCMUX4 "  "0 ,1 "
bitfld.long 0 5. " SYNCMUX5 "  "0 ,1 "
bitfld.long 0 6. " SYNCMUX6 "  "0 ,1 "
bitfld.long 0 7. " SYNCMUX7 "  "0 ,1 "
bitfld.long 0 12.--14. " IFIFOCTRLWTRMRKLVL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " OUTMUX0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--21. " OUTMUX1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 22.--24. " OUTMUX2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 25.--27. " OUTMUX3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 28.--30. " OUTMUX4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350008
;tree "SSP"
group 0--3
line.long 0 "SSP"
hexfld.byte 0 " SSPDATA "
bitfld.long 0 8. " SSPCMD "  "0 ,1 "
bitfld.long 0 16. " SSPEN "  "0 ,1 "
;tree.end

base ad:0xa0350100
;tree "AIS"
group 0--3
line.long 0 "AIS"
bitfld.long 0 0. " MCDEPPI "  "0 ,1 "
bitfld.long 0 1. " MCDEOVLI "  "0 ,1 "
bitfld.long 0 2. " MCDECHNLI "  "0 ,1 "
bitfld.long 0 3. " MCDEERRI "  "0 ,1 "
bitfld.long 0 4. " DSI0AI "  "0 ,1 "
bitfld.long 0 5. " DSI1AI "  "0 ,1 "
bitfld.long 0 6. " DSI2AI "  "0 ,1 "
;tree.end

base ad:0xa0350104
;tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " VCMPAIM "  "0 ,1 "
bitfld.long 0 1. " VCMPBIM "  "0 ,1 "
bitfld.long 0 2. " VSCC0IM "  "0 ,1 "
bitfld.long 0 3. " VSCC1IM "  "0 ,1 "
bitfld.long 0 4. " VCMPC0IM "  "0 ,1 "
bitfld.long 0 5. " VCMPC1IM "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDIM "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0350108
;tree "IMSCOVL"
group 0--3
line.long 0 "IMSCOVL"
hexfld.word 0 " OVLRDIM "
hexfld.word 1 " OVLFDIM "
;tree.end

base ad:0xa035010c
;tree "IMSCCHNL"
group 0--3
line.long 0 "IMSCCHNL"
hexfld.word 0 " CHNLRDIM "
hexfld.word 1 " CHNLAIM "
;tree.end

base ad:0xa0350110
;tree "IMSCERR"
group 0--3
line.long 0 "IMSCERR"
bitfld.long 0 0. " FUAIM "  "0 ,1 "
bitfld.long 0 1. " FUBIM "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDIM "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFEIM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " ROTBFEIM "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " FUC0IM "  "0 ,1 "
bitfld.long 0 8. " FUC1IM "  "0 ,1 "
hexfld.word 1 " OVLFERRIM "
;tree.end

base ad:0xa0350114
;tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " VCMPARIS "  "0 ,1 "
bitfld.long 0 1. " VCMPBRIS "  "0 ,1 "
bitfld.long 0 2. " VSCC0RIS "  "0 ,1 "
bitfld.long 0 3. " VSCC1RIS "  "0 ,1 "
bitfld.long 0 4. " VCMPC0RIS "  "0 ,1 "
bitfld.long 0 5. " VCMPC1RIS "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDRIS "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0350118
;tree "RISOVL"
rgroup 0--3
line.long 0 "RISOVL"
hexfld.word 0 " OVLRDRIS "
hexfld.word 1 " OVLFDRIS "
;tree.end

base ad:0xa035011c
;tree "RISCHNL"
rgroup 0--3
line.long 0 "RISCHNL"
hexfld.word 0 " CHNLRDRIS "
hexfld.word 1 " CHNLARIS "
;tree.end

base ad:0xa0350120
;tree "RISERR"
rgroup 0--3
line.long 0 "RISERR"
bitfld.long 0 0. " FUARIS "  "0 ,1 "
bitfld.long 0 1. " FUBRIS "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDRIS "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFERIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " ROTBFERIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " FUC0RIS "  "0 ,1 "
bitfld.long 0 8. " FUC1RIS "  "0 ,1 "
hexfld.word 1 " OVLFERRIS "
;tree.end

base ad:0xa0350124
;tree "MIS"
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " VCMPAMIS "  "0 ,1 "
bitfld.long 0 1. " VCMPBMIS "  "0 ,1 "
bitfld.long 0 2. " VSCC0MIS "  "0 ,1 "
bitfld.long 0 3. " VSCC1MIS "  "0 ,1 "
bitfld.long 0 4. " VCMPC0MIS "  "0 ,1 "
bitfld.long 0 5. " VCMPC1MIS "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDMIS "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0350128
;tree "MISOVL"
group 0--3
line.long 0 "MISOVL"
hexfld.word 0 " OVLRDMIS "
hexfld.word 1 " OVLFDMIS "
;tree.end

base ad:0xa035012c
;tree "MISCHNL"
group 0--3
line.long 0 "MISCHNL"
hexfld.word 0 " CHNLRDMIS "
hexfld.word 1 " CHNLAMIS "
;tree.end

base ad:0xa0350130
;tree "MISERR"
group 0--3
line.long 0 "MISERR"
bitfld.long 0 0. " FUAMIS "  "0 ,1 "
bitfld.long 0 1. " FUBMIS "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDMIS "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFEMIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " ROTBFEMIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " FUC0MIS "  "0 ,1 "
bitfld.long 0 8. " FUC1MIS "  "0 ,1 "
hexfld.word 1 " OVLFERMIS "
;tree.end

base ad:0xa0350134
;tree "SIS"
group 0--3
line.long 0 "SIS"
bitfld.long 0 0. " VCMPASIS "  "0 ,1 "
bitfld.long 0 1. " VCMPBSIS "  "0 ,1 "
bitfld.long 0 2. " VSCC0SIS "  "0 ,1 "
bitfld.long 0 3. " VSCC1SIS "  "0 ,1 "
bitfld.long 0 4. " VCMPC0SIS "  "0 ,1 "
bitfld.long 0 5. " VCMPC1SIS "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDSIS "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0350138
;tree "SISOVL"
group 0--3
line.long 0 "SISOVL"
hexfld.word 0 " OVLRDSIS "
hexfld.word 1 " OVLFDSIS "
;tree.end

base ad:0xa035013c
;tree "SISCHNL"
group 0--3
line.long 0 "SISCHNL"
hexfld.word 0 " CHNLRDSIS "
hexfld.word 1 " CHNLASIS "
;tree.end

base ad:0xa0350140
;tree "SISERR"
group 0--3
line.long 0 "SISERR"
bitfld.long 0 0. " FUASIS "  "0 ,1 "
bitfld.long 0 1. " FUBSIS "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDSIS "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFESIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " ROTBFESIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " FUC0SIS "  "0 ,1 "
bitfld.long 0 8. " FUC1SIS "  "0 ,1 "
hexfld.word 1 " OVLFERSIS "
;tree.end

base ad:0xa03501fc
;tree "PID"
group 0--3
line.long 0 "PID"
hexfld.byte 0 " METALFIX_VERSION "
hexfld.byte 1 " DEVELOPMENT_VERSION "
hexfld.byte 2 " MINOR_VERSION "
hexfld.byte 3 " MAJOR_VERSION "
;tree.end

base ad:0xa0350200
;tree "EXTSRC0A0"
group 0--3
line.long 0 "EXTSRC0A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

base ad:0xa0350204
;tree "EXTSRC0A1"
group 0--3
line.long 0 "EXTSRC0A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

base ad:0xa035020c
;tree "EXTSRC0CONF"
group 0--3
line.long 0 "EXTSRC0CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

base ad:0xa0350210
;tree "EXTSRC0CR"
group 0--3
line.long 0 "EXTSRC0CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350220
;tree "EXTSRC1A0"
group 0--3
line.long 0 "EXTSRC1A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

base ad:0xa0350224
;tree "EXTSRC1A1"
group 0--3
line.long 0 "EXTSRC1A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

base ad:0xa035022c
;tree "EXTSRC1CONF"
group 0--3
line.long 0 "EXTSRC1CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

base ad:0xa0350230
;tree "EXTSRC1CR"
group 0--3
line.long 0 "EXTSRC1CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350240
;tree "EXTSRC2A0"
group 0--3
line.long 0 "EXTSRC2A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

base ad:0xa0350244
;tree "EXTSRC2A1"
group 0--3
line.long 0 "EXTSRC2A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

base ad:0xa035024c
;tree "EXTSRC2CONF"
group 0--3
line.long 0 "EXTSRC2CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

base ad:0xa0350250
;tree "EXTSRC2CR"
group 0--3
line.long 0 "EXTSRC2CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350260
;tree "EXTSRC3A0"
group 0--3
line.long 0 "EXTSRC3A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

base ad:0xa0350264
;tree "EXTSRC3A1"
group 0--3
line.long 0 "EXTSRC3A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

base ad:0xa035026c
;tree "EXTSRC3CONF"
group 0--3
line.long 0 "EXTSRC3CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

base ad:0xa0350270
;tree "EXTSRC3CR"
group 0--3
line.long 0 "EXTSRC3CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350280
;tree "EXTSRC4A0"
group 0--3
line.long 0 "EXTSRC4A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

base ad:0xa0350284
;tree "EXTSRC4A1"
group 0--3
line.long 0 "EXTSRC4A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

base ad:0xa035028c
;tree "EXTSRC4CONF"
group 0--3
line.long 0 "EXTSRC4CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

base ad:0xa0350290
;tree "EXTSRC4CR"
group 0--3
line.long 0 "EXTSRC4CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa03502a0
;tree "EXTSRC5A0"
group 0--3
line.long 0 "EXTSRC5A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

base ad:0xa03502a4
;tree "EXTSRC5A1"
group 0--3
line.long 0 "EXTSRC5A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

base ad:0xa03502ac
;tree "EXTSRC5CONF"
group 0--3
line.long 0 "EXTSRC5CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

base ad:0xa03502b0
;tree "EXTSRC5CR"
group 0--3
line.long 0 "EXTSRC5CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa03502c0
;tree "EXTSRC6A0"
group 0--3
line.long 0 "EXTSRC6A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

base ad:0xa03502c4
;tree "EXTSRC6A1"
group 0--3
line.long 0 "EXTSRC6A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

base ad:0xa03502c8
;tree "EXTSRC6A2"
group 0--3
line.long 0 "EXTSRC6A2"
bitfld.long 0 0.--2. " BASEADDRESS2_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS2_MSB "  " "
;tree.end

base ad:0xa03502cc
;tree "EXTSRC6CONF"
group 0--3
line.long 0 "EXTSRC6CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

base ad:0xa03502d0
;tree "EXTSRC6CR"
group 0--3
line.long 0 "EXTSRC6CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa03502e0
;tree "EXTSRC7A0"
group 0--3
line.long 0 "EXTSRC7A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

base ad:0xa03502e4
;tree "EXTSRC7A1"
group 0--3
line.long 0 "EXTSRC7A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

base ad:0xa03502ec
;tree "EXTSRC7CONF"
group 0--3
line.long 0 "EXTSRC7CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

base ad:0xa03502f0
;tree "EXTSRC7CR"
group 0--3
line.long 0 "EXTSRC7CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350300
;tree "EXTSRC8A0"
group 0--3
line.long 0 "EXTSRC8A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

base ad:0xa0350304
;tree "EXTSRC8A1"
group 0--3
line.long 0 "EXTSRC8A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

base ad:0xa035030c
;tree "EXTSRC8CONF"
group 0--3
line.long 0 "EXTSRC8CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

base ad:0xa0350310
;tree "EXTSRC8CR"
group 0--3
line.long 0 "EXTSRC8CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350320
;tree "EXTSRC9A0"
group 0--3
line.long 0 "EXTSRC9A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

base ad:0xa0350324
;tree "EXTSRC9A1"
group 0--3
line.long 0 "EXTSRC9A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

base ad:0xa035032c
;tree "EXTSRC9CONF"
group 0--3
line.long 0 "EXTSRC9CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

base ad:0xa0350330
;tree "EXTSRC9CR"
group 0--3
line.long 0 "EXTSRC9CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

base ad:0xa0350400
;tree "OVL0CR"
group 0--3
line.long 0 "OVL0CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350404
;tree "OVL0CONF"
group 0--3
line.long 0 "OVL0CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350408
;tree "OVL0CONF2"
group 0--3
line.long 0 "OVL0CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
;tree.end

base ad:0xa035040c
;tree "OVL0JINC"
group 0--3
line.long 0 "OVL0JINC"
hexfld.long 0 " LJINC "
;tree.end

base ad:0xa0350410
;tree "OVL0CROP"
group 0--3
line.long 0 "OVL0CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

base ad:0xa0350414
;tree "OVL0COMP"
group 0--3
line.long 0 "OVL0COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350420
;tree "OVL1CR"
group 0--3
line.long 0 "OVL1CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350424
;tree "OVL1CONF"
group 0--3
line.long 0 "OVL1CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350428
;tree "OVL1CONF2"
group 0--3
line.long 0 "OVL1CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
;tree.end

base ad:0xa035042c
;tree "OVL1JINC"
group 0--3
line.long 0 "OVL1JINC"
hexfld.long 0 " LJINC "
;tree.end

base ad:0xa0350430
;tree "OVL1CROP"
group 0--3
line.long 0 "OVL1CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

base ad:0xa0350434
;tree "OVL1COMP"
group 0--3
line.long 0 "OVL1COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350440
;tree "OVL2CR"
group 0--3
line.long 0 "OVL2CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350444
;tree "OVL2CONF"
group 0--3
line.long 0 "OVL2CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350448
;tree "OVL2CONF2"
group 0--3
line.long 0 "OVL2CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
;tree.end

base ad:0xa035044c
;tree "OVL2JINC"
group 0--3
line.long 0 "OVL2JINC"
hexfld.long 0 " LJINC "
;tree.end

base ad:0xa0350450
;tree "OVL2CROP"
group 0--3
line.long 0 "OVL2CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

base ad:0xa0350454
;tree "OVL2COMP"
group 0--3
line.long 0 "OVL2COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350460
;tree "OVL3CR"
group 0--3
line.long 0 "OVL3CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350464
;tree "OVL3CONF"
group 0--3
line.long 0 "OVL3CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350468
;tree "OVL3CONF2"
group 0--3
line.long 0 "OVL3CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
;tree.end

base ad:0xa035046c
;tree "OVL3JINC"
group 0--3
line.long 0 "OVL3JINC"
hexfld.long 0 " LJINC "
;tree.end

base ad:0xa0350470
;tree "OVL3CROP"
group 0--3
line.long 0 "OVL3CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

base ad:0xa0350474
;tree "OVL3COMP"
group 0--3
line.long 0 "OVL3COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350480
;tree "OVL4CR"
group 0--3
line.long 0 "OVL4CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350484
;tree "OVL4CONF"
group 0--3
line.long 0 "OVL4CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350488
;tree "OVL4CONF2"
group 0--3
line.long 0 "OVL4CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
;tree.end

base ad:0xa035048c
;tree "OVL4JINC"
group 0--3
line.long 0 "OVL4JINC"
hexfld.long 0 " LJINC "
;tree.end

base ad:0xa0350490
;tree "OVL4CROP"
group 0--3
line.long 0 "OVL4CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

base ad:0xa0350494
;tree "OVL4COMP"
group 0--3
line.long 0 "OVL4COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03504a0
;tree "OVL5CR"
group 0--3
line.long 0 "OVL5CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03504a4
;tree "OVL5CONF"
group 0--3
line.long 0 "OVL5CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa03504a8
;tree "OVL5CONF2"
group 0--3
line.long 0 "OVL5CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
;tree.end

base ad:0xa03504ac
;tree "OVL5JINC"
group 0--3
line.long 0 "OVL5JINC"
hexfld.long 0 " LJINC "
;tree.end

base ad:0xa03504b0
;tree "OVL5CROP"
group 0--3
line.long 0 "OVL5CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

base ad:0xa03504b4
;tree "OVL5COMP"
group 0--3
line.long 0 "OVL5COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350600
;tree "CHNL0CONF"
group 0--3
line.long 0 "CHNL0CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350604
;tree "CHNL0STAT"
group 0--3
line.long 0 "CHNL0STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
;tree.end

base ad:0xa0350608
;tree "CHNL0SYNCMOD"
group 0--3
line.long 0 "CHNL0SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa035060c
;tree "CHNL0SYNCHSW"
wgroup 0--3
line.long 0 "CHNL0SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa0350610
;tree "CHNL0BCKCL"
group 0--3
line.long 0 "CHNL0BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350614
;tree "CHNL0MUXING"
group 0--3
line.long 0 "CHNL0MUXING"
bitfld.long 0 0.--2. " FIFOID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350620
;tree "CHNL1CONF"
group 0--3
line.long 0 "CHNL1CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350624
;tree "CHNL1STAT"
group 0--3
line.long 0 "CHNL1STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
;tree.end

base ad:0xa0350628
;tree "CHNL1SYNCMOD"
group 0--3
line.long 0 "CHNL1SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa035062c
;tree "CHNL1SYNCHSW"
wgroup 0--3
line.long 0 "CHNL1SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa0350630
;tree "CHNL1BCKCL"
group 0--3
line.long 0 "CHNL1BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350634
;tree "CHNL1MUXING"
group 0--3
line.long 0 "CHNL1MUXING"
bitfld.long 0 0.--2. " FIFOID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350640
;tree "CHNL2CONF"
group 0--3
line.long 0 "CHNL2CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350644
;tree "CHNL2STAT"
group 0--3
line.long 0 "CHNL2STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
;tree.end

base ad:0xa0350648
;tree "CHNL2SYNCMOD"
group 0--3
line.long 0 "CHNL2SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa035064c
;tree "CHNL2SYNCHSW"
wgroup 0--3
line.long 0 "CHNL2SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa0350650
;tree "CHNL2BCKCL"
group 0--3
line.long 0 "CHNL2BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350654
;tree "CHNL2MUXING"
group 0--3
line.long 0 "CHNL2MUXING"
bitfld.long 0 0.--2. " FIFOID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350660
;tree "CHNL3CONF"
group 0--3
line.long 0 "CHNL3CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

base ad:0xa0350664
;tree "CHNL3STAT"
group 0--3
line.long 0 "CHNL3STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
;tree.end

base ad:0xa0350668
;tree "CHNL3SYNCMOD"
group 0--3
line.long 0 "CHNL3SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa035066c
;tree "CHNL3SYNCHSW"
wgroup 0--3
line.long 0 "CHNL3SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

base ad:0xa0350670
;tree "CHNL3BCKCL"
group 0--3
line.long 0 "CHNL3BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

base ad:0xa0350674
;tree "CHNL3MUXING"
group 0--3
line.long 0 "CHNL3MUXING"
bitfld.long 0 0.--2. " FIFOID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350800
;tree "CRA0"
group 0--3
line.long 0 "CRA0"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 1. " POWEREN "  "0 ,1 "
bitfld.long 0 2. " BLENDEN "  "0 ,1 "
bitfld.long 0 3. " AFLICKEN "  "0 ,1 "
bitfld.long 0 4. " PALEN "  "0 ,1 "
bitfld.long 0 5. " DITHEN "  "0 ,1 "
bitfld.long 0 6. " GAMEN "  "0 ,1 "
bitfld.long 0 7.--9. " KEYCTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " BLENDCTRL "  "0 ,1 "
bitfld.long 0 11.--12. " FLICKMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " FLICKFORMAT "  "0 ,1 "
bitfld.long 0 14. " PALMODE "  "0 ,1 "
bitfld.long 0 15. " OLEDEN "  "0 ,1 "
hexfld.byte 2 " ALPHABLEND "
bitfld.long 0 24. " ROTEN "  "0 ,1 "
;tree.end

base ad:0xa0350804
;tree "CRA1"
group 0--3
line.long 0 "CRA1"
bitfld.long 0 0.--9. " PCD "  " "
bitfld.long 0 10.--12. " CLKSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--16. " CDWIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 25.--28. " OUTBPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 29. " BCD "  "0 ,1 "
bitfld.long 0 30. " CLKTYPE "  "0 ,1 "
;tree.end

base ad:0xa0350808
;tree "COLKEYA"
group 0--3
line.long 0 "COLKEYA"
hexfld.byte 0 " KEYB "
hexfld.byte 1 " KEYG "
hexfld.byte 2 " KEYR "
hexfld.byte 3 " KEYA "
;tree.end

base ad:0xa035080c
;tree "FCOLKEYA"
group 0--3
line.long 0 "FCOLKEYA"
hexfld.byte 0 " FKEYB "
hexfld.byte 1 " FKEYG "
hexfld.byte 2 " FKEYR "
hexfld.byte 3 " FKEYA "
;tree.end

base ad:0xa0350810
;tree "RGBCONV1A"
group 0--3
line.long 0 "RGBCONV1A"
bitfld.long 0 0.--10. " YR_GREEN "  " "
bitfld.long 0 16.--26. " YR_RED "  " "
;tree.end

base ad:0xa0350814
;tree "RGBCONV2A"
group 0--3
line.long 0 "RGBCONV2A"
bitfld.long 0 0.--10. " CR_RED "  " "
bitfld.long 0 16.--26. " YR_BLUE "  " "
;tree.end

base ad:0xa0350818
;tree "RGBCONV3A"
group 0--3
line.long 0 "RGBCONV3A"
bitfld.long 0 0.--10. " CR_BLUE "  " "
bitfld.long 0 16.--26. " CR_GREEN "  " "
;tree.end

base ad:0xa035081c
;tree "RGBCONV4A"
group 0--3
line.long 0 "RGBCONV4A"
bitfld.long 0 0.--10. " CB_GREEN "  " "
bitfld.long 0 16.--26. " CB_RED "  " "
;tree.end

base ad:0xa0350820
;tree "RGBCONV5A"
group 0--3
line.long 0 "RGBCONV5A"
bitfld.long 0 0.--10. " OFF_RED "  " "
bitfld.long 0 16.--26. " CB_BLUE "  " "
;tree.end

base ad:0xa0350824
;tree "RGBCONV6A"
group 0--3
line.long 0 "RGBCONV6A"
bitfld.long 0 0.--10. " OFF_BLUE "  " "
bitfld.long 0 16.--26. " OFF_GREEN "  " "
;tree.end

base ad:0xa0350828
;tree "FFCOEF0A"
group 0--3
line.long 0 "FFCOEF0A"
hexfld.byte 0 " COEFF0_N1 "
hexfld.byte 1 " COEFF0_N2 "
hexfld.byte 2 " COEFF0_N3 "
bitfld.long 0 24.--27. " T0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa035082c
;tree "FFCOEF1A"
group 0--3
line.long 0 "FFCOEF1A"
hexfld.byte 0 " COEFF1_N1 "
hexfld.byte 1 " COEFF1_N2 "
hexfld.byte 2 " COEFF1_N3 "
bitfld.long 0 24.--27. " T1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350830
;tree "FFCOEF2A"
group 0--3
line.long 0 "FFCOEF2A"
hexfld.byte 0 " COEFF2_N1 "
hexfld.byte 1 " COEFF2_N2 "
hexfld.byte 2 " COEFF2_N3 "
bitfld.long 0 24.--27. " T2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0350834
;tree "WDATAA"
group 0--3
line.long 0 "WDATAA"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
;tree.end

base ad:0xa0350838
;tree "TVCRA"
group 0--3
line.long 0 "TVCRA"
bitfld.long 0 0. " SEL_MOD "  "0 ,1 "
bitfld.long 0 1. " INTEREN "  "0 ,1 "
bitfld.long 0 2. " IFIELD "  "0 ,1 "
bitfld.long 0 3.--5. " TVMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--7. " SDTVMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8. " AVRGEN "  "0 ,1 "
bitfld.long 0 9. " CKINV "  "0 ,1 "
;tree.end

base ad:0xa035083c
;tree "TVBL1A"
group 0--3
line.long 0 "TVBL1A"
bitfld.long 0 0.--10. " BEL1 "  " "
bitfld.long 0 16.--26. " BSL1 "  " "
;tree.end

base ad:0xa0350840
;tree "TVISLA"
group 0--3
line.long 0 "TVISLA"
bitfld.long 0 0.--10. " FSL1 "  " "
bitfld.long 0 16.--26. " FSL2 "  " "
;tree.end

base ad:0xa0350844
;tree "TVDVOA"
group 0--3
line.long 0 "TVDVOA"
bitfld.long 0 0.--10. " DVO1 "  " "
bitfld.long 0 16.--26. " DVO2 "  " "
;tree.end

base ad:0xa035084c
;tree "TVTIM1A"
group 0--3
line.long 0 "TVTIM1A"
bitfld.long 0 0.--10. " DHO "  " "
;tree.end

base ad:0xa0350850
;tree "TVLBALWA"
group 0--3
line.long 0 "TVLBALWA"
bitfld.long 0 0.--10. " LBW "  " "
bitfld.long 0 16.--26. " ALW "  " "
;tree.end

base ad:0xa0350854
;tree "TVBL2A"
group 0--3
line.long 0 "TVBL2A"
bitfld.long 0 0.--10. " BEL2 "  " "
bitfld.long 0 16.--26. " BSL2 "  " "
;tree.end

base ad:0xa0350858
;tree "TVBLUA"
group 0--3
line.long 0 "TVBLUA"
hexfld.byte 0 " TVBLU "
hexfld.byte 1 " TVBCB "
hexfld.byte 2 " TVBCR "
;tree.end

base ad:0xa0350860
;tree "LCDTIM1A"
group 0--3
line.long 0 "LCDTIM1A"
bitfld.long 0 19. " IVP "  "0 ,1 "
bitfld.long 0 20. " IVS "  "0 ,1 "
bitfld.long 0 21. " IHS "  "0 ,1 "
bitfld.long 0 22. " IPC "  "0 ,1 "
bitfld.long 0 23. " IOE "  "0 ,1 "
;tree.end

base ad:0xa0350864
;tree "DITCTRLA"
group 0--3
line.long 0 "DITCTRLA"
bitfld.long 0 0. " TEMP "  "0 ,1 "
bitfld.long 0 1. " COMP "  "0 ,1 "
bitfld.long 0 2.--3. " MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MASK "  "0 ,1 "
bitfld.long 0 5.--9. " FOFFX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--14. " FOFFY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0350868
;tree "DITOFFA"
group 0--3
line.long 0 "DITOFFA"
bitfld.long 0 0.--4. " XG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " YG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " XB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--28. " YB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa035086c
;tree "PAL0A"
group 0--3
line.long 0 "PAL0A"
bitfld.long 0 0.--11. " BLUE "  " "
bitfld.long 0 16.--27. " GREEN "  " "
;tree.end

base ad:0xa0350870
;tree "PAL1A"
group 0--3
line.long 0 "PAL1A"
bitfld.long 0 0.--11. " RED "  " "
;tree.end

base ad:0xa0350874
;tree "ROTADD0A"
group 0--3
line.long 0 "ROTADD0A"
bitfld.long 0 0.--2. " ROTADD0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " ROTADD0_MSB "  " "
;tree.end

base ad:0xa0350878
;tree "ROTADD1A"
group 0--3
line.long 0 "ROTADD1A"
bitfld.long 0 0.--2. " ROTADD1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " ROTADD1_MSB "  " "
;tree.end

base ad:0xa035087c
;tree "ROTACONF"
group 0--3
line.long 0 "ROTACONF"
bitfld.long 0 0.--2. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " ROTDIR "  "0 ,1 "
bitfld.long 0 4.--5. " WR_MAXOUT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " RD_MAXOUT "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--14. " STRIP_WIDTH "  " "
bitfld.long 0 15. " SINGLE_BUF "  "0 ,1 "
hexfld.byte 2 " WR_ROPC "
hexfld.byte 3 " RD_ROPC "
;tree.end

base ad:0xa0350880
;tree "SYNCHCONFA"
group 0--3
line.long 0 "SYNCHCONFA"
bitfld.long 0 0.--1. " HWREQVEVENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--15. " HWREQVCNT "  " "
bitfld.long 0 16.--17. " SWINTVEVENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--31. " SWINTVCNT "  " "
;tree.end

base ad:0xa0350884
;tree "CTRLA"
group 0--3
line.long 0 "CTRLA"
bitfld.long 0 0.--9. " FIFOWTRMRK "  " "
bitfld.long 0 12. " FIFOEMPTY "  "0 ,1 "
bitfld.long 0 13. " FIFOFULL "  "0 ,1 "
bitfld.long 0 16.--18. " FORMID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " FORMTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350888
;tree "GAM0A"
group 0--3
line.long 0 "GAM0A"
bitfld.long 0 0.--23. " BLUE "  " "
;tree.end

base ad:0xa035088c
;tree "GAM1A"
group 0--3
line.long 0 "GAM1A"
bitfld.long 0 0.--23. " GREEN "  " "
;tree.end

base ad:0xa0350890
;tree "GAM2A"
group 0--3
line.long 0 "GAM2A"
bitfld.long 0 0.--23. " RED "  " "
;tree.end

base ad:0xa0350894
;tree "OLEDCONV1A"
group 0--3
line.long 0 "OLEDCONV1A"
bitfld.long 0 0.--13. " ALPHA_RED "  " "
bitfld.long 0 16.--29. " ALPHA_GREEN "  " "
;tree.end

base ad:0xa0350898
;tree "OLEDCONV2A"
group 0--3
line.long 0 "OLEDCONV2A"
bitfld.long 0 0.--13. " ALPHA_BLUE "  " "
bitfld.long 0 16.--29. " BETA_RED "  " "
;tree.end

base ad:0xa035089c
;tree "OLEDCONV3A"
group 0--3
line.long 0 "OLEDCONV3A"
bitfld.long 0 0.--13. " BETA_GREEN "  " "
bitfld.long 0 16.--29. " BETA_BLUE "  " "
;tree.end

base ad:0xa03508a0
;tree "OLEDCONV4A"
group 0--3
line.long 0 "OLEDCONV4A"
bitfld.long 0 0.--13. " GAMMA_RED "  " "
bitfld.long 0 16.--29. " GAMMA_GREEN "  " "
;tree.end

base ad:0xa03508a4
;tree "OLEDCONV5A"
group 0--3
line.long 0 "OLEDCONV5A"
bitfld.long 0 0.--13. " GAMMA_BLUE "  " "
bitfld.long 0 16.--29. " OFF_RED "  " "
;tree.end

base ad:0xa03508a8
;tree "OLEDCONV6A"
group 0--3
line.long 0 "OLEDCONV6A"
bitfld.long 0 0.--13. " OFF_GREEN "  " "
bitfld.long 0 16.--29. " OFF_BLUE "  " "
;tree.end

base ad:0xa0350a00
;tree "CRB0"
group 0--3
line.long 0 "CRB0"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 1. " POWEREN "  "0 ,1 "
bitfld.long 0 2. " BLENDEN "  "0 ,1 "
bitfld.long 0 3. " AFLICKEN "  "0 ,1 "
bitfld.long 0 4. " PALEN "  "0 ,1 "
bitfld.long 0 5. " DITHEN "  "0 ,1 "
bitfld.long 0 6. " GAMEN "  "0 ,1 "
bitfld.long 0 7.--9. " KEYCTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " BLENDCTRL "  "0 ,1 "
bitfld.long 0 11.--12. " FLICKMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " FLICKFORMAT "  "0 ,1 "
bitfld.long 0 14. " PALMODE "  "0 ,1 "
bitfld.long 0 15. " OLEDEN "  "0 ,1 "
hexfld.byte 2 " ALPHABLEND "
bitfld.long 0 24. " ROTEN "  "0 ,1 "
;tree.end

base ad:0xa0350a04
;tree "CRB1"
group 0--3
line.long 0 "CRB1"
bitfld.long 0 0.--9. " PCD "  " "
bitfld.long 0 10.--12. " CLKSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--16. " CDWIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 25.--28. " OUTBPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 29. " BCD "  "0 ,1 "
bitfld.long 0 30. " CLKTYPE "  "0 ,1 "
;tree.end

base ad:0xa0350a08
;tree "COLKEYB"
group 0--3
line.long 0 "COLKEYB"
hexfld.byte 0 " KEYB "
hexfld.byte 1 " KEYG "
hexfld.byte 2 " KEYR "
hexfld.byte 3 " KEYA "
;tree.end

base ad:0xa0350a0c
;tree "FCOLKEYB"
group 0--3
line.long 0 "FCOLKEYB"
hexfld.byte 0 " FKEYB "
hexfld.byte 1 " FKEYG "
hexfld.byte 2 " FKEYR "
hexfld.byte 3 " FKEYA "
;tree.end

base ad:0xa0350a10
;tree "RGBCONV1B"
group 0--3
line.long 0 "RGBCONV1B"
bitfld.long 0 0.--10. " YR_GREEN "  " "
bitfld.long 0 16.--26. " YR_RED "  " "
;tree.end

base ad:0xa0350a14
;tree "RGBCONV2B"
group 0--3
line.long 0 "RGBCONV2B"
bitfld.long 0 0.--10. " CR_RED "  " "
bitfld.long 0 16.--26. " YR_BLUE "  " "
;tree.end

base ad:0xa0350a18
;tree "RGBCONV3B"
group 0--3
line.long 0 "RGBCONV3B"
bitfld.long 0 0.--10. " CR_BLUE "  " "
bitfld.long 0 16.--26. " CR_GREEN "  " "
;tree.end

base ad:0xa0350a1c
;tree "RGBCONV4B"
group 0--3
line.long 0 "RGBCONV4B"
bitfld.long 0 0.--10. " CB_GREEN "  " "
bitfld.long 0 16.--26. " CB_RED "  " "
;tree.end

base ad:0xa0350a20
;tree "RGBCONV5B"
group 0--3
line.long 0 "RGBCONV5B"
bitfld.long 0 0.--10. " OFF_RED "  " "
bitfld.long 0 16.--26. " CB_BLUE "  " "
;tree.end

base ad:0xa0350a24
;tree "RGBCONV6B"
group 0--3
line.long 0 "RGBCONV6B"
bitfld.long 0 0.--10. " OFF_BLUE "  " "
bitfld.long 0 16.--26. " OFF_GREEN "  " "
;tree.end

base ad:0xa0350a34
;tree "WDATAB"
group 0--3
line.long 0 "WDATAB"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
;tree.end

base ad:0xa0350a38
;tree "TVCRB"
group 0--3
line.long 0 "TVCRB"
bitfld.long 0 0. " SEL_MOD "  "0 ,1 "
bitfld.long 0 1. " INTEREN "  "0 ,1 "
bitfld.long 0 2. " IFIELD "  "0 ,1 "
bitfld.long 0 3.--5. " TVMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--7. " SDTVMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8. " AVRGEN "  "0 ,1 "
bitfld.long 0 9. " CKINV "  "0 ,1 "
;tree.end

base ad:0xa0350a3c
;tree "TVBL1B"
group 0--3
line.long 0 "TVBL1B"
bitfld.long 0 0.--10. " BEL1 "  " "
bitfld.long 0 16.--26. " BSL1 "  " "
;tree.end

base ad:0xa0350a40
;tree "TVISLB"
group 0--3
line.long 0 "TVISLB"
bitfld.long 0 0.--10. " FSL1 "  " "
bitfld.long 0 16.--26. " FSL2 "  " "
;tree.end

base ad:0xa0350a44
;tree "TVDVOB"
group 0--3
line.long 0 "TVDVOB"
bitfld.long 0 0.--10. " DVO1 "  " "
bitfld.long 0 16.--26. " DVO2 "  " "
;tree.end

base ad:0xa0350a4c
;tree "TVTIM1B"
group 0--3
line.long 0 "TVTIM1B"
bitfld.long 0 0.--10. " DHO "  " "
;tree.end

base ad:0xa0350a50
;tree "TVLBALWB"
group 0--3
line.long 0 "TVLBALWB"
bitfld.long 0 0.--10. " LBW "  " "
bitfld.long 0 16.--26. " ALW "  " "
;tree.end

base ad:0xa0350a54
;tree "TVBL2B"
group 0--3
line.long 0 "TVBL2B"
bitfld.long 0 0.--10. " BEL2 "  " "
bitfld.long 0 16.--26. " BSL2 "  " "
;tree.end

base ad:0xa0350a58
;tree "TVBLUB"
group 0--3
line.long 0 "TVBLUB"
hexfld.byte 0 " TVBLU "
hexfld.byte 1 " TVBCB "
hexfld.byte 2 " TVBCR "
;tree.end

base ad:0xa0350a60
;tree "LCDTIM1B"
group 0--3
line.long 0 "LCDTIM1B"
bitfld.long 0 19. " IVP "  "0 ,1 "
bitfld.long 0 20. " IVS "  "0 ,1 "
bitfld.long 0 21. " IHS "  "0 ,1 "
bitfld.long 0 22. " IPC "  "0 ,1 "
bitfld.long 0 23. " IOE "  "0 ,1 "
;tree.end

base ad:0xa0350a64
;tree "DITCTRLB"
group 0--3
line.long 0 "DITCTRLB"
bitfld.long 0 0. " TEMP "  "0 ,1 "
bitfld.long 0 1. " COMP "  "0 ,1 "
bitfld.long 0 2.--3. " MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MASK "  "0 ,1 "
bitfld.long 0 5.--9. " FOFFX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--14. " FOFFY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0350a68
;tree "DITOFFB"
group 0--3
line.long 0 "DITOFFB"
bitfld.long 0 0.--4. " XG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " YG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " XB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--28. " YB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0350a6c
;tree "PAL0B"
group 0--3
line.long 0 "PAL0B"
bitfld.long 0 0.--11. " BLUE "  " "
bitfld.long 0 16.--27. " GREEN "  " "
;tree.end

base ad:0xa0350a70
;tree "PAL1B"
group 0--3
line.long 0 "PAL1B"
bitfld.long 0 0.--11. " RED "  " "
;tree.end

base ad:0xa0350a74
;tree "ROTADD0B"
group 0--3
line.long 0 "ROTADD0B"
bitfld.long 0 0.--2. " ROTADD0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " ROTADD0_MSB "  " "
;tree.end

base ad:0xa0350a78
;tree "ROTADD1B"
group 0--3
line.long 0 "ROTADD1B"
bitfld.long 0 0.--2. " ROTADD1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " ROTADD1_MSB "  " "
;tree.end

base ad:0xa0350a7c
;tree "ROTBCONF"
group 0--3
line.long 0 "ROTBCONF"
bitfld.long 0 0.--2. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " ROTDIR "  "0 ,1 "
bitfld.long 0 4.--5. " WR_MAXOUT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " RD_MAXOUT "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--14. " STRIP_WIDTH "  " "
bitfld.long 0 15. " SINGLE_BUF "  "0 ,1 "
hexfld.byte 2 " WR_ROPC "
hexfld.byte 3 " RD_ROPC "
;tree.end

base ad:0xa0350a80
;tree "SYNCHCONFB"
group 0--3
line.long 0 "SYNCHCONFB"
bitfld.long 0 0.--1. " HWREQVEVENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--15. " HWREQVCNT "  " "
bitfld.long 0 16.--17. " SWINTVEVENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--31. " SWINTVCNT "  " "
;tree.end

base ad:0xa0350a84
;tree "CTRLB"
group 0--3
line.long 0 "CTRLB"
bitfld.long 0 0.--9. " FIFOWTRMRK "  " "
bitfld.long 0 12. " FIFOEMPTY "  "0 ,1 "
bitfld.long 0 13. " FIFOFULL "  "0 ,1 "
bitfld.long 0 16.--18. " FORMID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " FORMTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350a88
;tree "GAM0B"
group 0--3
line.long 0 "GAM0B"
bitfld.long 0 0.--23. " BLUE "  " "
;tree.end

base ad:0xa0350a8c
;tree "GAM1B"
group 0--3
line.long 0 "GAM1B"
bitfld.long 0 0.--23. " GREEN "  " "
;tree.end

base ad:0xa0350a90
;tree "GAM2B"
group 0--3
line.long 0 "GAM2B"
bitfld.long 0 0.--23. " RED "  " "
;tree.end

base ad:0xa0350a94
;tree "OLEDCONV1B"
group 0--3
line.long 0 "OLEDCONV1B"
bitfld.long 0 0.--13. " ALPHA_RED "  " "
bitfld.long 0 16.--29. " ALPHA_GREEN "  " "
;tree.end

base ad:0xa0350a98
;tree "OLEDCONV2B"
group 0--3
line.long 0 "OLEDCONV2B"
bitfld.long 0 0.--13. " ALPHA_BLUE "  " "
bitfld.long 0 16.--29. " BETA_RED "  " "
;tree.end

base ad:0xa0350a9c
;tree "OLEDCONV3B"
group 0--3
line.long 0 "OLEDCONV3B"
bitfld.long 0 0.--13. " BETA_GREEN "  " "
bitfld.long 0 16.--29. " BETA_BLUE "  " "
;tree.end

base ad:0xa0350aa0
;tree "OLEDCONV4B"
group 0--3
line.long 0 "OLEDCONV4B"
bitfld.long 0 0.--13. " GAMMA_RED "  " "
bitfld.long 0 16.--29. " GAMMA_GREEN "  " "
;tree.end

base ad:0xa0350aa4
;tree "OLEDCONV5B"
group 0--3
line.long 0 "OLEDCONV5B"
bitfld.long 0 0.--13. " GAMMA_BLUE "  " "
bitfld.long 0 16.--29. " OFF_RED "  " "
;tree.end

base ad:0xa0350aa8
;tree "OLEDCONV6B"
group 0--3
line.long 0 "OLEDCONV6B"
bitfld.long 0 0.--13. " OFF_GREEN "  " "
bitfld.long 0 16.--29. " OFF_BLUE "  " "
;tree.end

base ad:0xa0350c00
;tree "CRC"
group 0--3
line.long 0 "CRC"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 1. " POWEREN "  "0 ,1 "
bitfld.long 0 2. " C1EN "  "0 ,1 "
bitfld.long 0 3. " C2EN "  "0 ,1 "
bitfld.long 0 4. " WMLVL1 "  "0 ,1 "
bitfld.long 0 5. " WMLVL2 "  "0 ,1 "
bitfld.long 0 6. " SYNCSEL "  "0 ,1 "
bitfld.long 0 7. " SYCEN0 "  "0 ,1 "
bitfld.long 0 8. " SYCEN1 "  "0 ,1 "
bitfld.long 0 9. " SIZE1 "  "0 ,1 "
bitfld.long 0 10. " SIZE2 "  "0 ,1 "
bitfld.long 0 11. " INBAND1 "  "0 ,1 "
bitfld.long 0 12. " INBAND2 "  "0 ,1 "
bitfld.long 0 13.--14. " CLKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " YUVCONVC1EN "  "0 ,1 "
bitfld.long 0 16. " CS1EN "  "0 ,1 "
bitfld.long 0 17. " CS2EN "  "0 ,1 "
bitfld.long 0 18. " RESEN "  "0 ,1 "
bitfld.long 0 19. " CS1POL "  "0 ,1 "
bitfld.long 0 20. " CS2POL "  "0 ,1 "
bitfld.long 0 21. " CD1POL "  "0 ,1 "
bitfld.long 0 22. " CD2POL "  "0 ,1 "
bitfld.long 0 23. " WR1POL "  "0 ,1 "
bitfld.long 0 24. " WR2POL "  "0 ,1 "
bitfld.long 0 25. " RD1POL "  "0 ,1 "
bitfld.long 0 26. " RD2POL "  "0 ,1 "
bitfld.long 0 27. " RES1POL "  "0 ,1 "
bitfld.long 0 28. " RES2POL "  "0 ,1 "
bitfld.long 0 29.--30. " SYNCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 31. " CLAMPC1EN "  "0 ,1 "
;tree.end

base ad:0xa0350c04
;tree "PBCCRC0"
group 0--3
line.long 0 "PBCCRC0"
bitfld.long 0 0.--2. " BSCM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " BSDM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " PDM "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PDCTRL "  "0 ,1 "
bitfld.long 0 13.--15. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350c08
;tree "PBCCRC1"
group 0--3
line.long 0 "PBCCRC1"
bitfld.long 0 0.--2. " BSCM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " BSDM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " PDM "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PDCTRL "  "0 ,1 "
bitfld.long 0 13.--15. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350c0c
;tree "PBCBMRC00"
group 0--3
line.long 0 "PBCBMRC00"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c10
;tree "PBCBMRC01"
group 0--3
line.long 0 "PBCBMRC01"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c14
;tree "PBCBMRC02"
group 0--3
line.long 0 "PBCBMRC02"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c18
;tree "PBCBMRC03"
group 0--3
line.long 0 "PBCBMRC03"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c1c
;tree "PBCBMRC04"
group 0--3
line.long 0 "PBCBMRC04"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c20
;tree "PBCBMRC10"
group 0--3
line.long 0 "PBCBMRC10"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c24
;tree "PBCBMRC11"
group 0--3
line.long 0 "PBCBMRC11"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c28
;tree "PBCBMRC12"
group 0--3
line.long 0 "PBCBMRC12"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c2c
;tree "PBCBMRC13"
group 0--3
line.long 0 "PBCBMRC13"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c30
;tree "PBCBMRC14"
group 0--3
line.long 0 "PBCBMRC14"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c34
;tree "PBCBCR00"
group 0--3
line.long 0 "PBCBCR00"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c38
;tree "PBCBCR01"
group 0--3
line.long 0 "PBCBCR01"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c48
;tree "PBCBCR10"
group 0--3
line.long 0 "PBCBCR10"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c4c
;tree "PBCBCR11"
group 0--3
line.long 0 "PBCBCR11"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
;tree.end

base ad:0xa0350c5c
;tree "VSCRC0"
group 0--3
line.long 0 "VSCRC0"
bitfld.long 0 0.--11. " VSPMIN "  " "
bitfld.long 0 12.--23. " VSPMAX "  " "
bitfld.long 0 24.--26. " VSPDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 27. " VSPOL "  "0 ,1 "
bitfld.long 0 28. " VSSEL "  "0 ,1 "
bitfld.long 0 29.--31. " VSDBL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350c60
;tree "VSCRC1"
group 0--3
line.long 0 "VSCRC1"
bitfld.long 0 0.--11. " VSPMIN "  " "
bitfld.long 0 12.--23. " VSPMAX "  " "
bitfld.long 0 24.--26. " VSPDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 27. " VSPOL "  "0 ,1 "
bitfld.long 0 28. " VSSEL "  "0 ,1 "
bitfld.long 0 29.--31. " VSDBL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350c64
;tree "SCTRC"
group 0--3
line.long 0 "SCTRC"
hexfld.byte 0 " SYNCDELC0 "
hexfld.byte 1 " SYNCDELC1 "
bitfld.long 0 16.--27. " TRDELC "  " "
;tree.end

base ad:0xa0350c6c
;tree "BCNR0"
group 0--3
line.long 0 "BCNR0"
hexfld.byte 0 " BCN "
;tree.end

base ad:0xa0350c70
;tree "BCNR1"
group 0--3
line.long 0 "BCNR1"
hexfld.byte 0 " BCN "
;tree.end

base ad:0xa0350c74
;tree "CSCDTRC0"
group 0--3
line.long 0 "CSCDTRC0"
hexfld.byte 0 " CSACT "
hexfld.byte 1 " CSDEACT "
hexfld.byte 2 " CDACT "
hexfld.byte 3 " CDDEACT "
;tree.end

base ad:0xa0350c78
;tree "CSCDTRC1"
group 0--3
line.long 0 "CSCDTRC1"
hexfld.byte 0 " CSACT "
hexfld.byte 1 " CSDEACT "
hexfld.byte 2 " CDACT "
hexfld.byte 3 " CDDEACT "
;tree.end

base ad:0xa0350c7c
;tree "RDWRTRC0"
group 0--3
line.long 0 "RDWRTRC0"
hexfld.byte 0 " RWACT "
hexfld.byte 1 " RWDEACT "
bitfld.long 0 16. " MOTINT "  "0 ,1 "
;tree.end

base ad:0xa0350c80
;tree "RDWRTRC1"
group 0--3
line.long 0 "RDWRTRC1"
hexfld.byte 0 " RWACT "
hexfld.byte 1 " RWDEACT "
bitfld.long 0 16. " MOTINT "  "0 ,1 "
;tree.end

base ad:0xa0350c84
;tree "DOTRC0"
group 0--3
line.long 0 "DOTRC0"
hexfld.byte 0 " DOACT "
hexfld.byte 1 " DODEACT "
;tree.end

base ad:0xa0350c88
;tree "DOTRC1"
group 0--3
line.long 0 "DOTRC1"
hexfld.byte 0 " DOACT "
hexfld.byte 1 " DODEACT "
;tree.end

base ad:0xa0350c94
;tree "WDATADC0"
group 0--3
line.long 0 "WDATADC0"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
;tree.end

base ad:0xa0350c98
;tree "WDATADC1"
group 0--3
line.long 0 "WDATADC1"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
;tree.end

base ad:0xa0350c9c
;tree "RDATADC0"
group 0--3
line.long 0 "RDATADC0"
hexfld.word 0 " DATAREADFROMDISPLAYMODULE "
bitfld.long 0 16. " STARTREAD "  "0 ,1 "
;tree.end

base ad:0xa0350ca0
;tree "RDATADC1"
group 0--3
line.long 0 "RDATADC1"
hexfld.word 0 " DATAREADFROMDISPLAYMODULE "
bitfld.long 0 16. " STARTREAD "  "0 ,1 "
;tree.end

base ad:0xa0350ca4
;tree "STATC"
rgroup 0--3
line.long 0 "STATC"
bitfld.long 0 0. " STATBUSY0 "  "0 ,1 "
bitfld.long 0 5. " STATBUSY1 "  "0 ,1 "
;tree.end

base ad:0xa0350ca8
;tree "CTRLC0"
group 0--3
line.long 0 "CTRLC0"
bitfld.long 0 0.--9. " FIFOWTRMRK "  " "
bitfld.long 0 12. " FIFOEMPTY "  "0 ,1 "
bitfld.long 0 13. " FIFOFULL "  "0 ,1 "
bitfld.long 0 16.--18. " FORMID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " FORMTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350cac
;tree "CTRLC1"
group 0--3
line.long 0 "CTRLC1"
bitfld.long 0 0.--9. " FIFOWTRMRK "  " "
bitfld.long 0 12. " FIFOEMPTY "  "0 ,1 "
bitfld.long 0 13. " FIFOFULL "  "0 ,1 "
bitfld.long 0 16.--18. " FORMID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " FORMTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e00
;tree "DSI0CONF0"
group 0--3
line.long 0 "DSI0CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e04
;tree "DSI0FRAME"
group 0--3
line.long 0 "DSI0FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e08
;tree "DSI0PKT"
group 0--3
line.long 0 "DSI0PKT"
hexfld.word 0 " PACKET "
;tree.end

base ad:0xa0350e0c
;tree "DSI0SYNC"
group 0--3
line.long 0 "DSI0SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
;tree.end

base ad:0xa0350e10
;tree "DSI0CMDW"
group 0--3
line.long 0 "DSI0CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 1 " CMDW_START "
;tree.end

base ad:0xa0350e14
;tree "DSI0DELAY0"
group 0--3
line.long 0 "DSI0DELAY0"
hexfld.word 0 " INTPKTDEL "
;tree.end

base ad:0xa0350e18
;tree "DSI0DELAY1"
group 0--3
line.long 0 "DSI0DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
;tree.end

base ad:0xa0350e20
;tree "DSI1CONF0"
group 0--3
line.long 0 "DSI1CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e24
;tree "DSI1FRAME"
group 0--3
line.long 0 "DSI1FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e28
;tree "DSI1PKT"
group 0--3
line.long 0 "DSI1PKT"
hexfld.word 0 " PACKET "
;tree.end

base ad:0xa0350e2c
;tree "DSI1SYNC"
group 0--3
line.long 0 "DSI1SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
;tree.end

base ad:0xa0350e30
;tree "DSI1CMDW"
group 0--3
line.long 0 "DSI1CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 1 " CMDW_START "
;tree.end

base ad:0xa0350e34
;tree "DSI1DELAY0"
group 0--3
line.long 0 "DSI1DELAY0"
hexfld.word 0 " INTPKTDEL "
;tree.end

base ad:0xa0350e38
;tree "DSI1DELAY1"
group 0--3
line.long 0 "DSI1DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
;tree.end

base ad:0xa0350e40
;tree "DSI2CONF0"
group 0--3
line.long 0 "DSI2CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e44
;tree "DSI2FRAME"
group 0--3
line.long 0 "DSI2FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e48
;tree "DSI2PKT"
group 0--3
line.long 0 "DSI2PKT"
hexfld.word 0 " PACKET "
;tree.end

base ad:0xa0350e4c
;tree "DSI2SYNC"
group 0--3
line.long 0 "DSI2SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
;tree.end

base ad:0xa0350e50
;tree "DSI2CMDW"
group 0--3
line.long 0 "DSI2CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 1 " CMDW_START "
;tree.end

base ad:0xa0350e54
;tree "DSI2DELAY0"
group 0--3
line.long 0 "DSI2DELAY0"
hexfld.word 0 " INTPKTDEL "
;tree.end

base ad:0xa0350e58
;tree "DSI2DELAY1"
group 0--3
line.long 0 "DSI2DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
;tree.end

base ad:0xa0350e60
;tree "DSI3CONF0"
group 0--3
line.long 0 "DSI3CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e64
;tree "DSI3FRAME"
group 0--3
line.long 0 "DSI3FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e68
;tree "DSI3PKT"
group 0--3
line.long 0 "DSI3PKT"
hexfld.word 0 " PACKET "
;tree.end

base ad:0xa0350e6c
;tree "DSI3SYNC"
group 0--3
line.long 0 "DSI3SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
;tree.end

base ad:0xa0350e70
;tree "DSI3CMDW"
group 0--3
line.long 0 "DSI3CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 1 " CMDW_START "
;tree.end

base ad:0xa0350e74
;tree "DSI3DELAY0"
group 0--3
line.long 0 "DSI3DELAY0"
hexfld.word 0 " INTPKTDEL "
;tree.end

base ad:0xa0350e78
;tree "DSI3DELAY1"
group 0--3
line.long 0 "DSI3DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
;tree.end

base ad:0xa0350e80
;tree "DSI4CONF0"
group 0--3
line.long 0 "DSI4CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350e84
;tree "DSI4FRAME"
group 0--3
line.long 0 "DSI4FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350e88
;tree "DSI4PKT"
group 0--3
line.long 0 "DSI4PKT"
hexfld.word 0 " PACKET "
;tree.end

base ad:0xa0350e8c
;tree "DSI4SYNC"
group 0--3
line.long 0 "DSI4SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
;tree.end

base ad:0xa0350e90
;tree "DSI4CMDW"
group 0--3
line.long 0 "DSI4CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 1 " CMDW_START "
;tree.end

base ad:0xa0350e94
;tree "DSI4DELAY0"
group 0--3
line.long 0 "DSI4DELAY0"
hexfld.word 0 " INTPKTDEL "
;tree.end

base ad:0xa0350e98
;tree "DSI4DELAY1"
group 0--3
line.long 0 "DSI4DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
;tree.end

base ad:0xa0350ea0
;tree "DSI5CONF0"
group 0--3
line.long 0 "DSI5CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0350ea4
;tree "DSI5FRAME"
group 0--3
line.long 0 "DSI5FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

base ad:0xa0350ea8
;tree "DSI5PKT"
group 0--3
line.long 0 "DSI5PKT"
hexfld.word 0 " PACKET "
;tree.end

base ad:0xa0350eac
;tree "DSI5SYNC"
group 0--3
line.long 0 "DSI5SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
;tree.end

base ad:0xa0350eb0
;tree "DSI5CMDW"
group 0--3
line.long 0 "DSI5CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 1 " CMDW_START "
;tree.end

base ad:0xa0350eb4
;tree "DSI5DELAY0"
group 0--3
line.long 0 "DSI5DELAY0"
hexfld.word 0 " INTPKTDEL "
;tree.end

base ad:0xa0350eb8
;tree "DSI5DELAY1"
group 0--3
line.long 0 "DSI5DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
;tree.end

endif

tree.end

;==============================================================
tree "MCSBAG"
;==============================================================
base ad:0xa0390000
;tree "BA_ENABLE"
group 0--3
line.long 0 "BA_ENABLE"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390004
;tree "BA_MODE"
group 0--3
line.long 0 "BA_MODE"
bitfld.long 0 0.--2. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0390008
;tree "BA_MSG_PORT_PACE"
group 0--3
line.long 0 "BA_MSG_PORT_PACE"
hexfld.word 0 " DIVIDER "
;tree.end

base ad:0xa039000c
;tree "BA_STATUS"
rgroup 0--3
line.long 0 "BA_STATUS"
bitfld.long 0 0.--1. " FF_FLAGS "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0390020
;tree "WPSAT_ENABLE"
group 0--3
line.long 0 "WPSAT_ENABLE"
bitfld.long 0 0.--3. " WPSen "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0390024
;tree "WPSAT_PROG_MODE"
group 0--3
line.long 0 "WPSAT_PROG_MODE"
bitfld.long 0 0.--3. " WPSprog "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0390028
;tree "WPSAT_PROG_STATUS"
rgroup 0--3
line.long 0 "WPSAT_PROG_STATUS"
bitfld.long 0 0.--3. " WPSprogstatus "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa039002c
;tree "WPSAT_PROG_CLEAR"
group 0--3
line.long 0 "WPSAT_PROG_CLEAR"
bitfld.long 0 0. " CLEAR "  "0 ,1 "
;tree.end

base ad:0xa0390040
;tree "TMSAT_ENABLE"
group 0--3
line.long 0 "TMSAT_ENABLE"
hexfld.byte 0 " TMSen "
;tree.end

base ad:0xa0390044
;tree "TMSAT_PROG_MODE"
group 0--3
line.long 0 "TMSAT_PROG_MODE"
hexfld.byte 0 " TMSprog "
;tree.end

base ad:0xa0390048
;tree "TMSAT_PROG_STATUS"
rgroup 0--3
line.long 0 "TMSAT_PROG_STATUS"
hexfld.byte 0 " TMSprogstatus "
;tree.end

base ad:0xa039004c
;tree "TMSAT_PROG_CLEAR"
group 0--3
line.long 0 "TMSAT_PROG_CLEAR"
bitfld.long 0 0. " CLEAR "  "0 ,1 "
;tree.end

base ad:0xa0390050
;tree "TMSAT_READ_STATUS"
rgroup 0--3
line.long 0 "TMSAT_READ_STATUS"
hexfld.byte 0 " TMSreadstatus "
;tree.end

base ad:0xa0390060
;tree "WPSAT_ITS"
rgroup 0--3
line.long 0 "WPSAT_ITS"
bitfld.long 0 0.--3. " WPSAT_ITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0390064
;tree "WPSAT_ITS_CLR"
group 0--3
line.long 0 "WPSAT_ITS_CLR"
bitfld.long 0 0.--3. " WPSAT_ITS_CLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0390068
;tree "WPSAT_ITS_SET"
wgroup 0--3
line.long 0 "WPSAT_ITS_SET"
bitfld.long 0 0.--3. " WPSAT_ITS_SET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa039006c
;tree "WPSAT_ITM"
rgroup 0--3
line.long 0 "WPSAT_ITM"
bitfld.long 0 0.--3. " WPSAT_ITM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0390070
;tree "WPSAT_ITM_CLR"
group 0--3
line.long 0 "WPSAT_ITM_CLR"
bitfld.long 0 0.--3. " WPSAT_ITM_CLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0390074
;tree "WPSAT_ITM_SET"
wgroup 0--3
line.long 0 "WPSAT_ITM_SET"
bitfld.long 0 0.--3. " WPSAT_ITM_SET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0390078
;tree "PI_ITS"
rgroup 0--3
line.long 0 "PI_ITS"
hexfld.word 0 " PI_ITS "
;tree.end

base ad:0xa039007c
;tree "PI_ITS_CLR"
group 0--3
line.long 0 "PI_ITS_CLR"
hexfld.word 0 " PI_ITS_CLR "
;tree.end

base ad:0xa0390080
;tree "PI_ITS_SET"
wgroup 0--3
line.long 0 "PI_ITS_SET"
hexfld.word 0 " PI_ITS_SET "
;tree.end

base ad:0xa0390084
;tree "PI_ITM"
rgroup 0--3
line.long 0 "PI_ITM"
hexfld.word 0 " PI_ITM "
;tree.end

base ad:0xa0390088
;tree "PI_ITM_CLR"
group 0--3
line.long 0 "PI_ITM_CLR"
hexfld.word 0 " PI_ITM_CLR "
;tree.end

base ad:0xa039008c
;tree "PI_ITM_SET"
wgroup 0--3
line.long 0 "PI_ITM_SET"
hexfld.word 0 " PI_ITM_SET "
;tree.end

base ad:0xa0390090
;tree "TMSAT_ITS"
rgroup 0--3
line.long 0 "TMSAT_ITS"
hexfld.byte 0 " TMSAT_ITS "
;tree.end

base ad:0xa0390094
;tree "TMSAT_ITS_CLR"
group 0--3
line.long 0 "TMSAT_ITS_CLR"
hexfld.byte 0 " TMSAT_ITS_CLR "
;tree.end

base ad:0xa0390098
;tree "TMSAT_ITS_SET"
wgroup 0--3
line.long 0 "TMSAT_ITS_SET"
hexfld.byte 0 " TMSAT_ITS_SET "
;tree.end

base ad:0xa039009c
;tree "TMSAT_ITM"
rgroup 0--3
line.long 0 "TMSAT_ITM"
hexfld.byte 0 " TMSAT_ITM "
;tree.end

base ad:0xa03900a0
;tree "TMSAT_ITM_CLR"
group 0--3
line.long 0 "TMSAT_ITM_CLR"
hexfld.byte 0 " TMSAT_ITM_CLR "
;tree.end

base ad:0xa03900a4
;tree "TMSAT_ITM_SET"
wgroup 0--3
line.long 0 "TMSAT_ITM_SET"
hexfld.byte 0 " TMSAT_ITM_SET "
;tree.end

base ad:0xa03900a8
;tree "PI_ERROR"
rgroup 0--3
line.long 0 "PI_ERROR"
hexfld.word 0 " PI_ERROR "
;tree.end

base ad:0xa03900ac
;tree "PI_ERROR_CLR"
group 0--3
line.long 0 "PI_ERROR_CLR"
hexfld.word 0 " PI_ERROR_CLR "
;tree.end

base ad:0xa03900b0
;tree "TMSAT0_T7_ERROR"
rgroup 0--3
line.long 0 "TMSAT0_T7_ERROR"
hexfld.long 0 " TMSAT0_T7_ERROR "
;tree.end

base ad:0xa03900b4
;tree "TMSAT8_T15_ERROR"
rgroup 0--3
line.long 0 "TMSAT8_T15_ERROR"
hexfld.long 0 " TMSAT8_T15_ERROR "
;tree.end

base ad:0xa03900b8
;tree "TM_LOST_ERROR"
rgroup 0--3
line.long 0 "TM_LOST_ERROR"
bitfld.long 0 0. " TM_ERROR "  "0 ,1 "
;tree.end

base ad:0xa03900bc
;tree "TM_ERROR_CLR"
group 0--3
line.long 0 "TM_ERROR_CLR"
bitfld.long 0 0. " TM_ERROR_CLR "  "0 ,1 "
;tree.end

base ad:0xa03900c0
;tree "SBAG_DVF0"
group 0--3
line.long 0 "SBAG_DVF0"
bitfld.long 0 0. " SBAG_DVF0 "  "0 ,1 "
;tree.end

base ad:0xa03900c4
;tree "TIME_ABSOLUTE_LSB"
group 0--3
line.long 0 "TIME_ABSOLUTE_LSB"
hexfld.long 0 " TIME_ABSOLUTE_LSB "
;tree.end

base ad:0xa03900c8
;tree "TIME_ABSOLUTE_MSB"
rgroup 0--3
line.long 0 "TIME_ABSOLUTE_MSB"
hexfld.long 0 " TIME_ABSOLUTE_MSB "
;tree.end

base ad:0xa0390200
;tree "WPSAT0_REG1"
group 0--3
line.long 0 "WPSAT0_REG1"
hexfld.long 0 " REG1 "
;tree.end

base ad:0xa0390204
;tree "WPSAT0_REG2"
group 0--3
line.long 0 "WPSAT0_REG2"
hexfld.long 0 " REG2 "
;tree.end

base ad:0xa0390208
;tree "WPSAT0_REG3"
group 0--3
line.long 0 "WPSAT0_REG3"
hexfld.long 0 " REG3 "
;tree.end

base ad:0xa039020c
;tree "WPSAT0_REG4"
group 0--3
line.long 0 "WPSAT0_REG4"
hexfld.long 0 " REG4 "
;tree.end

base ad:0xa0390210
;tree "WPSAT0_REQ_NOT_RSP"
rgroup 0--3
line.long 0 "WPSAT0_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
;tree.end

base ad:0xa0390214
;tree "WPSAT1_REG1"
group 0--3
line.long 0 "WPSAT1_REG1"
hexfld.long 0 " REG1 "
;tree.end

base ad:0xa0390218
;tree "WPSAT1_REG2"
group 0--3
line.long 0 "WPSAT1_REG2"
hexfld.long 0 " REG2 "
;tree.end

base ad:0xa039021c
;tree "WPSAT1_REG3"
group 0--3
line.long 0 "WPSAT1_REG3"
hexfld.long 0 " REG3 "
;tree.end

base ad:0xa0390220
;tree "WPSAT1_REG4"
group 0--3
line.long 0 "WPSAT1_REG4"
hexfld.long 0 " REG4 "
;tree.end

base ad:0xa0390224
;tree "WPSAT1_REQ_NOT_RSP"
rgroup 0--3
line.long 0 "WPSAT1_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
;tree.end

base ad:0xa0390228
;tree "WPSAT2_REG1"
group 0--3
line.long 0 "WPSAT2_REG1"
hexfld.long 0 " REG1 "
;tree.end

base ad:0xa039022c
;tree "WPSAT2_REG2"
group 0--3
line.long 0 "WPSAT2_REG2"
hexfld.long 0 " REG2 "
;tree.end

base ad:0xa0390230
;tree "WPSAT2_REG3"
group 0--3
line.long 0 "WPSAT2_REG3"
hexfld.long 0 " REG3 "
;tree.end

base ad:0xa0390234
;tree "WPSAT2_REG4"
group 0--3
line.long 0 "WPSAT2_REG4"
hexfld.long 0 " REG4 "
;tree.end

base ad:0xa0390238
;tree "WPSAT2_REQ_NOT_RSP"
rgroup 0--3
line.long 0 "WPSAT2_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
;tree.end

base ad:0xa039023c
;tree "WPSAT3_REG1"
group 0--3
line.long 0 "WPSAT3_REG1"
hexfld.long 0 " REG1 "
;tree.end

base ad:0xa0390240
;tree "WPSAT3_REG2"
group 0--3
line.long 0 "WPSAT3_REG2"
hexfld.long 0 " REG2 "
;tree.end

base ad:0xa0390244
;tree "WPSAT3_REG3"
group 0--3
line.long 0 "WPSAT3_REG3"
hexfld.long 0 " REG3 "
;tree.end

base ad:0xa0390248
;tree "WPSAT3_REG4"
group 0--3
line.long 0 "WPSAT3_REG4"
hexfld.long 0 " REG4 "
;tree.end

base ad:0xa039024c
;tree "WPSAT3_REQ_NOT_RSP"
rgroup 0--3
line.long 0 "WPSAT3_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
;tree.end

base ad:0xa0390400
;tree "MSG_REF_PACE"
group 0--3
line.long 0 "MSG_REF_PACE"
hexfld.long 0 " PACE "
;tree.end

base ad:0xa0390404
;tree "MSG_FPF_DATA"
group 0--3
line.long 0 "MSG_FPF_DATA"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa0390408
;tree "MSG_FPF_TRACE_CTRL"
group 0--3
line.long 0 "MSG_FPF_TRACE_CTRL"
bitfld.long 0 0. " DATA "  "0 ,1 "
bitfld.long 0 24. " TIME "  "0 ,1 "
bitfld.long 0 31. " EN "  "0 ,1 "
;tree.end

base ad:0xa039040c
;tree "MSG_PI_TRACE_CTRL"
group 0--3
line.long 0 "MSG_PI_TRACE_CTRL"
hexfld.word 0 " INCDATA "
bitfld.long 0 24. " TIME "  "0 ,1 "
bitfld.long 0 31. " EN "  "0 ,1 "
;tree.end

base ad:0xa0390410
;tree "MSG_REF_TRACE_CONTROL"
group 0--3
line.long 0 "MSG_REF_TRACE_CONTROL"
bitfld.long 0 31. " EN "  "0 ,1 "
;tree.end

base ad:0xa0390414
;tree "MSG_ERR_TRACE_CONTROL"
group 0--3
line.long 0 "MSG_ERR_TRACE_CONTROL"
bitfld.long 0 0. " FL0 "  "0 ,1 "
bitfld.long 0 8. " FL1 "  "0 ,1 "
bitfld.long 0 9. " FL2 "  "0 ,1 "
bitfld.long 0 16. " FL3 "  "0 ,1 "
bitfld.long 0 31. " EN "  "0 ,1 "
;tree.end

base ad:0xa0390418
;tree "MSG_WP_ENABLE"
group 0--3
line.long 0 "MSG_WP_ENABLE"
bitfld.long 0 0.--3. " MSGWPEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa039041c
;tree "MSG_WP_TRACE_CTRL"
group 0--3
line.long 0 "MSG_WP_TRACE_CTRL"
bitfld.long 0 0. " C1 "  "0 ,1 "
bitfld.long 0 1. " C2 "  "0 ,1 "
bitfld.long 0 8. " DATA "  "0 ,1 "
bitfld.long 0 24. " TIME "  "0 ,1 "
;tree.end

base ad:0xa0390420
;tree "MSG_TM_ENABLE"
group 0--3
line.long 0 "MSG_TM_ENABLE"
hexfld.byte 0 " MSGTMEN "
;tree.end

base ad:0xa0390424
;tree "MSG_TM_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG_TM_TRACE_CTRL_L"
bitfld.long 0 0. " ERR_M3_M2_M1 "  "0 ,1 "
;tree.end

base ad:0xa0390428
;tree "MSG_TM_TRACE_CTRL_M"
group 0--3
line.long 0 "MSG_TM_TRACE_CTRL_M"
bitfld.long 0 0. " ERR_M3_M2_M1 "  "0 ,1 "
;tree.end

base ad:0xa0390600
;tree "TMSAT0_REG1"
group 0--3
line.long 0 "TMSAT0_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390604
;tree "TMSAT0_REG2"
group 0--3
line.long 0 "TMSAT0_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390608
;tree "TMSAT0_REG3"
group 0--3
line.long 0 "TMSAT0_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa039060c
;tree "TMSAT1_REG1"
group 0--3
line.long 0 "TMSAT1_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390610
;tree "TMSAT1_REG2"
group 0--3
line.long 0 "TMSAT1_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390614
;tree "TMSAT1_REG3"
group 0--3
line.long 0 "TMSAT1_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390618
;tree "TMSAT2_REG1"
group 0--3
line.long 0 "TMSAT2_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa039061c
;tree "TMSAT2_REG2"
group 0--3
line.long 0 "TMSAT2_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390620
;tree "TMSAT2_REG3"
group 0--3
line.long 0 "TMSAT2_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390624
;tree "TMSAT3_REG1"
group 0--3
line.long 0 "TMSAT3_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390628
;tree "TMSAT3_REG2"
group 0--3
line.long 0 "TMSAT3_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa039062c
;tree "TMSAT3_REG3"
group 0--3
line.long 0 "TMSAT3_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390630
;tree "TMSAT4_REG1"
group 0--3
line.long 0 "TMSAT4_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390634
;tree "TMSAT4_REG2"
group 0--3
line.long 0 "TMSAT4_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390638
;tree "TMSAT4_REG3"
group 0--3
line.long 0 "TMSAT4_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa039063c
;tree "TMSAT5_REG1"
group 0--3
line.long 0 "TMSAT5_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390640
;tree "TMSAT5_REG2"
group 0--3
line.long 0 "TMSAT5_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390644
;tree "TMSAT5_REG3"
group 0--3
line.long 0 "TMSAT5_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390648
;tree "TMSAT6_REG1"
group 0--3
line.long 0 "TMSAT6_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa039064c
;tree "TMSAT6_REG2"
group 0--3
line.long 0 "TMSAT6_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390650
;tree "TMSAT6_REG3"
group 0--3
line.long 0 "TMSAT6_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390654
;tree "TMSAT7_REG1"
group 0--3
line.long 0 "TMSAT7_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390658
;tree "TMSAT7_REG2"
group 0--3
line.long 0 "TMSAT7_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa039065c
;tree "TMSAT7_REG3"
group 0--3
line.long 0 "TMSAT7_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390660
;tree "TMSAT8_REG1"
group 0--3
line.long 0 "TMSAT8_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390664
;tree "TMSAT8_REG2"
group 0--3
line.long 0 "TMSAT8_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390668
;tree "TMSAT8_REG3"
group 0--3
line.long 0 "TMSAT8_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa039066c
;tree "TMSAT9_REG1"
group 0--3
line.long 0 "TMSAT9_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390670
;tree "TMSAT9_REG2"
group 0--3
line.long 0 "TMSAT9_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390674
;tree "TMSAT9_REG3"
group 0--3
line.long 0 "TMSAT9_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390678
;tree "TMSAT10_REG1"
group 0--3
line.long 0 "TMSAT10_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa039067c
;tree "TMSAT10_REG2"
group 0--3
line.long 0 "TMSAT10_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390680
;tree "TMSAT10_REG3"
group 0--3
line.long 0 "TMSAT10_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390684
;tree "TMSAT11_REG1"
group 0--3
line.long 0 "TMSAT11_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390688
;tree "TMSAT11_REG2"
group 0--3
line.long 0 "TMSAT11_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa039068c
;tree "TMSAT11_REG3"
group 0--3
line.long 0 "TMSAT11_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390690
;tree "TMSAT12_REG1"
group 0--3
line.long 0 "TMSAT12_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390694
;tree "TMSAT12_REG2"
group 0--3
line.long 0 "TMSAT12_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390698
;tree "TMSAT12_REG3"
group 0--3
line.long 0 "TMSAT12_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa039069c
;tree "TMSAT13_REG1"
group 0--3
line.long 0 "TMSAT13_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa03906a0
;tree "TMSAT13_REG2"
group 0--3
line.long 0 "TMSAT13_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa03906a4
;tree "TMSAT13_REG3"
group 0--3
line.long 0 "TMSAT13_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

base ad:0xa0390800
;tree "PI_TRIGGER_RAISE"
group 0--3
line.long 0 "PI_TRIGGER_RAISE"
hexfld.word 0 " RISING "
;tree.end

base ad:0xa0390804
;tree "PI_TRIGGER_FALLING"
group 0--3
line.long 0 "PI_TRIGGER_FALLING"
hexfld.word 0 " FALLING "
;tree.end

tree.end

;==============================================================
tree "MMCI (6 instances)"
;==============================================================
base ad:0x80126000
;********************************************
tree "MMCI-0"
;********************************************
base ad:0x80126000
;tree "0Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
;tree.end

base ad:0x80126004
;tree "0Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
;tree.end

base ad:0x80126008
;tree "0Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

base ad:0x8012600c
;tree "0Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

base ad:0x80126010
;tree "0RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80126014
;tree "0Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

base ad:0x80126018
;tree "0Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

base ad:0x8012601c
;tree "0Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

base ad:0x80126020
;tree "0Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

base ad:0x80126024
;tree "0Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

base ad:0x80126028
;tree "0DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

base ad:0x8012602c
;tree "0DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
;tree.end

base ad:0x80126030
;tree "0DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

base ad:0x80126034
;tree "0Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
;tree.end

base ad:0x80126038
;tree "0Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
;tree.end

base ad:0x8012603c
;tree "0Mask0"
group 0--3
line.long 0 "Mask0"
;tree.end

base ad:0x80126040
;tree "0Mask1"
group 0--3
line.long 0 "Mask1"
;tree.end

base ad:0x80126044
;tree "0CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80126048
;tree "0FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

base ad:0x80126080
;tree "0Fifo"
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
;tree.end

base ad:0x801260c0
;tree "0DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

base ad:0x801260c4
;tree "0TRSCA"
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
;tree.end

base ad:0x80126fe0
;tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80126fe4
;tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80126fe8
;tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80126fec
;tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80126ff0
;tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

base ad:0x80126ff4
;tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

base ad:0x80126ff8
;tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

base ad:0x80126ffc
;tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

base ad:0x80114000
;********************************************
tree "MMCI-4"
;********************************************
base ad:0x80114000
;tree "4Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
;tree.end

base ad:0x80114004
;tree "4Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
;tree.end

base ad:0x80114008
;tree "4Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

base ad:0x8011400c
;tree "4Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

base ad:0x80114010
;tree "4RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80114014
;tree "4Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

base ad:0x80114018
;tree "4Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

base ad:0x8011401c
;tree "4Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

base ad:0x80114020
;tree "4Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

base ad:0x80114024
;tree "4Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

base ad:0x80114028
;tree "4DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

base ad:0x8011402c
;tree "4DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
;tree.end

base ad:0x80114030
;tree "4DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

base ad:0x80114034
;tree "4Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
;tree.end

base ad:0x80114038
;tree "4Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
;tree.end

base ad:0x8011403c
;tree "4Mask0"
group 0--3
line.long 0 "Mask0"
;tree.end

base ad:0x80114040
;tree "4Mask1"
group 0--3
line.long 0 "Mask1"
;tree.end

base ad:0x80114044
;tree "4CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80114048
;tree "4FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

base ad:0x80114080
;tree "4Fifo"
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
;tree.end

base ad:0x801140c0
;tree "4DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

base ad:0x801140c4
;tree "4TRSCA"
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
;tree.end

base ad:0x80114fe0
;tree "4PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80114fe4
;tree "4PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80114fe8
;tree "4PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80114fec
;tree "4PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80114ff0
;tree "4PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

base ad:0x80114ff4
;tree "4PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

base ad:0x80114ff8
;tree "4PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

base ad:0x80114ffc
;tree "4PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

base ad:0x80118000
;********************************************
tree "MMCI-1"
;********************************************
base ad:0x80118000
;tree "1Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
;tree.end

base ad:0x80118004
;tree "1Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
;tree.end

base ad:0x80118008
;tree "1Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

base ad:0x8011800c
;tree "1Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

base ad:0x80118010
;tree "1RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80118014
;tree "1Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

base ad:0x80118018
;tree "1Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

base ad:0x8011801c
;tree "1Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

base ad:0x80118020
;tree "1Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

base ad:0x80118024
;tree "1Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

base ad:0x80118028
;tree "1DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

base ad:0x8011802c
;tree "1DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
;tree.end

base ad:0x80118030
;tree "1DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

base ad:0x80118034
;tree "1Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
;tree.end

base ad:0x80118038
;tree "1Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
;tree.end

base ad:0x8011803c
;tree "1Mask0"
group 0--3
line.long 0 "Mask0"
;tree.end

base ad:0x80118040
;tree "1Mask1"
group 0--3
line.long 0 "Mask1"
;tree.end

base ad:0x80118044
;tree "1CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80118048
;tree "1FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

base ad:0x80118080
;tree "1Fifo"
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
;tree.end

base ad:0x801180c0
;tree "1DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

base ad:0x801180c4
;tree "1TRSCA"
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
;tree.end

base ad:0x80118fe0
;tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80118fe4
;tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80118fe8
;tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80118fec
;tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80118ff0
;tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

base ad:0x80118ff4
;tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

base ad:0x80118ff8
;tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

base ad:0x80118ffc
;tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

base ad:0x80119000
;********************************************
tree "MMCI-3"
;********************************************
base ad:0x80119000
;tree "3Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
;tree.end

base ad:0x80119004
;tree "3Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
;tree.end

base ad:0x80119008
;tree "3Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

base ad:0x8011900c
;tree "3Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

base ad:0x80119010
;tree "3RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80119014
;tree "3Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

base ad:0x80119018
;tree "3Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

base ad:0x8011901c
;tree "3Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

base ad:0x80119020
;tree "3Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

base ad:0x80119024
;tree "3Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

base ad:0x80119028
;tree "3DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

base ad:0x8011902c
;tree "3DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
;tree.end

base ad:0x80119030
;tree "3DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

base ad:0x80119034
;tree "3Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
;tree.end

base ad:0x80119038
;tree "3Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
;tree.end

base ad:0x8011903c
;tree "3Mask0"
group 0--3
line.long 0 "Mask0"
;tree.end

base ad:0x80119040
;tree "3Mask1"
group 0--3
line.long 0 "Mask1"
;tree.end

base ad:0x80119044
;tree "3CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80119048
;tree "3FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

base ad:0x80119080
;tree "3Fifo"
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
;tree.end

base ad:0x801190c0
;tree "3DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

base ad:0x801190c4
;tree "3TRSCA"
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
;tree.end

base ad:0x80119fe0
;tree "3PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80119fe4
;tree "3PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80119fe8
;tree "3PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80119fec
;tree "3PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80119ff0
;tree "3PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

base ad:0x80119ff4
;tree "3PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

base ad:0x80119ff8
;tree "3PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

base ad:0x80119ffc
;tree "3PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

base ad:0x80005000
;********************************************
tree "MMCI-2"
;********************************************
base ad:0x80005000
;tree "2Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
;tree.end

base ad:0x80005004
;tree "2Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
;tree.end

base ad:0x80005008
;tree "2Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

base ad:0x8000500c
;tree "2Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

base ad:0x80005010
;tree "2RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80005014
;tree "2Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

base ad:0x80005018
;tree "2Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

base ad:0x8000501c
;tree "2Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

base ad:0x80005020
;tree "2Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

base ad:0x80005024
;tree "2Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

base ad:0x80005028
;tree "2DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

base ad:0x8000502c
;tree "2DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
;tree.end

base ad:0x80005030
;tree "2DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

base ad:0x80005034
;tree "2Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
;tree.end

base ad:0x80005038
;tree "2Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
;tree.end

base ad:0x8000503c
;tree "2Mask0"
group 0--3
line.long 0 "Mask0"
;tree.end

base ad:0x80005040
;tree "2Mask1"
group 0--3
line.long 0 "Mask1"
;tree.end

base ad:0x80005044
;tree "2CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80005048
;tree "2FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

base ad:0x80005080
;tree "2Fifo"
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
;tree.end

base ad:0x800050c0
;tree "2DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

base ad:0x800050c4
;tree "2TRSCA"
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
;tree.end

base ad:0x80005fe0
;tree "2PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80005fe4
;tree "2PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80005fe8
;tree "2PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80005fec
;tree "2PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80005ff0
;tree "2PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

base ad:0x80005ff4
;tree "2PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

base ad:0x80005ff8
;tree "2PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

base ad:0x80005ffc
;tree "2PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

base ad:0x80008000
;********************************************
tree "MMCI-5"
;********************************************
base ad:0x80008000
;tree "5Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
;tree.end

base ad:0x80008004
;tree "5Clock"
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
;tree.end

base ad:0x80008008
;tree "5Argument"
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

base ad:0x8000800c
;tree "5Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

base ad:0x80008010
;tree "5RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80008014
;tree "5Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

base ad:0x80008018
;tree "5Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

base ad:0x8000801c
;tree "5Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

base ad:0x80008020
;tree "5Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

base ad:0x80008024
;tree "5Datatimer"
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

base ad:0x80008028
;tree "5DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

base ad:0x8000802c
;tree "5DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
;tree.end

base ad:0x80008030
;tree "5DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

base ad:0x80008034
;tree "5Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
;tree.end

base ad:0x80008038
;tree "5Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
;tree.end

base ad:0x8000803c
;tree "5Mask0"
group 0--3
line.long 0 "Mask0"
;tree.end

base ad:0x80008040
;tree "5Mask1"
group 0--3
line.long 0 "Mask1"
;tree.end

base ad:0x80008044
;tree "5CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80008048
;tree "5FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

base ad:0x80008080
;tree "5Fifo"
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
;tree.end

base ad:0x800080c0
;tree "5DBtimer"
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

base ad:0x800080c4
;tree "5TRSCA"
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
;tree.end

base ad:0x80008fe0
;tree "5PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80008fe4
;tree "5PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80008fe8
;tree "5PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80008fec
;tree "5PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80008ff0
;tree "5PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

base ad:0x80008ff4
;tree "5PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

base ad:0x80008ff8
;tree "5PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

base ad:0x80008ffc
;tree "5PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "MSP (4 instances)"
;==============================================================
base ad:0x80123000
;********************************************
tree "MSP-0"
;********************************************
base ad:0x80123000
;tree "0DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123004
;tree "0GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
;tree.end

base ad:0x80123008
;tree "0TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012300c
;tree "0RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80123010
;tree "0SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
;tree.end

base ad:0x80123014
;tree "0FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
;tree.end

base ad:0x80123018
;tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
;tree.end

base ad:0x8012301c
;tree "0WMRK"
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
;tree.end

base ad:0x80123020
;tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
;tree.end

base ad:0x80123024
;tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
;tree.end

base ad:0x80123028
;tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
;tree.end

base ad:0x8012302c
;tree "0ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
;tree.end

base ad:0x80123030
;tree "0MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80123034
;tree "0RCV"
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
;tree.end

base ad:0x80123038
;tree "0RCM"
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
;tree.end

base ad:0x80123040
;tree "0TCE0"
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
;tree.end

base ad:0x80123044
;tree "0TCE1"
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
;tree.end

base ad:0x80123048
;tree "0TCE2"
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
;tree.end

base ad:0x8012304c
;tree "0TCE3"
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
;tree.end

base ad:0x80123060
;tree "0RCE0"
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
;tree.end

base ad:0x80123064
;tree "0RCE1"
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
;tree.end

base ad:0x80123068
;tree "0RCE2"
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
;tree.end

base ad:0x8012306c
;tree "0RCE3"
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
;tree.end

base ad:0x80123070
;tree "0IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80123080
;tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

base ad:0x80123084
;tree "0ITIP"
group 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123088
;tree "0ITOP"
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8012308c
;tree "0TSTDR"
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123fe0
;tree "0PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123fe4
;tree "0PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123fe8
;tree "0PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123fec
;tree "0PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123ff0
;tree "0PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123ff4
;tree "0PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123ff8
;tree "0PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80123ffc
;tree "0PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
;tree.end

tree.end

base ad:0x80124000
;********************************************
tree "MSP-1"
;********************************************
base ad:0x80124000
;tree "1DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124004
;tree "1GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
;tree.end

base ad:0x80124008
;tree "1TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012400c
;tree "1RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80124010
;tree "1SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
;tree.end

base ad:0x80124014
;tree "1FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
;tree.end

base ad:0x80124018
;tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
;tree.end

base ad:0x8012401c
;tree "1WMRK"
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
;tree.end

base ad:0x80124020
;tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
;tree.end

base ad:0x80124024
;tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
;tree.end

base ad:0x80124028
;tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
;tree.end

base ad:0x8012402c
;tree "1ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
;tree.end

base ad:0x80124030
;tree "1MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80124034
;tree "1RCV"
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
;tree.end

base ad:0x80124038
;tree "1RCM"
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
;tree.end

base ad:0x80124040
;tree "1TCE0"
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
;tree.end

base ad:0x80124044
;tree "1TCE1"
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
;tree.end

base ad:0x80124048
;tree "1TCE2"
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
;tree.end

base ad:0x8012404c
;tree "1TCE3"
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
;tree.end

base ad:0x80124060
;tree "1RCE0"
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
;tree.end

base ad:0x80124064
;tree "1RCE1"
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
;tree.end

base ad:0x80124068
;tree "1RCE2"
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
;tree.end

base ad:0x8012406c
;tree "1RCE3"
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
;tree.end

base ad:0x80124070
;tree "1IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80124080
;tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

base ad:0x80124084
;tree "1ITIP"
group 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124088
;tree "1ITOP"
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8012408c
;tree "1TSTDR"
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124fe0
;tree "1PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124fe4
;tree "1PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124fe8
;tree "1PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124fec
;tree "1PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124ff0
;tree "1PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124ff4
;tree "1PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124ff8
;tree "1PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80124ffc
;tree "1PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
;tree.end

tree.end

base ad:0x80125000
;********************************************
tree "MSP-3"
;********************************************
base ad:0x80125000
;tree "3DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80125004
;tree "3GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
;tree.end

base ad:0x80125008
;tree "3TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012500c
;tree "3RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80125010
;tree "3SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
;tree.end

base ad:0x80125014
;tree "3FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
;tree.end

base ad:0x80125018
;tree "3DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
;tree.end

base ad:0x8012501c
;tree "3WMRK"
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
;tree.end

base ad:0x80125020
;tree "3IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
;tree.end

base ad:0x80125024
;tree "3RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
;tree.end

base ad:0x80125028
;tree "3MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
;tree.end

base ad:0x8012502c
;tree "3ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
;tree.end

base ad:0x80125030
;tree "3MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80125034
;tree "3RCV"
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
;tree.end

base ad:0x80125038
;tree "3RCM"
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
;tree.end

base ad:0x80125040
;tree "3TCE0"
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
;tree.end

base ad:0x80125044
;tree "3TCE1"
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
;tree.end

base ad:0x80125048
;tree "3TCE2"
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
;tree.end

base ad:0x8012504c
;tree "3TCE3"
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
;tree.end

base ad:0x80125060
;tree "3RCE0"
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
;tree.end

base ad:0x80125064
;tree "3RCE1"
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
;tree.end

base ad:0x80125068
;tree "3RCE2"
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
;tree.end

base ad:0x8012506c
;tree "3RCE3"
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
;tree.end

base ad:0x80125070
;tree "3IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80125080
;tree "3ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

base ad:0x80125084
;tree "3ITIP"
group 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80125088
;tree "3ITOP"
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8012508c
;tree "3TSTDR"
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80125fe0
;tree "3PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80125fe4
;tree "3PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80125fe8
;tree "3PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80125fec
;tree "3PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80125ff0
;tree "3PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80125ff4
;tree "3PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80125ff8
;tree "3PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80125ffc
;tree "3PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
;tree.end

tree.end

base ad:0x80117000
;********************************************
tree "MSP-2"
;********************************************
base ad:0x80117000
;tree "2DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117004
;tree "2GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
;tree.end

base ad:0x80117008
;tree "2TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8011700c
;tree "2RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80117010
;tree "2SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
;tree.end

base ad:0x80117014
;tree "2FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
;tree.end

base ad:0x80117018
;tree "2DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
;tree.end

base ad:0x8011701c
;tree "2WMRK"
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
;tree.end

base ad:0x80117020
;tree "2IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
;tree.end

base ad:0x80117024
;tree "2RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
;tree.end

base ad:0x80117028
;tree "2MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
;tree.end

base ad:0x8011702c
;tree "2ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
;tree.end

base ad:0x80117030
;tree "2MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80117034
;tree "2RCV"
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
;tree.end

base ad:0x80117038
;tree "2RCM"
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
;tree.end

base ad:0x80117040
;tree "2TCE0"
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
;tree.end

base ad:0x80117044
;tree "2TCE1"
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
;tree.end

base ad:0x80117048
;tree "2TCE2"
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
;tree.end

base ad:0x8011704c
;tree "2TCE3"
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
;tree.end

base ad:0x80117060
;tree "2RCE0"
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
;tree.end

base ad:0x80117064
;tree "2RCE1"
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
;tree.end

base ad:0x80117068
;tree "2RCE2"
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
;tree.end

base ad:0x8011706c
;tree "2RCE3"
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
;tree.end

base ad:0x80117070
;tree "2IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80117080
;tree "2ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

base ad:0x80117084
;tree "2ITIP"
group 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117088
;tree "2ITOP"
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8011708c
;tree "2TSTDR"
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117fe0
;tree "2PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117fe4
;tree "2PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117fe8
;tree "2PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117fec
;tree "2PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117ff0
;tree "2PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117ff4
;tree "2PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117ff8
;tree "2PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
;tree.end

base ad:0x80117ffc
;tree "2PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
;tree.end

tree.end

tree.end

;==============================================================
tree "MSSCSTF"
;==============================================================
base ad:0xb7a04000
;tree "CSTFCONTROLREG"
group 0--3
line.long 0 "CSTFCONTROLREG"
bitfld.long 0 0. " EnS0 "  "0 ,1 "
bitfld.long 0 1. " EnS1 "  "0 ,1 "
bitfld.long 0 2. " EnS2 "  "0 ,1 "
bitfld.long 0 3. " EnS3 "  "0 ,1 "
bitfld.long 0 4. " EnS4 "  "0 ,1 "
bitfld.long 0 5. " EnS5 "  "0 ,1 "
bitfld.long 0 6. " EnS6 "  "0 ,1 "
bitfld.long 0 7. " EnS7 "  "0 ,1 "
bitfld.long 0 8.--11. " HT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a04004
;tree "CSTFPRIORCNTRLREG"
group 0--3
line.long 0 "CSTFPRIORCNTRLREG"
bitfld.long 0 0.--2. " PriPort0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " PriPort1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--8. " PriPort2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9.--11. " PriPort3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " PriPort4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 15.--17. " PriPort5 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 18.--20. " PriPort6 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 21.--23. " PriPort7 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xb7a04eec
;tree "ITATBDATA0"
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ATDATA0 "  "0 ,1 "
bitfld.long 0 1. " ATDATA7 "  "0 ,1 "
bitfld.long 0 2. " ATDATA15 "  "0 ,1 "
bitfld.long 0 3. " ATDATA23 "  "0 ,1 "
bitfld.long 0 4. " ATDATA31 "  "0 ,1 "
;tree.end

base ad:0xb7a04ef0
;tree "ITATBCTR2"
group 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ATREADY "  "0 ,1 "
bitfld.long 0 1. " AFVALID "  "0 ,1 "
;tree.end

base ad:0xb7a04ef4
;tree "ITATBCTR1"
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0.--6. " ATID "  " "
;tree.end

base ad:0xb7a04ef8
;tree "ITATBCTR0"
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ATVALID "  "0 ,1 "
bitfld.long 0 1. " AFREADYS "  "0 ,1 "
bitfld.long 0 8.--9. " ATBYTES "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a04f00
;tree "IMCR"
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " IMCR "  "0 ,1 "
;tree.end

base ad:0xb7a04fa0
;tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a04fa4
;tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a04fb0
;tree "LAR"
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

base ad:0xb7a04fb4
;tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a04fb8
;tree "ASR"
rgroup 0--3
line.long 0 "ASR"
hexfld.byte 0 " ASR "
;tree.end

base ad:0xb7a04fc8
;tree "DID"
rgroup 0--3
line.long 0 "DID"
hexfld.byte 0 " DID "
;tree.end

base ad:0xb7a04fcc
;tree "DTIR"
rgroup 0--3
line.long 0 "DTIR"
hexfld.byte 0 " DTIR "
;tree.end

base ad:0xb7a04fd0
;tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

base ad:0xb7a04fd4
;tree "PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

base ad:0xb7a04fd8
;tree "PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

base ad:0xb7a04fdc
;tree "PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

base ad:0xb7a04fe0
;tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

base ad:0xb7a04fe4
;tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

base ad:0xb7a04fe8
;tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

base ad:0xb7a04fec
;tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

base ad:0xb7a04ff0
;tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

base ad:0xb7a04ff4
;tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

base ad:0xb7a04ff8
;tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

base ad:0xb7a04ffc
;tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

;==============================================================
tree "MSSCTI (4 instances)"
;==============================================================
base ad:0xb7a02000
;********************************************
tree "MSSCTI-CS"
;********************************************
base ad:0xb7a02000
;tree "CSCTICONTROL"
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
;tree.end

base ad:0xb7a02010
;tree "CSCTIINTACK"
wgroup 0--3
line.long 0 "CTIINTACK"
hexfld.byte 0 " INTACK "
;tree.end

base ad:0xb7a02014
;tree "CSCTIAPPSET"
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02018
;tree "CSCTIAPPCLEAR"
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0201c
;tree "CSCTIAPPPULSE"
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02020
;tree "CSCTIINEN0"
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02024
;tree "CSCTIINEN1"
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02028
;tree "CSCTIINEN2"
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0202c
;tree "CSCTIINEN3"
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02030
;tree "CSCTIINEN4"
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02034
;tree "CSCTIINEN5"
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02038
;tree "CSCTIINEN6"
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0203c
;tree "CSCTIINEN7"
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a020a0
;tree "CSCTIOUTEN0"
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a020a4
;tree "CSCTIOUTEN1"
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a020a8
;tree "CSCTIOUTEN2"
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a020ac
;tree "CSCTIOUTEN3"
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a020b0
;tree "CSCTIOUTEN4"
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a020b4
;tree "CSCTIOUTEN5"
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a020b8
;tree "CSCTIOUTEN6"
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a020bc
;tree "CSCTIOUTEN7"
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02130
;tree "CSCTITRIGINSTATUS"
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
hexfld.byte 0 " TRIGINSTATUS "
;tree.end

base ad:0xb7a02134
;tree "CSCTITRIGOUTSTATUS"
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
hexfld.byte 0 " TRIGOUTSTATUS "
;tree.end

base ad:0xb7a02138
;tree "CSCTICHINSTATUS"
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0213c
;tree "CSCTICHOUTSTATUS"
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02140
;tree "CSCTIGATE"
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
;tree.end

base ad:0xb7a02144
;tree "CSASICCTL"
group 0--3
line.long 0 "ASICCTL"
hexfld.byte 0 " ASICCTL "
;tree.end

base ad:0xb7a02edc
;tree "CSITCHINACK"
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02ee0
;tree "CSITTRIGINACK"
wgroup 0--3
line.long 0 "ITTRIGINACK"
hexfld.byte 0 " CTTRIGINACK "
;tree.end

base ad:0xb7a02ee4
;tree "CSITCHOUT"
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02ee8
;tree "CSITTRFLIN"
wgroup 0--3
line.long 0 "ITTRFLIN"
hexfld.byte 0 " CTTRIGOUT "
;tree.end

base ad:0xb7a02eec
;tree "CSITCHOUTACK"
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02ef0
;tree "CSITTRIGOUTACK"
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
hexfld.byte 0 " CTTRIGOUTACK "
;tree.end

base ad:0xb7a02ef4
;tree "CSITCHIN"
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02ef8
;tree "CSITRIGIN"
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
;tree.end

base ad:0xb7a02fa0
;tree "CSCTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02fa4
;tree "CSCTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02fb0
;tree "CSLAR"
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

base ad:0xb7a02fb4
;tree "CSLSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a02fb8
;tree "CSASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a02fc8
;tree "CSDID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
;tree.end

base ad:0xb7a02fcc
;tree "CSDTIR"
rgroup 0--3
line.long 0 "DTIR"
hexfld.byte 0 " DTIR "
;tree.end

base ad:0xb7a02fd0
;tree "CSPERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

base ad:0xb7a02fd4
;tree "CSPERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

base ad:0xb7a02fd8
;tree "CSPERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

base ad:0xb7a02fdc
;tree "CSPERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

base ad:0xb7a02fe0
;tree "CSPERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

base ad:0xb7a02fe4
;tree "CSPERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

base ad:0xb7a02fe8
;tree "CSPERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

base ad:0xb7a02fec
;tree "CSPERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

base ad:0xb7a02ff0
;tree "CSCOMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

base ad:0xb7a02ff4
;tree "CSCOMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

base ad:0xb7a02ff8
;tree "CSCOMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

base ad:0xb7a02ffc
;tree "CSCOMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

base ad:0xb7a09000
;********************************************
tree "MSSCTI-L1CTI"
;********************************************
base ad:0xb7a09000
;tree "L1CTICTICONTROL"
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
;tree.end

base ad:0xb7a09010
;tree "L1CTICTIINTACK"
wgroup 0--3
line.long 0 "CTIINTACK"
hexfld.byte 0 " INTACK "
;tree.end

base ad:0xb7a09014
;tree "L1CTICTIAPPSET"
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09018
;tree "L1CTICTIAPPCLEAR"
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0901c
;tree "L1CTICTIAPPPULSE"
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09020
;tree "L1CTICTIINEN0"
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09024
;tree "L1CTICTIINEN1"
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09028
;tree "L1CTICTIINEN2"
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0902c
;tree "L1CTICTIINEN3"
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09030
;tree "L1CTICTIINEN4"
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09034
;tree "L1CTICTIINEN5"
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09038
;tree "L1CTICTIINEN6"
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0903c
;tree "L1CTICTIINEN7"
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a090a0
;tree "L1CTICTIOUTEN0"
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a090a4
;tree "L1CTICTIOUTEN1"
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a090a8
;tree "L1CTICTIOUTEN2"
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a090ac
;tree "L1CTICTIOUTEN3"
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a090b0
;tree "L1CTICTIOUTEN4"
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a090b4
;tree "L1CTICTIOUTEN5"
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a090b8
;tree "L1CTICTIOUTEN6"
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a090bc
;tree "L1CTICTIOUTEN7"
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09130
;tree "L1CTICTITRIGINSTATUS"
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
hexfld.byte 0 " TRIGINSTATUS "
;tree.end

base ad:0xb7a09134
;tree "L1CTICTITRIGOUTSTATUS"
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
hexfld.byte 0 " TRIGOUTSTATUS "
;tree.end

base ad:0xb7a09138
;tree "L1CTICTICHINSTATUS"
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0913c
;tree "L1CTICTICHOUTSTATUS"
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09140
;tree "L1CTICTIGATE"
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
;tree.end

base ad:0xb7a09144
;tree "L1CTIASICCTL"
group 0--3
line.long 0 "ASICCTL"
hexfld.byte 0 " ASICCTL "
;tree.end

base ad:0xb7a09edc
;tree "L1CTIITCHINACK"
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09ee0
;tree "L1CTIITTRIGINACK"
wgroup 0--3
line.long 0 "ITTRIGINACK"
hexfld.byte 0 " CTTRIGINACK "
;tree.end

base ad:0xb7a09ee4
;tree "L1CTIITCHOUT"
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09ee8
;tree "L1CTIITTRFLIN"
wgroup 0--3
line.long 0 "ITTRFLIN"
hexfld.byte 0 " CTTRIGOUT "
;tree.end

base ad:0xb7a09eec
;tree "L1CTIITCHOUTACK"
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09ef0
;tree "L1CTIITTRIGOUTACK"
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
hexfld.byte 0 " CTTRIGOUTACK "
;tree.end

base ad:0xb7a09ef4
;tree "L1CTIITCHIN"
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09ef8
;tree "L1CTIITRIGIN"
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
;tree.end

base ad:0xb7a09fa0
;tree "L1CTICTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09fa4
;tree "L1CTICTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09fb0
;tree "L1CTILAR"
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

base ad:0xb7a09fb4
;tree "L1CTILSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a09fb8
;tree "L1CTIASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a09fc8
;tree "L1CTIDID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
;tree.end

base ad:0xb7a09fcc
;tree "L1CTIDTIR"
rgroup 0--3
line.long 0 "DTIR"
hexfld.byte 0 " DTIR "
;tree.end

base ad:0xb7a09fd0
;tree "L1CTIPERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

base ad:0xb7a09fd4
;tree "L1CTIPERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

base ad:0xb7a09fd8
;tree "L1CTIPERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

base ad:0xb7a09fdc
;tree "L1CTIPERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

base ad:0xb7a09fe0
;tree "L1CTIPERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

base ad:0xb7a09fe4
;tree "L1CTIPERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

base ad:0xb7a09fe8
;tree "L1CTIPERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

base ad:0xb7a09fec
;tree "L1CTIPERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

base ad:0xb7a09ff0
;tree "L1CTICOMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

base ad:0xb7a09ff4
;tree "L1CTICOMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

base ad:0xb7a09ff8
;tree "L1CTICOMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

base ad:0xb7a09ffc
;tree "L1CTICOMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

base ad:0xb7a0c000
;********************************************
tree "MSSCTI-L2CTI"
;********************************************
base ad:0xb7a0c000
;tree "L2CTICTICONTROL"
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
;tree.end

base ad:0xb7a0c010
;tree "L2CTICTIINTACK"
wgroup 0--3
line.long 0 "CTIINTACK"
hexfld.byte 0 " INTACK "
;tree.end

base ad:0xb7a0c014
;tree "L2CTICTIAPPSET"
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c018
;tree "L2CTICTIAPPCLEAR"
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c01c
;tree "L2CTICTIAPPPULSE"
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c020
;tree "L2CTICTIINEN0"
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c024
;tree "L2CTICTIINEN1"
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c028
;tree "L2CTICTIINEN2"
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c02c
;tree "L2CTICTIINEN3"
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c030
;tree "L2CTICTIINEN4"
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c034
;tree "L2CTICTIINEN5"
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c038
;tree "L2CTICTIINEN6"
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c03c
;tree "L2CTICTIINEN7"
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c0a0
;tree "L2CTICTIOUTEN0"
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c0a4
;tree "L2CTICTIOUTEN1"
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c0a8
;tree "L2CTICTIOUTEN2"
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c0ac
;tree "L2CTICTIOUTEN3"
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c0b0
;tree "L2CTICTIOUTEN4"
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c0b4
;tree "L2CTICTIOUTEN5"
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c0b8
;tree "L2CTICTIOUTEN6"
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c0bc
;tree "L2CTICTIOUTEN7"
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c130
;tree "L2CTICTITRIGINSTATUS"
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
hexfld.byte 0 " TRIGINSTATUS "
;tree.end

base ad:0xb7a0c134
;tree "L2CTICTITRIGOUTSTATUS"
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
hexfld.byte 0 " TRIGOUTSTATUS "
;tree.end

base ad:0xb7a0c138
;tree "L2CTICTICHINSTATUS"
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c13c
;tree "L2CTICTICHOUTSTATUS"
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0c140
;tree "L2CTICTIGATE"
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
;tree.end

base ad:0xb7a0c144
;tree "L2CTIASICCTL"
group 0--3
line.long 0 "ASICCTL"
hexfld.byte 0 " ASICCTL "
;tree.end

base ad:0xb7a0cedc
;tree "L2CTIITCHINACK"
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0cee0
;tree "L2CTIITTRIGINACK"
wgroup 0--3
line.long 0 "ITTRIGINACK"
hexfld.byte 0 " CTTRIGINACK "
;tree.end

base ad:0xb7a0cee4
;tree "L2CTIITCHOUT"
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0cee8
;tree "L2CTIITTRFLIN"
wgroup 0--3
line.long 0 "ITTRFLIN"
hexfld.byte 0 " CTTRIGOUT "
;tree.end

base ad:0xb7a0ceec
;tree "L2CTIITCHOUTACK"
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0cef0
;tree "L2CTIITTRIGOUTACK"
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
hexfld.byte 0 " CTTRIGOUTACK "
;tree.end

base ad:0xb7a0cef4
;tree "L2CTIITCHIN"
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0cef8
;tree "L2CTIITRIGIN"
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
;tree.end

base ad:0xb7a0cfa0
;tree "L2CTICTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0cfa4
;tree "L2CTICTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0cfb0
;tree "L2CTILAR"
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

base ad:0xb7a0cfb4
;tree "L2CTILSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a0cfb8
;tree "L2CTIASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0cfc8
;tree "L2CTIDID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
;tree.end

base ad:0xb7a0cfcc
;tree "L2CTIDTIR"
rgroup 0--3
line.long 0 "DTIR"
hexfld.byte 0 " DTIR "
;tree.end

base ad:0xb7a0cfd0
;tree "L2CTIPERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

base ad:0xb7a0cfd4
;tree "L2CTIPERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

base ad:0xb7a0cfd8
;tree "L2CTIPERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

base ad:0xb7a0cfdc
;tree "L2CTIPERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

base ad:0xb7a0cfe0
;tree "L2CTIPERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

base ad:0xb7a0cfe4
;tree "L2CTIPERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

base ad:0xb7a0cfe8
;tree "L2CTIPERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

base ad:0xb7a0cfec
;tree "L2CTIPERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

base ad:0xb7a0cff0
;tree "L2CTICOMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

base ad:0xb7a0cff4
;tree "L2CTICOMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

base ad:0xb7a0cff8
;tree "L2CTICOMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

base ad:0xb7a0cffc
;tree "L2CTICOMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

base ad:0xb7a0d000
;********************************************
tree "MSSCTI-MSS"
;********************************************
base ad:0xb7a0d000
;tree "MSSCTICONTROL"
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
;tree.end

base ad:0xb7a0d010
;tree "MSSCTIINTACK"
wgroup 0--3
line.long 0 "CTIINTACK"
hexfld.byte 0 " INTACK "
;tree.end

base ad:0xb7a0d014
;tree "MSSCTIAPPSET"
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d018
;tree "MSSCTIAPPCLEAR"
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d01c
;tree "MSSCTIAPPPULSE"
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d020
;tree "MSSCTIINEN0"
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d024
;tree "MSSCTIINEN1"
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d028
;tree "MSSCTIINEN2"
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d02c
;tree "MSSCTIINEN3"
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d030
;tree "MSSCTIINEN4"
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d034
;tree "MSSCTIINEN5"
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d038
;tree "MSSCTIINEN6"
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d03c
;tree "MSSCTIINEN7"
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d0a0
;tree "MSSCTIOUTEN0"
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d0a4
;tree "MSSCTIOUTEN1"
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d0a8
;tree "MSSCTIOUTEN2"
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d0ac
;tree "MSSCTIOUTEN3"
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d0b0
;tree "MSSCTIOUTEN4"
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d0b4
;tree "MSSCTIOUTEN5"
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d0b8
;tree "MSSCTIOUTEN6"
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d0bc
;tree "MSSCTIOUTEN7"
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d130
;tree "MSSCTITRIGINSTATUS"
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
hexfld.byte 0 " TRIGINSTATUS "
;tree.end

base ad:0xb7a0d134
;tree "MSSCTITRIGOUTSTATUS"
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
hexfld.byte 0 " TRIGOUTSTATUS "
;tree.end

base ad:0xb7a0d138
;tree "MSSCTICHINSTATUS"
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d13c
;tree "MSSCTICHOUTSTATUS"
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0d140
;tree "MSSCTIGATE"
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
;tree.end

base ad:0xb7a0d144
;tree "MSSASICCTL"
group 0--3
line.long 0 "ASICCTL"
hexfld.byte 0 " ASICCTL "
;tree.end

base ad:0xb7a0dedc
;tree "MSSITCHINACK"
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0dee0
;tree "MSSITTRIGINACK"
wgroup 0--3
line.long 0 "ITTRIGINACK"
hexfld.byte 0 " CTTRIGINACK "
;tree.end

base ad:0xb7a0dee4
;tree "MSSITCHOUT"
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0dee8
;tree "MSSITTRFLIN"
wgroup 0--3
line.long 0 "ITTRFLIN"
hexfld.byte 0 " CTTRIGOUT "
;tree.end

base ad:0xb7a0deec
;tree "MSSITCHOUTACK"
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0def0
;tree "MSSITTRIGOUTACK"
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
hexfld.byte 0 " CTTRIGOUTACK "
;tree.end

base ad:0xb7a0def4
;tree "MSSITCHIN"
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0def8
;tree "MSSITRIGIN"
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
;tree.end

base ad:0xb7a0dfa0
;tree "MSSCTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0dfa4
;tree "MSSCTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0dfb0
;tree "MSSLAR"
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

base ad:0xb7a0dfb4
;tree "MSSLSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a0dfb8
;tree "MSSASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a0dfc8
;tree "MSSDID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
;tree.end

base ad:0xb7a0dfcc
;tree "MSSDTIR"
rgroup 0--3
line.long 0 "DTIR"
hexfld.byte 0 " DTIR "
;tree.end

base ad:0xb7a0dfd0
;tree "MSSPERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

base ad:0xb7a0dfd4
;tree "MSSPERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

base ad:0xb7a0dfd8
;tree "MSSPERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

base ad:0xb7a0dfdc
;tree "MSSPERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

base ad:0xb7a0dfe0
;tree "MSSPERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

base ad:0xb7a0dfe4
;tree "MSSPERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

base ad:0xb7a0dfe8
;tree "MSSPERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

base ad:0xb7a0dfec
;tree "MSSPERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

base ad:0xb7a0dff0
;tree "MSSCOMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

base ad:0xb7a0dff4
;tree "MSSCOMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

base ad:0xb7a0dff8
;tree "MSSCOMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

base ad:0xb7a0dffc
;tree "MSSCOMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "MSSETB11"
;==============================================================
base ad:0xb7a01004
;tree "RAM_DEPTH"
rgroup 0--3
line.long 0 "RAM_DEPTH"
hexfld.long 0 " RDP "
;tree.end

base ad:0xb7a0100c
;tree "STATUS"
rgroup 0--3
line.long 0 "STATUS"
bitfld.long 0 0. " FULL "  "0 ,1 "
bitfld.long 0 1. " TRIGGERED "  "0 ,1 "
bitfld.long 0 2. " ACQCOMP "  "0 ,1 "
bitfld.long 0 3. " FTEMPTY "  "0 ,1 "
;tree.end

base ad:0xb7a01010
;tree "RAM_DATA"
group 0--3
line.long 0 "RAM_DATA"
hexfld.long 0 " RAM_READ_DATA "
;tree.end

base ad:0xb7a01014
;tree "RAM_READ_POINTER"
group 0--3
line.long 0 "RAM_READ_POINTER"
bitfld.long 0 0.--1. " RAM_READ_POINTER "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a01018
;tree "RAM_WRITE_POINTER"
group 0--3
line.long 0 "RAM_WRITE_POINTER"
bitfld.long 0 0.--1. " RAM_WRITE_POINTER "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a0101c
;tree "TRIGGER_COUNTER"
group 0--3
line.long 0 "TRIGGER_COUNTER"
bitfld.long 0 0.--1. " TRIGGER_COUNTER "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a01020
;tree "CONTROL"
group 0--3
line.long 0 "CONTROL"
bitfld.long 0 0. " TRACECAPTEN "  "0 ,1 "
;tree.end

base ad:0xb7a01024
;tree "RAM_WRITE"
wgroup 0--3
line.long 0 "RAM_WRITE"
hexfld.long 0 " RAM_WRITE_DATA "
;tree.end

base ad:0xb7a01300
;tree "FFSR"
rgroup 0--3
line.long 0 "FFSR"
bitfld.long 0 0. " FLINPROG "  "0 ,1 "
bitfld.long 0 1. " FTSTOPPED "  "0 ,1 "
;tree.end

base ad:0xb7a01304
;tree "DESCRIPTION"
group 0--3
line.long 0 "DESCRIPTION"
bitfld.long 0 0. " ENFTC "  "0 ,1 "
bitfld.long 0 1. " ENFCONT "  "0 ,1 "
bitfld.long 0 4. " FONFLIN "  "0 ,1 "
bitfld.long 0 5. " FONTRIG "  "0 ,1 "
bitfld.long 0 6. " FONMAN "  "0 ,1 "
bitfld.long 0 8. " TRIGIN "  "0 ,1 "
bitfld.long 0 9. " TRIGEVT "  "0 ,1 "
bitfld.long 0 10. " TRGFL "  "0 ,1 "
bitfld.long 0 12. " STOPFL "  "0 ,1 "
bitfld.long 0 13. " STOPTRIG "  "0 ,1 "
;tree.end

base ad:0xb7a01ee0
;tree "ITMISCOP0"
group 0--3
line.long 0 "ITMISCOP0"
bitfld.long 0 0. " ACQCOMP "  "0 ,1 "
bitfld.long 0 1. " FULL "  "0 ,1 "
;tree.end

base ad:0xb7a01ee4
;tree "ITTRFLINACK"
group 0--3
line.long 0 "ITTRFLINACK"
bitfld.long 0 0. " TRIGNACK "  "0 ,1 "
bitfld.long 0 1. " FLUSHINACK "  "0 ,1 "
;tree.end

base ad:0xb7a01ee8
;tree "ITTRFLIN"
group 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0. " TRIGIN "  "0 ,1 "
bitfld.long 0 1. " FLUSHIN "  "0 ,1 "
;tree.end

base ad:0xb7a01eec
;tree "ITATBDATA0"
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ATDATA0 "  "0 ,1 "
bitfld.long 0 1. " ATDATA7 "  "0 ,1 "
bitfld.long 0 2. " ATDATA15 "  "0 ,1 "
bitfld.long 0 3. " ATDATA23 "  "0 ,1 "
bitfld.long 0 4. " ATDATA31 "  "0 ,1 "
;tree.end

base ad:0xb7a01ef0
;tree "ITATBCTR2"
group 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ATREADYS "  "0 ,1 "
bitfld.long 0 1. " AFVALIDS "  "0 ,1 "
;tree.end

base ad:0xb7a01ef4
;tree "ITATBCTR1"
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0.--6. " ATID "  " "
;tree.end

base ad:0xb7a01ef8
;tree "ITATBCTR0"
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ATVALID "  "0 ,1 "
bitfld.long 0 1. " AFREADY "  "0 ,1 "
bitfld.long 0 8.--9. " ATBYTES "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a01f00
;tree "IMCR"
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " IMCR "  "0 ,1 "
;tree.end

base ad:0xb7a01fa0
;tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0. " CTSR "  "0 ,1 "
;tree.end

base ad:0xb7a01fa4
;tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0. " CTCR "  "0 ,1 "
;tree.end

base ad:0xb7a01fb0
;tree "LAR"
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

base ad:0xb7a01fb4
;tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a01fb8
;tree "ASR"
rgroup 0--3
line.long 0 "ASR"
hexfld.byte 0 " ASR "
;tree.end

base ad:0xb7a01fc8
;tree "DID"
rgroup 0--3
line.long 0 "DID"
hexfld.long 0 " DID "
;tree.end

base ad:0xb7a01fcc
;tree "DTIR"
rgroup 0--3
line.long 0 "DTIR"
hexfld.byte 0 " DTIR "
;tree.end

base ad:0xb7a01fd0
;tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

base ad:0xb7a01fd4
;tree "PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
hexfld.byte 0 " PERIPHERAL_ID5 "
;tree.end

base ad:0xb7a01fd8
;tree "PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
hexfld.byte 0 " PERIPHERAL_ID6 "
;tree.end

base ad:0xb7a01fdc
;tree "PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
hexfld.byte 0 " PERIPHERAL_ID7 "
;tree.end

base ad:0xb7a01fe0
;tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

base ad:0xb7a01fe4
;tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

base ad:0xb7a01fe8
;tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

base ad:0xb7a01fec
;tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

base ad:0xb7a01ff0
;tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
hexfld.byte 0 " COMPONENT_ID0 "
;tree.end

base ad:0xb7a01ff4
;tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

base ad:0xb7a01ff8
;tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

base ad:0xb7a01ffc
;tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

;==============================================================
tree "MSSETM11CS (2 instances)"
;==============================================================
base ad:0xb7a08000
;********************************************
tree "MSSETM11CS-1"
;********************************************
base ad:0xb7a08000
;tree "1ETMCR"
group 0--3
line.long 0 "ETMCR"
bitfld.long 0 0. " ETMCR "  "0 ,1 "
;tree.end

base ad:0xb7a08004
;tree "1ETMCCR"
rgroup 0--3
line.long 0 "ETMCCR"
bitfld.long 0 0. " ETMCCR "  "0 ,1 "
;tree.end

base ad:0xb7a08008
;tree "1ETMTRIGGER"
wgroup 0--3
line.long 0 "ETMTRIGGER"
bitfld.long 0 0. " ETMTRIGGER "  "0 ,1 "
;tree.end

base ad:0xb7a0800c
;tree "1ETMASICCTLR"
wgroup 0--3
line.long 0 "ETMASICCTLR"
bitfld.long 0 0. " ETMASICCTLR "  "0 ,1 "
;tree.end

base ad:0xb7a08010
;tree "1ETMSR"
group 0--3
line.long 0 "ETMSR"
bitfld.long 0 0. " STATUS "  "0 ,1 "
;tree.end

base ad:0xb7a08014
;tree "1SYSCONFIG"
group 0--3
line.long 0 "SYSCONFIG"
bitfld.long 0 0. " SYSCONFIG "  "0 ,1 "
;tree.end

base ad:0xb7a08018
;tree "1TRACEENSTARTSTOP"
wgroup 0--3
line.long 0 "TRACEENSTARTSTOP"
bitfld.long 0 0. " TRACEENSTARTSTOP "  "0 ,1 "
;tree.end

base ad:0xb7a0801c
;tree "1TRACEENCTRL2"
wgroup 0--3
line.long 0 "TRACEENCTRL2"
bitfld.long 0 0. " TRACEENCTRL2 "  "0 ,1 "
;tree.end

base ad:0xb7a08020
;tree "1TRACEENEVENT"
wgroup 0--3
line.long 0 "TRACEENEVENT"
bitfld.long 0 0. " TRACEENEVENT "  "0 ,1 "
;tree.end

base ad:0xb7a08024
;tree "1TRACEENCTRL1"
wgroup 0--3
line.long 0 "TRACEENCTRL1"
bitfld.long 0 0. " TRACEENCTRL1 "  "0 ,1 "
;tree.end

base ad:0xb7a08028
;tree "1FIFOFULLREGION"
wgroup 0--3
line.long 0 "FIFOFULLREGION"
bitfld.long 0 0. " FIFOFULLREGION "  "0 ,1 "
;tree.end

base ad:0xb7a0802c
;tree "1FIFOFULLLEVEL"
group 0--3
line.long 0 "FIFOFULLLEVEL"
bitfld.long 0 0. " FIFOFULLLEVEL "  "0 ,1 "
;tree.end

base ad:0xb7a08030
;tree "1VIEWDATAEVENT"
wgroup 0--3
line.long 0 "VIEWDATAEVENT"
bitfld.long 0 0. " VIEWDATAEVENT "  "0 ,1 "
;tree.end

base ad:0xb7a08034
;tree "1VIEWDATACTRL1"
wgroup 0--3
line.long 0 "VIEWDATACTRL1"
bitfld.long 0 0. " VIEWDATACTRL1 "  "0 ,1 "
;tree.end

base ad:0xb7a08038
;tree "1VIEWDATACTRL2"
wgroup 0--3
line.long 0 "VIEWDATACTRL2"
bitfld.long 0 0. " VIEWDATACTRL2 "  "0 ,1 "
;tree.end

base ad:0xb7a0803c
;tree "1VIEWDATACTRL3"
wgroup 0--3
line.long 0 "VIEWDATACTRL3"
bitfld.long 0 0. " VIEWDATACTRL3 "  "0 ,1 "
;tree.end

base ad:0xb7a08040
;tree "1ADDRCOMP0"
wgroup 0--3
line.long 0 "ADDRCOMP0"
bitfld.long 0 0. " ADDRCOMP0 "  "0 ,1 "
;tree.end

base ad:0xb7a08044
;tree "1ADDRCOMP1"
wgroup 0--3
line.long 0 "ADDRCOMP1"
bitfld.long 0 0. " ADDRCOMP1 "  "0 ,1 "
;tree.end

base ad:0xb7a08048
;tree "1ADDRCOMP2"
wgroup 0--3
line.long 0 "ADDRCOMP2"
bitfld.long 0 0. " ADDRCOMP2 "  "0 ,1 "
;tree.end

base ad:0xb7a0804c
;tree "1ADDRCOMP3"
wgroup 0--3
line.long 0 "ADDRCOMP3"
bitfld.long 0 0. " ADDRCOMP3 "  "0 ,1 "
;tree.end

base ad:0xb7a08050
;tree "1ADDRCOMP4"
wgroup 0--3
line.long 0 "ADDRCOMP4"
bitfld.long 0 0. " ADDRCOMP4 "  "0 ,1 "
;tree.end

base ad:0xb7a08054
;tree "1ADDRCOMP5"
wgroup 0--3
line.long 0 "ADDRCOMP5"
bitfld.long 0 0. " ADDRCOMP5 "  "0 ,1 "
;tree.end

base ad:0xb7a08058
;tree "1ADDRCOMP6"
wgroup 0--3
line.long 0 "ADDRCOMP6"
bitfld.long 0 0. " ADDRCOMP6 "  "0 ,1 "
;tree.end

base ad:0xb7a0805c
;tree "1ADDRCOMP7"
wgroup 0--3
line.long 0 "ADDRCOMP7"
bitfld.long 0 0. " ADDRCOMP7 "  "0 ,1 "
;tree.end

base ad:0xb7a08080
;tree "1ADDRACCTYPE0"
wgroup 0--3
line.long 0 "ADDRACCTYPE0"
bitfld.long 0 0. " ADDRACCTYPE0 "  "0 ,1 "
;tree.end

base ad:0xb7a08084
;tree "1ADDRACCTYPE1"
wgroup 0--3
line.long 0 "ADDRACCTYPE1"
bitfld.long 0 0. " ADDRACCTYPE1 "  "0 ,1 "
;tree.end

base ad:0xb7a08088
;tree "1ADDRACCTYPE2"
wgroup 0--3
line.long 0 "ADDRACCTYPE2"
bitfld.long 0 0. " ADDRACCTYPE2 "  "0 ,1 "
;tree.end

base ad:0xb7a0808c
;tree "1ADDRACCTYPE3"
wgroup 0--3
line.long 0 "ADDRACCTYPE3"
bitfld.long 0 0. " ADDRACCTYPE3 "  "0 ,1 "
;tree.end

base ad:0xb7a08090
;tree "1ADDRACCTYPE4"
wgroup 0--3
line.long 0 "ADDRACCTYPE4"
bitfld.long 0 0. " ADDRACCTYPE4 "  "0 ,1 "
;tree.end

base ad:0xb7a08094
;tree "1ADDRACCTYPE5"
wgroup 0--3
line.long 0 "ADDRACCTYPE5"
bitfld.long 0 0. " ADDRACCTYPE5 "  "0 ,1 "
;tree.end

base ad:0xb7a08098
;tree "1ADDRACCTYPE6"
wgroup 0--3
line.long 0 "ADDRACCTYPE6"
bitfld.long 0 0. " ADDRACCTYPE6 "  "0 ,1 "
;tree.end

base ad:0xb7a0809c
;tree "1ADDRACCTYPE7"
wgroup 0--3
line.long 0 "ADDRACCTYPE7"
bitfld.long 0 0. " ADDRACCTYPE7 "  "0 ,1 "
;tree.end

base ad:0xb7a080c0
;tree "1DATACOMP0"
wgroup 0--3
line.long 0 "DATACOMP0"
bitfld.long 0 0. " DATACOMP0 "  "0 ,1 "
;tree.end

base ad:0xb7a080c8
;tree "1DATACOMP1"
wgroup 0--3
line.long 0 "DATACOMP1"
bitfld.long 0 0. " DATACOMP1 "  "0 ,1 "
;tree.end

base ad:0xb7a08100
;tree "1DATAMASK0"
wgroup 0--3
line.long 0 "DATAMASK0"
bitfld.long 0 0. " DATAMASK0 "  "0 ,1 "
;tree.end

base ad:0xb7a08108
;tree "1DATAMASK1"
wgroup 0--3
line.long 0 "DATAMASK1"
bitfld.long 0 0. " DATAMASK1 "  "0 ,1 "
;tree.end

base ad:0xb7a08140
;tree "1COUNTRELOADVAL0"
wgroup 0--3
line.long 0 "COUNTRELOADVAL0"
bitfld.long 0 0. " COUNTRELOADVAL0 "  "0 ,1 "
;tree.end

base ad:0xb7a08144
;tree "1COUNTRELOADVAL1"
wgroup 0--3
line.long 0 "COUNTRELOADVAL1"
bitfld.long 0 0. " COUNTRELOADVAL1 "  "0 ,1 "
;tree.end

base ad:0xb7a08150
;tree "1COUNTEN0"
wgroup 0--3
line.long 0 "COUNTEN0"
bitfld.long 0 0. " COUNTEN0 "  "0 ,1 "
;tree.end

base ad:0xb7a08154
;tree "1COUNTEN1"
wgroup 0--3
line.long 0 "COUNTEN1"
bitfld.long 0 0. " COUNTEN1 "  "0 ,1 "
;tree.end

base ad:0xb7a08160
;tree "1COUNTRELOADEV0"
wgroup 0--3
line.long 0 "COUNTRELOADEV0"
bitfld.long 0 0. " COUNTRELOADEV0 "  "0 ,1 "
;tree.end

base ad:0xb7a08164
;tree "1COUNTRELOADEV1"
wgroup 0--3
line.long 0 "COUNTRELOADEV1"
bitfld.long 0 0. " COUNTRELOADEV1 "  "0 ,1 "
;tree.end

base ad:0xb7a08170
;tree "1COUNTVALUE0"
group 0--3
line.long 0 "COUNTVALUE0"
bitfld.long 0 0. " COUNTVALUE0 "  "0 ,1 "
;tree.end

base ad:0xb7a08174
;tree "1COUNTVALUE1"
group 0--3
line.long 0 "COUNTVALUE1"
bitfld.long 0 0. " COUNTVALUE1 "  "0 ,1 "
;tree.end

base ad:0xb7a08180
;tree "1SEQCTRL0"
wgroup 0--3
line.long 0 "SEQCTRL0"
bitfld.long 0 0. " SEQCTRL0 "  "0 ,1 "
;tree.end

base ad:0xb7a08184
;tree "1SEQCTRL1"
wgroup 0--3
line.long 0 "SEQCTRL1"
bitfld.long 0 0. " SEQCTRL1 "  "0 ,1 "
;tree.end

base ad:0xb7a08188
;tree "1SEQCTRL2"
wgroup 0--3
line.long 0 "SEQCTRL2"
bitfld.long 0 0. " SEQCTRL2 "  "0 ,1 "
;tree.end

base ad:0xb7a0818c
;tree "1SEQCTRL3"
wgroup 0--3
line.long 0 "SEQCTRL3"
bitfld.long 0 0. " SEQCTRL3 "  "0 ,1 "
;tree.end

base ad:0xb7a08190
;tree "1SEQCTRL4"
wgroup 0--3
line.long 0 "SEQCTRL4"
bitfld.long 0 0. " SEQCTRL4 "  "0 ,1 "
;tree.end

base ad:0xb7a08194
;tree "1SEQCTRL5"
wgroup 0--3
line.long 0 "SEQCTRL5"
bitfld.long 0 0. " SEQCTRL5 "  "0 ,1 "
;tree.end

base ad:0xb7a0819c
;tree "1SEQSTATE"
group 0--3
line.long 0 "SEQSTATE"
bitfld.long 0 0. " SEQSTATE "  "0 ,1 "
;tree.end

base ad:0xb7a081a0
;tree "1EXTOUTPUT0"
wgroup 0--3
line.long 0 "EXTOUTPUT0"
bitfld.long 0 0. " EXTOUTPUT0 "  "0 ,1 "
;tree.end

base ad:0xb7a081a4
;tree "1EXTOUTPUT1"
wgroup 0--3
line.long 0 "EXTOUTPUT1"
bitfld.long 0 0. " EXTOUTPUT1 "  "0 ,1 "
;tree.end

base ad:0xb7a081b0
;tree "1CONTEXTIDCOMP"
wgroup 0--3
line.long 0 "CONTEXTIDCOMP"
bitfld.long 0 0. " CONTEXTIDCOMP "  "0 ,1 "
;tree.end

base ad:0xb7a081bc
;tree "1CONTEXTIDMASK"
wgroup 0--3
line.long 0 "CONTEXTIDMASK"
bitfld.long 0 0. " CONTEXTIDMASK "  "0 ,1 "
;tree.end

base ad:0xb7a081c0
;tree "1IMPSPECIFIC0"
wgroup 0--3
line.long 0 "IMPSPECIFIC0"
bitfld.long 0 0. " IMPSPECIFIC0 "  "0 ,1 "
;tree.end

base ad:0xb7a081c4
;tree "1IMPSPECIFIC1"
wgroup 0--3
line.long 0 "IMPSPECIFIC1"
bitfld.long 0 0. " IMPSPECIFIC1 "  "0 ,1 "
;tree.end

base ad:0xb7a081c8
;tree "1IMPSPECIFIC2"
wgroup 0--3
line.long 0 "IMPSPECIFIC2"
bitfld.long 0 0. " IMPSPECIFIC2 "  "0 ,1 "
;tree.end

base ad:0xb7a081cc
;tree "1IMPSPECIFIC3"
wgroup 0--3
line.long 0 "IMPSPECIFIC3"
bitfld.long 0 0. " IMPSPECIFIC3 "  "0 ,1 "
;tree.end

base ad:0xb7a081d0
;tree "1IMPSPECIFIC4"
wgroup 0--3
line.long 0 "IMPSPECIFIC4"
bitfld.long 0 0. " IMPSPECIFIC4 "  "0 ,1 "
;tree.end

base ad:0xb7a081d4
;tree "1IMPSPECIFIC5"
wgroup 0--3
line.long 0 "IMPSPECIFIC5"
bitfld.long 0 0. " IMPSPECIFIC5 "  "0 ,1 "
;tree.end

base ad:0xb7a081d8
;tree "1IMPSPECIFIC6"
wgroup 0--3
line.long 0 "IMPSPECIFIC6"
bitfld.long 0 0. " IMPSPECIFIC6 "  "0 ,1 "
;tree.end

base ad:0xb7a081dc
;tree "1IMPSPECIFIC7"
wgroup 0--3
line.long 0 "IMPSPECIFIC7"
bitfld.long 0 0. " IMPSPECIFIC7 "  "0 ,1 "
;tree.end

base ad:0xb7a081e0
;tree "1SYNCHFREQ"
wgroup 0--3
line.long 0 "SYNCHFREQ"
bitfld.long 0 0. " SYNCHFREQ "  "0 ,1 "
;tree.end

base ad:0xb7a081e4
;tree "1ETMID"
group 0--3
line.long 0 "ETMID"
bitfld.long 0 0. " ETMID "  "0 ,1 "
;tree.end

base ad:0xb7a081e8
;tree "1CONFIGCODEEXT"
group 0--3
line.long 0 "CONFIGCODEEXT"
bitfld.long 0 0. " CONFIGCODEEXT "  "0 ,1 "
;tree.end

base ad:0xb7a081ec
;tree "1EXTERNALINEXT"
wgroup 0--3
line.long 0 "EXTERNALINEXT"
bitfld.long 0 0. " EXTERNALINEXT "  "0 ,1 "
;tree.end

base ad:0xb7a08200
;tree "1CSTRACEID"
wgroup 0--3
line.long 0 "CSTRACEID"
bitfld.long 0 0. " CSTRACEID "  "0 ,1 "
;tree.end

base ad:0xb7a08fa0
;tree "1CLAIMTAGSET"
group 0--3
line.long 0 "CLAIMTAGSET"
bitfld.long 0 0. " CLAIMTAGSET "  "0 ,1 "
;tree.end

base ad:0xb7a08fa4
;tree "1CLAIMTAGCLR"
group 0--3
line.long 0 "CLAIMTAGCLR"
bitfld.long 0 0. " CLAIMTAGCLR "  "0 ,1 "
;tree.end

base ad:0xb7a08fb0
;tree "1LAR"
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

base ad:0xb7a08fb4
;tree "1LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a08fb8
;tree "1ASR"
rgroup 0--3
line.long 0 "ASR"
hexfld.byte 0 " ASR "
;tree.end

base ad:0xb7a08fcc
;tree "1CSDEVICETYPE"
rgroup 0--3
line.long 0 "CSDEVICETYPE"
bitfld.long 0 0. " CSDEVICETYPE "  "0 ,1 "
;tree.end

base ad:0xb7a08fd0
;tree "1PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

base ad:0xb7a08fd4
;tree "1PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
hexfld.byte 0 " PERIPHERAL_ID5 "
;tree.end

base ad:0xb7a08fd8
;tree "1PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
hexfld.byte 0 " PERIPHERAL_ID6 "
;tree.end

base ad:0xb7a08fdc
;tree "1PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
hexfld.byte 0 " PERIPHERAL_ID7 "
;tree.end

base ad:0xb7a08fe0
;tree "1PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

base ad:0xb7a08fe4
;tree "1PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

base ad:0xb7a08fe8
;tree "1PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

base ad:0xb7a08fec
;tree "1PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

base ad:0xb7a08ff0
;tree "1COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
hexfld.byte 0 " COMPONENT_ID0 "
;tree.end

base ad:0xb7a08ff4
;tree "1COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

base ad:0xb7a08ff8
;tree "1COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

base ad:0xb7a08ffc
;tree "1COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

base ad:0xb7a0b000
;********************************************
tree "MSSETM11CS-2"
;********************************************
base ad:0xb7a0b000
;tree "2ETMCR"
group 0--3
line.long 0 "ETMCR"
bitfld.long 0 0. " ETMCR "  "0 ,1 "
;tree.end

base ad:0xb7a0b004
;tree "2ETMCCR"
rgroup 0--3
line.long 0 "ETMCCR"
bitfld.long 0 0. " ETMCCR "  "0 ,1 "
;tree.end

base ad:0xb7a0b008
;tree "2ETMTRIGGER"
wgroup 0--3
line.long 0 "ETMTRIGGER"
bitfld.long 0 0. " ETMTRIGGER "  "0 ,1 "
;tree.end

base ad:0xb7a0b00c
;tree "2ETMASICCTLR"
wgroup 0--3
line.long 0 "ETMASICCTLR"
bitfld.long 0 0. " ETMASICCTLR "  "0 ,1 "
;tree.end

base ad:0xb7a0b010
;tree "2ETMSR"
group 0--3
line.long 0 "ETMSR"
bitfld.long 0 0. " STATUS "  "0 ,1 "
;tree.end

base ad:0xb7a0b014
;tree "2SYSCONFIG"
group 0--3
line.long 0 "SYSCONFIG"
bitfld.long 0 0. " SYSCONFIG "  "0 ,1 "
;tree.end

base ad:0xb7a0b018
;tree "2TRACEENSTARTSTOP"
wgroup 0--3
line.long 0 "TRACEENSTARTSTOP"
bitfld.long 0 0. " TRACEENSTARTSTOP "  "0 ,1 "
;tree.end

base ad:0xb7a0b01c
;tree "2TRACEENCTRL2"
wgroup 0--3
line.long 0 "TRACEENCTRL2"
bitfld.long 0 0. " TRACEENCTRL2 "  "0 ,1 "
;tree.end

base ad:0xb7a0b020
;tree "2TRACEENEVENT"
wgroup 0--3
line.long 0 "TRACEENEVENT"
bitfld.long 0 0. " TRACEENEVENT "  "0 ,1 "
;tree.end

base ad:0xb7a0b024
;tree "2TRACEENCTRL1"
wgroup 0--3
line.long 0 "TRACEENCTRL1"
bitfld.long 0 0. " TRACEENCTRL1 "  "0 ,1 "
;tree.end

base ad:0xb7a0b028
;tree "2FIFOFULLREGION"
wgroup 0--3
line.long 0 "FIFOFULLREGION"
bitfld.long 0 0. " FIFOFULLREGION "  "0 ,1 "
;tree.end

base ad:0xb7a0b02c
;tree "2FIFOFULLLEVEL"
group 0--3
line.long 0 "FIFOFULLLEVEL"
bitfld.long 0 0. " FIFOFULLLEVEL "  "0 ,1 "
;tree.end

base ad:0xb7a0b030
;tree "2VIEWDATAEVENT"
wgroup 0--3
line.long 0 "VIEWDATAEVENT"
bitfld.long 0 0. " VIEWDATAEVENT "  "0 ,1 "
;tree.end

base ad:0xb7a0b034
;tree "2VIEWDATACTRL1"
wgroup 0--3
line.long 0 "VIEWDATACTRL1"
bitfld.long 0 0. " VIEWDATACTRL1 "  "0 ,1 "
;tree.end

base ad:0xb7a0b038
;tree "2VIEWDATACTRL2"
wgroup 0--3
line.long 0 "VIEWDATACTRL2"
bitfld.long 0 0. " VIEWDATACTRL2 "  "0 ,1 "
;tree.end

base ad:0xb7a0b03c
;tree "2VIEWDATACTRL3"
wgroup 0--3
line.long 0 "VIEWDATACTRL3"
bitfld.long 0 0. " VIEWDATACTRL3 "  "0 ,1 "
;tree.end

base ad:0xb7a0b040
;tree "2ADDRCOMP0"
wgroup 0--3
line.long 0 "ADDRCOMP0"
bitfld.long 0 0. " ADDRCOMP0 "  "0 ,1 "
;tree.end

base ad:0xb7a0b044
;tree "2ADDRCOMP1"
wgroup 0--3
line.long 0 "ADDRCOMP1"
bitfld.long 0 0. " ADDRCOMP1 "  "0 ,1 "
;tree.end

base ad:0xb7a0b048
;tree "2ADDRCOMP2"
wgroup 0--3
line.long 0 "ADDRCOMP2"
bitfld.long 0 0. " ADDRCOMP2 "  "0 ,1 "
;tree.end

base ad:0xb7a0b04c
;tree "2ADDRCOMP3"
wgroup 0--3
line.long 0 "ADDRCOMP3"
bitfld.long 0 0. " ADDRCOMP3 "  "0 ,1 "
;tree.end

base ad:0xb7a0b050
;tree "2ADDRCOMP4"
wgroup 0--3
line.long 0 "ADDRCOMP4"
bitfld.long 0 0. " ADDRCOMP4 "  "0 ,1 "
;tree.end

base ad:0xb7a0b054
;tree "2ADDRCOMP5"
wgroup 0--3
line.long 0 "ADDRCOMP5"
bitfld.long 0 0. " ADDRCOMP5 "  "0 ,1 "
;tree.end

base ad:0xb7a0b058
;tree "2ADDRCOMP6"
wgroup 0--3
line.long 0 "ADDRCOMP6"
bitfld.long 0 0. " ADDRCOMP6 "  "0 ,1 "
;tree.end

base ad:0xb7a0b05c
;tree "2ADDRCOMP7"
wgroup 0--3
line.long 0 "ADDRCOMP7"
bitfld.long 0 0. " ADDRCOMP7 "  "0 ,1 "
;tree.end

base ad:0xb7a0b080
;tree "2ADDRACCTYPE0"
wgroup 0--3
line.long 0 "ADDRACCTYPE0"
bitfld.long 0 0. " ADDRACCTYPE0 "  "0 ,1 "
;tree.end

base ad:0xb7a0b084
;tree "2ADDRACCTYPE1"
wgroup 0--3
line.long 0 "ADDRACCTYPE1"
bitfld.long 0 0. " ADDRACCTYPE1 "  "0 ,1 "
;tree.end

base ad:0xb7a0b088
;tree "2ADDRACCTYPE2"
wgroup 0--3
line.long 0 "ADDRACCTYPE2"
bitfld.long 0 0. " ADDRACCTYPE2 "  "0 ,1 "
;tree.end

base ad:0xb7a0b08c
;tree "2ADDRACCTYPE3"
wgroup 0--3
line.long 0 "ADDRACCTYPE3"
bitfld.long 0 0. " ADDRACCTYPE3 "  "0 ,1 "
;tree.end

base ad:0xb7a0b090
;tree "2ADDRACCTYPE4"
wgroup 0--3
line.long 0 "ADDRACCTYPE4"
bitfld.long 0 0. " ADDRACCTYPE4 "  "0 ,1 "
;tree.end

base ad:0xb7a0b094
;tree "2ADDRACCTYPE5"
wgroup 0--3
line.long 0 "ADDRACCTYPE5"
bitfld.long 0 0. " ADDRACCTYPE5 "  "0 ,1 "
;tree.end

base ad:0xb7a0b098
;tree "2ADDRACCTYPE6"
wgroup 0--3
line.long 0 "ADDRACCTYPE6"
bitfld.long 0 0. " ADDRACCTYPE6 "  "0 ,1 "
;tree.end

base ad:0xb7a0b09c
;tree "2ADDRACCTYPE7"
wgroup 0--3
line.long 0 "ADDRACCTYPE7"
bitfld.long 0 0. " ADDRACCTYPE7 "  "0 ,1 "
;tree.end

base ad:0xb7a0b0c0
;tree "2DATACOMP0"
wgroup 0--3
line.long 0 "DATACOMP0"
bitfld.long 0 0. " DATACOMP0 "  "0 ,1 "
;tree.end

base ad:0xb7a0b0c8
;tree "2DATACOMP1"
wgroup 0--3
line.long 0 "DATACOMP1"
bitfld.long 0 0. " DATACOMP1 "  "0 ,1 "
;tree.end

base ad:0xb7a0b100
;tree "2DATAMASK0"
wgroup 0--3
line.long 0 "DATAMASK0"
bitfld.long 0 0. " DATAMASK0 "  "0 ,1 "
;tree.end

base ad:0xb7a0b108
;tree "2DATAMASK1"
wgroup 0--3
line.long 0 "DATAMASK1"
bitfld.long 0 0. " DATAMASK1 "  "0 ,1 "
;tree.end

base ad:0xb7a0b140
;tree "2COUNTRELOADVAL0"
wgroup 0--3
line.long 0 "COUNTRELOADVAL0"
bitfld.long 0 0. " COUNTRELOADVAL0 "  "0 ,1 "
;tree.end

base ad:0xb7a0b144
;tree "2COUNTRELOADVAL1"
wgroup 0--3
line.long 0 "COUNTRELOADVAL1"
bitfld.long 0 0. " COUNTRELOADVAL1 "  "0 ,1 "
;tree.end

base ad:0xb7a0b150
;tree "2COUNTEN0"
wgroup 0--3
line.long 0 "COUNTEN0"
bitfld.long 0 0. " COUNTEN0 "  "0 ,1 "
;tree.end

base ad:0xb7a0b154
;tree "2COUNTEN1"
wgroup 0--3
line.long 0 "COUNTEN1"
bitfld.long 0 0. " COUNTEN1 "  "0 ,1 "
;tree.end

base ad:0xb7a0b160
;tree "2COUNTRELOADEV0"
wgroup 0--3
line.long 0 "COUNTRELOADEV0"
bitfld.long 0 0. " COUNTRELOADEV0 "  "0 ,1 "
;tree.end

base ad:0xb7a0b164
;tree "2COUNTRELOADEV1"
wgroup 0--3
line.long 0 "COUNTRELOADEV1"
bitfld.long 0 0. " COUNTRELOADEV1 "  "0 ,1 "
;tree.end

base ad:0xb7a0b170
;tree "2COUNTVALUE0"
group 0--3
line.long 0 "COUNTVALUE0"
bitfld.long 0 0. " COUNTVALUE0 "  "0 ,1 "
;tree.end

base ad:0xb7a0b174
;tree "2COUNTVALUE1"
group 0--3
line.long 0 "COUNTVALUE1"
bitfld.long 0 0. " COUNTVALUE1 "  "0 ,1 "
;tree.end

base ad:0xb7a0b180
;tree "2SEQCTRL0"
wgroup 0--3
line.long 0 "SEQCTRL0"
bitfld.long 0 0. " SEQCTRL0 "  "0 ,1 "
;tree.end

base ad:0xb7a0b184
;tree "2SEQCTRL1"
wgroup 0--3
line.long 0 "SEQCTRL1"
bitfld.long 0 0. " SEQCTRL1 "  "0 ,1 "
;tree.end

base ad:0xb7a0b188
;tree "2SEQCTRL2"
wgroup 0--3
line.long 0 "SEQCTRL2"
bitfld.long 0 0. " SEQCTRL2 "  "0 ,1 "
;tree.end

base ad:0xb7a0b18c
;tree "2SEQCTRL3"
wgroup 0--3
line.long 0 "SEQCTRL3"
bitfld.long 0 0. " SEQCTRL3 "  "0 ,1 "
;tree.end

base ad:0xb7a0b190
;tree "2SEQCTRL4"
wgroup 0--3
line.long 0 "SEQCTRL4"
bitfld.long 0 0. " SEQCTRL4 "  "0 ,1 "
;tree.end

base ad:0xb7a0b194
;tree "2SEQCTRL5"
wgroup 0--3
line.long 0 "SEQCTRL5"
bitfld.long 0 0. " SEQCTRL5 "  "0 ,1 "
;tree.end

base ad:0xb7a0b19c
;tree "2SEQSTATE"
group 0--3
line.long 0 "SEQSTATE"
bitfld.long 0 0. " SEQSTATE "  "0 ,1 "
;tree.end

base ad:0xb7a0b1a0
;tree "2EXTOUTPUT0"
wgroup 0--3
line.long 0 "EXTOUTPUT0"
bitfld.long 0 0. " EXTOUTPUT0 "  "0 ,1 "
;tree.end

base ad:0xb7a0b1a4
;tree "2EXTOUTPUT1"
wgroup 0--3
line.long 0 "EXTOUTPUT1"
bitfld.long 0 0. " EXTOUTPUT1 "  "0 ,1 "
;tree.end

base ad:0xb7a0b1b0
;tree "2CONTEXTIDCOMP"
wgroup 0--3
line.long 0 "CONTEXTIDCOMP"
bitfld.long 0 0. " CONTEXTIDCOMP "  "0 ,1 "
;tree.end

base ad:0xb7a0b1bc
;tree "2CONTEXTIDMASK"
wgroup 0--3
line.long 0 "CONTEXTIDMASK"
bitfld.long 0 0. " CONTEXTIDMASK "  "0 ,1 "
;tree.end

base ad:0xb7a0b1c0
;tree "2IMPSPECIFIC0"
wgroup 0--3
line.long 0 "IMPSPECIFIC0"
bitfld.long 0 0. " IMPSPECIFIC0 "  "0 ,1 "
;tree.end

base ad:0xb7a0b1c4
;tree "2IMPSPECIFIC1"
wgroup 0--3
line.long 0 "IMPSPECIFIC1"
bitfld.long 0 0. " IMPSPECIFIC1 "  "0 ,1 "
;tree.end

base ad:0xb7a0b1c8
;tree "2IMPSPECIFIC2"
wgroup 0--3
line.long 0 "IMPSPECIFIC2"
bitfld.long 0 0. " IMPSPECIFIC2 "  "0 ,1 "
;tree.end

base ad:0xb7a0b1cc
;tree "2IMPSPECIFIC3"
wgroup 0--3
line.long 0 "IMPSPECIFIC3"
bitfld.long 0 0. " IMPSPECIFIC3 "  "0 ,1 "
;tree.end

base ad:0xb7a0b1d0
;tree "2IMPSPECIFIC4"
wgroup 0--3
line.long 0 "IMPSPECIFIC4"
bitfld.long 0 0. " IMPSPECIFIC4 "  "0 ,1 "
;tree.end

base ad:0xb7a0b1d4
;tree "2IMPSPECIFIC5"
wgroup 0--3
line.long 0 "IMPSPECIFIC5"
bitfld.long 0 0. " IMPSPECIFIC5 "  "0 ,1 "
;tree.end

base ad:0xb7a0b1d8
;tree "2IMPSPECIFIC6"
wgroup 0--3
line.long 0 "IMPSPECIFIC6"
bitfld.long 0 0. " IMPSPECIFIC6 "  "0 ,1 "
;tree.end

base ad:0xb7a0b1dc
;tree "2IMPSPECIFIC7"
wgroup 0--3
line.long 0 "IMPSPECIFIC7"
bitfld.long 0 0. " IMPSPECIFIC7 "  "0 ,1 "
;tree.end

base ad:0xb7a0b1e0
;tree "2SYNCHFREQ"
wgroup 0--3
line.long 0 "SYNCHFREQ"
bitfld.long 0 0. " SYNCHFREQ "  "0 ,1 "
;tree.end

base ad:0xb7a0b1e4
;tree "2ETMID"
group 0--3
line.long 0 "ETMID"
bitfld.long 0 0. " ETMID "  "0 ,1 "
;tree.end

base ad:0xb7a0b1e8
;tree "2CONFIGCODEEXT"
group 0--3
line.long 0 "CONFIGCODEEXT"
bitfld.long 0 0. " CONFIGCODEEXT "  "0 ,1 "
;tree.end

base ad:0xb7a0b1ec
;tree "2EXTERNALINEXT"
wgroup 0--3
line.long 0 "EXTERNALINEXT"
bitfld.long 0 0. " EXTERNALINEXT "  "0 ,1 "
;tree.end

base ad:0xb7a0b200
;tree "2CSTRACEID"
wgroup 0--3
line.long 0 "CSTRACEID"
bitfld.long 0 0. " CSTRACEID "  "0 ,1 "
;tree.end

base ad:0xb7a0bfa0
;tree "2CLAIMTAGSET"
group 0--3
line.long 0 "CLAIMTAGSET"
bitfld.long 0 0. " CLAIMTAGSET "  "0 ,1 "
;tree.end

base ad:0xb7a0bfa4
;tree "2CLAIMTAGCLR"
group 0--3
line.long 0 "CLAIMTAGCLR"
bitfld.long 0 0. " CLAIMTAGCLR "  "0 ,1 "
;tree.end

base ad:0xb7a0bfb0
;tree "2LAR"
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

base ad:0xb7a0bfb4
;tree "2LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a0bfb8
;tree "2ASR"
rgroup 0--3
line.long 0 "ASR"
hexfld.byte 0 " ASR "
;tree.end

base ad:0xb7a0bfcc
;tree "2CSDEVICETYPE"
rgroup 0--3
line.long 0 "CSDEVICETYPE"
bitfld.long 0 0. " CSDEVICETYPE "  "0 ,1 "
;tree.end

base ad:0xb7a0bfd0
;tree "2PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

base ad:0xb7a0bfd4
;tree "2PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
hexfld.byte 0 " PERIPHERAL_ID5 "
;tree.end

base ad:0xb7a0bfd8
;tree "2PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
hexfld.byte 0 " PERIPHERAL_ID6 "
;tree.end

base ad:0xb7a0bfdc
;tree "2PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
hexfld.byte 0 " PERIPHERAL_ID7 "
;tree.end

base ad:0xb7a0bfe0
;tree "2PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

base ad:0xb7a0bfe4
;tree "2PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

base ad:0xb7a0bfe8
;tree "2PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

base ad:0xb7a0bfec
;tree "2PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

base ad:0xb7a0bff0
;tree "2COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
hexfld.byte 0 " COMPONENT_ID0 "
;tree.end

base ad:0xb7a0bff4
;tree "2COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

base ad:0xb7a0bff8
;tree "2COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

base ad:0xb7a0bffc
;tree "2COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "MSSTPIU"
;==============================================================
base ad:0xb7a03000
;tree "PORTSIZE"
rgroup 0--3
line.long 0 "PORTSIZE"
bitfld.long 0 0. " PORTSIZE "  "0 ,1 "
;tree.end

base ad:0xb7a03004
;tree "CURRPORTSIZE"
group 0--3
line.long 0 "CURRPORTSIZE"
hexfld.long 0 " CURRPORTSIZE "
;tree.end

base ad:0xb7a03100
;tree "SUPPTRIGMODES"
rgroup 0--3
line.long 0 "SUPPTRIGMODES"
bitfld.long 0 0. " MULT2 "  "0 ,1 "
bitfld.long 0 1. " MULT4 "  "0 ,1 "
bitfld.long 0 2. " MULT16 "  "0 ,1 "
bitfld.long 0 3. " MULT256 "  "0 ,1 "
bitfld.long 0 4. " MULT64K "  "0 ,1 "
bitfld.long 0 8. " TCOUNT8 "  "0 ,1 "
bitfld.long 0 16. " TRIGGERED "  "0 ,1 "
bitfld.long 0 17. " TRGRUN "  "0 ,1 "
;tree.end

base ad:0xb7a03104
;tree "TRIGCOUNT"
group 0--3
line.long 0 "TRIGCOUNT"
hexfld.byte 0 " TRIGCOUNT "
;tree.end

base ad:0xb7a03108
;tree "TRIGMULT"
group 0--3
line.long 0 "TRIGMULT"
bitfld.long 0 0. " MULT2 "  "0 ,1 "
bitfld.long 0 1. " MULT4 "  "0 ,1 "
bitfld.long 0 2. " MULT16 "  "0 ,1 "
bitfld.long 0 3. " MULT256 "  "0 ,1 "
bitfld.long 0 4. " MULT64K "  "0 ,1 "
;tree.end

base ad:0xb7a03200
;tree "SUPPTESTPAT"
rgroup 0--3
line.long 0 "SUPPTESTPAT"
bitfld.long 0 0. " PATW1 "  "0 ,1 "
bitfld.long 0 1. " PATW0 "  "0 ,1 "
bitfld.long 0 2. " PATA5 "  "0 ,1 "
bitfld.long 0 3. " PATF0 "  "0 ,1 "
bitfld.long 0 16. " PTIMEEN "  "0 ,1 "
bitfld.long 0 17. " PCONTEN "  "0 ,1 "
;tree.end

base ad:0xb7a03204
;tree "CURRTESTPAT"
group 0--3
line.long 0 "CURRTESTPAT"
bitfld.long 0 0. " PATW1 "  "0 ,1 "
bitfld.long 0 1. " PATW0 "  "0 ,1 "
bitfld.long 0 2. " PATA5 "  "0 ,1 "
bitfld.long 0 3. " PATF0 "  "0 ,1 "
bitfld.long 0 16. " PTIMEEN "  "0 ,1 "
bitfld.long 0 17. " PCONTEN "  "0 ,1 "
;tree.end

base ad:0xb7a03208
;tree "TESTPATTREPCNT"
group 0--3
line.long 0 "TESTPATTREPCNT"
hexfld.byte 0 " PATTCOUNT "
;tree.end

base ad:0xb7a03300
;tree "FORMATSTAT"
rgroup 0--3
line.long 0 "FORMATSTAT"
bitfld.long 0 0. " FIP "  "0 ,1 "
bitfld.long 0 1. " FTS "  "0 ,1 "
bitfld.long 0 2. " TCP "  "0 ,1 "
;tree.end

base ad:0xb7a03304
;tree "FORMATCTRL"
group 0--3
line.long 0 "FORMATCTRL"
bitfld.long 0 0. " ENFTC "  "0 ,1 "
bitfld.long 0 1. " ENFCONT "  "0 ,1 "
bitfld.long 0 4. " FONFLIN "  "0 ,1 "
bitfld.long 0 5. " FONTRIG "  "0 ,1 "
bitfld.long 0 6. " FONMAN "  "0 ,1 "
bitfld.long 0 8. " TRIGIN "  "0 ,1 "
bitfld.long 0 9. " TRIGEVT "  "0 ,1 "
bitfld.long 0 10. " TRIGFL "  "0 ,1 "
bitfld.long 0 12. " STOPFI "  "0 ,1 "
bitfld.long 0 13. " STOPTRIG "  "0 ,1 "
;tree.end

base ad:0xb7a03308
;tree "FORMATSYNC"
group 0--3
line.long 0 "FORMATSYNC"
bitfld.long 0 0.--11. " CYCCOUNT "  " "
;tree.end

base ad:0xb7a03400
;tree "EXTCTLIN"
group 0--3
line.long 0 "EXTCTLIN"
bitfld.long 0 0. " EXTCTLIN "  "0 ,1 "
;tree.end

base ad:0xb7a03404
;tree "EXTCTLOUT"
group 0--3
line.long 0 "EXTCTLOUT"
bitfld.long 0 0. " EXTCTLOUT "  "0 ,1 "
;tree.end

base ad:0xb7a03ee4
;tree "ITTRFLINACK"
wgroup 0--3
line.long 0 "ITTRFLINACK"
bitfld.long 0 0. " ITTRFLINACK "  "0 ,1 "
;tree.end

base ad:0xb7a03ee8
;tree "ITTRFLIN"
group 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0. " ITTRFLIN "  "0 ,1 "
;tree.end

base ad:0xb7a03eec
;tree "ITATBDATA0"
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ITATBDATA0 "  "0 ,1 "
;tree.end

base ad:0xb7a03ef0
;tree "ITATBCTR2"
wgroup 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ITATBCTR2 "  "0 ,1 "
;tree.end

base ad:0xb7a03ef4
;tree "ITATBCTR1"
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0. " ITATBCTR1 "  "0 ,1 "
;tree.end

base ad:0xb7a03ef8
;tree "ITATBCTR0"
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ITATBCTR0 "  "0 ,1 "
;tree.end

base ad:0xb7a03f00
;tree "IMCR"
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " IMCR "  "0 ,1 "
;tree.end

base ad:0xb7a03fa0
;tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a03fa4
;tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xb7a03fb0
;tree "LAR"
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

base ad:0xb7a03fb4
;tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xb7a03fb8
;tree "ASR"
rgroup 0--3
line.long 0 "ASR"
hexfld.byte 0 " ASR "
;tree.end

base ad:0xb7a03fc8
;tree "DevID"
rgroup 0--3
line.long 0 "DevID"
bitfld.long 0 0. " DevID "  "0 ,1 "
;tree.end

base ad:0xb7a03fcc
;tree "Dev"
rgroup 0--3
line.long 0 "Dev"
hexfld.byte 0 " Dev "
;tree.end

base ad:0xb7a03fd0
;tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

base ad:0xb7a03fd4
;tree "PERIPHERAL_ID5"
group 0--3
line.long 0 "PERIPHERAL_ID5"
hexfld.byte 0 " PERIPHERAL_ID5 "
;tree.end

base ad:0xb7a03fd8
;tree "PERIPHERAL_ID6"
group 0--3
line.long 0 "PERIPHERAL_ID6"
hexfld.byte 0 " PERIPHERAL_ID6 "
;tree.end

base ad:0xb7a03fdc
;tree "PERIPHERAL_ID7"
group 0--3
line.long 0 "PERIPHERAL_ID7"
hexfld.byte 0 " PERIPHERAL_ID7 "
;tree.end

base ad:0xb7a03fe0
;tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

base ad:0xb7a03fe4
;tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

base ad:0xb7a03fe8
;tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

base ad:0xb7a03fec
;tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

base ad:0xb7a03ff0
;tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
hexfld.byte 0 " COMPONENT_ID0 "
;tree.end

base ad:0xb7a03ff4
;tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

base ad:0xb7a03ff8
;tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

base ad:0xb7a03ffc
;tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

;==============================================================
tree "PKA"
;==============================================================
base ad:0xa03c4000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PKAGO "  "0 ,1 "
bitfld.long 0 1. " PKASTOP "  "0 ,1 "
bitfld.long 0 2. " PKARESTORE "  "0 ,1 "
;tree.end

base ad:0xa03c4004
;tree "CFG"
group 0--3
line.long 0 "CFG"
bitfld.long 0 0. " SEC "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGOMODE "  "0 ,1 "
bitfld.long 0 3.--4. " ALGOCALC "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " SECLVL "  "0 ,1 ,2 ,3 "
bitfld.long 0 7.--8. " DATASWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa03c4008
;tree "SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " BUSY "  "0 ,1 "
bitfld.long 0 1. " STATUSSTOP "  "0 ,1 "
bitfld.long 0 2. " STATUSRESTORE "  "0 ,1 "
;tree.end

base ad:0xa03c400c
;tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " PKAIM "  "0 ,1 "
;tree.end

base ad:0xa03c4010
;tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " PKARIS "  "0 ,1 "
;tree.end

base ad:0xa03c4014
;tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " PKAMIS "  "0 ,1 "
;tree.end

base ad:0xa03c4018
;tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " PKAIC "  "0 ,1 "
;tree.end

base ad:0xa03c4800
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0xa03c4804
;tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
;tree.end

base ad:0xa03c4808
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " PKAINTR "  "0 ,1 "
;tree.end

base ad:0xa03c4fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03c4fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c4fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c4fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03c4ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PKAPCellID0 "
;tree.end

base ad:0xa03c4ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PKAPCellID1 "
;tree.end

base ad:0xa03c4ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PKAPCellID2 "
;tree.end

base ad:0xa03c4ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PKA0PCellID3 "
;tree.end

tree.end

;==============================================================
tree "PL310"
;==============================================================
base ad:0xa0412000
;tree "ID"
rgroup 0--3
line.long 0 "ID"
bitfld.long 0 0.--5. " REL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--9. " PART "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10.--15. " ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
hexfld.byte 3 " IMPL "
;tree.end

base ad:0xa0412004
;tree "Type"
rgroup 0--3
line.long 0 "Type"
bitfld.long 0 0.--1. " ILINELEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " IASSOC "  "0 ,1 "
bitfld.long 0 7.--11. " ISIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 12.--13. " DLINELEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " DASSOC "  "0 ,1 "
bitfld.long 0 19.--23. " DSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24. " H "  "0 ,1 "
bitfld.long 0 25.--28. " CTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0412100
;tree "Control"
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " EN "  "0 ,1 "
;tree.end

base ad:0xa0412104
;tree "AuxControl"
group 0--3
line.long 0 "AuxControl"
bitfld.long 0 12. " EXCONF "  "0 ,1 "
bitfld.long 0 16. " ASSOC "  "0 ,1 "
bitfld.long 0 17.--19. " WAYSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " EMBEN "  "0 ,1 "
bitfld.long 0 21. " PAREN "  "0 ,1 "
bitfld.long 0 22. " SAOEN "  "0 ,1 "
bitfld.long 0 23.--24. " FWALLOC "  "0 ,1 ,2 ,3 "
bitfld.long 0 26. " NSLCKEN "  "0 ,1 "
bitfld.long 0 27. " NSIAC "  "0 ,1 "
bitfld.long 0 28. " DPFEN "  "0 ,1 "
bitfld.long 0 29. " IPFEN "  "0 ,1 "
;tree.end

base ad:0xa0412108
;tree "TagLatControl"
group 0--3
line.long 0 "TagLatControl"
bitfld.long 0 0.--2. " SLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " RLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " WLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa041210c
;tree "DataLatControl"
group 0--3
line.long 0 "DataLatControl"
bitfld.long 0 0.--2. " SLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " RLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " WLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0412200
;tree "EventCountControl"
group 0--3
line.long 0 "EventCountControl"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 1.--2. " RES "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0412204
;tree "EventCount1Conf"
group 0--3
line.long 0 "EventCount1Conf"
bitfld.long 0 0.--1. " EVINTGEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--5. " EVSRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0412208
;tree "EventCount0Conf"
group 0--3
line.long 0 "EventCount0Conf"
bitfld.long 0 0.--1. " EVINTGEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--5. " EVSRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa041220c
;tree "EventCount1Value"
group 0--3
line.long 0 "EventCount1Value"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa0412210
;tree "EventCount0Value"
group 0--3
line.long 0 "EventCount0Value"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa0412214
;tree "IntMask"
group 0--3
line.long 0 "IntMask"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
;tree.end

base ad:0xa0412218
;tree "MaskedIntStatus"
rgroup 0--3
line.long 0 "MaskedIntStatus"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
;tree.end

base ad:0xa041221c
;tree "RawIntStatus"
rgroup 0--3
line.long 0 "RawIntStatus"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
;tree.end

base ad:0xa0412220
;tree "IntClear"
wgroup 0--3
line.long 0 "IntClear"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
;tree.end

base ad:0xa0412730
;tree "CacheSync"
group 0--3
line.long 0 "CacheSync"
hexfld.long 0 " SYNC "
;tree.end

base ad:0xa0412770
;tree "InvalidateLine"
group 0--3
line.long 0 "InvalidateLine"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
;tree.end

base ad:0xa041277c
;tree "InvalidateByWay"
group 0--3
line.long 0 "InvalidateByWay"
hexfld.word 0 " WAYBITS "
;tree.end

base ad:0xa04127b0
;tree "CleanLine"
group 0--3
line.long 0 "CleanLine"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
;tree.end

base ad:0xa04127b8
;tree "CleanLineByWay"
group 0--3
line.long 0 "CleanLineByWay"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 28.--31. " WAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa04127bc
;tree "CleanByWay"
group 0--3
line.long 0 "CleanByWay"
hexfld.word 0 " WAYBITS "
;tree.end

base ad:0xa04127f0
;tree "CleanInvLine"
group 0--3
line.long 0 "CleanInvLine"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
;tree.end

base ad:0xa04127f8
;tree "CleanInvLineByWay"
group 0--3
line.long 0 "CleanInvLineByWay"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 28.--31. " WAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa04127fc
;tree "CleanInvByWay"
group 0--3
line.long 0 "CleanInvByWay"
hexfld.word 0 " WAYBITS "
;tree.end

base ad:0xa0412900
;tree "DataLockdownByWay_0"
group 0--3
line.long 0 "DataLockdownByWay_0"
hexfld.word 0 " DATALOCK000 "
;tree.end

base ad:0xa0412904
;tree "InstLockdownByWay_0"
group 0--3
line.long 0 "InstLockdownByWay_0"
hexfld.word 0 " INSTRLOCK000 "
;tree.end

base ad:0xa0412908
;tree "DataLockdownByWay_1"
group 0--3
line.long 0 "DataLockdownByWay_1"
hexfld.word 0 " DATALOCK001 "
;tree.end

base ad:0xa041290c
;tree "InstLockdownByWay_1"
group 0--3
line.long 0 "InstLockdownByWay_1"
hexfld.word 0 " INSTRLOCK001 "
;tree.end

base ad:0xa0412910
;tree "DataLockdownByWay_2"
group 0--3
line.long 0 "DataLockdownByWay_2"
hexfld.word 0 " DATALOCK010 "
;tree.end

base ad:0xa0412914
;tree "InstLockdownByWay_2"
group 0--3
line.long 0 "InstLockdownByWay_2"
hexfld.word 0 " INSTRLOCK010 "
;tree.end

base ad:0xa0412918
;tree "DataLockdownByWay_3"
group 0--3
line.long 0 "DataLockdownByWay_3"
hexfld.word 0 " DATALOCK011 "
;tree.end

base ad:0xa041291c
;tree "InstLockdownByWay_3"
group 0--3
line.long 0 "InstLockdownByWay_3"
hexfld.word 0 " INSTRLOCK011 "
;tree.end

base ad:0xa0412920
;tree "DataLockdownByWay_4"
group 0--3
line.long 0 "DataLockdownByWay_4"
hexfld.word 0 " DATALOCK100 "
;tree.end

base ad:0xa0412924
;tree "InstLockdownByWay_4"
group 0--3
line.long 0 "InstLockdownByWay_4"
hexfld.word 0 " INSTRLOCK100 "
;tree.end

base ad:0xa0412928
;tree "DataLockdownByWay_5"
group 0--3
line.long 0 "DataLockdownByWay_5"
hexfld.word 0 " DATALOCK101 "
;tree.end

base ad:0xa041292c
;tree "InstLockdownByWay_5"
group 0--3
line.long 0 "InstLockdownByWay_5"
hexfld.word 0 " INSTRLOCK101 "
;tree.end

base ad:0xa0412930
;tree "DataLockdownByWay_6"
group 0--3
line.long 0 "DataLockdownByWay_6"
hexfld.word 0 " DATALOCK110 "
;tree.end

base ad:0xa0412934
;tree "InstLockdownByWay_6"
group 0--3
line.long 0 "InstLockdownByWay_6"
hexfld.word 0 " INSTRLOCK110 "
;tree.end

base ad:0xa0412938
;tree "DataLockdownByWay_7"
group 0--3
line.long 0 "DataLockdownByWay_7"
hexfld.word 0 " DATALOCK111 "
;tree.end

base ad:0xa041293c
;tree "InstLockdownByWay_7"
group 0--3
line.long 0 "InstLockdownByWay_7"
hexfld.word 0 " INSTRLOCK111 "
;tree.end

base ad:0xa0412950
;tree "LockdownByLineEnable"
group 0--3
line.long 0 "LockdownByLineEnable"
bitfld.long 0 0. " EN "  "0 ,1 "
;tree.end

base ad:0xa0412954
;tree "UnlockAllLinesByWay"
group 0--3
line.long 0 "UnlockAllLinesByWay"
hexfld.word 0 " UNLOCK "
;tree.end

base ad:0xa0412c00
;tree "AddrFilterStart"
group 0--3
line.long 0 "AddrFilterStart"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 20.--31. " AFS "  " "
;tree.end

base ad:0xa0412c04
;tree "AddrFilterEnd"
group 0--3
line.long 0 "AddrFilterEnd"
bitfld.long 0 20.--31. " AFE "  " "
;tree.end

base ad:0xa0412f40
;tree "DebugControl"
group 0--3
line.long 0 "DebugControl"
bitfld.long 0 0. " DCL "  "0 ,1 "
bitfld.long 0 1. " DWB "  "0 ,1 "
bitfld.long 0 2. " SPNIDEN "  "0 ,1 "
;tree.end

base ad:0xa0412f80
;tree "PowerControl"
group 0--3
line.long 0 "PowerControl"
bitfld.long 0 0. " STDBY_MODE_EN "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "PRCMU"
;==============================================================
base ad:0x80157000
;tree "PRCM_ARMCLKFIX_MGT"
group 0--3
line.long 0 "PRCM_ARMCLKFIX_MGT"
bitfld.long 0 0.--4. " ARMCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " ARMCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 9. " ARMCLK38 "  "0 ,1 "
bitfld.long 0 10. " ARMCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " ARMCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157004
;tree "PRCM_ACLK_MGT"
group 0--3
line.long 0 "PRCM_ACLK_MGT"
bitfld.long 0 0.--4. " ACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " ACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " ACLKEN "  "0 ,1 "
bitfld.long 0 9. " ACLK38 "  "0 ,1 "
bitfld.long 0 10. " ACLK38SRC "  "0 ,1 "
bitfld.long 0 11. " ACLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157008
;tree "PRCM_SVAMMDSPCLK_MGT"
group 0--3
line.long 0 "PRCM_SVAMMDSPCLK_MGT"
bitfld.long 0 0.--4. " SVAMMDSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SVAMMDSPCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 9. " SVAMMDSPCLK38 "  "0 ,1 "
bitfld.long 0 10. " SVAMMDSPCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SVA_LOW_FREQ "  "0 ,1 "
bitfld.long 0 12. " SVA_PHY_EN "  "0 ,1 "
bitfld.long 0 13. " SVAMMDSPCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x8015700c
;tree "PRCM_SIAMMDSPCLK_MGT"
group 0--3
line.long 0 "PRCM_SIAMMDSPCLK_MGT"
bitfld.long 0 0.--4. " SIAMMDSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SIAMMDSPCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 9. " SIAMMDSPCLK38 "  "0 ,1 "
bitfld.long 0 10. " SIAMMDSPCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SIA_LOW_FREQ "  "0 ,1 "
bitfld.long 0 12. " SIA_PHY_EN "  "0 ,1 "
bitfld.long 0 13. " SIAMMDSPCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157014
;tree "PRCM_SGACLK_MGT"
group 0--3
line.long 0 "PRCM_SGACLK_MGT"
bitfld.long 0 0.--4. " SGACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SGACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SGACLKEN "  "0 ,1 "
bitfld.long 0 9. " SGACLK38 "  "0 ,1 "
bitfld.long 0 10. " SGACLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SGACLK38DIV "  "0 ,1 "
bitfld.long 0 12. " SGACLKDIV_by_2_5_en "  "0 ,1 "
;tree.end

base ad:0x80157018
;tree "PRCM_UARTCLK_MGT"
group 0--3
line.long 0 "PRCM_UARTCLK_MGT"
bitfld.long 0 0.--4. " UARTCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " UARTCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 9. " UARTCLK38 "  "0 ,1 "
bitfld.long 0 10. " UARTCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " UARTCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x8015701c
;tree "PRCM_MSP02CLK_MGT"
group 0--3
line.long 0 "PRCM_MSP02CLK_MGT"
bitfld.long 0 0.--4. " MSP02CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " MSP02CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 9. " MSP02CLK38 "  "0 ,1 "
bitfld.long 0 10. " MSP02CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " MSP02CLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157020
;tree "PRCM_I2CCLK_MGT"
group 0--3
line.long 0 "PRCM_I2CCLK_MGT"
bitfld.long 0 0.--4. " I2CCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " I2CCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " I2CCLK38 "  "0 ,1 "
bitfld.long 0 10. " I2CCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " I2CCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157024
;tree "PRCM_SDMMCCLK_MGT"
group 0--3
line.long 0 "PRCM_SDMMCCLK_MGT"
bitfld.long 0 0.--4. " SDMMCCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SDMMCCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLK38 "  "0 ,1 "
bitfld.long 0 10. " SDMMCCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SDMMCCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157028
;tree "PRCM_SLIMCLK_MGT"
group 0--3
line.long 0 "PRCM_SLIMCLK_MGT"
bitfld.long 0 0.--4. " SLIMCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SLIMCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SLIMCLKEN "  "0 ,1 "
bitfld.long 0 9. " SLIMCLK38 "  "0 ,1 "
bitfld.long 0 10. " SLIMCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SLIMCLK38DIV "  "0 ,1 "
bitfld.long 0 12.--14. " SLIMCLKMSP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8015702c
;tree "PRCM_PER1CLK_MGT"
group 0--3
line.long 0 "PRCM_PER1CLK_MGT"
bitfld.long 0 0.--4. " PER1CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER1CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER1CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER1CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER1CLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157030
;tree "PRCM_PER2CLK_MGT"
group 0--3
line.long 0 "PRCM_PER2CLK_MGT"
bitfld.long 0 0.--4. " PER2CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER2CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER2CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER2CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER2CLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157034
;tree "PRCM_PER3CLK_MGT"
group 0--3
line.long 0 "PRCM_PER3CLK_MGT"
bitfld.long 0 0.--4. " PER3CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER3CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER3CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER3CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER3CLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157038
;tree "PRCM_PER5CLK_MGT"
group 0--3
line.long 0 "PRCM_PER5CLK_MGT"
bitfld.long 0 0.--4. " PER5CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER5CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER5CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER5CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER5CLK38DIV "  "0 ,1 "
;tree.end

base ad:0x8015703c
;tree "PRCM_PER6CLK_MGT"
group 0--3
line.long 0 "PRCM_PER6CLK_MGT"
bitfld.long 0 0.--4. " PER6CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER6CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER6CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER6CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER6CLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157040
;tree "PRCM_PER7CLK_MGT"
group 0--3
line.long 0 "PRCM_PER7CLK_MGT"
bitfld.long 0 0.--4. " PER7CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER7CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER7CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER7CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER7CLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157044
;tree "PRCM_LCDCLK_MGT"
group 0--3
line.long 0 "PRCM_LCDCLK_MGT"
bitfld.long 0 0.--4. " LCDCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " LCDCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 9. " LCDCLK38 "  "0 ,1 "
bitfld.long 0 10. " LCDCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " LCDCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157048
;tree "PRCM_SPARE1CLK_MGT"
group 0--3
line.long 0 "PRCM_SPARE1CLK_MGT"
;tree.end

base ad:0x8015704c
;tree "PRCM_BMLCLK_MGT"
group 0--3
line.long 0 "PRCM_BMLCLK_MGT"
bitfld.long 0 0.--4. " BMLCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " BMLCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " BMLCLKEN "  "0 ,1 "
bitfld.long 0 9. " BMLCLK38 "  "0 ,1 "
bitfld.long 0 10. " BMLCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " BMLCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157050
;tree "PRCM_HSITXCLK_MGT"
group 0--3
line.long 0 "PRCM_HSITXCLK_MGT"
bitfld.long 0 0.--4. " HSITXCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " HSITXCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 9. " HSITXCLK38 "  "0 ,1 "
bitfld.long 0 10. " HSITXCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " HSITXCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157054
;tree "PRCM_HSIRXCLK_MGT"
group 0--3
line.long 0 "PRCM_HSIRXCLK_MGT"
bitfld.long 0 0.--4. " HSIRXCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " HSIRXCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 9. " HSIRXCLK38 "  "0 ,1 "
bitfld.long 0 10. " HSIRXCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " HSIRXCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157058
;tree "PRCM_HDMICLK_MGT"
group 0--3
line.long 0 "PRCM_HDMICLK_MGT"
bitfld.long 0 0.--4. " HDMICLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " HDMICLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 9. " HDMICLK38 "  "0 ,1 "
bitfld.long 0 10. " HDMICLK38SRC "  "0 ,1 "
bitfld.long 0 11. " HDMICLK38DIV "  "0 ,1 "
;tree.end

base ad:0x8015705c
;tree "PRCM_APEATCLK_MGT"
group 0--3
line.long 0 "PRCM_APEATCLK_MGT"
bitfld.long 0 0.--4. " APEATCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " APEATCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 9. " APEATCLK38 "  "0 ,1 "
bitfld.long 0 10. " APEATCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " APEATCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157060
;tree "PRCM_APETRACECLK_MGT"
group 0--3
line.long 0 "PRCM_APETRACECLK_MGT"
bitfld.long 0 0.--4. " APETRACECLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " APETRACECLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 9. " APETRACECLK38 "  "0 ,1 "
bitfld.long 0 10. " APETRACECLK38SRC "  "0 ,1 "
bitfld.long 0 11. " APETRACECLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157064
;tree "PRCM_MCDECLK_MGT"
group 0--3
line.long 0 "PRCM_MCDECLK_MGT"
bitfld.long 0 0.--4. " MCDECLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " MCDECLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 9. " MCDECLK38 "  "0 ,1 "
bitfld.long 0 10. " MCDECLK38SRC "  "0 ,1 "
bitfld.long 0 11. " MCDECLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157068
;tree "PRCM_IPI2CCLK_MGT"
group 0--3
line.long 0 "PRCM_IPI2CCLK_MGT"
bitfld.long 0 0.--4. " IPI2CCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " IPI2CCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " IPI2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " IPI2CCLK38 "  "0 ,1 "
bitfld.long 0 10. " IPI2CCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " IPI2CCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x8015706c
;tree "PRCM_DSIALTCLK_MGT"
group 0--3
line.long 0 "PRCM_DSIALTCLK_MGT"
bitfld.long 0 0.--4. " DSIALTCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " DSIALTCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 9. " DSIALTCLK38 "  "0 ,1 "
bitfld.long 0 10. " DSIALTCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " DSIALTCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157070
;tree "PRCM_SPARE2CLK_MGT"
group 0--3
line.long 0 "PRCM_SPARE2CLK_MGT"
;tree.end

base ad:0x80157074
;tree "PRCM_DMACLK_MGT"
group 0--3
line.long 0 "PRCM_DMACLK_MGT"
bitfld.long 0 0.--4. " DMACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " DMACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " DMACLKEN "  "0 ,1 "
bitfld.long 0 9. " DMACLK38 "  "0 ,1 "
bitfld.long 0 10. " DMACLK38SRC "  "0 ,1 "
bitfld.long 0 11. " DMACLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157078
;tree "PRCM_B2R2CLK_MGT"
group 0--3
line.long 0 "PRCM_B2R2CLK_MGT"
bitfld.long 0 0.--4. " B2R2CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " B2R2CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 9. " B2R2CLK38 "  "0 ,1 "
bitfld.long 0 10. " B2R2CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " B2R2CLK38DIV "  "0 ,1 "
;tree.end

base ad:0x8015707c
;tree "PRCM_TVCLK_MGT"
group 0--3
line.long 0 "PRCM_TVCLK_MGT"
bitfld.long 0 0.--4. " TVCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " TVCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " TVCLKEN "  "0 ,1 "
bitfld.long 0 9. " TVCLK38 "  "0 ,1 "
bitfld.long 0 10. " TVCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " TVCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157080
;tree "PRCM_PLLSOC0_FREQ"
group 0--3
line.long 0 "PRCM_PLLSOC0_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
bitfld.long 0 25. " DIV2EN "  "0 ,1 "
;tree.end

base ad:0x80157084
;tree "PRCM_PLLSOC1_FREQ"
group 0--3
line.long 0 "PRCM_PLLSOC1_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
;tree.end

base ad:0x80157088
;tree "PRCM_PLLARM_FREQ"
group 0--3
line.long 0 "PRCM_PLLARM_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
;tree.end

base ad:0x8015708c
;tree "PRCM_PLLDDR_FREQ"
group 0--3
line.long 0 "PRCM_PLLDDR_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
bitfld.long 0 25. " DIV2EN "  "0 ,1 "
;tree.end

base ad:0x80157090
;tree "PRCM_PLLSOC0_ENABLE"
group 0--3
line.long 0 "PRCM_PLLSOC0_ENABLE"
bitfld.long 0 0. " PRCM_PLLSOC0_ENABLE "  "0 ,1 "
;tree.end

base ad:0x80157094
;tree "PRCM_PLLSOC1_ENABLE"
group 0--3
line.long 0 "PRCM_PLLSOC1_ENABLE"
bitfld.long 0 0. " PRCM_PLLSOC1_ENABLE "  "0 ,1 "
;tree.end

base ad:0x80157098
;tree "PRCM_PLLARM_ENABLE"
group 0--3
line.long 0 "PRCM_PLLARM_ENABLE"
bitfld.long 0 0. " PRCM_PLLARM_ENABLE "  "0 ,1 "
bitfld.long 0 8. " PRCM_PLLARM_COUNTON "  "0 ,1 "
;tree.end

base ad:0x8015709c
;tree "PRCM_PLLDDR_ENABLE"
group 0--3
line.long 0 "PRCM_PLLDDR_ENABLE"
bitfld.long 0 0. " PRCM_PLLDDR_ENABLE "  "0 ,1 "
;tree.end

base ad:0x801570a0
;tree "PRCM_PLLSOC0_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLSOC0_LOCKP"
bitfld.long 0 0. " PRCM_PLLSOC0_LOCK10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLSOC0_LOCK3 "  "0 ,1 "
;tree.end

base ad:0x801570a4
;tree "PRCM_PLLSOC1_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLSOC1_LOCKP"
bitfld.long 0 0. " PRCM_PLLSOC1_LOCK10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLSOC1_LOCK3 "  "0 ,1 "
;tree.end

base ad:0x801570a8
;tree "PRCM_PLLARM_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLARM_LOCKP"
bitfld.long 0 0. " PRCM_PLLARM_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLARM_LOCKP3 "  "0 ,1 "
;tree.end

base ad:0x801570ac
;tree "PRCM_PLLDDR_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLDDR_LOCKP"
bitfld.long 0 0. " PRCM_PLLDDR_LOCKP "  "0 ,1 "
;tree.end

base ad:0x801570b0
;tree "PRCM_XP70CLK_MGT"
group 0--3
line.long 0 "PRCM_XP70CLK_MGT"
bitfld.long 0 1. " PMBCLK_DIV4_SEL "  "0 ,1 "
bitfld.long 0 3. " P4PRCM_CLK_L2_SW "  "0 ,1 "
bitfld.long 0 4. " CLK38M2CLKGEN_SW "  "0 ,1 "
bitfld.long 0 5.--7. " CLK38M_DDRPLL_SW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--14. " FREERUNNINGOSC_DIV "  " "
bitfld.long 0 15.--16. " SPARE_P4SUBCLK_EN "  "0 ,1 ,2 ,3 "
bitfld.long 0 17.--19. " P4SUBCLK_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 22. " EVT_FORCESFREERUNNING_CLK "  "0 ,1 "
bitfld.long 0 23.--25. " CLK38M_SOC1PLL_SW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 26. " CLK38MDSI_SW "  "0 ,1 "
bitfld.long 0 27. " PCLK_DBG_EN "  "0 ,1 "
bitfld.long 0 28. " CLK38M2CLKGEN_EN "  "0 ,1 "
bitfld.long 0 29. " CLK38M2DSI_EN "  "0 ,1 "
bitfld.long 0 30. " PMBCLK_EN "  "0 ,1 "
bitfld.long 0 31. " TEMP_SENS_EN "  "0 ,1 "
;tree.end

base ad:0x801570b4
;tree "PRCM_TIMER_0_REF"
group 0--3
line.long 0 "PRCM_TIMER_0_REF"
hexfld.long 0 " PRCM_TIMER_0_REF "
;tree.end

base ad:0x801570b8
;tree "PRCM_TIMER_0_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_0_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_0_DOWNCOUNT "
;tree.end

base ad:0x801570bc
;tree "PRCM_TIMER_0_MODE"
group 0--3
line.long 0 "PRCM_TIMER_0_MODE"
bitfld.long 0 0. " PRCM_TIMER_0_MODE "  "0 ,1 "
;tree.end

base ad:0x801570c0
;tree "PRCM_TIMER_1_REF"
group 0--3
line.long 0 "PRCM_TIMER_1_REF"
hexfld.long 0 " PRCM_TIMER_1_REF "
;tree.end

base ad:0x801570c4
;tree "PRCM_TIMER_1_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_1_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_1_DOWNCOUNT "
;tree.end

base ad:0x801570c8
;tree "PRCM_TIMER_1_MODE"
group 0--3
line.long 0 "PRCM_TIMER_1_MODE"
bitfld.long 0 0. " PRCM_TIMER_1_MODE "  "0 ,1 "
;tree.end

base ad:0x801570cc
;tree "PRCM_TIMER_2_REF"
group 0--3
line.long 0 "PRCM_TIMER_2_REF"
hexfld.long 0 " PRCM_TIMER_2_REF "
;tree.end

base ad:0x801570d0
;tree "PRCM_TIMER_2_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_2_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_2_DOWNCOUNT "
;tree.end

base ad:0x801570d4
;tree "PRCM_TIMER_2_MODE"
group 0--3
line.long 0 "PRCM_TIMER_2_MODE"
bitfld.long 0 0. " PRCM_TIMER_2_MODE "  "0 ,1 "
;tree.end

base ad:0x801570e4
;tree "PRCM_CLK009_MGT"
group 0--3
line.long 0 "PRCM_CLK009_MGT"
bitfld.long 0 0.--2. " CLK009DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CLK009CLK38SRC "  "0 ,1 "
;tree.end

base ad:0x801570e8
;tree "PRCM_MODECLK"
group 0--3
line.long 0 "PRCM_MODECLK"
bitfld.long 0 0.--2. " PRCM_MODECLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x801570f0
;tree "PRCM_ARM_IT_SET"
group 0--3
line.long 0 "PRCM_ARM_IT_SET"
bitfld.long 0 0. " PRCM_ARM_IT_SET "  "0 ,1 "
;tree.end

base ad:0x801570f4
;tree "PRCM_ARM_IT_CLR"
group 0--3
line.long 0 "PRCM_ARM_IT_CLR"
bitfld.long 0 0. " PRCM_ARM_IT_CLR "  "0 ,1 "
;tree.end

base ad:0x801570f8
;tree "PRCM_4500_CLK_REQ"
group 0--3
line.long 0 "PRCM_4500_CLK_REQ"
bitfld.long 0 0. " PRCM_4500_CLK_REQ "  "0 ,1 "
bitfld.long 0 16. " PRCM_MODSYSCLKREQ_EN "  "0 ,1 "
;tree.end

base ad:0x801570fc
;tree "PRCM_MBOX_CPU_VAL"
rgroup 0--3
line.long 0 "PRCM_MBOX_CPU_VAL"
bitfld.long 0 0. " XP70_IT_EVENT_10 "  "0 ,1 "
bitfld.long 0 1. " XP70_IT_EVENT_11 "  "0 ,1 "
bitfld.long 0 2. " XP70_IT_EVENT_12 "  "0 ,1 "
bitfld.long 0 3. " XP70_IT_EVENT_13 "  "0 ,1 "
bitfld.long 0 4. " XP70_IT_EVENT_16 "  "0 ,1 "
bitfld.long 0 5. " XP70_IT_EVENT_17 "  "0 ,1 "
bitfld.long 0 6. " XP70_IT_EVENT_18 "  "0 ,1 "
bitfld.long 0 7. " XP70_IT_EVENT_19 "  "0 ,1 "
;tree.end

base ad:0x80157100
;tree "PRCM_MBOX_CPU_SET"
wgroup 0--3
line.long 0 "PRCM_MBOX_CPU_SET"
bitfld.long 0 0. " XP70_IT_EVENT_10 "  "0 ,1 "
bitfld.long 0 1. " XP70_IT_EVENT_11 "  "0 ,1 "
bitfld.long 0 2. " XP70_IT_EVENT_12 "  "0 ,1 "
bitfld.long 0 3. " XP70_IT_EVENT_13 "  "0 ,1 "
bitfld.long 0 4. " XP70_IT_EVENT_16 "  "0 ,1 "
bitfld.long 0 5. " XP70_IT_EVENT_17 "  "0 ,1 "
bitfld.long 0 6. " XP70_IT_EVENT_18 "  "0 ,1 "
bitfld.long 0 7. " XP70_IT_EVENT_19 "  "0 ,1 "
;tree.end

base ad:0x80157104
;tree "PRCM_MBOX_CPU_CLR"
wgroup 0--3
line.long 0 "PRCM_MBOX_CPU_CLR"
bitfld.long 0 0. " XP70_IT_EVENT_10 "  "0 ,1 "
bitfld.long 0 1. " XP70_IT_EVENT_11 "  "0 ,1 "
bitfld.long 0 2. " XP70_IT_EVENT_12 "  "0 ,1 "
bitfld.long 0 3. " XP70_IT_EVENT_13 "  "0 ,1 "
bitfld.long 0 4. " XP70_IT_EVENT_16 "  "0 ,1 "
bitfld.long 0 5. " XP70_IT_EVENT_17 "  "0 ,1 "
bitfld.long 0 6. " XP70_IT_EVENT_18 "  "0 ,1 "
bitfld.long 0 7. " XP70_IT_EVENT_19 "  "0 ,1 "
;tree.end

base ad:0x8015710c
;tree "PRCM_PLL32K_ENABLE"
group 0--3
line.long 0 "PRCM_PLL32K_ENABLE"
bitfld.long 0 0. " PRCM_PLL32K_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLL32K_BIDIR_OEN "  "0 ,1 "
bitfld.long 0 2. " PRCM_PLL32K_GATE_EN "  "0 ,1 "
;tree.end

base ad:0x80157110
;tree "PRCM_PLL32K_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLL32K_LOCKP"
bitfld.long 0 0. " PRCM_PLL32K_LOCKP "  "0 ,1 "
;tree.end

base ad:0x80157114
;tree "PRCM_ARM_CHGCLKREQ"
group 0--3
line.long 0 "PRCM_ARM_CHGCLKREQ"
bitfld.long 0 0. " PRCM_ARM_CHGCLKREQ "  "0 ,1 "
bitfld.long 0 16. " PRCM_ARM_DIVSEL "  "0 ,1 "
;tree.end

base ad:0x80157118
;tree "PRCM_ARM_PLLDIVPS"
group 0--3
line.long 0 "PRCM_ARM_PLLDIVPS"
bitfld.long 0 0.--5. " ARM_BRM_RATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8.--9. " ARM_BRM_IDLEDIV "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " ARM_BRM_IDLEEN "  "0 ,1 "
bitfld.long 0 16.--17. " ARM_PLL_OBSDIV "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " ARM_PLL_OBSEN "  "0 ,1 "
;tree.end

base ad:0x8015711c
;tree "PRCM_ARMITMSK31TO0"
group 0--3
line.long 0 "PRCM_ARMITMSK31TO0"
hexfld.long 0 " PRCM_ARMITMSK31TO0 "
;tree.end

base ad:0x80157120
;tree "PRCM_ARMITMSK63TO32"
group 0--3
line.long 0 "PRCM_ARMITMSK63TO32"
hexfld.long 0 " PRCM_ARMITMSK63TO32 "
;tree.end

base ad:0x80157124
;tree "PRCM_ARMITMSK95TO64"
group 0--3
line.long 0 "PRCM_ARMITMSK95TO64"
hexfld.long 0 " PRCM_ARMITMSK95TO64 "
;tree.end

base ad:0x80157128
;tree "PRCM_ARMITMSK127TO96"
group 0--3
line.long 0 "PRCM_ARMITMSK127TO96"
hexfld.long 0 " PRCM_ARMITMSK127TO96 "
;tree.end

base ad:0x80157130
;tree "PRCM_ARMSTANDBY_STATUS"
rgroup 0--3
line.long 0 "PRCM_ARMSTANDBY_STATUS"
bitfld.long 0 0. " PL320_IDLE "  "0 ,1 "
bitfld.long 0 1. " STANDBYWFE_0 "  "0 ,1 "
bitfld.long 0 2. " STANDBYWFE_1 "  "0 ,1 "
bitfld.long 0 3. " STANDBYWFI_0 "  "0 ,1 "
bitfld.long 0 4. " STANDBYWFI_1 "  "0 ,1 "
bitfld.long 0 5. " STANDBYWFI_WFE "  "0 ,1 "
bitfld.long 0 6. " EVENT_O "  "0 ,1 "
;tree.end

base ad:0x80157134
;tree "PRCM_CGATING_BYPASS"
group 0--3
line.long 0 "PRCM_CGATING_BYPASS"
bitfld.long 0 0. " PRCMCKGEN_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 1. " APECKGEN_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 2. " DSS_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 3. " DMA_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 4. " ICN0_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 5. " ICN1_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 6. " ICN2_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 7. " ICN3_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 8. " SPARE0_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 9. " SPARE1_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 10. " SPARE2_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 11. " SPARE3_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 12. " SPARE4_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 13. " SPARE5_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 14. " SPARE6_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 15. " SPARE7_CGATING_BYPASS "  "0 ,1 "
;tree.end

base ad:0x80157138
;tree "PRCM_GPIOCR"
group 0--3
line.long 0 "PRCM_GPIOCR"
bitfld.long 0 0. " DBG_UARTMOD_CMD0 "  "0 ,1 "
bitfld.long 0 1. " DBG_UARTMOD_CMD1 "  "0 ,1 "
bitfld.long 0 2. " DBG_ETM_R4_CMD0 "  "0 ,1 "
bitfld.long 0 4. " DBG_NEXUS_CMD "  "0 ,1 "
bitfld.long 0 5. " DBG_PTM_A9_CMD0 "  "0 ,1 "
bitfld.long 0 6. " DBG_PTM_A9_CMD1 "  "0 ,1 "
bitfld.long 0 7. " DBG_SBAG_CMD0 "  "0 ,1 "
bitfld.long 0 8. " DBG_SBAG_CMD1 "  "0 ,1 "
bitfld.long 0 9. " DBG_STM_APE_CMD "  "0 ,1 "
bitfld.long 0 10. " DBG_STM_MOD_CMD0 "  "0 ,1 "
bitfld.long 0 11. " DBG_STM_MOD_CMD1 "  "0 ,1 "
bitfld.long 0 12. " DBG_KBD_CMD "  "0 ,1 "
bitfld.long 0 13. " DBG_STM_MOD_CMD2 "  "0 ,1 "
bitfld.long 0 14. " DBG_PTM_A9_CMD2 "  "0 ,1 "
bitfld.long 0 15. " DBG_ETM_R4_CMD1 "  "0 ,1 "
bitfld.long 0 16. " DBG_UARTMOD_CMD2 "  "0 ,1 "
bitfld.long 0 17. " TRIGGER_SELECT "  "0 ,1 "
bitfld.long 0 18. " REMAP_SELECT_ON "  "0 ,1 "
bitfld.long 0 19. " DBG_ETM_R4_CMD2 "  "0 ,1 "
bitfld.long 0 20. " DBG_PTM_A9_CMD3 "  "0 ,1 "
bitfld.long 0 21. " DBG_PTM_A9_CMD4 "  "0 ,1 "
bitfld.long 0 22. " DBG_PTM_A9_CMD5 "  "0 ,1 "
bitfld.long 0 23. " SPI2_SELECT "  "0 ,1 "
bitfld.long 0 24. " DBG_HW_OBS_CMD1 "  "0 ,1 "
bitfld.long 0 25. " DBG_HW_OBS_CMD2 "  "0 ,1 "
bitfld.long 0 27. " MSPBYP01AEN "  "0 ,1 "
bitfld.long 0 28. " MSPBYP01CK10 "  "0 ,1 "
bitfld.long 0 29. " MSPBYP01CK01 "  "0 ,1 "
bitfld.long 0 30. " MSPBYP01FS10 "  "0 ,1 "
bitfld.long 0 31. " MSPBYP01FS01 "  "0 ,1 "
;tree.end

base ad:0x8015713c
;tree "PRCM_LEMI"
group 0--3
line.long 0 "PRCM_LEMI"
bitfld.long 0 0. " APECLK "  "0 ,1 "
bitfld.long 0 1. " APEINT "  "0 ,1 "
bitfld.long 0 2. " I2CAPE "  "0 ,1 "
bitfld.long 0 3. " I2CMOD "  "0 ,1 "
bitfld.long 0 4. " GPS "  "0 ,1 "
bitfld.long 0 5. " UICC "  "0 ,1 "
bitfld.long 0 6. " LINKO "  "0 ,1 "
bitfld.long 0 7. " MOD4500 "  "0 ,1 "
bitfld.long 0 8. " RST4500 "  "0 ,1 "
bitfld.long 0 9. " RTCK "  "0 ,1 "
bitfld.long 0 10. " CLKREQ "  "0 ,1 "
bitfld.long 0 11. " JTAG "  "0 ,1 "
hexfld.word 1 " RESERVED_FOR_PUPD "
;tree.end

base ad:0x80157140
;tree "PRCM_COMPCR"
group 0--3
line.long 0 "PRCM_COMPCR"
bitfld.long 0 0. " C1V2COMPTYP "  "0 ,1 "
bitfld.long 0 1. " C1V2COMPFRZ "  "0 ,1 "
bitfld.long 0 2. " C1V2COMPN "  "0 ,1 "
bitfld.long 0 3. " C1V8COMPTQ "  "0 ,1 "
bitfld.long 0 4. " C1V8COMPFRZ "  "0 ,1 "
bitfld.long 0 5. " C1V8COMPN "  "0 ,1 "
bitfld.long 0 6. " C1V8COMPACCURATE "  "0 ,1 "
bitfld.long 0 7. " C1V8COMPFASTFRZ "  "0 ,1 "
bitfld.long 0 16.--22. " C1V8NASRCR "  " "
bitfld.long 0 23.--29. " C1V8PASRCR "  " "
;tree.end

base ad:0x80157144
;tree "PRCM_COMPSTA"
rgroup 0--3
line.long 0 "PRCM_COMPSTA"
bitfld.long 0 0. " C1V2COMPOK "  "0 ,1 "
bitfld.long 0 2.--8. " C1V2NASRC "  " "
bitfld.long 0 9.--15. " C1V2PASRC "  " "
bitfld.long 0 16. " C1V8COMPOK "  "0 ,1 "
bitfld.long 0 18.--24. " C1V8NASRC "  " "
bitfld.long 0 25.--31. " C1V8PASRC "  " "
;tree.end

base ad:0x80157148
;tree "PRCM_ITSTATUS0"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS0"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " HSI_CAWAKE0 "  "0 ,1 "
bitfld.long 0 4. " HSI_CAWAKE1 "  "0 ,1 "
bitfld.long 0 5. " MOD_WAKE_HOST_IRQ "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " APEINT_4500 "  "0 ,1 "
;tree.end

base ad:0x8015714c
;tree "PRCM_ITCLR0"
wgroup 0--3
line.long 0 "PRCM_ITCLR0"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " HSI_CAWAKE0 "  "0 ,1 "
bitfld.long 0 4. " HSI_CAWAKE1 "  "0 ,1 "
bitfld.long 0 5. " MOD_WAKE_HOST_IRQ "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " APEINT_4500 "  "0 ,1 "
;tree.end

base ad:0x80157150
;tree "PRCM_ITSTATUS1"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS1"
bitfld.long 0 0. " FIFO4500IT "  "0 ,1 "
;tree.end

base ad:0x80157154
;tree "PRCM_ITCLR1"
wgroup 0--3
line.long 0 "PRCM_ITCLR1"
bitfld.long 0 0. " FIFO4500IT "  "0 ,1 "
;tree.end

base ad:0x80157158
;tree "PRCM_ITSTATUS2"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS2"
bitfld.long 0 0. " MOD_MEM_IF_REQ "  "0 ,1 "
bitfld.long 0 1. " MOD_REQ_LATENCY "  "0 ,1 "
bitfld.long 0 2. " MOD_HOST_PORT_AVAILABLE "  "0 ,1 "
bitfld.long 0 3. " MOD_MEM_IF_ACK "  "0 ,1 "
;tree.end

base ad:0x8015715c
;tree "PRCM_ITCLR2"
wgroup 0--3
line.long 0 "PRCM_ITCLR2"
bitfld.long 0 0. " MOD_MEM_IF_REQ "  "0 ,1 "
bitfld.long 0 1. " MOD_REQ_LATENCY "  "0 ,1 "
bitfld.long 0 2. " MOD_HOST_PORT_AVAILABLE "  "0 ,1 "
bitfld.long 0 3. " MOD_MEM_IF_ACK "  "0 ,1 "
;tree.end

base ad:0x80157160
;tree "PRCM_ITSTATUS3"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS3"
bitfld.long 0 0. " MOD_STATE "  "0 ,1 "
bitfld.long 0 1. " MOD_PWRENA "  "0 ,1 "
bitfld.long 0 2. " MOD_SYSCLKREQ "  "0 ,1 "
bitfld.long 0 3. " MOD_AUX_CLK_REQ "  "0 ,1 "
;tree.end

base ad:0x80157164
;tree "PRCM_ITCLR3"
wgroup 0--3
line.long 0 "PRCM_ITCLR3"
bitfld.long 0 0. " MOD_STATE "  "0 ,1 "
bitfld.long 0 1. " MOD_PWRENA "  "0 ,1 "
bitfld.long 0 2. " MOD_SYSCLKREQ "  "0 ,1 "
bitfld.long 0 3. " MOD_AUX_CLK_REQ "  "0 ,1 "
;tree.end

base ad:0x80157168
;tree "PRCM_ITSTATUS4"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS4"
bitfld.long 0 0. " SWRESET "  "0 ,1 "
bitfld.long 0 1. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 2. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 3. " MOD_SW_RESET_REQ "  "0 ,1 "
bitfld.long 0 4. " HSEM_INT_SVA_MMDSP "  "0 ,1 "
bitfld.long 0 5. " HSEM_INT_SIA_MMDSP "  "0 ,1 "
;tree.end

base ad:0x8015716c
;tree "PRCM_ITCLR4"
wgroup 0--3
line.long 0 "PRCM_ITCLR4"
bitfld.long 0 0. " SWRESET "  "0 ,1 "
bitfld.long 0 1. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 2. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 3. " MOD_SW_RESET_REQ "  "0 ,1 "
bitfld.long 0 4. " HSEM_INT_SVA_MMDSP "  "0 ,1 "
bitfld.long 0 5. " HSEM_INT_SIA_MMDSP "  "0 ,1 "
;tree.end

base ad:0x80157170
;tree "PRCM_LINE_VALUE"
rgroup 0--3
line.long 0 "PRCM_LINE_VALUE"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " HSI_CAWAKE0 "  "0 ,1 "
bitfld.long 0 4. " HSI_CAWAKE1 "  "0 ,1 "
bitfld.long 0 5. " MOD_WAKE_HOST_IRQ "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " APEINT_4500 "  "0 ,1 "
bitfld.long 0 8. " FIFO4500IT "  "0 ,1 "
bitfld.long 0 9. " MOD_MEM_IF_REQ "  "0 ,1 "
bitfld.long 0 10. " MOD_REQ_LATENCY "  "0 ,1 "
bitfld.long 0 11. " MOD_HOST_PORT_AVAILABLE "  "0 ,1 "
bitfld.long 0 12. " MOD_MEM_IF_ACK "  "0 ,1 "
bitfld.long 0 13. " MOD_STATE "  "0 ,1 "
bitfld.long 0 14. " MOD_PWRENA "  "0 ,1 "
bitfld.long 0 15. " MOD_SYSCLKREQ "  "0 ,1 "
bitfld.long 0 16. " MOD_AUX_CLK_REQ "  "0 ,1 "
bitfld.long 0 17. " SWRESET "  "0 ,1 "
bitfld.long 0 18. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 19. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 20. " MOD_SW_RESET_REQ "  "0 ,1 "
bitfld.long 0 21. " HSEM_INT_SVA_MMDSP "  "0 ,1 "
bitfld.long 0 22. " HSEM_INT_SIA_MMDSP "  "0 ,1 "
bitfld.long 0 23.--31. " GPIO_EVENTS "  " "
;tree.end

base ad:0x80157174
;tree "PRCM_HOLD_EVT"
group 0--3
line.long 0 "PRCM_HOLD_EVT"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " HSI_CAWAKE0 "  "0 ,1 "
bitfld.long 0 4. " HSI_CAWAKE1 "  "0 ,1 "
bitfld.long 0 5. " MOD_WAKE_HOST_IRQ "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " APEINT_4500 "  "0 ,1 "
bitfld.long 0 8. " FIFO4500IT "  "0 ,1 "
bitfld.long 0 9. " MOD_MEM_IF_REQ "  "0 ,1 "
bitfld.long 0 10. " MOD_REQ_LATENCY "  "0 ,1 "
bitfld.long 0 11. " MOD_HOST_PORT_AVAILABLE "  "0 ,1 "
bitfld.long 0 12. " MOD_MEM_IF_ACK "  "0 ,1 "
bitfld.long 0 13. " MOD_STATE "  "0 ,1 "
bitfld.long 0 14. " MOD_PWRENA "  "0 ,1 "
bitfld.long 0 15. " MOD_SYSCLKREQ "  "0 ,1 "
bitfld.long 0 16. " MOD_AUX_CLK_REQ "  "0 ,1 "
bitfld.long 0 17. " SWRESET "  "0 ,1 "
bitfld.long 0 18. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 19. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 20. " MOD_SW_RESET_REQ "  "0 ,1 "
bitfld.long 0 21. " HSEM_INT_SVA_MMDSP "  "0 ,1 "
bitfld.long 0 22. " HSEM_INT_SIA_MMDSP "  "0 ,1 "
bitfld.long 0 23.--31. " GPIO_EVENTS "  " "
;tree.end

base ad:0x80157178
;tree "PRCM_EDGE_SENS_L"
group 0--3
line.long 0 "PRCM_EDGE_SENS_L"
bitfld.long 0 0.--1. " RTCWKUP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " RTT0WKUP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " RTT1WKUP "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " HSI_CAWAKE0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " HSI_CAWAKE1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " MOD_WAKE_HOST_IRQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " USB_WKUP "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " APEINT_4500 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " FIFO4500IT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " MOD_MEM_IF_REQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " MOD_REQ_LATENCY "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " MOD_HOST_PORT_AVAILABLE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " MOD_MEM_IF_ACK "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " MOD_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " MOD_PWRENA "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " MOD_SYSCLKREQ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8015717c
;tree "PRCM_EDGE_SENS_H"
group 0--3
line.long 0 "PRCM_EDGE_SENS_H"
bitfld.long 0 0.--1. " MOD_AUX_CLK_REQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " SWRESET "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " A9_WDRSTREQ_INT_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " A9_WDRSTREQ_INT_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " MOD_SW_RESET_REQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " HSEM_INT_SVA_MMDSP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " HSEM_INT_SIA_MMDSP "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " GPIO_EVENTS_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " GPIO_EVENTS_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " GPIO_EVENTS_2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " GPIO_EVENTS_3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " GPIO_EVENTS_4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " GPIO_EVENTS_5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " GPIO_EVENTS_6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " GPIO_EVENTS_7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " GPIO_EVENTS_8 "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80157190
;tree "PRCM_DEBUG_CTRL_VAL"
rgroup 0--3
line.long 0 "PRCM_DEBUG_CTRL_VAL"
bitfld.long 0 0. " MOD_PWRUPACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
;tree.end

base ad:0x80157194
;tree "PRCM_DEBUG_NOPWRDOWN_VAL"
rgroup 0--3
line.long 0 "PRCM_DEBUG_NOPWRDOWN_VAL"
bitfld.long 0 0. " ARM_DEBUG_NOPOWER_DOWN_REQ "  "0 ,1 "
bitfld.long 0 1. " SVA_DEBUG_NOPOWER_DOWN_REQ "  "0 ,1 "
bitfld.long 0 2. " SIA_DEBUG_NOPOWER_DOWN_REQ "  "0 ,1 "
;tree.end

base ad:0x80157198
;tree "PRCM_DEBUG_CTRL_ACK"
group 0--3
line.long 0 "PRCM_DEBUG_CTRL_ACK"
bitfld.long 0 0. " SIA_PWRUP_ACK "  "0 ,1 "
bitfld.long 0 1. " SVA_PWRUP_ACK "  "0 ,1 "
bitfld.long 0 2. " MOD_PWRUPREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_CSYSPWRUPACK "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_CDBGRSTACK "  "0 ,1 "
bitfld.long 0 8. " CSYSPWRUP_SWT "  "0 ,1 "
;tree.end

base ad:0x8015719c
;tree "PRCM_A9PL_FORCE_CLKEN"
group 0--3
line.long 0 "PRCM_A9PL_FORCE_CLKEN"
bitfld.long 0 0. " PRCM_A9PL_FORCE_CLKEN "  "0 ,1 "
bitfld.long 0 1. " PRCM_A9AXI_FORCE_CLKEN "  "0 ,1 "
;tree.end

base ad:0x801571a0
;tree "PRCM_TPIU_FLUSHIN_REQ"
group 0--3
line.long 0 "PRCM_TPIU_FLUSHIN_REQ"
bitfld.long 0 0. " PRCM_TPIU_FLUSHIN_REQ "  "0 ,1 "
;tree.end

base ad:0x801571a4
;tree "PRCM_TPIU_FLUSHIN_ACK"
rgroup 0--3
line.long 0 "PRCM_TPIU_FLUSHIN_ACK"
bitfld.long 0 0. " PRCM_TPIU_FLUSHIN_ACK "  "0 ,1 "
;tree.end

base ad:0x801571a8
;tree "PRCM_STP_FLUSHIN_REQ"
group 0--3
line.long 0 "PRCM_STP_FLUSHIN_REQ"
bitfld.long 0 0. " PRCM_STP_FLUSHIN_REQ "  "0 ,1 "
;tree.end

base ad:0x801571ac
;tree "PRCM_STP_FLUSHIN_ACK"
rgroup 0--3
line.long 0 "PRCM_STP_FLUSHIN_ACK"
bitfld.long 0 0. " PRCM_STP_FLUSHIN_ACK "  "0 ,1 "
;tree.end

base ad:0x801571b0
;tree "PRCM_HWI2C_DIV"
group 0--3
line.long 0 "PRCM_HWI2C_DIV"
