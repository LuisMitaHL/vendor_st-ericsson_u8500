bitfld.long 0 0.--1. " PRCM_HWI2C_DIV "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x801571b4
;tree "PRCM_HWI2C_GO"
group 0--3
line.long 0 "PRCM_HWI2C_GO"
bitfld.long 0 0. " PRCM_HWI2C_GO "  "0 ,1 "
;tree.end

base ad:0x801571b8
;tree "PRCM_HWI2C_CMD"
group 0--3
line.long 0 "PRCM_HWI2C_CMD"
bitfld.long 0 0. " RWB "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--9. " TSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " HWGCEN "  "0 ,1 "
bitfld.long 0 11. " STOPEN "  "0 ,1 "
hexfld.byte 2 " REG_ADD "
hexfld.byte 3 " REG_DATA "
;tree.end

base ad:0x801571bc
;tree "PRCM_HWI2C_DATA123"
group 0--3
line.long 0 "PRCM_HWI2C_DATA123"
hexfld.byte 0 " DATA1 "
hexfld.byte 1 " DATA2 "
hexfld.byte 2 " DATA3 "
;tree.end

base ad:0x801571c0
;tree "PRCM_HWI2C_SR"
rgroup 0--3
line.long 0 "PRCM_HWI2C_SR"
bitfld.long 0 0.--1. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x801571c4
;tree "PRCM_REMAPCR"
group 0--3
line.long 0 "PRCM_REMAPCR"
bitfld.long 0 0. " REMAPCLR "  "0 ,1 "
bitfld.long 0 1. " REMAPSTAT "  "0 ,1 "
;tree.end

base ad:0x801571c8
;tree "PRCM_TCR"
group 0--3
line.long 0 "PRCM_TCR"
bitfld.long 0 0. " TENSEL0 "  "0 ,1 "
bitfld.long 0 1. " TENSEL1 "  "0 ,1 "
bitfld.long 0 2. " TENSEL2 "  "0 ,1 "
bitfld.long 0 3. " TENSEL3 "  "0 ,1 "
bitfld.long 0 4. " TENSEL4 "  "0 ,1 "
bitfld.long 0 5. " TENSEL5 "  "0 ,1 "
bitfld.long 0 6. " TENSEL6 "  "0 ,1 "
bitfld.long 0 7. " TENSEL7 "  "0 ,1 "
bitfld.long 0 16. " STOP_TIMERS "  "0 ,1 "
bitfld.long 0 17. " DOZE_MODE "  "0 ,1 "
;tree.end

base ad:0x801571cc
;tree "PRCM_CLKOCR"
group 0--3
line.long 0 "PRCM_CLKOCR"
bitfld.long 0 0.--5. " CLKODIV0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--8. " CLKOSEL0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--21. " CLKODIV1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--24. " CLKOSEL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 28. " CLK1TYPE "  "0 ,1 "
;tree.end

base ad:0x801571d0
;tree "PRCM_ITSTATUS_DBG"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS_DBG"
bitfld.long 0 0. " MOD_PWRUPACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
;tree.end

base ad:0x801571d4
;tree "PRCM_ITCLR_DBG"
wgroup 0--3
line.long 0 "PRCM_ITCLR_DBG"
bitfld.long 0 0. " MOD_PWRUPACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
;tree.end

base ad:0x801571d8
;tree "PRCM_LINE_VALUE_DBG"
rgroup 0--3
line.long 0 "PRCM_LINE_VALUE_DBG"
bitfld.long 0 0. " MOD_PWRUPACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
;tree.end

base ad:0x801571dc
;tree "PRCM_DBG_HOLD"
group 0--3
line.long 0 "PRCM_DBG_HOLD"
bitfld.long 0 0. " MOD_PWRUPACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
;tree.end

base ad:0x801571e0
;tree "PRCM_EDGE_SENS_DBG"
group 0--3
line.long 0 "PRCM_EDGE_SENS_DBG"
bitfld.long 0 0.--1. " MOD_PWRUPACK "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " DAP_APE_CDBGRSTREQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x801571e4
;tree "PRCM_APE_RESETN_SET"
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "
bitfld.long 0 1. " SGA_M_INITN "  "0 ,1 "
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " DSS_M_INITN "  "0 ,1 "
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 11. " SIA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 14. " DSIPLL_RESETN "  "0 ,1 "
bitfld.long 0 17. " DDR_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 18. " DDR_MOD_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 19. " DDR_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 20. " DDR_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 21. " SPARE_1 "  "0 ,1 "
bitfld.long 0 22. " SIA_PIPE_M_RAD_RESETN "  "0 ,1 "
bitfld.long 0 24. " ESRAM1_INITN "  "0 ,1 "
bitfld.long 0 25. " ESRAM2_INITN "  "0 ,1 "
bitfld.long 0 26. " ESRAM3_INITN "  "0 ,1 "
bitfld.long 0 27. " ESRAM4_INITN "  "0 ,1 "
bitfld.long 0 29. " APE_MEM_INITN "  "0 ,1 "
bitfld.long 0 30. " APE_PWRON_RESETN "  "0 ,1 "
bitfld.long 0 31. " APE_RESETN "  "0 ,1 "
;tree.end

base ad:0x801571e8
;tree "PRCM_APE_RESETN_CLR"
group 0--3
line.long 0 "PRCM_APE_RESETN_CLR"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "
bitfld.long 0 1. " SGA_M_INITN "  "0 ,1 "
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " DSS_M_INITN "  "0 ,1 "
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 11. " SIA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 14. " DSIPLL_RESETN "  "0 ,1 "
bitfld.long 0 17. " DDR_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 18. " DDR_MOD_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 19. " DDR_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 20. " DDR_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 21. " SPARE_1 "  "0 ,1 "
bitfld.long 0 22. " SIA_PIPE_M_RAD_RESETN "  "0 ,1 "
bitfld.long 0 24. " ESRAM1_INITN "  "0 ,1 "
bitfld.long 0 25. " ESRAM2_INITN "  "0 ,1 "
bitfld.long 0 26. " ESRAM3_INITN "  "0 ,1 "
bitfld.long 0 27. " ESRAM4_INITN "  "0 ,1 "
bitfld.long 0 29. " APE_MEM_INITN "  "0 ,1 "
bitfld.long 0 30. " APE_PWRON_RESETN "  "0 ,1 "
bitfld.long 0 31. " APE_RESETN "  "0 ,1 "
;tree.end

base ad:0x801571ec
;tree "PRCM_APE_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "
bitfld.long 0 1. " SGA_M_INITN "  "0 ,1 "
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " DSS_M_INITN "  "0 ,1 "
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 11. " SIA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 14. " DSIPLL_RESETN "  "0 ,1 "
bitfld.long 0 17. " DDR_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 18. " DDR_MOD_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 19. " DDR_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 20. " DDR_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 21. " SPARE_1 "  "0 ,1 "
bitfld.long 0 22. " SIA_PIPE_M_RAD_RESETN "  "0 ,1 "
bitfld.long 0 24. " ESRAM1_INITN "  "0 ,1 "
bitfld.long 0 25. " ESRAM2_INITN "  "0 ,1 "
bitfld.long 0 26. " ESRAM3_INITN "  "0 ,1 "
bitfld.long 0 27. " ESRAM4_INITN "  "0 ,1 "
bitfld.long 0 29. " APE_MEM_INITN "  "0 ,1 "
bitfld.long 0 30. " APE_PWRON_RESETN "  "0 ,1 "
bitfld.long 0 31. " APE_RESETN "  "0 ,1 "
;tree.end

base ad:0x801571f0
;tree "PRCM_A9_RESETN_SET"
group 0--3
line.long 0 "PRCM_A9_RESETN_SET"
bitfld.long 0 0. " A9_NPORESET "  "0 ,1 "
bitfld.long 0 1. " A9_NRESET_SLICE "  "0 ,1 "
bitfld.long 0 2. " APE_NRESET "  "0 ,1 "
bitfld.long 0 3. " A9_NRESET_DBG "  "0 ,1 "
bitfld.long 0 4. " A9_NRESET_0 "  "0 ,1 "
bitfld.long 0 5. " A9_NRESET_1 "  "0 ,1 "
bitfld.long 0 6. " A9_WD_REQ_RESETN "  "0 ,1 "
bitfld.long 0 7. " A9_NRESET_SWPLL_FF "  "0 ,1 "
;tree.end

base ad:0x801571f4
;tree "PRCM_A9_RESETN_CLR"
group 0--3
line.long 0 "PRCM_A9_RESETN_CLR"
bitfld.long 0 0. " A9_NPORESET "  "0 ,1 "
bitfld.long 0 1. " A9_NRESET_SLICE "  "0 ,1 "
bitfld.long 0 2. " APE_NRESET "  "0 ,1 "
bitfld.long 0 3. " A9_NRESET_DBG "  "0 ,1 "
bitfld.long 0 4. " A9_NRESET_0 "  "0 ,1 "
bitfld.long 0 5. " A9_NRESET_1 "  "0 ,1 "
bitfld.long 0 6. " A9_WD_REQ_RESETN "  "0 ,1 "
bitfld.long 0 7. " A9_NRESET_SWPLL_FF "  "0 ,1 "
;tree.end

base ad:0x801571f8
;tree "PRCM_A9_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_A9_RESETN_VAL"
bitfld.long 0 0. " A9_NPORESET "  "0 ,1 "
bitfld.long 0 1. " A9_NRESET_SLICE "  "0 ,1 "
bitfld.long 0 2. " APE_NRESET "  "0 ,1 "
bitfld.long 0 3. " A9_NRESET_DBG "  "0 ,1 "
bitfld.long 0 4. " A9_NRESET_0 "  "0 ,1 "
bitfld.long 0 5. " A9_NRESET_1 "  "0 ,1 "
bitfld.long 0 6. " A9_WD_REQ_RESETN "  "0 ,1 "
bitfld.long 0 7. " A9_NRESET_SWPLL_FF "  "0 ,1 "
;tree.end

base ad:0x801571fc
;tree "PRCM_MOD_RESETN_SET"
group 0--3
line.long 0 "PRCM_MOD_RESETN_SET"
bitfld.long 0 0. " NPURESET "  "0 ,1 "
bitfld.long 0 1. " NSWRESET "  "0 ,1 "
;tree.end

base ad:0x80157200
;tree "PRCM_MOD_RESETN_CLR"
group 0--3
line.long 0 "PRCM_MOD_RESETN_CLR"
bitfld.long 0 0. " NPURESET "  "0 ,1 "
bitfld.long 0 1. " NSWRESET "  "0 ,1 "
;tree.end

base ad:0x80157204
;tree "PRCM_MOD_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_MOD_RESETN_VAL"
bitfld.long 0 0. " NPURESET "  "0 ,1 "
bitfld.long 0 1. " NSWRESET "  "0 ,1 "
;tree.end

base ad:0x80157208
;tree "PRCM_GPIO_RESETN_SET"
group 0--3
line.long 0 "PRCM_GPIO_RESETN_SET"
bitfld.long 0 0. " GPIO_RESETN_GRP0 "  "0 ,1 "
bitfld.long 0 1. " GPIO_RESETN_GRP0_MX "  "0 ,1 "
bitfld.long 0 2. " GPIO_RESETN_GRP1 "  "0 ,1 "
bitfld.long 0 3. " GPIO_RESETN_GRP1_MX "  "0 ,1 "
bitfld.long 0 4. " GPIO_RESETN_GRP2 "  "0 ,1 "
bitfld.long 0 5. " GPIO_RESETN_GRP2_MX "  "0 ,1 "
bitfld.long 0 6. " GPIO_RESETN_GRP3 "  "0 ,1 "
bitfld.long 0 7. " GPIO_RESETN_GRP3_MX "  "0 ,1 "
bitfld.long 0 8. " GPIO_RESETN_GRP4 "  "0 ,1 "
bitfld.long 0 9. " GPIO_RESETN_GRP4_MX "  "0 ,1 "
bitfld.long 0 10. " GPIO_RESETN_GRP5 "  "0 ,1 "
bitfld.long 0 11. " GPIO_RESETN_GRP5_MX "  "0 ,1 "
bitfld.long 0 12. " GPIO_RESETN_GRP6 "  "0 ,1 "
bitfld.long 0 13. " GPIO_RESETN_GRP6_MX "  "0 ,1 "
bitfld.long 0 14. " GPIO_RESETN_GRP7 "  "0 ,1 "
bitfld.long 0 15. " GPIO_RESETN_GRP7_MX "  "0 ,1 "
bitfld.long 0 16. " GPIO_RESETN_GRP8 "  "0 ,1 "
bitfld.long 0 17. " GPIO_RESETN_GRP8_MX "  "0 ,1 "
;tree.end

base ad:0x8015720c
;tree "PRCM_GPIO_RESETN_CLR"
group 0--3
line.long 0 "PRCM_GPIO_RESETN_CLR"
bitfld.long 0 0. " GPIO_RESETN_GRP0 "  "0 ,1 "
bitfld.long 0 1. " GPIO_RESETN_GRP0_MX "  "0 ,1 "
bitfld.long 0 2. " GPIO_RESETN_GRP1 "  "0 ,1 "
bitfld.long 0 3. " GPIO_RESETN_GRP1_MX "  "0 ,1 "
bitfld.long 0 4. " GPIO_RESETN_GRP2 "  "0 ,1 "
bitfld.long 0 5. " GPIO_RESETN_GRP2_MX "  "0 ,1 "
bitfld.long 0 6. " GPIO_RESETN_GRP3 "  "0 ,1 "
bitfld.long 0 7. " GPIO_RESETN_GRP3_MX "  "0 ,1 "
bitfld.long 0 8. " GPIO_RESETN_GRP4 "  "0 ,1 "
bitfld.long 0 9. " GPIO_RESETN_GRP4_MX "  "0 ,1 "
bitfld.long 0 10. " GPIO_RESETN_GRP5 "  "0 ,1 "
bitfld.long 0 11. " GPIO_RESETN_GRP5_MX "  "0 ,1 "
bitfld.long 0 12. " GPIO_RESETN_GRP6 "  "0 ,1 "
bitfld.long 0 13. " GPIO_RESETN_GRP6_MX "  "0 ,1 "
bitfld.long 0 14. " GPIO_RESETN_GRP7 "  "0 ,1 "
bitfld.long 0 15. " GPIO_RESETN_GRP7_MX "  "0 ,1 "
bitfld.long 0 16. " GPIO_RESETN_GRP8 "  "0 ,1 "
bitfld.long 0 17. " GPIO_RESETN_GRP8_MX "  "0 ,1 "
;tree.end

base ad:0x80157210
;tree "PRCM_GPIO_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_GPIO_RESETN_VAL"
bitfld.long 0 0. " GPIO_RESETN_GRP0 "  "0 ,1 "
bitfld.long 0 1. " GPIO_RESETN_GRP0_MX "  "0 ,1 "
bitfld.long 0 2. " GPIO_RESETN_GRP1 "  "0 ,1 "
bitfld.long 0 3. " GPIO_RESETN_GRP1_MX "  "0 ,1 "
bitfld.long 0 4. " GPIO_RESETN_GRP2 "  "0 ,1 "
bitfld.long 0 5. " GPIO_RESETN_GRP2_MX "  "0 ,1 "
bitfld.long 0 6. " GPIO_RESETN_GRP3 "  "0 ,1 "
bitfld.long 0 7. " GPIO_RESETN_GRP3_MX "  "0 ,1 "
bitfld.long 0 8. " GPIO_RESETN_GRP4 "  "0 ,1 "
bitfld.long 0 9. " GPIO_RESETN_GRP4_MX "  "0 ,1 "
bitfld.long 0 10. " GPIO_RESETN_GRP5 "  "0 ,1 "
bitfld.long 0 11. " GPIO_RESETN_GRP5_MX "  "0 ,1 "
bitfld.long 0 12. " GPIO_RESETN_GRP6 "  "0 ,1 "
bitfld.long 0 13. " GPIO_RESETN_GRP6_MX "  "0 ,1 "
bitfld.long 0 14. " GPIO_RESETN_GRP7 "  "0 ,1 "
bitfld.long 0 15. " GPIO_RESETN_GRP7_MX "  "0 ,1 "
bitfld.long 0 16. " GPIO_RESETN_GRP8 "  "0 ,1 "
bitfld.long 0 17. " GPIO_RESETN_GRP8_MX "  "0 ,1 "
;tree.end

base ad:0x80157214
;tree "PRCM_4500_RESETN_SET"
group 0--3
line.long 0 "PRCM_4500_RESETN_SET"
bitfld.long 0 0. " STN4500_RESETN "  "0 ,1 "
;tree.end

base ad:0x80157218
;tree "PRCM_4500_RESETN_CLR"
group 0--3
line.long 0 "PRCM_4500_RESETN_CLR"
bitfld.long 0 0. " STN4500_RESETN "  "0 ,1 "
;tree.end

base ad:0x8015721c
;tree "PRCM_4500_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_4500_RESETN_VAL"
bitfld.long 0 0. " STN4500_RESETN "  "0 ,1 "
;tree.end

base ad:0x80157224
;tree "PRCM_HSI_SOFTRST"
wgroup 0--3
line.long 0 "PRCM_HSI_SOFTRST"
bitfld.long 0 0. " HSITX_SOFTRST "  "0 ,1 "
bitfld.long 0 1. " HSIRX_SOFTRST "  "0 ,1 "
;tree.end

base ad:0x80157228
;tree "PRCM_APE_SOFTRST"
wgroup 0--3
line.long 0 "PRCM_APE_SOFTRST"
bitfld.long 0 0. " PRCM_APE_SOFTRST "  "0 ,1 "
;tree.end

base ad:0x80157238
;tree "PRCM_SWD_RST_TEMPO"
group 0--3
line.long 0 "PRCM_SWD_RST_TEMPO"
bitfld.long 0 0.--9. " PRCM_SWD_RST_TEMPO "  " "
;tree.end

base ad:0x8015723c
;tree "PRCM_RST_4500_TEMPO"
group 0--3
line.long 0 "PRCM_RST_4500_TEMPO"
bitfld.long 0 0.--9. " PRCM_RST_4500_TEMPO "  " "
;tree.end

base ad:0x80157240
;tree "PRCM_SVAMMDSP_IT"
group 0--3
line.long 0 "PRCM_SVAMMDSP_IT"
hexfld.byte 0 " PRCM_SVAMMDSP_IT "
;tree.end

base ad:0x80157244
;tree "PRCM_SVAMMDSP_IT_CLR"
group 0--3
line.long 0 "PRCM_SVAMMDSP_IT_CLR"
bitfld.long 0 0. " PRCM_SVAMMDSP_IT_CLR "  "0 ,1 "
;tree.end

base ad:0x80157248
;tree "PRCM_SIAMMDSP_IT"
group 0--3
line.long 0 "PRCM_SIAMMDSP_IT"
hexfld.byte 0 " PRCM_SIAMMDSP_IT "
;tree.end

base ad:0x8015724c
;tree "PRCM_SIAMMDSP_IT_CLR"
group 0--3
line.long 0 "PRCM_SIAMMDSP_IT_CLR"
bitfld.long 0 0. " PRCM_SIAMMDSP_IT_CLR "  "0 ,1 "
;tree.end

base ad:0x80157250
;tree "PRCM_STM_DATA"
wgroup 0--3
line.long 0 "PRCM_STM_DATA"
hexfld.byte 0 " PRCM_STM_DATA "
;tree.end

base ad:0x80157254
;tree "PRCM_POWER_STATE_SET"
group 0--3
line.long 0 "PRCM_POWER_STATE_SET"
bitfld.long 0 0.--1. " VAPE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " VARM_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " DDR_CONTROLLER "  "0 ,1 "
bitfld.long 0 5.--6. " SIA_MMDSP_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SIA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 8.--9. " SVA_MMDSP_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " SVA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 11. " DSS_STATE "  "0 ,1 "
bitfld.long 0 12. " SGA_STATE "  "0 ,1 "
bitfld.long 0 13.--14. " VMODEM_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " CSI_DSI "  "0 ,1 "
bitfld.long 0 16.--17. " ESRAM0_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " ESRAM1_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " ESRAM2_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " ESRAM3_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " ESRAM4_STATE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80157258
;tree "PRCM_POWER_STATE_CLR"
group 0--3
line.long 0 "PRCM_POWER_STATE_CLR"
bitfld.long 0 0.--1. " VAPE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " VARM_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " DDR_CONTROLLER "  "0 ,1 "
bitfld.long 0 5.--6. " SIA_MMDSP_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SIA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 8.--9. " SVA_MMDSP_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " SVA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 11. " DSS_STATE "  "0 ,1 "
bitfld.long 0 12. " SGA_STATE "  "0 ,1 "
bitfld.long 0 13.--14. " VMODEM_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " CSI_DSI "  "0 ,1 "
bitfld.long 0 16.--17. " ESRAM0_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " ESRAM1_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " ESRAM2_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " ESRAM3_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " ESRAM4_STATE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8015725c
;tree "PRCM_POWER_STATE_VAL"
group 0--3
line.long 0 "PRCM_POWER_STATE_VAL"
bitfld.long 0 0.--1. " VAPE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " VARM_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " DDR_CONTROLLER "  "0 ,1 "
bitfld.long 0 5.--6. " SIA_MMDSP_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SIA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 8.--9. " SVA_MMDSP_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " SVA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 11. " DSS_STATE "  "0 ,1 "
bitfld.long 0 12. " SGA_STATE "  "0 ,1 "
bitfld.long 0 13.--14. " VMODEM_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " CSI_DSI "  "0 ,1 "
bitfld.long 0 16.--17. " ESRAM0_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " ESRAM1_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " ESRAM2_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " ESRAM3_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " ESRAM4_STATE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80157260
;tree "PRCM_ARMITVALUE31TO0"
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE31TO0"
hexfld.long 0 " PRCM_ARMITVALUE31TO0 "
;tree.end

base ad:0x80157264
;tree "PRCM_ARMITVALUE63TO32"
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE63TO32"
hexfld.long 0 " PRCM_ARMITVALUE63TO32 "
;tree.end

base ad:0x80157268
;tree "PRCM_ARMITVALUE95TO64"
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE95TO64"
hexfld.long 0 " PRCM_ARMITVALUE95TO64 "
;tree.end

base ad:0x8015726c
;tree "PRCM_ARMITVALUE127TO96"
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE127TO96"
hexfld.long 0 " PRCM_ARMITVALUE127TO96 "
;tree.end

base ad:0x80157270
;tree "PRCM_REDUN_LOAD"
group 0--3
line.long 0 "PRCM_REDUN_LOAD"
bitfld.long 0 0. " PRCM_REDUN_GO_ARM "  "0 ,1 "
bitfld.long 0 1. " PRCM_REDUN_GO_SIA "  "0 ,1 "
;tree.end

base ad:0x80157274
;tree "PRCM_REDUN_STATUS"
rgroup 0--3
line.long 0 "PRCM_REDUN_STATUS"
bitfld.long 0 0. " PRCM_REDUN_OK_ARM "  "0 ,1 "
bitfld.long 0 1. " PRCM_REDUN_OK_SIA "  "0 ,1 "
bitfld.long 0 2. " PRCM_REDUN_OK_ESRAM "  "0 ,1 "
;tree.end

base ad:0x80157278
;tree "PRCM_UNIPROCLK_MGT"
rgroup 0--3
line.long 0 "PRCM_UNIPROCLK_MGT"
;tree.end

base ad:0x8015727c
;tree "PRCM_UICCCLK_MGT"
group 0--3
line.long 0 "PRCM_UICCCLK_MGT"
bitfld.long 0 0.--4. " UICCCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " UICCCLKEN "  "0 ,1 "
bitfld.long 0 9. " UICCCLK38 "  "0 ,1 "
bitfld.long 0 10. " UICCCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " UICCCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157280
;tree "PRCM_SSPCLK_MGT"
group 0--3
line.long 0 "PRCM_SSPCLK_MGT"
bitfld.long 0 0.--4. " SSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SSPCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SSPCLKEN "  "0 ,1 "
bitfld.long 0 9. " SSPCLK38 "  "0 ,1 "
bitfld.long 0 10. " SSPCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SSPCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157284
;tree "PRCM_RNGCLK_MGT"
group 0--3
line.long 0 "PRCM_RNGCLK_MGT"
bitfld.long 0 0.--4. " RNGCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " RNGCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 9. " RNGCLK38 "  "0 ,1 "
bitfld.long 0 10. " RNGCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " RNGCLK38DIV "  "0 ,1 "
;tree.end

base ad:0x80157288
;tree "PRCM_MSP1CLK_MGT"
group 0--3
line.long 0 "PRCM_MSP1CLK_MGT"
bitfld.long 0 0.--4. " MSP1CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " MSP1CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " MSP1CLKEN "  "0 ,1 "
bitfld.long 0 9. " MSP1CLK38 "  "0 ,1 "
bitfld.long 0 10. " MSP1CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " MSP1CLK38DIV "  "0 ,1 "
;tree.end

base ad:0x801572a0
;tree "PRCM_DAP_RESETN_SET"
group 0--3
line.long 0 "PRCM_DAP_RESETN_SET"
bitfld.long 0 0. " DAP_RESETN "  "0 ,1 "
;tree.end

base ad:0x801572a4
;tree "PRCM_DAP_RESETN_CLR"
group 0--3
line.long 0 "PRCM_DAP_RESETN_CLR"
bitfld.long 0 0. " DAP_RESETN "  "0 ,1 "
;tree.end

base ad:0x801572a8
;tree "PRCM_DAP_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_DAP_RESETN_VAL"
bitfld.long 0 0. " DAP_RESETN "  "0 ,1 "
;tree.end

base ad:0x80157300
;tree "PRCM_SRAM_DEDCSTOV"
group 0--3
line.long 0 "PRCM_SRAM_DEDCSTOV"
bitfld.long 0 0.--5. " DC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " DE "  "0 ,1 "
bitfld.long 0 7. " STOV "  "0 ,1 "
;tree.end

base ad:0x80157304
;tree "PRCM_SRAM_LS_SLEEP"
group 0--3
line.long 0 "PRCM_SRAM_LS_SLEEP"
bitfld.long 0 0. " SGA_SLEEP "  "0 ,1 "
bitfld.long 0 1. " SGA_LS "  "0 ,1 "
bitfld.long 0 2. " SVA_PIPE_SLEEP "  "0 ,1 "
bitfld.long 0 3. " SVA_PIPE_LS "  "0 ,1 "
bitfld.long 0 4. " SVA_MMDSP_SLEEP "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_LS "  "0 ,1 "
bitfld.long 0 6. " SIA_PIPE_SLEEP "  "0 ,1 "
bitfld.long 0 7. " SIA_PIPE_LS "  "0 ,1 "
bitfld.long 0 8. " SIA_MMDSP_SLEEP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_LS "  "0 ,1 "
bitfld.long 0 10. " DSS_SLEEP "  "0 ,1 "
bitfld.long 0 11. " DSS_LS "  "0 ,1 "
bitfld.long 0 14. " APE_SLEEP "  "0 ,1 "
bitfld.long 0 15. " APE_LS "  "0 ,1 "
bitfld.long 0 18. " ESRAM1_SLEEP "  "0 ,1 "
bitfld.long 0 19. " ESRAM1_LS "  "0 ,1 "
bitfld.long 0 20. " ESRAM2_SLEEP "  "0 ,1 "
bitfld.long 0 21. " ESRAM2_LS "  "0 ,1 "
bitfld.long 0 22. " ESRAM3_SLEEP "  "0 ,1 "
bitfld.long 0 23. " ESRAM3_LS "  "0 ,1 "
bitfld.long 0 24. " ESRAM4_SLEEP "  "0 ,1 "
bitfld.long 0 25. " ESRAM4_LS "  "0 ,1 "
bitfld.long 0 28. " SPARE "  "0 ,1 "
bitfld.long 0 29. " SVAROM_PDN "  "0 ,1 "
;tree.end

base ad:0x80157308
;tree "PRCM_SRAM_A9"
group 0--3
line.long 0 "PRCM_SRAM_A9"
bitfld.long 0 0.--5. " A9_DC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " A9_DE "  "0 ,1 "
bitfld.long 0 7. " A9_STOV "  "0 ,1 "
bitfld.long 0 8. " A9_SLEEP "  "0 ,1 "
bitfld.long 0 9. " A9_LS "  "0 ,1 "
;tree.end

base ad:0x8015730c
;tree "PRCM_ARM_LS_CLAMP"
group 0--3
line.long 0 "PRCM_ARM_LS_CLAMP"
bitfld.long 0 0. " INCLAMP_I "  "0 ,1 "
bitfld.long 0 1. " OUTCLAMP_I "  "0 ,1 "
bitfld.long 0 2. " PLL_INLATCH_I "  "0 ,1 "
bitfld.long 0 3. " TST_CLK_INLATCH_I "  "0 ,1 "
bitfld.long 0 4. " TST_FCT_INLATCH_I "  "0 ,1 "
bitfld.long 0 5. " TST_OUTCLAMP_I "  "0 ,1 "
;tree.end

base ad:0x80157310
;tree "PRCM_IOCR"
group 0--3
line.long 0 "PRCM_IOCR"
bitfld.long 0 0. " IOFORCE "  "0 ,1 "
;tree.end

base ad:0x80157314
;tree "PRCM_MODEM_SYSCLKOK"
group 0--3
line.long 0 "PRCM_MODEM_SYSCLKOK"
bitfld.long 0 0.--1. " PRCM_MODEM_SYSCLKOK "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80157318
;tree "PRCM_SYSCLKOK_DELAY"
group 0--3
line.long 0 "PRCM_SYSCLKOK_DELAY"
hexfld.byte 0 " PRCM_SYSCLKOK_DELAY "
;tree.end

base ad:0x8015731c
;tree "PRCM_SYSCLKSTATUS"
rgroup 0--3
line.long 0 "PRCM_SYSCLKSTATUS"
bitfld.long 0 0. " SYSCLKIND_SYNC "  "0 ,1 "
bitfld.long 0 1. " SYSCLKLOCKED "  "0 ,1 "
;tree.end

base ad:0x80157324
;tree "PRCM_DSI_SW_RESET"
group 0--3
line.long 0 "PRCM_DSI_SW_RESET"
bitfld.long 0 0. " DSI0_SW_RESETN "  "0 ,1 "
bitfld.long 0 1. " DSI1_SW_RESETN "  "0 ,1 "
bitfld.long 0 2. " DSI2_SW_RESETN "  "0 ,1 "
;tree.end

base ad:0x80157328
;tree "PRCM_A9_MASK_REQ"
group 0--3
line.long 0 "PRCM_A9_MASK_REQ"
bitfld.long 0 0. " PRCM_A9_MASK_REQ "  "0 ,1 "
;tree.end

base ad:0x8015732c
;tree "PRCM_A9_MASK_ACK"
rgroup 0--3
line.long 0 "PRCM_A9_MASK_ACK"
bitfld.long 0 0. " PRCM_A9_MASK_ACK "  "0 ,1 "
;tree.end

base ad:0x80157334
;tree "PRCM_HOSTACCESS_REQ"
group 0--3
line.long 0 "PRCM_HOSTACCESS_REQ"
bitfld.long 0 0. " HOSTACCESS_REQ "  "0 ,1 "
bitfld.long 0 1.--2. " HOSTACCESS_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 16. " WAKE_REQ "  "0 ,1 "
;tree.end

base ad:0x80157338
;tree "PRCM_TIMER_3_REF"
group 0--3
line.long 0 "PRCM_TIMER_3_REF"
hexfld.long 0 " PRCM_TIMER_3_REF "
;tree.end

base ad:0x8015733c
;tree "PRCM_TIMER_3_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_3_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_3_DOWNCOUNT "
;tree.end

base ad:0x80157340
;tree "PRCM_TIMER_3_MODE"
group 0--3
line.long 0 "PRCM_TIMER_3_MODE"
bitfld.long 0 0. " PRCM_TIMER_3_MODE "  "0 ,1 "
;tree.end

base ad:0x80157344
;tree "PRCM_PMB_SENS_CTRL"
group 0--3
line.long 0 "PRCM_PMB_SENS_CTRL"
bitfld.long 0 0.--3. " SEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--7. " DIV_SPEED "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " DIV_LEAK "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " SENS_RUN "  "0 ,1 "
bitfld.long 0 11.--12. " SMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " AUX_SEL "  "0 ,1 "
bitfld.long 0 14. " ALL_SENS "  "0 ,1 "
bitfld.long 0 15. " PD_SENS "  "0 ,1 "
;tree.end

base ad:0x80157348
;tree "PRCM_PMB_REF_COUNTER"
group 0--3
line.long 0 "PRCM_PMB_REF_COUNTER"
hexfld.word 0 " REF_COUNTER "
;tree.end

base ad:0x8015734c
;tree "PRCM_PMB_SENSOR_STATUS"
group 0--3
line.long 0 "PRCM_PMB_SENSOR_STATUS"
hexfld.word 0 " SENSOR_STATUS "
;tree.end

base ad:0x80157400
;tree "PRCM_SEM"
group 0--3
line.long 0 "PRCM_SEM"
bitfld.long 0 0. " PRCM_SEM "  "0 ,1 "
;tree.end

base ad:0x80157404
;tree "PRCM_APE_EPOD_CFG"
group 0--3
line.long 0 "PRCM_APE_EPOD_CFG"
bitfld.long 0 0.--1. " VDDI_WAKEUP_CUR_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " VDDI_WAKEUP_CUR_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " VDDI_BIAS_VOLT_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--9. " VDDI_BIAS_VOLT_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--11. " VDDI_BIAS_CUR_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " BIAS_BOOST_VDDI_ESRAM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " VDDI_BIAS_CUR_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16. " BIAS_BOOST_VDDI_MMDSP "  "0 ,1 "
;tree.end

base ad:0x80157408
;tree "PRCM_DDR_EPOD_CFG"
group 0--3
line.long 0 "PRCM_DDR_EPOD_CFG"
bitfld.long 0 0.--1. " GNDI_WAKEUP_CUR "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " VDDI_WAKEUP_CUR "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " GNDI_BIAS_VOLT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--8. " VDDI_BIAS_VOLT_CTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9.--11. " VDDI_BIAS_VOLT_PHY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--13. " BIAS_CUR_CTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " BIAS_BOOST_GNDI_CTRL "  "0 ,1 "
bitfld.long 0 15.--17. " BIAS_BOOST_VDDI_CTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80157410
;tree "PRCM_EPOD_C_SET"
group 0--3
line.long 0 "PRCM_EPOD_C_SET"
bitfld.long 0 0. " ESRAM1_2_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM1_2_RET "  "0 ,1 "
bitfld.long 0 2. " ESRAM3_4_ON "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_4_RET "  "0 ,1 "
bitfld.long 0 8. " SGA_L_ON "  "0 ,1 "
bitfld.long 0 9. " SGA_M_ON "  "0 ,1 "
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 11. " SVA_M_ON "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_ON "  "0 ,1 "
bitfld.long 0 13. " SVA_MM_M_ON "  "0 ,1 "
bitfld.long 0 14. " SVA_MM_M_RET "  "0 ,1 "
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 16. " SIA_M_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "
bitfld.long 0 18. " SIA_MM_M_ON "  "0 ,1 "
bitfld.long 0 19. " SIA_MM_M_RET "  "0 ,1 "
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "
bitfld.long 0 21. " DSS_M_ON "  "0 ,1 "
bitfld.long 0 22. " APERAMS_ON "  "0 ,1 "
;tree.end

base ad:0x80157414
;tree "PRCM_EPOD_C_CLR"
group 0--3
line.long 0 "PRCM_EPOD_C_CLR"
bitfld.long 0 0. " ESRAM1_2_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM1_2_RET "  "0 ,1 "
bitfld.long 0 2. " ESRAM3_4_ON "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_4_RET "  "0 ,1 "
bitfld.long 0 8. " SGA_L_ON "  "0 ,1 "
bitfld.long 0 9. " SGA_M_ON "  "0 ,1 "
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 11. " SVA_M_ON "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_ON "  "0 ,1 "
bitfld.long 0 13. " SVA_MM_M_ON "  "0 ,1 "
bitfld.long 0 14. " SVA_MM_M_RET "  "0 ,1 "
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 16. " SIA_M_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "
bitfld.long 0 18. " SIA_MM_M_ON "  "0 ,1 "
bitfld.long 0 19. " SIA_MM_M_RET "  "0 ,1 "
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "
bitfld.long 0 21. " DSS_M_ON "  "0 ,1 "
bitfld.long 0 22. " APERAMS_ON "  "0 ,1 "
;tree.end

base ad:0x80157418
;tree "PRCM_EPOD_C_VAL"
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 0. " ESRAM1_2_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM1_2_RET "  "0 ,1 "
bitfld.long 0 2. " ESRAM3_4_ON "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_4_RET "  "0 ,1 "
bitfld.long 0 8. " SGA_L_ON "  "0 ,1 "
bitfld.long 0 9. " SGA_M_ON "  "0 ,1 "
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 11. " SVA_M_ON "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_ON "  "0 ,1 "
bitfld.long 0 13. " SVA_MM_M_ON "  "0 ,1 "
bitfld.long 0 14. " SVA_MM_M_RET "  "0 ,1 "
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 16. " SIA_M_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "
bitfld.long 0 18. " SIA_MM_M_ON "  "0 ,1 "
bitfld.long 0 19. " SIA_MM_M_RET "  "0 ,1 "
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "
bitfld.long 0 21. " DSS_M_ON "  "0 ,1 "
bitfld.long 0 22. " APERAMS_ON "  "0 ,1 "
;tree.end

base ad:0x8015741c
;tree "PRCM_EPOD_VOK"
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 0. " ESRAM1_2_VOK "  "0 ,1 "
bitfld.long 0 1. " ESRAM3_4_VOK "  "0 ,1 "
bitfld.long 0 8. " SGA_L_VOK "  "0 ,1 "
bitfld.long 0 9. " SGA_M_VOK "  "0 ,1 "
bitfld.long 0 10. " SVA_L_VOK "  "0 ,1 "
bitfld.long 0 11. " SVA_M_VOK "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_VOK "  "0 ,1 "
bitfld.long 0 13. " SVA_MM_M_VOK "  "0 ,1 "
bitfld.long 0 14. " SVA_MM_MRET_VOK "  "0 ,1 "
bitfld.long 0 15. " SIA_L_VOK "  "0 ,1 "
bitfld.long 0 16. " SIA_M_VOK "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_VOK "  "0 ,1 "
bitfld.long 0 18. " SIA_MM_M_VOK "  "0 ,1 "
bitfld.long 0 19. " SIA_MM_MRET_VOK "  "0 ,1 "
bitfld.long 0 20. " DSS_L_VOK "  "0 ,1 "
bitfld.long 0 21. " DSS_M_VOK "  "0 ,1 "
bitfld.long 0 22. " APERAMS_M_VOK "  "0 ,1 "
;tree.end

base ad:0x80157420
;tree "PRCM_MMIP_LS_CLAMP_SET"
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_SET"
bitfld.long 0 0. " SIA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 1. " SVA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 2. " ESRAM2_CLAMP "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_CLAMP "  "0 ,1 "
bitfld.long 0 4. " ESRAM4_CLAMP "  "0 ,1 "
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "
bitfld.long 0 11. " DSIPLL_CLAMP "  "0 ,1 "
bitfld.long 0 16. " SGA_CLAMPI "  "0 ,1 "
bitfld.long 0 17. " SVA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 18. " SVA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 19. " SIA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 20. " SIA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 21. " DSS_CLAMPI "  "0 ,1 "
bitfld.long 0 22. " DSIPLL_CLAMPI "  "0 ,1 "
;tree.end

base ad:0x80157424
;tree "PRCM_MMIP_LS_CLAMP_CLR"
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 0. " SIA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 1. " SVA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 2. " ESRAM2_CLAMP "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_CLAMP "  "0 ,1 "
bitfld.long 0 4. " ESRAM4_CLAMP "  "0 ,1 "
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "
bitfld.long 0 11. " DSIPLL_CLAMP "  "0 ,1 "
bitfld.long 0 16. " SGA_CLAMPI "  "0 ,1 "
bitfld.long 0 17. " SVA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 18. " SVA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 19. " SIA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 20. " SIA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 21. " DSS_CLAMPI "  "0 ,1 "
bitfld.long 0 22. " DSIPLL_CLAMPI "  "0 ,1 "
;tree.end

base ad:0x80157428
;tree "PRCM_MMIP_LS_CLAMP_VAL"
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 0. " SIA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 1. " SVA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 2. " ESRAM2_CLAMP "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_CLAMP "  "0 ,1 "
bitfld.long 0 4. " ESRAM4_CLAMP "  "0 ,1 "
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "
bitfld.long 0 11. " DSIPLL_CLAMP "  "0 ,1 "
bitfld.long 0 16. " SGA_CLAMPI "  "0 ,1 "
bitfld.long 0 17. " SVA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 18. " SVA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 19. " SIA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 20. " SIA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 21. " DSS_CLAMPI "  "0 ,1 "
bitfld.long 0 22. " DSIPLL_CLAMPI "  "0 ,1 "
;tree.end

base ad:0x8015742c
;tree "PRCM_VSAFE_LS_CLAMP_SET"
group 0--3
line.long 0 "PRCM_VSAFE_LS_CLAMP_SET"
bitfld.long 0 0. " VAPE_VSAFE_FIFOCLAMP "  "0 ,1 "
bitfld.long 0 1. " VAPE_VSAFE_HOLD_0 "  "0 ,1 "
bitfld.long 0 2. " VAPE_VSAFE_CLAMP_0 "  "0 ,1 "
bitfld.long 0 3. " VAPE_VSAFE_HOLD_1 "  "0 ,1 "
bitfld.long 0 4. " VAPE_VSAFE_CLAMP_1 "  "0 ,1 "
bitfld.long 0 5. " VAPE_VSAFE_HOLD_2 "  "0 ,1 "
bitfld.long 0 6. " VAPE_VSAFE_CSI_CLAMP "  "0 ,1 "
bitfld.long 0 7. " VAPE_VSAFE_HOLD_3 "  "0 ,1 "
bitfld.long 0 8. " VAPE_VSAFE_CLAMP_3 "  "0 ,1 "
bitfld.long 0 16. " PMB_CLAMP_VARM "  "0 ,1 "
bitfld.long 0 17. " PMB_CLAMP_VAPE "  "0 ,1 "
bitfld.long 0 18. " PMB_CLAMP_VMODEM "  "0 ,1 "
;tree.end

base ad:0x80157430
;tree "PRCM_VSAFE_LS_CLAMP_CLR"
group 0--3
line.long 0 "PRCM_VSAFE_LS_CLAMP_CLR"
bitfld.long 0 0. " VAPE_VSAFE_FIFOCLAMP "  "0 ,1 "
bitfld.long 0 1. " VAPE_VSAFE_HOLD_0 "  "0 ,1 "
bitfld.long 0 2. " VAPE_VSAFE_CLAMP_0 "  "0 ,1 "
bitfld.long 0 3. " VAPE_VSAFE_HOLD_1 "  "0 ,1 "
bitfld.long 0 4. " VAPE_VSAFE_CLAMP_1 "  "0 ,1 "
bitfld.long 0 5. " VAPE_VSAFE_HOLD_2 "  "0 ,1 "
bitfld.long 0 6. " VAPE_VSAFE_CSI_CLAMP "  "0 ,1 "
bitfld.long 0 7. " VAPE_VSAFE_HOLD_3 "  "0 ,1 "
bitfld.long 0 8. " VAPE_VSAFE_CLAMP_3 "  "0 ,1 "
bitfld.long 0 16. " PMB_CLAMP_VARM "  "0 ,1 "
bitfld.long 0 17. " PMB_CLAMP_VAPE "  "0 ,1 "
bitfld.long 0 18. " PMB_CLAMP_VMODEM "  "0 ,1 "
;tree.end

base ad:0x80157434
;tree "PRCM_VSAFE_LS_CLAMP_VAL"
group 0--3
line.long 0 "PRCM_VSAFE_LS_CLAMP_VAL"
bitfld.long 0 0. " VAPE_VSAFE_FIFOCLAMP "  "0 ,1 "
bitfld.long 0 1. " VAPE_VSAFE_HOLD_0 "  "0 ,1 "
bitfld.long 0 2. " VAPE_VSAFE_CLAMP_0 "  "0 ,1 "
bitfld.long 0 3. " VAPE_VSAFE_HOLD_1 "  "0 ,1 "
bitfld.long 0 4. " VAPE_VSAFE_CLAMP_1 "  "0 ,1 "
bitfld.long 0 5. " VAPE_VSAFE_HOLD_2 "  "0 ,1 "
bitfld.long 0 6. " VAPE_VSAFE_CSI_CLAMP "  "0 ,1 "
bitfld.long 0 7. " VAPE_VSAFE_HOLD_3 "  "0 ,1 "
bitfld.long 0 8. " VAPE_VSAFE_CLAMP_3 "  "0 ,1 "
bitfld.long 0 16. " PMB_CLAMP_VARM "  "0 ,1 "
bitfld.long 0 17. " PMB_CLAMP_VAPE "  "0 ,1 "
bitfld.long 0 18. " PMB_CLAMP_VMODEM "  "0 ,1 "
;tree.end

base ad:0x80157438
;tree "PRCM_DDRSUBSYS_APE_MINBW"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_APE_MINBW"
bitfld.long 0 0.--1. " APE_MIN_BW "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8015743c
;tree "PRCM_DDRSUBSYS_STATUS"
rgroup 0--3
line.long 0 "PRCM_DDRSUBSYS_STATUS"
bitfld.long 0 0.--4. " MAIN_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " EFFECTIVE_MIN_BW "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " CORE_VDDIOK "  "0 ,1 "
bitfld.long 0 8. " CORE_GNDIOK "  "0 ,1 "
bitfld.long 0 9. " PHY_VDDIOK "  "0 ,1 "
bitfld.long 0 10.--13. " CORE_DOMAIN_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14.--16. " PHY_DOMAIN_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17.--19. " PLL_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--31. " SPARE "  " "
;tree.end

base ad:0x80157440
;tree "PRCM_DDRSUBSYS_CONTROL"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_CONTROL"
bitfld.long 0 0. " CORE_BIAS_DISABLE "  "0 ,1 "
bitfld.long 0 1. " CORE_OFF_DISABLE "  "0 ,1 "
bitfld.long 0 2. " PHY_OFF_DISABLE "  "0 ,1 "
bitfld.long 0 3.--4. " SPARE_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " FREQDIV_BY4_DISABLE "  "0 ,1 "
bitfld.long 0 6. " CORE_ISOLATION_RESYNCH_DISABLE "  "0 ,1 "
bitfld.long 0 7. " FORCE_CORE_ISOLATION "  "0 ,1 "
bitfld.long 0 8. " FORCE_PHY_IO_ISOLATION "  "0 ,1 "
bitfld.long 0 9. " VREF_IO_SET_WITH_EXTERNAL_VREF "  "0 ,1 "
bitfld.long 0 10.--23. " SPARE_2 "  " "
;tree.end

base ad:0x80157444
;tree "PRCM_DDRSUBSYS_HIGH_LEAK_COND"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_HIGH_LEAK_COND"
bitfld.long 0 0. " HIGH_LEAK "  "0 ,1 "
;tree.end

base ad:0x80157448
;tree "PRCM_DDRSUBSYS_CONFIG"
rgroup 0--3
line.long 0 "PRCM_DDRSUBSYS_CONFIG"
bitfld.long 0 0.--1. " DDRCONFIG_REQ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8015744c
;tree "PRCM_DDRSUBSYS_CONFIG_ACK"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_CONFIG_ACK"
bitfld.long 0 0.--1. " DDRCONFIG_ACK "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80157450
;tree "PRCM_TIMER_4_REF"
group 0--3
line.long 0 "PRCM_TIMER_4_REF"
hexfld.long 0 " PRCM_TIMER_4_REF "
;tree.end

base ad:0x80157454
;tree "PRCM_TIMER_4_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_4_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_4_DOWNCOUNT "
;tree.end

base ad:0x80157458
;tree "PRCM_TIMER_4_MODE"
group 0--3
line.long 0 "PRCM_TIMER_4_MODE"
bitfld.long 0 0. " PRCM_TIMER_4_MODE "  "0 ,1 "
;tree.end

base ad:0x8015745c
;tree "PRCM_TIMER_5_REF"
group 0--3
line.long 0 "PRCM_TIMER_5_REF"
hexfld.long 0 " PRCM_TIMER_5_REF "
;tree.end

base ad:0x80157460
;tree "PRCM_TIMER_5_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_5_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_5_DOWNCOUNT "
;tree.end

base ad:0x80157464
;tree "PRCM_TIMER_5_MODE"
group 0--3
line.long 0 "PRCM_TIMER_5_MODE"
bitfld.long 0 0. " PRCM_TIMER_5_MODE "  "0 ,1 "
;tree.end

base ad:0x8015746c
;tree "PRCM_SEM_A9_IT_CLR"
group 0--3
line.long 0 "PRCM_SEM_A9_IT_CLR"
bitfld.long 0 0. " PRCM_SEM_A9_IT_CLR "  "0 ,1 "
;tree.end

base ad:0x80157470
;tree "PRCM_APE_MEM_REQ"
group 0--3
line.long 0 "PRCM_APE_MEM_REQ"
bitfld.long 0 0. " APE_MEM_REQ "  "0 ,1 "
;tree.end

base ad:0x80157474
;tree "PRCM_DBG_FORCES_APE_MEM_REQ"
group 0--3
line.long 0 "PRCM_DBG_FORCES_APE_MEM_REQ"
bitfld.long 0 0. " DBG_FORCES_APE_MEM_REQ "  "0 ,1 "
;tree.end

base ad:0x80157478
;tree "PRCM_APE_MEM_WFX_EN"
group 0--3
line.long 0 "PRCM_APE_MEM_WFX_EN"
bitfld.long 0 0. " PL310_IDLE_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WFI_0_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WFI_1_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WFE_0_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WFE_1_ENABLE "  "0 ,1 "
;tree.end

base ad:0x8015747c
;tree "PRCM_APE_MEM_LATENCY"
group 0--3
line.long 0 "PRCM_APE_MEM_LATENCY"
bitfld.long 0 0. " APE_MEM_LATENCY "  "0 ,1 "
;tree.end

base ad:0x80157480
;tree "PRCM_APE_MEM_ACK"
rgroup 0--3
line.long 0 "PRCM_APE_MEM_ACK"
bitfld.long 0 0. " APE_MEM_ACK "  "0 ,1 "
;tree.end

base ad:0x80157484
;tree "PRCM_ITSTATUS5"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS5"
bitfld.long 0 0.--8. " GPIO_EVENTS "  " "
;tree.end

base ad:0x80157488
;tree "PRCM_ITCLR5"
wgroup 0--3
line.long 0 "PRCM_ITCLR5"
bitfld.long 0 0.--8. " GPIO_EVENTS "  " "
;tree.end

base ad:0x8015748c
;tree "PRCM_ARM_IT1_CLR"
group 0--3
line.long 0 "PRCM_ARM_IT1_CLR"
hexfld.byte 0 " PRCM_ARM_IT1_CLR "
;tree.end

base ad:0x80157490
;tree "PRCM_ARM_IT1_SET"
group 0--3
line.long 0 "PRCM_ARM_IT1_SET"
hexfld.byte 0 " PRCM_ARM_IT1_SET "
;tree.end

base ad:0x80157494
;tree "PRCM_ARM_IT1_VAL"
group 0--3
line.long 0 "PRCM_ARM_IT1_VAL"
hexfld.byte 0 " PRCM_ARM_IT1_VAL "
;tree.end

base ad:0x80157498
;tree "PRCM_MOD_PWR_OK"
group 0--3
line.long 0 "PRCM_MOD_PWR_OK"
bitfld.long 0 0. " PRCM_MOD_PWR_OK "  "0 ,1 "
;tree.end

base ad:0x8015749c
;tree "PRCM_MOD_AUXCLKOK"
group 0--3
line.long 0 "PRCM_MOD_AUXCLKOK"
bitfld.long 0 0. " PRCM_MOD_AUXCLKOK "  "0 ,1 "
;tree.end

base ad:0x801574a0
;tree "PRCM_MOD_AWAKE_STATUS"
rgroup 0--3
line.long 0 "PRCM_MOD_AWAKE_STATUS"
bitfld.long 0 0. " PRCM_MOD_COREPD_AWAKE "  "0 ,1 "
bitfld.long 0 1. " PRCM_MOD_AAPD_AWAKE "  "0 ,1 "
bitfld.long 0 2. " PRCM_MOD_VMODEM_OFF_ISO "  "0 ,1 "
;tree.end

base ad:0x801574a4
;tree "PRCM_MOD_SWRESET_IRQ_ACK"
group 0--3
line.long 0 "PRCM_MOD_SWRESET_IRQ_ACK"
bitfld.long 0 0. " PRCM_MOD_SWRESET_IRQ_ACK "  "0 ,1 "
;tree.end

base ad:0x801574a8
;tree "PRCM_MOD_SWRESET_ACK"
rgroup 0--3
line.long 0 "PRCM_MOD_SWRESET_ACK"
bitfld.long 0 0. " PRCM_MOD_SWRESET_ACK "  "0 ,1 "
;tree.end

base ad:0x801574ac
;tree "PRCM_DBG_PWRCTL"
group 0--3
line.long 0 "PRCM_DBG_PWRCTL"
bitfld.long 0 0. " A9PWRUPEN "  "0 ,1 "
bitfld.long 0 1. " MODPWRUPEN "  "0 ,1 "
bitfld.long 0 2. " MODNOPWRDN "  "0 ,1 "
;tree.end

base ad:0x801574b0
;tree "PRCM_HWOBS_H"
group 0--3
line.long 0 "PRCM_HWOBS_H"
bitfld.long 0 0.--1. " HW_OBS_SEL_16 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " HW_OBS_SEL_17 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " HW_OBS_EN "  "0 ,1 "
;tree.end

base ad:0x801574b4
;tree "PRCM_HWOBS_L"
group 0--3
line.long 0 "PRCM_HWOBS_L"
bitfld.long 0 0.--1. " HW_OBS_SEL_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " HW_OBS_SEL_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " HW_OBS_SEL_2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " HW_OBS_SEL_3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " HW_OBS_SEL_4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " HW_OBS_SEL_5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " HW_OBS_SEL_6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " HW_OBS_SEL_7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " HW_OBS_SEL_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " HW_OBS_SEL_9 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " HW_OBS_SEL_10 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " HW_OBS_SEL_11 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " HW_OBS_SEL_12 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " HW_OBS_SEL_13 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " HW_OBS_SEL_14 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " HW_OBS_SEL_15 "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80157500
;tree "PRCM_PLLDSI_FREQ"
group 0--3
line.long 0 "PRCM_PLLDSI_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
;tree.end

base ad:0x80157504
;tree "PRCM_PLLDSI_ENABLE"
group 0--3
line.long 0 "PRCM_PLLDSI_ENABLE"
bitfld.long 0 0. " PRCM_PLLDSI_ENABLE "  "0 ,1 "
;tree.end

base ad:0x80157508
;tree "PRCM_PLLDSI_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLDSI_LOCKP"
bitfld.long 0 0. " PRCM_PLLDSI_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLDSI_LOCKP3 "  "0 ,1 "
;tree.end

base ad:0x8015750c
;tree "PRCM_RNG_ENABLE"
group 0--3
line.long 0 "PRCM_RNG_ENABLE"
bitfld.long 0 0. " PRCM_RNG_ENABLE "  "0 ,1 "
;tree.end

base ad:0x80157510
;tree "PRCM_YYCLKEN0_MGT_SET"
group 0--3
line.long 0 "PRCM_YYCLKEN0_MGT_SET"
bitfld.long 0 0. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 1. " ACLKEN "  "0 ,1 "
bitfld.long 0 2. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 3. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 4. " SGACLKEN "  "0 ,1 "
bitfld.long 0 5. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 6. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 7. " MSP1CLKEN "  "0 ,1 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 10. " SLIMCLKEN "  "0 ,1 "
bitfld.long 0 11. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 12. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 13. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 14. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 15. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 16. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 17. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 18. " BMLCLKEN "  "0 ,1 "
bitfld.long 0 19. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 20. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 21. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 22. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 23. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 24. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 25. " IPI2CCLKEN "  "0 ,1 "
bitfld.long 0 26. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 27. " DMACLKEN "  "0 ,1 "
bitfld.long 0 28. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 29. " TVCLKEN "  "0 ,1 "
bitfld.long 0 30. " SPARE_UNIPROCLKEN "  "0 ,1 "
bitfld.long 0 31. " SSPCLKEN "  "0 ,1 "
;tree.end

base ad:0x80157514
;tree "PRCM_YYCLKEN1_MGT_SET"
group 0--3
line.long 0 "PRCM_YYCLKEN1_MGT_SET"
bitfld.long 0 0. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 1. " UICCCLKEN "  "0 ,1 "
bitfld.long 0 8. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE2CLKEN "  "0 ,1 "
;tree.end

base ad:0x80157518
;tree "PRCM_YYCLKEN0_MGT_CLR"
group 0--3
line.long 0 "PRCM_YYCLKEN0_MGT_CLR"
bitfld.long 0 0. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 1. " ACLKEN "  "0 ,1 "
bitfld.long 0 2. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 3. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 4. " SGACLKEN "  "0 ,1 "
bitfld.long 0 5. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 6. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 7. " MSP1CLKEN "  "0 ,1 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 10. " SLIMCLKEN "  "0 ,1 "
bitfld.long 0 11. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 12. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 13. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 14. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 15. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 16. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 17. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 18. " BMLCLKEN "  "0 ,1 "
bitfld.long 0 19. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 20. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 21. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 22. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 23. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 24. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 25. " IPI2CCLKEN "  "0 ,1 "
bitfld.long 0 26. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 27. " DMACLKEN "  "0 ,1 "
bitfld.long 0 28. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 29. " TVCLKEN "  "0 ,1 "
bitfld.long 0 30. " SPARE_UNIPROCLKEN "  "0 ,1 "
bitfld.long 0 31. " SSPCLKEN "  "0 ,1 "
;tree.end

base ad:0x8015751c
;tree "PRCM_YYCLKEN1_MGT_CLR"
group 0--3
line.long 0 "PRCM_YYCLKEN1_MGT_CLR"
bitfld.long 0 0. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 1. " UICCCLKEN "  "0 ,1 "
bitfld.long 0 8. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE2CLKEN "  "0 ,1 "
;tree.end

base ad:0x80157520
;tree "PRCM_YYCLKEN0_MGT_VAL"
group 0--3
line.long 0 "PRCM_YYCLKEN0_MGT_VAL"
bitfld.long 0 0. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 1. " ACLKEN "  "0 ,1 "
bitfld.long 0 2. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 3. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 4. " SGACLKEN "  "0 ,1 "
bitfld.long 0 5. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 6. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 7. " MSP1CLKEN "  "0 ,1 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 10. " SLIMCLKEN "  "0 ,1 "
bitfld.long 0 11. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 12. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 13. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 14. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 15. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 16. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 17. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 18. " BMLCLKEN "  "0 ,1 "
bitfld.long 0 19. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 20. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 21. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 22. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 23. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 24. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 25. " IPI2CCLKEN "  "0 ,1 "
bitfld.long 0 26. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 27. " DMACLKEN "  "0 ,1 "
bitfld.long 0 28. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 29. " TVCLKEN "  "0 ,1 "
bitfld.long 0 30. " SPARE_UNIPROCLKEN "  "0 ,1 "
bitfld.long 0 31. " SSPCLKEN "  "0 ,1 "
;tree.end

base ad:0x80157524
;tree "PRCM_YYCLKEN1_MGT_VAL"
group 0--3
line.long 0 "PRCM_YYCLKEN1_MGT_VAL"
bitfld.long 0 0. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 1. " UICCCLKEN "  "0 ,1 "
bitfld.long 0 8. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE2CLKEN "  "0 ,1 "
;tree.end

base ad:0x80157528
;tree "PRCM_XP70CLK_MGT2"
group 0--3
line.long 0 "PRCM_XP70CLK_MGT2"
bitfld.long 0 0.--2. " PLL_SOC0_MX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " XP70_CLK_L2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--8. " XP70_CLK_L1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " SPARE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8015752c
;tree "PRCM_DSITVCLK_DIV"
group 0--3
line.long 0 "PRCM_DSITVCLK_DIV"
hexfld.byte 0 " DSI0_ESC_CLK_DIV "
hexfld.byte 1 " DSI1_ESC_CLK_DIV "
hexfld.byte 2 " DSI2_ESC_CLK_DIV "
bitfld.long 0 24. " DSI0_ESC_CLK_EN "  "0 ,1 "
bitfld.long 0 25. " DSI1_ESC_CLK_EN "  "0 ,1 "
bitfld.long 0 26. " DSI2_ESC_CLK_EN "  "0 ,1 "
;tree.end

base ad:0x80157530
;tree "PRCM_DSI_PLLOUT_SEL"
group 0--3
line.long 0 "PRCM_DSI_PLLOUT_SEL"
bitfld.long 0 0.--2. " DSI0_PLLOUT_DIVSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " DSI1_PLLOUT_DIVSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80157534
;tree "PRCM_DSI_GLITCHFREE_EN"
group 0--3
line.long 0 "PRCM_DSI_GLITCHFREE_EN"
bitfld.long 0 0. " DSI0_BYPASS_BYTE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 1. " DSI0_BYPASS_MCDE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 8. " DSI1_BYPASS_BYTE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 9. " DSI1_BYPASS_MCDE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 16. " DSI2_BYPASS_BYTE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 17. " DSI2_BYPASS_MCDE_CLK_SYNC "  "0 ,1 "
;tree.end

base ad:0x80157538
;tree "PRCM_CLKACTIV"
group 0--3
line.long 0 "PRCM_CLKACTIV"
bitfld.long 0 0. " CLK32_RUNNING "  "0 ,1 "
bitfld.long 0 1. " SYSCLK_RUNNING "  "0 ,1 "
bitfld.long 0 2. " PLLSOC0_RUNNING "  "0 ,1 "
bitfld.long 0 3. " PLLSOC1_RUNNING "  "0 ,1 "
bitfld.long 0 4. " PLLDDR_RUNNING "  "0 ,1 "
bitfld.long 0 5. " STW4500_ULPCLK_RUNNING "  "0 ,1 "
bitfld.long 0 6. " STW8500_ULPCLK_RUNNING "  "0 ,1 "
bitfld.long 0 7. " MSP0SCK_RUNNING "  "0 ,1 "
bitfld.long 0 8. " MSP2SCK_RUNNING "  "0 ,1 "
bitfld.long 0 16. " PLLSOC0_EN "  "0 ,1 "
bitfld.long 0 17. " PLLSOC1_EN "  "0 ,1 "
bitfld.long 0 18. " PLLDDR_DIV12_EN "  "0 ,1 "
bitfld.long 0 19. " PLLDDR_DIV2_EN "  "0 ,1 "
bitfld.long 0 20. " PLLSOC0_DIV12_EN "  "0 ,1 "
bitfld.long 0 21. " PLLSOC0_DIV2_EN "  "0 ,1 "
;tree.end

base ad:0x8015753c
;tree "PRCM_SIA_MMDSP_MEM_MGT"
group 0--3
line.long 0 "PRCM_SIA_MMDSP_MEM_MGT"
bitfld.long 0 0. " MEM_REQ "  "0 ,1 "
bitfld.long 0 1. " MEM_LATENCY "  "0 ,1 "
;tree.end

base ad:0x80157540
;tree "PRCM_SVA_MMDSP_MEM_MGT"
group 0--3
line.long 0 "PRCM_SVA_MMDSP_MEM_MGT"
bitfld.long 0 0. " MEM_REQ "  "0 ,1 "
bitfld.long 0 1. " MEM_LATENCY "  "0 ,1 "
;tree.end

base ad:0x80157544
;tree "PRCM_SXAMMDSP_FORCE_CLKEN"
group 0--3
line.long 0 "PRCM_SXAMMDSP_FORCE_CLKEN"
bitfld.long 0 0. " SIA "  "0 ,1 "
bitfld.long 0 1. " SVA "  "0 ,1 "
;tree.end

base ad:0x80157570
;tree "PRCM_UICC_NANDTREE"
group 0--3
line.long 0 "PRCM_UICC_NANDTREE"
bitfld.long 0 0. " UICC_NAND_I "  "0 ,1 "
bitfld.long 0 1. " UICC_NAND_O "  "0 ,1 "
;tree.end

base ad:0x80157574
;tree "PRCM_GPIOCR2"
group 0--3
line.long 0 "PRCM_GPIOCR2"
bitfld.long 0 0. " DBG_MODEMRF_CTRL_CMD1 "  "0 ,1 "
bitfld.long 0 1. " DBG_MODEMRF_CTRL_CMD0 "  "0 ,1 "
bitfld.long 0 2. " DBG_MODEMRF_INT_CMD1 "  "0 ,1 "
bitfld.long 0 3. " DBG_MODEMRF_INT_CMD0 "  "0 ,1 "
bitfld.long 0 4.--5. " MOD_DDR_SPACE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " PORn_PULL_DOWN "  "0 ,1 "
bitfld.long 0 7.--15. " MOD_GPIOCR_SPARE "  " "
;tree.end

base ad:0x80157578
;tree "PRCM_MDM_ACWAKE"
group 0--3
line.long 0 "PRCM_MDM_ACWAKE"
bitfld.long 0 0. " MDM_ACWAKE "  "0 ,1 "
;tree.end

base ad:0x801575a4
;tree "PRCM_MOD_MEM_REQ"
group 0--3
line.long 0 "PRCM_MOD_MEM_REQ"
bitfld.long 0 0. " MOD_MEM_REQ_EN "  "0 ,1 "
bitfld.long 0 1. " MOD_MEM_REQ_FORCE "  "0 ,1 "
;tree.end

base ad:0x801575a8
;tree "PRCM_MOD_MEM_ACK"
group 0--3
line.long 0 "PRCM_MOD_MEM_ACK"
bitfld.long 0 0. " MOD_MEM_ACK_EN "  "0 ,1 "
bitfld.long 0 1. " MOD_MEM_ACK_FORCE "  "0 ,1 "
;tree.end

base ad:0x801575b0
;tree "PRCM_ARM_PLLDIVPS_REQ"
group 0--3
line.long 0 "PRCM_ARM_PLLDIVPS_REQ"
bitfld.long 0 0. " ARM_BRM_RATEVAL "  "0 ,1 "
bitfld.long 0 4. " ARM_PLL_OBSVAL "  "0 ,1 "
;tree.end

base ad:0x801575b4
;tree "PRCM_ARM_PLLDIVPS_ACK"
rgroup 0--3
line.long 0 "PRCM_ARM_PLLDIVPS_ACK"
bitfld.long 0 0. " ARM_BRM_RATEACK "  "0 ,1 "
bitfld.long 0 4. " ARM_PLL_OBSACK "  "0 ,1 "
;tree.end

base ad:0x801575d0
;tree "PRCM_SRPTIMER_VAL"
group 0--3
line.long 0 "PRCM_SRPTIMER_VAL"
hexfld.byte 0 " SRPTIMER_VAL "
;tree.end

base ad:0x801575d4
;tree "PRCM_SRPTIMER_A9_IT_CLR"
wgroup 0--3
line.long 0 "PRCM_SRPTIMER_A9_IT_CLR"
bitfld.long 0 0. " PRCM_SRPTIMER_A9_IT_CLR "  "0 ,1 "
;tree.end

base ad:0x801575d8
;tree "PRCM_HWI2C_A9_IT_CLR"
wgroup 0--3
line.long 0 "PRCM_HWI2C_A9_IT_CLR"
bitfld.long 0 0. " PRCM_HWI2C_A9_IT_CLR "  "0 ,1 "
;tree.end

base ad:0x80158000
;tree "PRCM_SECNONSEWM"
group 0--3
line.long 0 "PRCM_SECNONSEWM"
hexfld.word 0 " SECNONSECWM "
;tree.end

base ad:0x80158004
;tree "PRCM_ESRAM0_INITN"
group 0--3
line.long 0 "PRCM_ESRAM0_INITN"
bitfld.long 0 0. " PRCM_ESRAM0_INITN "  "0 ,1 "
;tree.end

base ad:0x80158008
;tree "PRCM_ARMITMSKSEC_31TO0"
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_31TO0"
hexfld.long 0 " PRCM_ARMITMSKSEC_31TO0 "
;tree.end

base ad:0x8015800c
;tree "PRCM_ARMITMSKSEC_63TO32"
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_63TO32"
hexfld.long 0 " PRCM_ARMITMSKSEC_63TO32 "
;tree.end

base ad:0x80158010
;tree "PRCM_ARMITMSKSEC_95TO64"
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_95TO64"
hexfld.long 0 " PRCM_ARMITMSKSEC_95TO64 "
;tree.end

base ad:0x80158014
;tree "PRCM_ARMITMSKSEC_127TO96"
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_127TO96"
hexfld.long 0 " PRCM_ARMITMSKSEC_127TO96 "
;tree.end

base ad:0x80158018
;tree "PRCM_ARMIT_MASKXP70_IT"
group 0--3
line.long 0 "PRCM_ARMIT_MASKXP70_IT"
bitfld.long 0 0. " PRCM_ARMIT_MASKXP70_IT "  "0 ,1 "
;tree.end

base ad:0x8015801c
;tree "PRCM_ESRAM0_EPOD_CFG"
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_CFG"
bitfld.long 0 0.--1. " VDDI_WAKEUP_CUR "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " VDDI_BIAS_VOLT_CTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " BIAS_CUR_CTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " BOOST "  "0 ,1 "
;tree.end

base ad:0x80158020
;tree "PRCM_ESRAM0_EPOD_C_VAL"
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_C_VAL"
bitfld.long 0 0. " ESRAM0_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_RET "  "0 ,1 "
;tree.end

base ad:0x80158024
;tree "PRCM_ESRAM0_EPOD_C_SET"
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_C_SET"
bitfld.long 0 0. " ESRAM0_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_RET "  "0 ,1 "
;tree.end

base ad:0x80158028
;tree "PRCM_ESRAM0_EPOD_C_CLR"
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_C_CLR"
bitfld.long 0 0. " ESRAM0_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_RET "  "0 ,1 "
;tree.end

base ad:0x8015802c
;tree "PRCM_ESRAM0_EPOD_VOK"
rgroup 0--3
line.long 0 "PRCM_ESRAM0_EPOD_VOK"
bitfld.long 0 0. " ESRAM0_VOK "  "0 ,1 "
;tree.end

base ad:0x80158030
;tree "PRCM_ESRAM0_LS_SLEEP"
group 0--3
line.long 0 "PRCM_ESRAM0_LS_SLEEP"
bitfld.long 0 0. " ESRAM0_SLEEP "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_LS "  "0 ,1 "
;tree.end

base ad:0x80158034
;tree "PRCM_SECURE_ONGOING"
group 0--3
line.long 0 "PRCM_SECURE_ONGOING"
bitfld.long 0 0. " SECURE_ONGOING "  "0 ,1 "
;tree.end

base ad:0x80158038
;tree "PRCM_I2C_SECURE"
group 0--3
line.long 0 "PRCM_I2C_SECURE"
bitfld.long 0 0. " I2C_SECURE "  "0 ,1 "
;tree.end

base ad:0x8015803c
;tree "PRCM_RESET_STATUS"
group 0--3
line.long 0 "PRCM_RESET_STATUS"
bitfld.long 0 0. " A9_CPU0_WATCHDOG_RESET "  "0 ,1 "
bitfld.long 0 1. " A9_CPU1_WATCHDOG_RESET "  "0 ,1 "
bitfld.long 0 2. " APE_SOFTWARE_RESET "  "0 ,1 "
bitfld.long 0 3. " APE_RESET "  "0 ,1 "
bitfld.long 0 4. " SECURE_WATCHDOG "  "0 ,1 "
bitfld.long 0 5. " POWER_ON_RESET "  "0 ,1 "
bitfld.long 0 6. " A9_RESTART "  "0 ,1 "
bitfld.long 0 7. " APE_RESTART "  "0 ,1 "
bitfld.long 0 8. " MODEM_SOFTWARE_RESET "  "0 ,1 "
bitfld.long 0 16. " BOOT_ENGI "  "0 ,1 "
;tree.end

base ad:0x80158040
;tree "PRCM_PERIPH4_RESETN_SET"
group 0--3
line.long 0 "PRCM_PERIPH4_RESETN_SET"
bitfld.long 0 0. " RTC_RESETN "  "0 ,1 "
bitfld.long 0 1. " RTT0_RESETN "  "0 ,1 "
bitfld.long 0 2. " RTT1_RESETN "  "0 ,1 "
bitfld.long 0 3. " BACKUP_RAM_RESETN "  "0 ,1 "
bitfld.long 0 4. " SEC_REG_RESETN "  "0 ,1 "
bitfld.long 0 5. " CLK_PLL_CONF_RESETN "  "0 ,1 "
bitfld.long 0 6. " HWI2C_RESETN "  "0 ,1 "
;tree.end

base ad:0x80158044
;tree "PRCM_PERIPH4_RESETN_CLR"
group 0--3
line.long 0 "PRCM_PERIPH4_RESETN_CLR"
bitfld.long 0 0. " RTC_RESETN "  "0 ,1 "
bitfld.long 0 1. " RTT0_RESETN "  "0 ,1 "
bitfld.long 0 2. " RTT1_RESETN "  "0 ,1 "
bitfld.long 0 3. " BACKUP_RAM_RESETN "  "0 ,1 "
bitfld.long 0 4. " SEC_REG_RESETN "  "0 ,1 "
bitfld.long 0 5. " CLK_PLL_CONF_RESETN "  "0 ,1 "
bitfld.long 0 6. " HWI2C_RESETN "  "0 ,1 "
;tree.end

base ad:0x80158048
;tree "PRCM_PERIPH4_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_PERIPH4_RESETN_VAL"
bitfld.long 0 0. " RTC_RESETN "  "0 ,1 "
bitfld.long 0 1. " RTT0_RESETN "  "0 ,1 "
bitfld.long 0 2. " RTT1_RESETN "  "0 ,1 "
bitfld.long 0 3. " BACKUP_RAM_RESETN "  "0 ,1 "
bitfld.long 0 4. " SEC_REG_RESETN "  "0 ,1 "
bitfld.long 0 5. " CLK_PLL_CONF_RESETN "  "0 ,1 "
bitfld.long 0 6. " HWI2C_RESETN "  "0 ,1 "
;tree.end

base ad:0x8015804c
;tree "PRCM_SPAREOUT_SEC"
group 0--3
line.long 0 "PRCM_SPAREOUT_SEC"
bitfld.long 0 0. " BOOT_ROM_PDN "  "0 ,1 "
bitfld.long 0 1.--3. " SPAREOUT_SEC_3_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4. " PCLK_RTT0_EN "  "0 ,1 "
bitfld.long 0 5. " PCLK_RTT1_EN "  "0 ,1 "
bitfld.long 0 6.--7. " SPAREOUT_SEC_7_6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--10. " FREERUNNINGOSC_COMP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11.--15. " SPAREOUT_SEC_15_11 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x801580d8
;tree "PRCM_PIPELINEDCR"
group 0--3
line.long 0 "PRCM_PIPELINEDCR"
hexfld.long 0 " PRCM_PIPELINEDCR "
;tree.end

base ad:0x801580dc
;tree "PRCM_VOLATILEIOCR"
group 0--3
line.long 0 "PRCM_VOLATILEIOCR"
hexfld.long 0 " PRCM_VOLATILEIOCR "
;tree.end

base ad:0x801580e0
;tree "PRCM_XP70CFGCR"
group 0--3
line.long 0 "PRCM_XP70CFGCR"
bitfld.long 0 0. " XP70_P_FETCH_EN "  "0 ,1 "
bitfld.long 0 1. " XP70_WAKE_UP "  "0 ,1 "
bitfld.long 0 2. " XP70_EXCEPT_VB "  "0 ,1 "
bitfld.long 0 3. " XP70_IDLE_ACK "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "PTM0"
;==============================================================
base ad:0x801BE000
;tree "Control"
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " rolControl "  "0 ,1 "
;tree.end

bitfld.long 0 2. " ode "  "0 ,1 "
base ad:0x801BE004
;tree "ConfigCode"
rgroup 0--3
line.long 0 "ConfigCode"
bitfld.long 0 0. " odeConfigCode "  "0 ,1 "
;tree.end

bitfld.long 0 3. " ent "  "0 ,1 "
base ad:0x801BE008
;tree "TriggerEvent"
wgroup 0--3
line.long 0 "TriggerEvent"
bitfld.long 0 0. " entTriggerEvent "  "0 ,1 "
;tree.end

bitfld.long 0 0.--3. " rol "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
base ad:0x801BE00c
;tree "AsicControl"
wgroup 0--3
line.long 0 "AsicControl"
bitfld.long 0 0. " rolAsicControl "  "0 ,1 "
;tree.end

bitfld.long 0 4. " tus "  "0 ,1 "
base ad:0x801BE010
;tree "Status"
group 0--3
line.long 0 "Status"
bitfld.long 0 0. " tusStatus "  "0 ,1 "
;tree.end

bitfld.long 0 0.--4. " fig "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
base ad:0x801BE014
;tree "SysConfig"
group 0--3
line.long 0 "SysConfig"
bitfld.long 0 0. " figSysConfig "  "0 ,1 "
;tree.end

bitfld.long 0 0.--4. " top "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
base ad:0x801BE018
;tree "TraceEnStartStop"
wgroup 0--3
line.long 0 "TraceEnStartStop"
bitfld.long 0 0. " topTraceEnStartStop "  "0 ,1 "
;tree.end

bitfld.long 0 0.--4. " rl2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
base ad:0x801BE01c
;tree "TraceEnCtrl2"
wgroup 0--3
line.long 0 "TraceEnCtrl2"
bitfld.long 0 0. " rl2TraceEnCtrl2 "  "0 ,1 "
;tree.end

bitfld.long 0 5. " ent "  "0 ,1 "
base ad:0x801BE020
;tree "TraceEnEvent"
wgroup 0--3
line.long 0 "TraceEnEvent"
bitfld.long 0 0. " entTraceEnEvent "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " rl1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BE024
;tree "TraceEnCtrl1"
wgroup 0--3
line.long 0 "TraceEnCtrl1"
bitfld.long 0 0. " rl1TraceEnCtrl1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " ion "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BE028
;tree "FifoFullRegion"
wgroup 0--3
line.long 0 "FifoFullRegion"
bitfld.long 0 0. " ionFifoFullRegion "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " vel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BE02c
;tree "FifoFullLevel"
group 0--3
line.long 0 "FifoFullLevel"
bitfld.long 0 0. " velFifoFullLevel "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " ent "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BE030
;tree "ViewDataEvent"
wgroup 0--3
line.long 0 "ViewDataEvent"
bitfld.long 0 0. " entViewDataEvent "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " rl1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BE034
;tree "ViewDataCtrl1"
wgroup 0--3
line.long 0 "ViewDataCtrl1"
bitfld.long 0 0. " rl1ViewDataCtrl1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " rl2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BE038
;tree "ViewDataCtrl2"
wgroup 0--3
line.long 0 "ViewDataCtrl2"
bitfld.long 0 0. " rl2ViewDataCtrl2 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " rl3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BE03c
;tree "ViewDataCtrl3"
wgroup 0--3
line.long 0 "ViewDataCtrl3"
bitfld.long 0 0. " rl3ViewDataCtrl3 "  "0 ,1 "
;tree.end

bitfld.long 0 6. " mp0 "  "0 ,1 "
base ad:0x801BE040
;tree "AddrComp0"
wgroup 0--3
line.long 0 "AddrComp0"
bitfld.long 0 0. " mp0AddrComp0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp1 "  " "
base ad:0x801BE044
;tree "AddrComp1"
wgroup 0--3
line.long 0 "AddrComp1"
bitfld.long 0 0. " mp1AddrComp1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp2 "  " "
base ad:0x801BE048
;tree "AddrComp2"
wgroup 0--3
line.long 0 "AddrComp2"
bitfld.long 0 0. " mp2AddrComp2 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp3 "  " "
base ad:0x801BE04c
;tree "AddrComp3"
wgroup 0--3
line.long 0 "AddrComp3"
bitfld.long 0 0. " mp3AddrComp3 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp4 "  " "
base ad:0x801BE050
;tree "AddrComp4"
wgroup 0--3
line.long 0 "AddrComp4"
bitfld.long 0 0. " mp4AddrComp4 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp5 "  " "
base ad:0x801BE054
;tree "AddrComp5"
wgroup 0--3
line.long 0 "AddrComp5"
bitfld.long 0 0. " mp5AddrComp5 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp6 "  " "
base ad:0x801BE058
;tree "AddrComp6"
wgroup 0--3
line.long 0 "AddrComp6"
bitfld.long 0 0. " mp6AddrComp6 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp7 "  " "
base ad:0x801BE05c
;tree "AddrComp7"
wgroup 0--3
line.long 0 "AddrComp7"
bitfld.long 0 0. " mp7AddrComp7 "  "0 ,1 "
;tree.end

bitfld.long 0 7. " pe0 "  "0 ,1 "
base ad:0x801BE080
;tree "AddrAccType0"
wgroup 0--3
line.long 0 "AddrAccType0"
bitfld.long 0 0. " pe0AddrAccType0 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe1 "
base ad:0x801BE084
;tree "AddrAccType1"
wgroup 0--3
line.long 0 "AddrAccType1"
bitfld.long 0 0. " pe1AddrAccType1 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe2 "
base ad:0x801BE088
;tree "AddrAccType2"
wgroup 0--3
line.long 0 "AddrAccType2"
bitfld.long 0 0. " pe2AddrAccType2 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe3 "
base ad:0x801BE08c
;tree "AddrAccType3"
wgroup 0--3
line.long 0 "AddrAccType3"
bitfld.long 0 0. " pe3AddrAccType3 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe4 "
base ad:0x801BE090
;tree "AddrAccType4"
wgroup 0--3
line.long 0 "AddrAccType4"
bitfld.long 0 0. " pe4AddrAccType4 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe5 "
base ad:0x801BE094
;tree "AddrAccType5"
wgroup 0--3
line.long 0 "AddrAccType5"
bitfld.long 0 0. " pe5AddrAccType5 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe6 "
base ad:0x801BE098
;tree "AddrAccType6"
wgroup 0--3
line.long 0 "AddrAccType6"
bitfld.long 0 0. " pe6AddrAccType6 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe7 "
base ad:0x801BE09c
;tree "AddrAccType7"
wgroup 0--3
line.long 0 "AddrAccType7"
bitfld.long 0 0. " pe7AddrAccType7 "  "0 ,1 "
;tree.end

hexfld.byte 0 " mp0 "
base ad:0x801BE0c0
;tree "DataComp0"
wgroup 0--3
line.long 0 "DataComp0"
bitfld.long 0 0. " mp0DataComp0 "  "0 ,1 "
;tree.end

hexfld.byte 0 " mp1 "
base ad:0x801BE0c4
;tree "DataComp1"
wgroup 0--3
line.long 0 "DataComp1"
bitfld.long 0 0. " mp1DataComp1 "  "0 ,1 "
;tree.end

bitfld.long 0 8. " sk0 "  "0 ,1 "
base ad:0x801BE100
;tree "DataMask0"
wgroup 0--3
line.long 0 "DataMask0"
;tree.end

bitfld.long 0 0.--8. " sk1 "  " "
base ad:0x801BE104
;tree "DataMask1"
wgroup 0--3
line.long 0 "DataMask1"
;tree.end

bitfld.long 0 0.--8. " al0 "  " "
base ad:0x801BE140
;tree "CountReloadVal0"
wgroup 0--3
line.long 0 "CountReloadVal0"
bitfld.long 0 0. " al0CountReloadVal0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " al1 "  " "
base ad:0x801BE144
;tree "CountReloadVal1"
wgroup 0--3
line.long 0 "CountReloadVal1"
bitfld.long 0 0. " al1CountReloadVal1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " En0 "  " "
base ad:0x801BE150
;tree "CountEn0"
wgroup 0--3
line.long 0 "CountEn0"
bitfld.long 0 0. " En0CountEn0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " En1 "  " "
base ad:0x801BE154
;tree "CountEn1"
wgroup 0--3
line.long 0 "CountEn1"
bitfld.long 0 0. " En1CountEn1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " Ev0 "  " "
base ad:0x801BE160
;tree "CountReloadEv0"
wgroup 0--3
line.long 0 "CountReloadEv0"
bitfld.long 0 0. " Ev0CountReloadEv0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " Ev1 "  " "
base ad:0x801BE164
;tree "CountReloadEv1"
wgroup 0--3
line.long 0 "CountReloadEv1"
bitfld.long 0 0. " Ev1CountReloadEv1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ue0 "  " "
base ad:0x801BE170
;tree "CountValue0"
group 0--3
line.long 0 "CountValue0"
;tree.end

bitfld.long 0 0.--8. " ue1 "  " "
base ad:0x801BE174
;tree "CountValue1"
group 0--3
line.long 0 "CountValue1"
;tree.end

bitfld.long 0 0.--8. " rl0 "  " "
base ad:0x801BE180
;tree "SeqCtrl0"
wgroup 0--3
line.long 0 "SeqCtrl0"
bitfld.long 0 0. " rl0SeqCtrl0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " rl1 "  " "
base ad:0x801BE184
;tree "SeqCtrl1"
wgroup 0--3
line.long 0 "SeqCtrl1"
bitfld.long 0 0. " rl1SeqCtrl1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " rl2 "  " "
base ad:0x801BE188
;tree "SeqCtrl2"
wgroup 0--3
line.long 0 "SeqCtrl2"
bitfld.long 0 0. " rl2SeqCtrl2 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " rl3 "  " "
base ad:0x801BE18c
;tree "SeqCtrl3"
wgroup 0--3
line.long 0 "SeqCtrl3"
bitfld.long 0 0. " rl3SeqCtrl3 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " rl4 "  " "
base ad:0x801BE190
;tree "SeqCtrl4"
wgroup 0--3
line.long 0 "SeqCtrl4"
bitfld.long 0 0. " rl4SeqCtrl4 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " rl5 "  " "
base ad:0x801BE194
;tree "SeqCtrl5"
wgroup 0--3
line.long 0 "SeqCtrl5"
bitfld.long 0 0. " rl5SeqCtrl5 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ate "  " "
base ad:0x801BE19c
;tree "SeqState"
group 0--3
line.long 0 "SeqState"
bitfld.long 0 0. " ateSeqState "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ut0 "  " "
base ad:0x801BE1a0
;tree "ExtOutput0"
wgroup 0--3
line.long 0 "ExtOutput0"
bitfld.long 0 0. " ut0ExtOutput0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ut1 "  " "
base ad:0x801BE1a4
;tree "ExtOutput1"
wgroup 0--3
line.long 0 "ExtOutput1"
bitfld.long 0 0. " ut1ExtOutput1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " omp "  " "
base ad:0x801BE1b0
;tree "ContextIdComp"
wgroup 0--3
line.long 0 "ContextIdComp"
bitfld.long 0 0. " ompContextIdComp "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ask "  " "
base ad:0x801BE1bc
;tree "ContextIdMask"
wgroup 0--3
line.long 0 "ContextIdMask"
;tree.end

bitfld.long 0 0.--8. " ic0 "  " "
base ad:0x801BE1c0
;tree "ImpSpecific0"
wgroup 0--3
line.long 0 "ImpSpecific0"
bitfld.long 0 0. " ic0ImpSpecific0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic1 "  " "
base ad:0x801BE1c4
;tree "ImpSpecific1"
wgroup 0--3
line.long 0 "ImpSpecific1"
bitfld.long 0 0. " ic1ImpSpecific1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic2 "  " "
base ad:0x801BE1c8
;tree "ImpSpecific2"
wgroup 0--3
line.long 0 "ImpSpecific2"
bitfld.long 0 0. " ic2ImpSpecific2 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic3 "  " "
base ad:0x801BE1cc
;tree "ImpSpecific3"
wgroup 0--3
line.long 0 "ImpSpecific3"
bitfld.long 0 0. " ic3ImpSpecific3 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic4 "  " "
base ad:0x801BE1d0
;tree "ImpSpecific4"
wgroup 0--3
line.long 0 "ImpSpecific4"
bitfld.long 0 0. " ic4ImpSpecific4 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic5 "  " "
base ad:0x801BE1d4
;tree "ImpSpecific5"
wgroup 0--3
line.long 0 "ImpSpecific5"
bitfld.long 0 0. " ic5ImpSpecific5 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic6 "  " "
base ad:0x801BE1d8
;tree "ImpSpecific6"
wgroup 0--3
line.long 0 "ImpSpecific6"
bitfld.long 0 0. " ic6ImpSpecific6 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic7 "  " "
base ad:0x801BE1dc
;tree "ImpSpecific7"
wgroup 0--3
line.long 0 "ImpSpecific7"
bitfld.long 0 0. " ic7ImpSpecific7 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " req "  " "
base ad:0x801BE1e0
;tree "SynchFreq"
wgroup 0--3
line.long 0 "SynchFreq"
bitfld.long 0 0. " reqSynchFreq "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " mId "  " "
base ad:0x801BE1e4
;tree "EtmId"
group 0--3
line.long 0 "EtmId"
bitfld.long 0 0. " mIdEtmId "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " Ext "  " "
base ad:0x801BE1e8
;tree "ConfigCodeExt"
group 0--3
line.long 0 "ConfigCodeExt"
bitfld.long 0 0. " ExtConfigCodeExt "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " Ext "  " "
base ad:0x801BE1ec
;tree "ExternalInExt"
wgroup 0--3
line.long 0 "ExternalInExt"
bitfld.long 0 0. " ExtExternalInExt "  "0 ,1 "
;tree.end

bitfld.long 0 9. " eID "  "0 ,1 "
base ad:0x801BE200
;tree "CSTraceID"
wgroup 0--3
line.long 0 "CSTraceID"
bitfld.long 0 0. " eIDCSTraceID "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " Set "  " "
base ad:0x801BEfa0
;tree "ClaimTagSet"
group 0--3
line.long 0 "ClaimTagSet"
bitfld.long 0 0. " SetClaimTagSet "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " Clr "  " "
base ad:0x801BEfa4
;tree "ClaimTagClr"
group 0--3
line.long 0 "ClaimTagClr"
bitfld.long 0 0. " ClrClaimTagClr "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ess "  " "
base ad:0x801BEfb0
;tree "LockAccess"
wgroup 0--3
line.long 0 "LockAccess"
bitfld.long 0 0. " essLockAccess "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " tus "  " "
base ad:0x801BEfb4
;tree "LockStatus"
wgroup 0--3
line.long 0 "LockStatus"
bitfld.long 0 0. " tusLockStatus "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " tus "  " "
base ad:0x801BEfb8
;tree "AuthenticationStatus"
group 0--3
line.long 0 "AuthenticationStatus"
bitfld.long 0 0. " tusAuthenticationStatus "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ype "  " "
base ad:0x801BEfcc
;tree "CSDeviceType"
rgroup 0--3
line.long 0 "CSDeviceType"
bitfld.long 0 0. " ypeCSDeviceType "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID4 "  " "
base ad:0x801BEfd0
;tree "PeriphID4"
rgroup 0--3
line.long 0 "PeriphID4"
bitfld.long 0 0. " ID4PeriphID4 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID5 "  " "
base ad:0x801BEfd4
;tree "PeriphID5"
rgroup 0--3
line.long 0 "PeriphID5"
bitfld.long 0 0. " ID5PeriphID5 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID6 "  " "
base ad:0x801BEfd8
;tree "PeriphID6"
rgroup 0--3
line.long 0 "PeriphID6"
bitfld.long 0 0. " ID6PeriphID6 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID7 "  " "
base ad:0x801BEfdc
;tree "PeriphID7"
rgroup 0--3
line.long 0 "PeriphID7"
bitfld.long 0 0. " ID7PeriphID7 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID0 "  " "
base ad:0x801BEfe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0. " ID0PeriphID0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID1 "  " "
base ad:0x801BEfe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0. " ID1PeriphID1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID2 "  " "
base ad:0x801BEfe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0. " ID2PeriphID2 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID3 "  " "
base ad:0x801BEfec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0. " ID3PeriphID3 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID0 "  " "
base ad:0x801BEff0
;tree "CompID0"
rgroup 0--3
line.long 0 "CompID0"
bitfld.long 0 0. " ID0CompID0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID1 "  " "
base ad:0x801BEff4
;tree "CompID1"
rgroup 0--3
line.long 0 "CompID1"
bitfld.long 0 0. " ID1CompID1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID2 "  " "
base ad:0x801BEff8
;tree "CompID2"
rgroup 0--3
line.long 0 "CompID2"
bitfld.long 0 0. " ID2CompID2 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID3 "  " "
base ad:0x801BEffc
;tree "CompID3"
rgroup 0--3
line.long 0 "CompID3"
bitfld.long 0 0. " ID3CompID3 "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "PTM1"
;==============================================================
base ad:0x801BF000
;tree "Control"
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " rolControl "  "0 ,1 "
;tree.end

bitfld.long 0 2. " ode "  "0 ,1 "
base ad:0x801BF004
;tree "ConfigCode"
rgroup 0--3
line.long 0 "ConfigCode"
bitfld.long 0 0. " odeConfigCode "  "0 ,1 "
;tree.end

bitfld.long 0 3. " ent "  "0 ,1 "
base ad:0x801BF008
;tree "TriggerEvent"
wgroup 0--3
line.long 0 "TriggerEvent"
bitfld.long 0 0. " entTriggerEvent "  "0 ,1 "
;tree.end

bitfld.long 0 0.--3. " rol "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
base ad:0x801BF00c
;tree "AsicControl"
wgroup 0--3
line.long 0 "AsicControl"
bitfld.long 0 0. " rolAsicControl "  "0 ,1 "
;tree.end

bitfld.long 0 4. " tus "  "0 ,1 "
base ad:0x801BF010
;tree "Status"
group 0--3
line.long 0 "Status"
bitfld.long 0 0. " tusStatus "  "0 ,1 "
;tree.end

bitfld.long 0 0.--4. " fig "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
base ad:0x801BF014
;tree "SysConfig"
group 0--3
line.long 0 "SysConfig"
bitfld.long 0 0. " figSysConfig "  "0 ,1 "
;tree.end

bitfld.long 0 0.--4. " top "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
base ad:0x801BF018
;tree "TraceEnStartStop"
wgroup 0--3
line.long 0 "TraceEnStartStop"
bitfld.long 0 0. " topTraceEnStartStop "  "0 ,1 "
;tree.end

bitfld.long 0 0.--4. " rl2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
base ad:0x801BF01c
;tree "TraceEnCtrl2"
wgroup 0--3
line.long 0 "TraceEnCtrl2"
bitfld.long 0 0. " rl2TraceEnCtrl2 "  "0 ,1 "
;tree.end

bitfld.long 0 5. " ent "  "0 ,1 "
base ad:0x801BF020
;tree "TraceEnEvent"
wgroup 0--3
line.long 0 "TraceEnEvent"
bitfld.long 0 0. " entTraceEnEvent "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " rl1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BF024
;tree "TraceEnCtrl1"
wgroup 0--3
line.long 0 "TraceEnCtrl1"
bitfld.long 0 0. " rl1TraceEnCtrl1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " ion "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BF028
;tree "FifoFullRegion"
wgroup 0--3
line.long 0 "FifoFullRegion"
bitfld.long 0 0. " ionFifoFullRegion "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " vel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BF02c
;tree "FifoFullLevel"
group 0--3
line.long 0 "FifoFullLevel"
bitfld.long 0 0. " velFifoFullLevel "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " ent "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BF030
;tree "ViewDataEvent"
wgroup 0--3
line.long 0 "ViewDataEvent"
bitfld.long 0 0. " entViewDataEvent "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " rl1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BF034
;tree "ViewDataCtrl1"
wgroup 0--3
line.long 0 "ViewDataCtrl1"
bitfld.long 0 0. " rl1ViewDataCtrl1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " rl2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BF038
;tree "ViewDataCtrl2"
wgroup 0--3
line.long 0 "ViewDataCtrl2"
bitfld.long 0 0. " rl2ViewDataCtrl2 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--5. " rl3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
base ad:0x801BF03c
;tree "ViewDataCtrl3"
wgroup 0--3
line.long 0 "ViewDataCtrl3"
bitfld.long 0 0. " rl3ViewDataCtrl3 "  "0 ,1 "
;tree.end

bitfld.long 0 6. " mp0 "  "0 ,1 "
base ad:0x801BF040
;tree "AddrComp0"
wgroup 0--3
line.long 0 "AddrComp0"
bitfld.long 0 0. " mp0AddrComp0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp1 "  " "
base ad:0x801BF044
;tree "AddrComp1"
wgroup 0--3
line.long 0 "AddrComp1"
bitfld.long 0 0. " mp1AddrComp1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp2 "  " "
base ad:0x801BF048
;tree "AddrComp2"
wgroup 0--3
line.long 0 "AddrComp2"
bitfld.long 0 0. " mp2AddrComp2 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp3 "  " "
base ad:0x801BF04c
;tree "AddrComp3"
wgroup 0--3
line.long 0 "AddrComp3"
bitfld.long 0 0. " mp3AddrComp3 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp4 "  " "
base ad:0x801BF050
;tree "AddrComp4"
wgroup 0--3
line.long 0 "AddrComp4"
bitfld.long 0 0. " mp4AddrComp4 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp5 "  " "
base ad:0x801BF054
;tree "AddrComp5"
wgroup 0--3
line.long 0 "AddrComp5"
bitfld.long 0 0. " mp5AddrComp5 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp6 "  " "
base ad:0x801BF058
;tree "AddrComp6"
wgroup 0--3
line.long 0 "AddrComp6"
bitfld.long 0 0. " mp6AddrComp6 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--6. " mp7 "  " "
base ad:0x801BF05c
;tree "AddrComp7"
wgroup 0--3
line.long 0 "AddrComp7"
bitfld.long 0 0. " mp7AddrComp7 "  "0 ,1 "
;tree.end

bitfld.long 0 7. " pe0 "  "0 ,1 "
base ad:0x801BF080
;tree "AddrAccType0"
wgroup 0--3
line.long 0 "AddrAccType0"
bitfld.long 0 0. " pe0AddrAccType0 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe1 "
base ad:0x801BF084
;tree "AddrAccType1"
wgroup 0--3
line.long 0 "AddrAccType1"
bitfld.long 0 0. " pe1AddrAccType1 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe2 "
base ad:0x801BF088
;tree "AddrAccType2"
wgroup 0--3
line.long 0 "AddrAccType2"
bitfld.long 0 0. " pe2AddrAccType2 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe3 "
base ad:0x801BF08c
;tree "AddrAccType3"
wgroup 0--3
line.long 0 "AddrAccType3"
bitfld.long 0 0. " pe3AddrAccType3 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe4 "
base ad:0x801BF090
;tree "AddrAccType4"
wgroup 0--3
line.long 0 "AddrAccType4"
bitfld.long 0 0. " pe4AddrAccType4 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe5 "
base ad:0x801BF094
;tree "AddrAccType5"
wgroup 0--3
line.long 0 "AddrAccType5"
bitfld.long 0 0. " pe5AddrAccType5 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe6 "
base ad:0x801BF098
;tree "AddrAccType6"
wgroup 0--3
line.long 0 "AddrAccType6"
bitfld.long 0 0. " pe6AddrAccType6 "  "0 ,1 "
;tree.end

hexfld.byte 0 " pe7 "
base ad:0x801BF09c
;tree "AddrAccType7"
wgroup 0--3
line.long 0 "AddrAccType7"
bitfld.long 0 0. " pe7AddrAccType7 "  "0 ,1 "
;tree.end

hexfld.byte 0 " mp0 "
base ad:0x801BF0c0
;tree "DataComp0"
wgroup 0--3
line.long 0 "DataComp0"
bitfld.long 0 0. " mp0DataComp0 "  "0 ,1 "
;tree.end

hexfld.byte 0 " mp1 "
base ad:0x801BF0c4
;tree "DataComp1"
wgroup 0--3
line.long 0 "DataComp1"
bitfld.long 0 0. " mp1DataComp1 "  "0 ,1 "
;tree.end

bitfld.long 0 8. " sk0 "  "0 ,1 "
base ad:0x801BF100
;tree "DataMask0"
wgroup 0--3
line.long 0 "DataMask0"
;tree.end

bitfld.long 0 0.--8. " sk1 "  " "
base ad:0x801BF104
;tree "DataMask1"
wgroup 0--3
line.long 0 "DataMask1"
;tree.end

bitfld.long 0 0.--8. " al0 "  " "
base ad:0x801BF140
;tree "CountReloadVal0"
wgroup 0--3
line.long 0 "CountReloadVal0"
bitfld.long 0 0. " al0CountReloadVal0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " al1 "  " "
base ad:0x801BF144
;tree "CountReloadVal1"
wgroup 0--3
line.long 0 "CountReloadVal1"
bitfld.long 0 0. " al1CountReloadVal1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " En0 "  " "
base ad:0x801BF150
;tree "CountEn0"
wgroup 0--3
line.long 0 "CountEn0"
bitfld.long 0 0. " En0CountEn0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " En1 "  " "
base ad:0x801BF154
;tree "CountEn1"
wgroup 0--3
line.long 0 "CountEn1"
bitfld.long 0 0. " En1CountEn1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " Ev0 "  " "
base ad:0x801BF160
;tree "CountReloadEv0"
wgroup 0--3
line.long 0 "CountReloadEv0"
bitfld.long 0 0. " Ev0CountReloadEv0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " Ev1 "  " "
base ad:0x801BF164
;tree "CountReloadEv1"
wgroup 0--3
line.long 0 "CountReloadEv1"
bitfld.long 0 0. " Ev1CountReloadEv1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ue0 "  " "
base ad:0x801BF170
;tree "CountValue0"
group 0--3
line.long 0 "CountValue0"
;tree.end

bitfld.long 0 0.--8. " ue1 "  " "
base ad:0x801BF174
;tree "CountValue1"
group 0--3
line.long 0 "CountValue1"
;tree.end

bitfld.long 0 0.--8. " rl0 "  " "
base ad:0x801BF180
;tree "SeqCtrl0"
wgroup 0--3
line.long 0 "SeqCtrl0"
bitfld.long 0 0. " rl0SeqCtrl0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " rl1 "  " "
base ad:0x801BF184
;tree "SeqCtrl1"
wgroup 0--3
line.long 0 "SeqCtrl1"
bitfld.long 0 0. " rl1SeqCtrl1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " rl2 "  " "
base ad:0x801BF188
;tree "SeqCtrl2"
wgroup 0--3
line.long 0 "SeqCtrl2"
bitfld.long 0 0. " rl2SeqCtrl2 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " rl3 "  " "
base ad:0x801BF18c
;tree "SeqCtrl3"
wgroup 0--3
line.long 0 "SeqCtrl3"
bitfld.long 0 0. " rl3SeqCtrl3 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " rl4 "  " "
base ad:0x801BF190
;tree "SeqCtrl4"
wgroup 0--3
line.long 0 "SeqCtrl4"
bitfld.long 0 0. " rl4SeqCtrl4 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " rl5 "  " "
base ad:0x801BF194
;tree "SeqCtrl5"
wgroup 0--3
line.long 0 "SeqCtrl5"
bitfld.long 0 0. " rl5SeqCtrl5 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ate "  " "
base ad:0x801BF19c
;tree "SeqState"
group 0--3
line.long 0 "SeqState"
bitfld.long 0 0. " ateSeqState "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ut0 "  " "
base ad:0x801BF1a0
;tree "ExtOutput0"
wgroup 0--3
line.long 0 "ExtOutput0"
bitfld.long 0 0. " ut0ExtOutput0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ut1 "  " "
base ad:0x801BF1a4
;tree "ExtOutput1"
wgroup 0--3
line.long 0 "ExtOutput1"
bitfld.long 0 0. " ut1ExtOutput1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " omp "  " "
base ad:0x801BF1b0
;tree "ContextIdComp"
wgroup 0--3
line.long 0 "ContextIdComp"
bitfld.long 0 0. " ompContextIdComp "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ask "  " "
base ad:0x801BF1bc
;tree "ContextIdMask"
wgroup 0--3
line.long 0 "ContextIdMask"
;tree.end

bitfld.long 0 0.--8. " ic0 "  " "
base ad:0x801BF1c0
;tree "ImpSpecific0"
wgroup 0--3
line.long 0 "ImpSpecific0"
bitfld.long 0 0. " ic0ImpSpecific0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic1 "  " "
base ad:0x801BF1c4
;tree "ImpSpecific1"
wgroup 0--3
line.long 0 "ImpSpecific1"
bitfld.long 0 0. " ic1ImpSpecific1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic2 "  " "
base ad:0x801BF1c8
;tree "ImpSpecific2"
wgroup 0--3
line.long 0 "ImpSpecific2"
bitfld.long 0 0. " ic2ImpSpecific2 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic3 "  " "
base ad:0x801BF1cc
;tree "ImpSpecific3"
wgroup 0--3
line.long 0 "ImpSpecific3"
bitfld.long 0 0. " ic3ImpSpecific3 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic4 "  " "
base ad:0x801BF1d0
;tree "ImpSpecific4"
wgroup 0--3
line.long 0 "ImpSpecific4"
bitfld.long 0 0. " ic4ImpSpecific4 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic5 "  " "
base ad:0x801BF1d4
;tree "ImpSpecific5"
wgroup 0--3
line.long 0 "ImpSpecific5"
bitfld.long 0 0. " ic5ImpSpecific5 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic6 "  " "
base ad:0x801BF1d8
;tree "ImpSpecific6"
wgroup 0--3
line.long 0 "ImpSpecific6"
bitfld.long 0 0. " ic6ImpSpecific6 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " ic7 "  " "
base ad:0x801BF1dc
;tree "ImpSpecific7"
wgroup 0--3
line.long 0 "ImpSpecific7"
bitfld.long 0 0. " ic7ImpSpecific7 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " req "  " "
base ad:0x801BF1e0
;tree "SynchFreq"
wgroup 0--3
line.long 0 "SynchFreq"
bitfld.long 0 0. " reqSynchFreq "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " mId "  " "
base ad:0x801BF1e4
;tree "EtmId"
group 0--3
line.long 0 "EtmId"
bitfld.long 0 0. " mIdEtmId "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " Ext "  " "
base ad:0x801BF1e8
;tree "ConfigCodeExt"
group 0--3
line.long 0 "ConfigCodeExt"
bitfld.long 0 0. " ExtConfigCodeExt "  "0 ,1 "
;tree.end

bitfld.long 0 0.--8. " Ext "  " "
base ad:0x801BF1ec
;tree "ExternalInExt"
wgroup 0--3
line.long 0 "ExternalInExt"
bitfld.long 0 0. " ExtExternalInExt "  "0 ,1 "
;tree.end

bitfld.long 0 9. " eID "  "0 ,1 "
base ad:0x801BF200
;tree "CSTraceID"
wgroup 0--3
line.long 0 "CSTraceID"
bitfld.long 0 0. " eIDCSTraceID "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " Set "  " "
base ad:0x801BFfa0
;tree "ClaimTagSet"
group 0--3
line.long 0 "ClaimTagSet"
bitfld.long 0 0. " SetClaimTagSet "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " Clr "  " "
base ad:0x801BFfa4
;tree "ClaimTagClr"
group 0--3
line.long 0 "ClaimTagClr"
bitfld.long 0 0. " ClrClaimTagClr "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ess "  " "
base ad:0x801BFfb0
;tree "LockAccess"
wgroup 0--3
line.long 0 "LockAccess"
bitfld.long 0 0. " essLockAccess "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " tus "  " "
base ad:0x801BFfb4
;tree "LockStatus"
wgroup 0--3
line.long 0 "LockStatus"
bitfld.long 0 0. " tusLockStatus "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " tus "  " "
base ad:0x801BFfb8
;tree "AuthenticationStatus"
group 0--3
line.long 0 "AuthenticationStatus"
bitfld.long 0 0. " tusAuthenticationStatus "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ype "  " "
base ad:0x801BFfcc
;tree "CSDeviceType"
rgroup 0--3
line.long 0 "CSDeviceType"
bitfld.long 0 0. " ypeCSDeviceType "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID4 "  " "
base ad:0x801BFfd0
;tree "PeriphID4"
rgroup 0--3
line.long 0 "PeriphID4"
bitfld.long 0 0. " ID4PeriphID4 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID5 "  " "
base ad:0x801BFfd4
;tree "PeriphID5"
rgroup 0--3
line.long 0 "PeriphID5"
bitfld.long 0 0. " ID5PeriphID5 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID6 "  " "
base ad:0x801BFfd8
;tree "PeriphID6"
rgroup 0--3
line.long 0 "PeriphID6"
bitfld.long 0 0. " ID6PeriphID6 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID7 "  " "
base ad:0x801BFfdc
;tree "PeriphID7"
rgroup 0--3
line.long 0 "PeriphID7"
bitfld.long 0 0. " ID7PeriphID7 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID0 "  " "
base ad:0x801BFfe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0. " ID0PeriphID0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID1 "  " "
base ad:0x801BFfe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0. " ID1PeriphID1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID2 "  " "
base ad:0x801BFfe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0. " ID2PeriphID2 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID3 "  " "
base ad:0x801BFfec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0. " ID3PeriphID3 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID0 "  " "
base ad:0x801BFff0
;tree "CompID0"
rgroup 0--3
line.long 0 "CompID0"
bitfld.long 0 0. " ID0CompID0 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID1 "  " "
base ad:0x801BFff4
;tree "CompID1"
rgroup 0--3
line.long 0 "CompID1"
bitfld.long 0 0. " ID1CompID1 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID2 "  " "
base ad:0x801BFff8
;tree "CompID2"
rgroup 0--3
line.long 0 "CompID2"
bitfld.long 0 0. " ID2CompID2 "  "0 ,1 "
;tree.end

bitfld.long 0 0.--11. " ID3 "  " "
base ad:0x801BFffc
;tree "CompID3"
rgroup 0--3
line.long 0 "CompID3"
bitfld.long 0 0. " ID3CompID3 "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "PWL"
;==============================================================
base ad:0x80113000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PWLEN "  "0 ,1 "
;tree.end

base ad:0x80113004
;tree "LR"
group 0--3
line.long 0 "LR"
hexfld.byte 0 " PWLVL "
;tree.end

base ad:0x80113080
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80113088
;tree "ITOP"
rgroup 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " PWLOUT "  "0 ,1 "
;tree.end

base ad:0x80113fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80113fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80113fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80113fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80113ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

base ad:0x80113ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

base ad:0x80113ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

base ad:0x80113ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

;==============================================================
tree "RNG"
;==============================================================
base ad:0xa03c0000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SEC "  "0 ,1 "
bitfld.long 0 1. " PRIV "  "0 ,1 "
bitfld.long 0 2. " RNGDIS "  "0 ,1 "
bitfld.long 0 3. " TSTCLK "  "0 ,1 "
;tree.end

base ad:0xa03c0004
;tree "SR"
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RNGRDY "  "0 ,1 "
bitfld.long 0 1. " REVCLK "  "0 ,1 "
bitfld.long 0 2. " FAULT "  "0 ,1 "
;tree.end

base ad:0xa03c0008
;tree "VAL"
group 0--3
line.long 0 "VAL"
bitfld.long 0 0. " 16 "  "0 ,1 "
;tree.end

base ad:0xa03c0080
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0xa03c0084
;tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
;tree.end

base ad:0xa03c0fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03c0fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c0fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c0fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03c0ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

base ad:0xa03c0ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

base ad:0xa03c0ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

base ad:0xa03c0ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

;==============================================================
tree "RTC"
;==============================================================
base ad:0x80154000
;tree "DR"
rgroup 0--3
line.long 0 "DR"
bitfld.long 0 0.--5. " CWSEC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " WMIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--16. " CWHOUR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 17.--19. " CWDAYW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--24. " CWDAYM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--28. " CWMONTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80154004
;tree "MR"
group 0--3
line.long 0 "MR"
bitfld.long 0 0.--5. " CWSECM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " WMINM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--16. " CWHOURM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 17.--19. " CWDAYWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--24. " CWDAYMM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--28. " CWMONTHM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80154008
;tree "LR"
group 0--3
line.long 0 "LR"
bitfld.long 0 0.--5. " CWSECL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " WMINL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--16. " CWHOURL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 17.--19. " CWDAYWL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--24. " CWDAYML "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--28. " CWMONTHL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8015400c
;tree "TCR"
group 0--3
line.long 0 "TCR"
hexfld.word 0 " CKDIV "
bitfld.long 0 16.--25. " CKDEL "  " "
bitfld.long 0 26. " RTCEN "  "0 ,1 "
bitfld.long 0 27. " SEC "  "0 ,1 "
;tree.end

base ad:0x80154010
;tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTCIMSC "  "0 ,1 "
bitfld.long 0 1. " RTTIMSC "  "0 ,1 "
;tree.end

base ad:0x80154014
;tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTCRIS "  "0 ,1 "
bitfld.long 0 1. " RTTRIS "  "0 ,1 "
;tree.end

base ad:0x80154018
;tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTCMIS "  "0 ,1 "
bitfld.long 0 1. " RTTMIS "  "0 ,1 "
;tree.end

base ad:0x8015401c
;tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTCIC "  "0 ,1 "
bitfld.long 0 1. " RTTIC "  "0 ,1 "
;tree.end

base ad:0x80154020
;tree "RTT_DR"
group 0--3
line.long 0 "RTT_DR"
hexfld.long 0 " Data "
;tree.end

base ad:0x80154024
;tree "RTT_LR1"
group 0--3
line.long 0 "RTT_LR1"
hexfld.long 0 " Load "
;tree.end

base ad:0x8015402c
;tree "RTT_LR2"
group 0--3
line.long 0 "RTT_LR2"
hexfld.long 0 " Load "
;tree.end

base ad:0x8015403c
;tree "RTT_PR1"
group 0--3
line.long 0 "RTT_PR1"
hexfld.long 0 " Load "
;tree.end

base ad:0x80154040
;tree "RTT_PR2"
group 0--3
line.long 0 "RTT_PR2"
hexfld.long 0 " Load "
;tree.end

base ad:0x80154044
;tree "RTT_PR3"
group 0--3
line.long 0 "RTT_PR3"
hexfld.long 0 " Load "
;tree.end

base ad:0x80154048
;tree "RTT_PR4"
group 0--3
line.long 0 "RTT_PR4"
hexfld.long 0 " Load "
;tree.end

base ad:0x8015404c
;tree "IN"
rgroup 0--3
line.long 0 "IN"
hexfld.long 0 " TINTERRUPT "
;tree.end

base ad:0x80154050
;tree "WK"
group 0--3
line.long 0 "WK"
hexfld.long 0 " TINTERRUPT "
;tree.end

base ad:0x80154054
;tree "SMIN"
rgroup 0--3
line.long 0 "SMIN"
hexfld.long 0 " SINTERRUPT "
;tree.end

base ad:0x80154028
;tree "RTT_CR"
group 0--3
line.long 0 "RTT_CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
bitfld.long 0 2. " RTTSS "  "0 ,1 "
bitfld.long 0 3. " RTTSM "  "0 ,1 "
bitfld.long 0 4.--10. " RTTPS "  " "
bitfld.long 0 11. " RTTCLK "  "0 ,1 "
;tree.end

base ad:0x80154030
;tree "YR"
rgroup 0--3
line.long 0 "YR"
bitfld.long 0 0.--13. " CWYEAR "  " "
;tree.end

base ad:0x80154034
;tree "YMR"
group 0--3
line.long 0 "YMR"
bitfld.long 0 0.--13. " CWYEARM "  " "
;tree.end

base ad:0x80154038
;tree "YLR"
group 0--3
line.long 0 "YLR"
bitfld.long 0 0.--13. " CWYEARL "  " "
;tree.end

base ad:0x80154080
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTCNT "  "0 ,1 "
;tree.end

base ad:0x80154084
;tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
;tree.end

base ad:0x80154088
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTCINTR "  "0 ,1 "
bitfld.long 0 1. " RTCWKUP "  "0 ,1 "
bitfld.long 0 2. " PWLOUT "  "0 ,1 "
bitfld.long 0 3. " RTTINTR "  "0 ,1 "
bitfld.long 0 4. " RTTWKUP "  "0 ,1 "
;tree.end

base ad:0x80154fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80154fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80154fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80154fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80154ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " RTCPCellID0 "
;tree.end

base ad:0x80154ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " RTCPCellID1 "
;tree.end

base ad:0x80154ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " RTCPCellID2 "
;tree.end

base ad:0x80154ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " RTCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "RTT0"
;==============================================================
base ad:0x80152000
;tree "CTCR"
group 0--3
line.long 0 "CTCR"
hexfld.word 0 " CKDIV "
;tree.end

base ad:0x80152004
;tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTTIMSC "  "0 ,1 "
;tree.end

base ad:0x80152008
;tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTTRIS "  "0 ,1 "
;tree.end

base ad:0x8015200c
;tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTTMIS "  "0 ,1 "
;tree.end

base ad:0x80152010
;tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTTIC "  "0 ,1 "
;tree.end

base ad:0x80152014
;tree "DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " Data "
;tree.end

base ad:0x80152018
;tree "LR"
group 0--3
line.long 0 "LR"
hexfld.long 0 " Load "
;tree.end

base ad:0x8015201c
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
bitfld.long 0 2. " RTTENS "  "0 ,1 "
;tree.end

base ad:0x80152080
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80152084
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTTINTR "  "0 ,1 "
bitfld.long 0 1. " RTTWKUP "  "0 ,1 "
;tree.end

base ad:0x80152fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80152fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80152fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80152fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80152ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " RTCPCellID0 "
;tree.end

base ad:0x80152ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " RTCPCellID1 "
;tree.end

base ad:0x80152ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " RTCPCellID2 "
;tree.end

base ad:0x80152ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " RTCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "RTT1"
;==============================================================
base ad:0x80153000
;tree "CTCR"
group 0--3
line.long 0 "CTCR"
hexfld.word 0 " CKDIV "
;tree.end

base ad:0x80153004
;tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTTIMSC "  "0 ,1 "
;tree.end

base ad:0x80153008
;tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTTRIS "  "0 ,1 "
;tree.end

base ad:0x8015300c
;tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTTMIS "  "0 ,1 "
;tree.end

base ad:0x80153010
;tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTTIC "  "0 ,1 "
;tree.end

base ad:0x80153014
;tree "DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " Data "
;tree.end

base ad:0x80153018
;tree "LR"
group 0--3
line.long 0 "LR"
hexfld.long 0 " Load "
;tree.end

base ad:0x8015301c
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
bitfld.long 0 2. " RTTENS "  "0 ,1 "
;tree.end

base ad:0x80153080
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80153084
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTTINTR "  "0 ,1 "
bitfld.long 0 1. " RTTWKUP "  "0 ,1 "
;tree.end

base ad:0x80153fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80153fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80153fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80153fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80153ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " RTCPCellID0 "
;tree.end

base ad:0x80153ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " RTCPCellID1 "
;tree.end

base ad:0x80153ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " RTCPCellID2 "
;tree.end

base ad:0x80153ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " RTCPCellID3 "
;tree.end

tree.end

;==============================================================
tree "SBAG"
;==============================================================
base ad:0xa0390000
;tree "BA_ENABLE_L"
group 0--3
line.long 0 "BA_ENABLE_L"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390004
;tree "BA_ENABLE_H"
group 0--3
line.long 0 "BA_ENABLE_H"
;tree.end

base ad:0xa0390008
;tree "BA_MODE_L"
group 0--3
line.long 0 "BA_MODE_L"
bitfld.long 0 0.--2. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa039000c
;tree "BA_MODE_H"
group 0--3
line.long 0 "BA_MODE_H"
;tree.end

base ad:0xa0390010
;tree "BA_MSG_PORT_PACE_L"
group 0--3
line.long 0 "BA_MSG_PORT_PACE_L"
hexfld.word 0 " DIVIDER "
;tree.end

base ad:0xa0390014
;tree "BA_MSG_PORT_PACE_H"
group 0--3
line.long 0 "BA_MSG_PORT_PACE_H"
;tree.end

base ad:0xa0390018
;tree "BA_STATUS_L"
rgroup 0--3
line.long 0 "BA_STATUS_L"
bitfld.long 0 0.--1. " FF_FLAGS "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa039001c
;tree "BA_STATUS_H"
rgroup 0--3
line.long 0 "BA_STATUS_H"
;tree.end

base ad:0xa0390200
;tree "TIME_ABSOLUTE_L"
group 0--3
line.long 0 "TIME_ABSOLUTE_L"
hexfld.long 0 " TIME "
;tree.end

base ad:0xa0390204
;tree "TIME_ABSOLUTE_H"
rgroup 0--3
line.long 0 "TIME_ABSOLUTE_H"
hexfld.word 0 " TIME "
;tree.end

base ad:0xa0390400
;tree "WP0_CTRL_L"
group 0--3
line.long 0 "WP0_CTRL_L"
hexfld.byte 0 " RSRC_MSK "
hexfld.byte 1 " RSRC_VAL "
hexfld.byte 2 " SRC_MSK "
hexfld.byte 3 " SRC_VAL "
;tree.end

base ad:0xa0390404
;tree "WP0_CTRL_H"
group 0--3
line.long 0 "WP0_CTRL_H"
hexfld.byte 0 " OPC_MSK "
hexfld.byte 1 " OPC_VAL "
bitfld.long 0 16. " OUT_OF_RANGE "  "0 ,1 "
;tree.end

base ad:0xa0390408
;tree "WP0_EX_CTRL_L"
group 0--3
line.long 0 "WP0_EX_CTRL_L"
bitfld.long 0 0. " CBUF_FREEZE "  "0 ,1 "
;tree.end

base ad:0xa039040c
;tree "WP0_EX_CTRL_H"
group 0--3
line.long 0 "WP0_EX_CTRL_H"
;tree.end

base ad:0xa0390410
;tree "WP0_MATCH_START_L"
group 0--3
line.long 0 "WP0_MATCH_START_L"
bitfld.long 0 2.--23. " START_ADDR "  " "
;tree.end

base ad:0xa0390414
;tree "WP0_MATCH_START_H"
group 0--3
line.long 0 "WP0_MATCH_START_H"
;tree.end

base ad:0xa0390418
;tree "WP0_MATCH_END_L"
group 0--3
line.long 0 "WP0_MATCH_END_L"
bitfld.long 0 2.--23. " END_ADDR "  " "
;tree.end

base ad:0xa039041c
;tree "WP0_MATCH_END_H"
group 0--3
line.long 0 "WP0_MATCH_END_H"
;tree.end

base ad:0xa0390420
;tree "WP0_CB_HDR_L"
rgroup 0--3
line.long 0 "WP0_CB_HDR_L"
hexfld.byte 0 " SB3_DEST "
hexfld.byte 1 " SB3_OPC "
hexfld.byte 2 " SB3_TID "
hexfld.byte 3 " SB3_SRC "
;tree.end

base ad:0xa0390424
;tree "WP0_CB_HDR_H"
rgroup 0--3
line.long 0 "WP0_CB_HDR_H"
bitfld.long 0 3.--23. " SB3_ADDR "  " "
hexfld.byte 3 " SB3_MSK "
;tree.end

base ad:0xa0390428
;tree "WP0_CB_DATA_L"
rgroup 0--3
line.long 0 "WP0_CB_DATA_L"
hexfld.long 0 " SB3_DATA "
;tree.end

base ad:0xa039042c
;tree "WP0_CB_DATA_H"
rgroup 0--3
line.long 0 "WP0_CB_DATA_H"
hexfld.long 0 " SB3_DATA "
;tree.end

base ad:0xa0390430
;tree "WP0_ENABLE_L"
group 0--3
line.long 0 "WP0_ENABLE_L"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390434
;tree "WP0_ENABLE_H"
group 0--3
line.long 0 "WP0_ENABLE_H"
;tree.end

base ad:0xa0390480
;tree "WP1_CTRL_L"
group 0--3
line.long 0 "WP1_CTRL_L"
hexfld.byte 0 " RSRC_MSK "
hexfld.byte 1 " RSRC_VAL "
hexfld.byte 2 " SRC_MSK "
hexfld.byte 3 " SRC_VAL "
;tree.end

base ad:0xa0390484
;tree "WP1_CTRL_H"
group 0--3
line.long 0 "WP1_CTRL_H"
hexfld.byte 0 " OPC_MSK "
hexfld.byte 1 " OPC_VAL "
bitfld.long 0 16. " OUT_OF_RANGE "  "0 ,1 "
;tree.end

base ad:0xa0390488
;tree "WP1_EX_CTRL_L"
group 0--3
line.long 0 "WP1_EX_CTRL_L"
bitfld.long 0 0. " CBUF_FREEZE "  "0 ,1 "
;tree.end

base ad:0xa039048c
;tree "WP1_EX_CTRL_H"
group 0--3
line.long 0 "WP1_EX_CTRL_H"
;tree.end

base ad:0xa0390490
;tree "WP1_MATCH_START_L"
group 0--3
line.long 0 "WP1_MATCH_START_L"
bitfld.long 0 2.--23. " START_ADDR "  " "
;tree.end

base ad:0xa0390494
;tree "WP1_MATCH_START_H"
group 0--3
line.long 0 "WP1_MATCH_START_H"
;tree.end

base ad:0xa0390498
;tree "WP1_MATCH_END_L"
group 0--3
line.long 0 "WP1_MATCH_END_L"
bitfld.long 0 2.--23. " END_ADDR "  " "
;tree.end

base ad:0xa039049c
;tree "WP1_MATCH_END_H"
group 0--3
line.long 0 "WP1_MATCH_END_H"
;tree.end

base ad:0xa03904a0
;tree "WP1_CB_HDR_L"
rgroup 0--3
line.long 0 "WP1_CB_HDR_L"
hexfld.byte 0 " SB3_DEST "
hexfld.byte 1 " SB3_OPC "
hexfld.byte 2 " SB3_TID "
hexfld.byte 3 " SB3_SRC "
;tree.end

base ad:0xa03904a4
;tree "WP1_CB_HDR_H"
rgroup 0--3
line.long 0 "WP1_CB_HDR_H"
bitfld.long 0 3.--23. " SB3_ADDR "  " "
hexfld.byte 3 " SB3_MSK "
;tree.end

base ad:0xa03904a8
;tree "WP1_CB_DATA_L"
rgroup 0--3
line.long 0 "WP1_CB_DATA_L"
hexfld.long 0 " SB3_DATA "
;tree.end

base ad:0xa03904ac
;tree "WP1_CB_DATA_H"
rgroup 0--3
line.long 0 "WP1_CB_DATA_H"
hexfld.long 0 " SB3_DATA "
;tree.end

base ad:0xa03904b0
;tree "WP1_ENABLE_L"
group 0--3
line.long 0 "WP1_ENABLE_L"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa03904b4
;tree "WP1_ENABLE_H"
group 0--3
line.long 0 "WP1_ENABLE_H"
;tree.end

base ad:0xa0390600
;tree "MSG_REF_PACE_L"
group 0--3
line.long 0 "MSG_REF_PACE_L"
hexfld.long 0 " PACE "
;tree.end

base ad:0xa0390604
;tree "MSG_REF_PACE_H"
group 0--3
line.long 0 "MSG_REF_PACE_H"
;tree.end

base ad:0xa0390608
;tree "MSG_FPF_DATA_L"
group 0--3
line.long 0 "MSG_FPF_DATA_L"
hexfld.long 0 " DATA "
;tree.end

base ad:0xa039060c
;tree "MSG_FPF_DATA_H"
group 0--3
line.long 0 "MSG_FPF_DATA_H"
;tree.end

base ad:0xa0390610
;tree "MSG_FPF_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG_FPF_TRACE_CTRL_L"
bitfld.long 0 0. " DATA "  "0 ,1 "
;tree.end

base ad:0xa0390614
;tree "MSG_FPF_TRACE_CTRL_H"
group 0--3
line.long 0 "MSG_FPF_TRACE_CTRL_H"
bitfld.long 0 16. " TIME "  "0 ,1 "
bitfld.long 0 17. " IT_EN "  "0 ,1 "
bitfld.long 0 31. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390618
;tree "MSG_PI_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG_PI_TRACE_CTRL_L"
hexfld.word 0 " INCDATA "
;tree.end

base ad:0xa039061c
;tree "MSG_PI_TRACE_CTRL_H"
group 0--3
line.long 0 "MSG_PI_TRACE_CTRL_H"
bitfld.long 0 16. " TIME "  "0 ,1 "
bitfld.long 0 31. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390a00
;tree "PI_TRIGGER_RAISE_L"
group 0--3
line.long 0 "PI_TRIGGER_RAISE_L"
hexfld.word 0 " RISING "
;tree.end

base ad:0xa0390a04
;tree "PI_TRIGGER_RAISE_H"
group 0--3
line.long 0 "PI_TRIGGER_RAISE_H"
;tree.end

base ad:0xa0390a08
;tree "PI_TRIGGER_FALLING_L"
group 0--3
line.long 0 "PI_TRIGGER_FALLING_L"
hexfld.word 0 " RISING "
;tree.end

base ad:0xa0390a0c
;tree "PI_TRIGGER_FALLING_H"
group 0--3
line.long 0 "PI_TRIGGER_FALLING_H"
;tree.end

base ad:0xa0390620
;tree "MSG0_BUS_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG0_BUS_TRACE_CTRL_L"
bitfld.long 0 0. " OPC "  "0 ,1 "
bitfld.long 0 1. " SRC "  "0 ,1 "
bitfld.long 0 2. " TID "  "0 ,1 "
bitfld.long 0 3. " MSK "  "0 ,1 "
bitfld.long 0 8. " ADDR "  "0 ,1 "
bitfld.long 0 16. " DATA "  "0 ,1 "
bitfld.long 0 24.--25. " DWIDTH "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0390624
;tree "MSG0_BUS_TRACE_CTRL_H"
group 0--3
line.long 0 "MSG0_BUS_TRACE_CTRL_H"
bitfld.long 0 16. " TIME "  "0 ,1 "
bitfld.long 0 31. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390628
;tree "MSG1_BUS_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG1_BUS_TRACE_CTRL_L"
bitfld.long 0 0. " OPC "  "0 ,1 "
bitfld.long 0 1. " SRC "  "0 ,1 "
bitfld.long 0 2. " TID "  "0 ,1 "
bitfld.long 0 3. " MSK "  "0 ,1 "
bitfld.long 0 8. " ADDR "  "0 ,1 "
bitfld.long 0 16. " DATA "  "0 ,1 "
bitfld.long 0 24.--25. " DWIDTH "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa039062c
;tree "MSG1_BUS_TRACE_CTRL_H"
group 0--3
line.long 0 "MSG1_BUS_TRACE_CTRL_H"
bitfld.long 0 16. " TIME "  "0 ,1 "
bitfld.long 0 31. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390630
;tree "MSG_ERR_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG_ERR_TRACE_CTRL_L"
bitfld.long 0 0. " FLG0 "  "0 ,1 "
bitfld.long 0 8. " FLG1 "  "0 ,1 "
bitfld.long 0 9. " FLG2 "  "0 ,1 "
bitfld.long 0 16. " FLG3 "  "0 ,1 "
;tree.end

base ad:0xa0390634
;tree "MSG_ERR_TRACE_CTRL_H"
group 0--3
line.long 0 "MSG_ERR_TRACE_CTRL_H"
bitfld.long 0 31. " ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0390638
;tree "MSG_TM_TRACE_ENABLE_L"
group 0--3
line.long 0 "MSG_TM_TRACE_ENABLE_L"
bitfld.long 0 0.--12. " ENABLE "  " "
;tree.end

base ad:0xa039063c
;tree "MSG_TM_TRACE_ENABLE_H"
group 0--3
line.long 0 "MSG_TM_TRACE_ENABLE_H"
;tree.end

base ad:0xa0390640
;tree "MSG_TM0_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG_TM0_TRACE_CTRL_L"
bitfld.long 0 0. " INCM1 "  "0 ,1 "
bitfld.long 0 1. " INCM2 "  "0 ,1 "
bitfld.long 0 2. " INCM3 "  "0 ,1 "
bitfld.long 0 8. " INCERR "  "0 ,1 "
;tree.end

base ad:0xa0390644
;tree "MSG_TM0_TRACE_CTRL_H"
group 0--3
line.long 0 "MSG_TM0_TRACE_CTRL_H"
;tree.end

base ad:0xa0390800
;tree "TM_PORT0_FILTER_L"
group 0--3
line.long 0 "TM_PORT0_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390804
;tree "TM_PORT0_FILTER_H"
group 0--3
line.long 0 "TM_PORT0_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390808
;tree "TM_PORT1_FILTER_L"
group 0--3
line.long 0 "TM_PORT1_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa039080c
;tree "TM_PORT1_FILTER_H"
group 0--3
line.long 0 "TM_PORT1_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390810
;tree "TM_PORT2_FILTER_L"
group 0--3
line.long 0 "TM_PORT2_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390814
;tree "TM_PORT2_FILTER_H"
group 0--3
line.long 0 "TM_PORT2_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390818
;tree "TM_PORT3_FILTER_L"
group 0--3
line.long 0 "TM_PORT3_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa039081c
;tree "TM_PORT3_FILTER_H"
group 0--3
line.long 0 "TM_PORT3_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390820
;tree "TM_PORT4_FILTER_L"
group 0--3
line.long 0 "TM_PORT4_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390824
;tree "TM_PORT4_FILTER_H"
group 0--3
line.long 0 "TM_PORT4_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390828
;tree "TM_PORT5_FILTER_L"
group 0--3
line.long 0 "TM_PORT5_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa039082c
;tree "TM_PORT5_FILTER_H"
group 0--3
line.long 0 "TM_PORT5_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390830
;tree "TM_PORT6_FILTER_L"
group 0--3
line.long 0 "TM_PORT6_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390834
;tree "TM_PORT6_FILTER_H"
group 0--3
line.long 0 "TM_PORT6_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390838
;tree "TM_PORT7_FILTER_L"
group 0--3
line.long 0 "TM_PORT7_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa039083c
;tree "TM_PORT7_FILTER_H"
group 0--3
line.long 0 "TM_PORT7_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390840
;tree "TM_PORT8_FILTER_L"
group 0--3
line.long 0 "TM_PORT8_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390844
;tree "TM_PORT8_FILTER_H"
group 0--3
line.long 0 "TM_PORT8_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390848
;tree "TM_PORT9_FILTER_L"
group 0--3
line.long 0 "TM_PORT9_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa039084c
;tree "TM_PORT9_FILTER_H"
group 0--3
line.long 0 "TM_PORT9_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390850
;tree "TM_PORT10_FILTER_L"
group 0--3
line.long 0 "TM_PORT10_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390854
;tree "TM_PORT10_FILTER_H"
group 0--3
line.long 0 "TM_PORT10_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390858
;tree "TM_PORT11_FILTER_L"
group 0--3
line.long 0 "TM_PORT11_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa039085c
;tree "TM_PORT11_FILTER_H"
group 0--3
line.long 0 "TM_PORT11_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390860
;tree "TM_PORT12_FILTER_L"
group 0--3
line.long 0 "TM_PORT12_FILTER_L"
hexfld.byte 0 " SRCVAL "
hexfld.byte 1 " OPCVAL "
hexfld.byte 2 " SRCMSK "
hexfld.byte 3 " OPCMSK "
;tree.end

base ad:0xa0390864
;tree "TM_PORT12_FILTER_H"
group 0--3
line.long 0 "TM_PORT12_FILTER_H"
bitfld.long 0 24. " SRCEN "  "0 ,1 "
bitfld.long 0 25. " OPCEN "  "0 ,1 "
;tree.end

base ad:0xa0390880
;tree "TM_PORT0_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC1_L"
hexfld.word 0 " MCT "
hexfld.word 0 " MCT "
;tree.end

base ad:0xa0390884
;tree "TM_PORT0_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC1_H"
;tree.end

base ad:0xa0390880
;tree "TM_PORT0_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC1_L"
hexfld.word 0 " MCT "
hexfld.word 0 " MCT "
;tree.end

base ad:0xa0390884
;tree "TM_PORT0_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC1_H"
;tree.end

base ad:0xa0390888
;tree "TM_PORT1_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT1_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa039088c
;tree "TM_PORT1_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT1_METRIC1_H"
;tree.end

base ad:0xa0390890
;tree "TM_PORT2_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT2_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa0390894
;tree "TM_PORT2_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT2_METRIC1_H"
;tree.end

base ad:0xa0390898
;tree "TM_PORT3_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT3_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa039089c
;tree "TM_PORT3_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT3_METRIC1_H"
;tree.end

base ad:0xa03908a0
;tree "TM_PORT4_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT4_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908a4
;tree "TM_PORT4_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT4_METRIC1_H"
;tree.end

base ad:0xa03908a8
;tree "TM_PORT5_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT5_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908ac
;tree "TM_PORT5_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT5_METRIC1_H"
;tree.end

base ad:0xa03908b0
;tree "TM_PORT6_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT6_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908b4
;tree "TM_PORT6_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT6_METRIC1_H"
;tree.end

base ad:0xa03908b8
;tree "TM_PORT7_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT7_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908bc
;tree "TM_PORT7_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT7_METRIC1_H"
;tree.end

base ad:0xa03908c0
;tree "TM_PORT8_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT8_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908c4
;tree "TM_PORT8_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT8_METRIC1_H"
;tree.end

base ad:0xa03908c8
;tree "TM_PORT9_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT9_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908cc
;tree "TM_PORT9_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT9_METRIC1_H"
;tree.end

base ad:0xa03908d0
;tree "TM_PORT10_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT10_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908d4
;tree "TM_PORT10_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT10_METRIC1_H"
;tree.end

base ad:0xa03908d8
;tree "TM_PORT11_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT11_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908dc
;tree "TM_PORT11_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT11_METRIC1_H"
;tree.end

base ad:0xa03908e0
;tree "TM_PORT12_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT12_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908e4
;tree "TM_PORT12_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT12_METRIC1_H"
;tree.end

base ad:0xa03908e8
;tree "TM_PORT13_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT13_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908ec
;tree "TM_PORT13_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT13_METRIC1_H"
;tree.end

base ad:0xa03908f0
;tree "TM_PORT14_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT14_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908f4
;tree "TM_PORT14_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT14_METRIC1_H"
;tree.end

base ad:0xa03908f8
;tree "TM_PORT15_METRIC1_L"
rgroup 0--3
line.long 0 "TM_PORT15_METRIC1_L"
hexfld.word 0 " MCT "
;tree.end

base ad:0xa03908fc
;tree "TM_PORT15_METRIC1_H"
rgroup 0--3
line.long 0 "TM_PORT15_METRIC1_H"
;tree.end

base ad:0xa0390900
;tree "TM_PORT0_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390904
;tree "TM_PORT0_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC2_H"
;tree.end

base ad:0xa0390908
;tree "TM_PORT1_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT1_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039090c
;tree "TM_PORT1_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT1_METRIC2_H"
;tree.end

base ad:0xa0390910
;tree "TM_PORT2_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT2_METRIC2_L"
;tree.end

base ad:0xa0390914
;tree "TM_PORT2_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT2_METRIC2_H"
;tree.end

base ad:0xa0390918
;tree "TM_PORT3_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT3_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039091c
;tree "TM_PORT3_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT3_METRIC2_H"
;tree.end

base ad:0xa0390920
;tree "TM_PORT4_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT4_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390924
;tree "TM_PORT4_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT4_METRIC2_H"
;tree.end

base ad:0xa0390928
;tree "TM_PORT5_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT5_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039092c
;tree "TM_PORT5_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT5_METRIC2_H"
;tree.end

base ad:0xa0390930
;tree "TM_PORT6_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT6_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390934
;tree "TM_PORT6_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT6_METRIC2_H"
;tree.end

base ad:0xa0390938
;tree "TM_PORT7_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT7_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039093c
;tree "TM_PORT7_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT7_METRIC2_H"
;tree.end

base ad:0xa0390940
;tree "TM_PORT8_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT8_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390944
;tree "TM_PORT8_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT8_METRIC2_H"
;tree.end

base ad:0xa0390948
;tree "TM_PORT9_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT9_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039094c
;tree "TM_PORT9_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT9_METRIC2_H"
;tree.end

base ad:0xa0390950
;tree "TM_PORT10_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT10_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390954
;tree "TM_PORT10_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT10_METRIC2_H"
;tree.end

base ad:0xa0390958
;tree "TM_PORT11_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT11_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039095c
;tree "TM_PORT11_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT11_METRIC2_H"
;tree.end

base ad:0xa0390960
;tree "TM_PORT12_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT12_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390964
;tree "TM_PORT12_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT12_METRIC2_H"
;tree.end

base ad:0xa0390968
;tree "TM_PORT13_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT13_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039096c
;tree "TM_PORT13_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT13_METRIC2_H"
;tree.end

base ad:0xa0390970
;tree "TM_PORT14_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT14_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa0390974
;tree "TM_PORT14_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT14_METRIC2_H"
;tree.end

base ad:0xa0390978
;tree "TM_PORT15_METRIC2_L"
rgroup 0--3
line.long 0 "TM_PORT15_METRIC2_L"
bitfld.long 0 0.--23. " BOT "  " "
;tree.end

base ad:0xa039097c
;tree "TM_PORT15_METRIC2_H"
rgroup 0--3
line.long 0 "TM_PORT15_METRIC2_H"
;tree.end

base ad:0xa0390980
;tree "TM_PORT0_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC3_L"
hexfld.word 0 " BAT "
hexfld.word 0 " BAT "
;tree.end

base ad:0xa0390984
;tree "TM_PORT0_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC3_H"
;tree.end

base ad:0xa0390980
;tree "TM_PORT0_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC3_L"
hexfld.word 0 " BAT "
hexfld.word 0 " BAT "
;tree.end

base ad:0xa0390984
;tree "TM_PORT0_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT0_METRIC3_H"
;tree.end

base ad:0xa0390988
;tree "TM_PORT1_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT1_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa039098c
;tree "TM_PORT1_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT1_METRIC3_H"
;tree.end

base ad:0xa0390990
;tree "TM_PORT2_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT2_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa0390994
;tree "TM_PORT2_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT2_METRIC3_H"
;tree.end

base ad:0xa0390998
;tree "TM_PORT3_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT3_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa039099c
;tree "TM_PORT3_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT3_METRIC3_H"
;tree.end

base ad:0xa03909a0
;tree "TM_PORT4_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT4_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909a4
;tree "TM_PORT4_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT4_METRIC3_H"
;tree.end

base ad:0xa03909a8
;tree "TM_PORT5_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT5_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909ac
;tree "TM_PORT5_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT5_METRIC3_H"
;tree.end

base ad:0xa03909b0
;tree "TM_PORT6_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT6_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909b4
;tree "TM_PORT6_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT6_METRIC3_H"
;tree.end

base ad:0xa03909b8
;tree "TM_PORT7_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT7_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909bc
;tree "TM_PORT7_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT7_METRIC3_H"
;tree.end

base ad:0xa03909c0
;tree "TM_PORT8_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT8_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909c4
;tree "TM_PORT8_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT8_METRIC3_H"
;tree.end

base ad:0xa03909c8
;tree "TM_PORT9_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT9_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909cc
;tree "TM_PORT9_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT9_METRIC3_H"
;tree.end

base ad:0xa03909d0
;tree "TM_PORT10_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT10_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909d4
;tree "TM_PORT10_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT10_METRIC3_H"
;tree.end

base ad:0xa03909d8
;tree "TM_PORT11_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT11_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909dc
;tree "TM_PORT11_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT11_METRIC3_H"
;tree.end

base ad:0xa03909e0
;tree "TM_PORT12_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT12_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909e4
;tree "TM_PORT12_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT12_METRIC3_H"
;tree.end

base ad:0xa03909e8
;tree "TM_PORT13_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT13_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909ec
;tree "TM_PORT13_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT13_METRIC3_H"
;tree.end

base ad:0xa03909f0
;tree "TM_PORT14_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT14_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909f4
;tree "TM_PORT14_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT14_METRIC3_H"
;tree.end

base ad:0xa03909f8
;tree "TM_PORT15_METRIC3_L"
rgroup 0--3
line.long 0 "TM_PORT15_METRIC3_L"
hexfld.word 0 " BAT "
;tree.end

base ad:0xa03909fc
;tree "TM_PORT15_METRIC3_H"
rgroup 0--3
line.long 0 "TM_PORT15_METRIC3_H"
;tree.end

tree.end

;==============================================================
tree "SCR"
;==============================================================
base ad:0x80155000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " APEDBGEN0 "  "0 ,1 "
bitfld.long 0 1. " APENIDEN0 "  "0 ,1 "
bitfld.long 0 2. " APESPNIDEN0 "  "0 ,1 "
bitfld.long 0 3. " APESPIDEN0 "  "0 ,1 "
bitfld.long 0 4. " APEDBGEN1 "  "0 ,1 "
bitfld.long 0 5. " APENIDEN1 "  "0 ,1 "
bitfld.long 0 6. " APESPNIDEN1 "  "0 ,1 "
bitfld.long 0 7. " APESPIDEN1 "  "0 ,1 "
bitfld.long 0 8. " TOPDBGEN "  "0 ,1 "
bitfld.long 0 9. " MCSBAGEN "  "0 ,1 "
bitfld.long 0 10. " APESTRCEN "  "0 ,1 "
bitfld.long 0 11. " APESTMEN "  "0 ,1 "
bitfld.long 0 12. " SIADBGEN "  "0 ,1 "
bitfld.long 0 13. " TOPAPEDBGEN "  "0 ,1 "
bitfld.long 0 14. " SPRSTEN0 "  "0 ,1 "
bitfld.long 0 15. " SPRSTEN1 "  "0 ,1 "
bitfld.long 0 16. " PRCMUDBGEn "  "0 ,1 "
bitfld.long 0 17. " SFRDIS "  "0 ,1 "
bitfld.long 0 18. " CRRSTEN "  "0 ,1 "
bitfld.long 0 23. " MODEMDIS "  "0 ,1 "
bitfld.long 0 24. " FBVALDIS "  "0 ,1 "
bitfld.long 0 25. " SCRDAF "  "0 ,1 "
bitfld.long 0 26. " SWDGCLK "  "0 ,1 "
bitfld.long 0 27. " APECLKSW "  "0 ,1 "
bitfld.long 0 28. " cJTAGEn "  "0 ,1 "
bitfld.long 0 29. " REMAPDIS "  "0 ,1 "
bitfld.long 0 30. " SECMODDIS "  "0 ,1 "
bitfld.long 0 31. " OPENDEVn "  "0 ,1 "
;tree.end

base ad:0x80155004
;tree "WDR"
rgroup 0--3
line.long 0 "WDR"
hexfld.long 0 " SWDTVAL "
;tree.end

base ad:0x80155008
;tree "WLR"
group 0--3
line.long 0 "WLR"
hexfld.long 0 " SWDTLOAD "
;tree.end

base ad:0x8015500c
;tree "WCR"
group 0--3
line.long 0 "WCR"
bitfld.long 0 0. " SWDTDIS "  "0 ,1 "
bitfld.long 0 1. " SWDTLDIS "  "0 ,1 "
;tree.end

base ad:0x80155010
;tree "FVR0"
rgroup 0--3
line.long 0 "FVR0"
hexfld.long 0 " FUSE0_VALUE "
;tree.end

base ad:0x80155014
;tree "FVR1"
rgroup 0--3
line.long 0 "FVR1"
hexfld.long 0 " FUSE1_VALUE "
;tree.end

base ad:0x80155018
;tree "FVR2"
rgroup 0--3
line.long 0 "FVR2"
hexfld.long 0 " FUSE2_VALUE "
;tree.end

base ad:0x8015501c
;tree "FVR3"
rgroup 0--3
line.long 0 "FVR3"
hexfld.long 0 " FUSE3_VALUE "
;tree.end

base ad:0x80155020
;tree "FVR4"
rgroup 0--3
line.long 0 "FVR4"
hexfld.long 0 " FUSE4_VALUE "
;tree.end

base ad:0x80155024
;tree "FVR5"
rgroup 0--3
line.long 0 "FVR5"
hexfld.long 0 " FUSE5_VALUE "
;tree.end

base ad:0x80155028
;tree "FVR6"
rgroup 0--3
line.long 0 "FVR6"
hexfld.long 0 " FUSE6_VALUE "
;tree.end

base ad:0x8015502c
;tree "FVR7"
rgroup 0--3
line.long 0 "FVR7"
hexfld.long 0 " FUSE7_VALUE "
;tree.end

base ad:0x80155030
;tree "FVR8"
rgroup 0--3
line.long 0 "FVR8"
hexfld.long 0 " FUSE8_VALUE "
;tree.end

base ad:0x80155034
;tree "FVR9"
rgroup 0--3
line.long 0 "FVR9"
hexfld.long 0 " FUSE9_VALUE "
;tree.end

base ad:0x80155038
;tree "FVR10"
rgroup 0--3
line.long 0 "FVR10"
hexfld.long 0 " FUSE10_VALUE "
;tree.end

base ad:0x8015503c
;tree "FVR11"
rgroup 0--3
line.long 0 "FVR11"
hexfld.long 0 " FUSE11_VALUE "
;tree.end

base ad:0x80155040
;tree "FVR12"
rgroup 0--3
line.long 0 "FVR12"
hexfld.long 0 " FUSE12_VALUE "
;tree.end

base ad:0x80155044
;tree "FVR13"
rgroup 0--3
line.long 0 "FVR13"
hexfld.long 0 " FUSE13_VALUE "
;tree.end

base ad:0x80155048
;tree "FVR14"
rgroup 0--3
line.long 0 "FVR14"
hexfld.long 0 " FUSE14_VALUE "
;tree.end

base ad:0x8015504c
;tree "FVR15"
rgroup 0--3
line.long 0 "FVR15"
hexfld.long 0 " FUSE15_VALUE "
;tree.end

base ad:0x80155050
;tree "FVR16"
rgroup 0--3
line.long 0 "FVR16"
hexfld.long 0 " FUSE16_VALUE "
;tree.end

base ad:0x80155054
;tree "FVR17"
rgroup 0--3
line.long 0 "FVR17"
hexfld.long 0 " FUSE17_VALUE "
;tree.end

base ad:0x80155058
;tree "FVR18"
rgroup 0--3
line.long 0 "FVR18"
hexfld.long 0 " FUSE18_VALUE "
;tree.end

base ad:0x8015505c
;tree "FVR19"
rgroup 0--3
line.long 0 "FVR19"
hexfld.long 0 " FUSE19_VALUE "
;tree.end

base ad:0x80155060
;tree "FVR20"
rgroup 0--3
line.long 0 "FVR20"
hexfld.long 0 " FUSE20_VALUE "
;tree.end

base ad:0x80155064
;tree "FVR21"
rgroup 0--3
line.long 0 "FVR21"
hexfld.long 0 " FUSE21_VALUE "
;tree.end

base ad:0x80155068
;tree "FVR22"
rgroup 0--3
line.long 0 "FVR22"
hexfld.long 0 " FUSE22_VALUE "
;tree.end

base ad:0x8015506c
;tree "FVR23"
rgroup 0--3
line.long 0 "FVR23"
hexfld.long 0 " FUSE23_VALUE "
;tree.end

base ad:0x80155070
;tree "SRAMPROT0"
group 0--3
line.long 0 "SRAMPROT0"
bitfld.long 0 0.--3. " SRAMPROT0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80155090
;tree "SPR0"
group 0--3
line.long 0 "SPR0"
hexfld.long 0 " SSPR0 "
;tree.end

base ad:0x80155094
;tree "SPR1"
group 0--3
line.long 0 "SPR1"
hexfld.long 0 " SSPR1 "
;tree.end

base ad:0x80155098
;tree "ROSZ"
group 0--3
line.long 0 "ROSZ"
bitfld.long 0 0.--9. " ROSZ0 "  " "
bitfld.long 0 10. " 2 "  "0 ,1 "
bitfld.long 0 11.--20. " R0SZ1 "  " "
;tree.end

base ad:0x8015509c
;tree "DECPROT"
group 0--3
line.long 0 "DECPROT"
bitfld.long 0 0.--25. " DECPROT "  " "
;tree.end

base ad:0x801550d0
;tree "DDRSECLOW"
group 0--3
line.long 0 "DDRSECLOW"
hexfld.long 0 " DDRSECLOW "
;tree.end

base ad:0x801550d4
;tree "DDRSECHIGH"
group 0--3
line.long 0 "DDRSECHIGH"
hexfld.long 0 " DDRSECHIGH "
;tree.end

base ad:0x801550d8
;tree "DDRA9LOW"
group 0--3
line.long 0 "DDRA9LOW"
hexfld.long 0 " DDRA9LOW "
;tree.end

base ad:0x801550dc
;tree "DDRA9HIGH"
group 0--3
line.long 0 "DDRA9HIGH"
hexfld.long 0 " DDRA9HIGH "
;tree.end

base ad:0x801550e0
;tree "DDRMODLOW"
group 0--3
line.long 0 "DDRMODLOW"
hexfld.long 0 " DDRMODLOW "
;tree.end

base ad:0x801550e4
;tree "DDRMODHIGH"
group 0--3
line.long 0 "DDRMODHIGH"
hexfld.long 0 " DDRMODHIGH "
;tree.end

base ad:0x801550e8
;tree "DDRSHAREHIGH"
group 0--3
line.long 0 "DDRSHAREHIGH"
hexfld.long 0 " DDRSHAREHIGH "
;tree.end

base ad:0x801550ec
;tree "DDRMAXSPACE"
group 0--3
line.long 0 "DDRMAXSPACE"
hexfld.long 0 " DDRMAXSPACE "
;tree.end

base ad:0x801550b0
;tree "FUSECRC"
group 0--3
line.long 0 "FUSECRC"
hexfld.byte 0 " CRC0 "
hexfld.byte 1 " CRC1 "
hexfld.byte 2 " CRC2 "
;tree.end

base ad:0x801550c0
;tree "SCRBCTRL"
group 0--3
line.long 0 "SCRBCTRL"
bitfld.long 0 0. " SCRBEN "  "0 ,1 "
;tree.end

base ad:0x801550c4
;tree "SCRBKEY_L"
group 0--3
line.long 0 "SCRBKEY_L"
hexfld.long 0 " SCRAMBLE_KEY "
;tree.end

base ad:0x801550c8
;tree "SCRBKEY_H"
group 0--3
line.long 0 "SCRBKEY_H"
hexfld.long 0 " SCRAMBLE_KEY "
;tree.end

base ad:0x80155100
;tree "MODEM_CR"
group 0--3
line.long 0 "MODEM_CR"
bitfld.long 0 0. " DBGEN "  "0 ,1 "
bitfld.long 0 1. " NIDEN "  "0 ,1 "
bitfld.long 0 2. " SPNIDEN "  "0 ,1 "
bitfld.long 0 3. " SPIDEN "  "0 ,1 "
bitfld.long 0 10. " STRCEN "  "0 ,1 "
bitfld.long 0 11. " STMDIS "  "0 ,1 "
bitfld.long 0 13. " TOPDBGEN "  "0 ,1 "
bitfld.long 0 16. " TXDIS "  "0 ,1 "
;tree.end

base ad:0x80155fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80155fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80155fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80155fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80155ff0
;tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

base ad:0x80155ff4
;tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

base ad:0x80155ff8
;tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

base ad:0x80155ffc
;tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

;==============================================================
tree "SCU"
;==============================================================
base ad:0xa0410000
;tree "SCU_CR"
group 0--3
line.long 0 "SCU_CR"
bitfld.long 0 0. " SCUCREN "  "0 ,1 "
bitfld.long 0 1. " SCUCRAFEN "  "0 ,1 "
bitfld.long 0 2. " SCUCRRPE "  "0 ,1 "
;tree.end

base ad:0xa0410004
;tree "SCU_CONFR"
group 0--3
line.long 0 "SCU_CONFR"
bitfld.long 0 0.--1. " SCUCONFRCPUN "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " SCUCONFRCPUSMP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " SCUCONFRTRS "
;tree.end

base ad:0xa0410008
;tree "SCU_CPUPSR"
group 0--3
line.long 0 "SCU_CPUPSR"
bitfld.long 0 0.--1. " SCUCPUPSRCPU0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " SCUCPUPSRCPU1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " SCUCPUPSRCPU2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " SCUCPUPSRCPU3 "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa041000c
;tree "SCU_IA"
wgroup 0--3
line.long 0 "SCU_IA"
bitfld.long 0 0.--3. " SCUIACPU0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " SCUIACPU1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " SCUIACPU2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " SCUIACPU3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0410040
;tree "SCU_FSAR"
group 0--3
line.long 0 "SCU_FSAR"
bitfld.long 0 20.--31. " SCUFSARFSA "  " "
;tree.end

base ad:0xa0410044
;tree "SCU_FEAR"
group 0--3
line.long 0 "SCU_FEAR"
bitfld.long 0 20.--31. " SCUFEARFEA "  " "
;tree.end

base ad:0xa0410050
;tree "SCU_ACR"
group 0--3
line.long 0 "SCU_ACR"
bitfld.long 0 0. " SCUACRCPU0 "  "0 ,1 "
bitfld.long 0 1. " SCUACRCPU1 "  "0 ,1 "
bitfld.long 0 2. " SCUACRCPU2 "  "0 ,1 "
bitfld.long 0 3. " SCUACRCPU3 "  "0 ,1 "
;tree.end

base ad:0xa0410054
;tree "SCU_SACR"
group 0--3
line.long 0 "SCU_SACR"
bitfld.long 0 0. " SCUSACRCPU0 "  "0 ,1 "
bitfld.long 0 1. " SCUSACRCPU1 "  "0 ,1 "
bitfld.long 0 2. " SCUSACRCPU2 "  "0 ,1 "
bitfld.long 0 3. " SCUSACRCPU3 "  "0 ,1 "
bitfld.long 0 4. " SCUSACRTCPU0 "  "0 ,1 "
bitfld.long 0 5. " SCUSACRTCPU1 "  "0 ,1 "
bitfld.long 0 6. " SCUSACRTCPU2 "  "0 ,1 "
bitfld.long 0 7. " SCUSACRTCPU3 "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "SCU_AD_A9"
;==============================================================
base ad:0xB7D40000
;tree "MADR"
group 0--3
line.long 0 "MADR"
hexfld.word 0 " ACCESSDELAYTIME_MAXVAL "
;tree.end

base ad:0xB7D40004
;tree "RADR"
group 0--3
line.long 0 "RADR"
hexfld.word 0 " ACCESSDELAYTIME_MAXVAL "
;tree.end

base ad:0xB7D4000C
;tree "CVSTR"
group 0--3
line.long 0 "CVSTR"
bitfld.long 0 0. " CVSTCOUNTER_EN "  "0 ,1 "
bitfld.long 0 1.--14. " CVSTCOUNTERVAL_MAXVAL "  " "
;tree.end

base ad:0xB7D40010
;tree "WMASR"
rgroup 0--3
line.long 0 "WMASR"
bitfld.long 0 0. " L1PDARRAY_RDY "  "0 ,1 "
bitfld.long 0 1. " L2PDARRAY_RDY "  "0 ,1 "
bitfld.long 0 2. " HAMSAPDARRAY_RDY "  "0 ,1 "
;tree.end

base ad:0xB7D40018
;tree "LRSR"
rgroup 0--3
line.long 0 "LRSR"
bitfld.long 0 0. " WGMRESETAX_PURX "  "0 ,1 "
bitfld.long 0 1. " SWSRESET_SWRX "  "0 ,1 "
bitfld.long 0 2. " SWDRESET_WDRX "  "0 ,1 "
;tree.end

base ad:0xB7D40020
;tree "PDCR_STATUS"
rgroup 0--3
line.long 0 "PDCR_STATUS"
bitfld.long 0 0. " FORCELM_EN "  "0 ,1 "
bitfld.long 0 1. " L2_PWRDOWN_EN "  "0 ,1 "
bitfld.long 0 2. " HAMSA_PWRDOWN_EN "  "0 ,1 "
bitfld.long 0 3. " CORE_PWRDOWN_EN "  "0 ,1 "
bitfld.long 0 4. " SWITCHOFF_L2PD_EN "  "0 ,1 "
bitfld.long 0 5. " SWITCHOFF_HAMSAPD_EN "  "0 ,1 "
bitfld.long 0 6. " L1WAITFORPLL_EN "  "0 ,1 "
bitfld.long 0 7. " L2WAITFORPLL_EN "  "0 ,1 "
bitfld.long 0 8. " COREWAITFORPLL_EN "  "0 ,1 "
;tree.end

base ad:0xB7D40024
;tree "PDCR_SET"
wgroup 0--3
line.long 0 "PDCR_SET"
bitfld.long 0 0. " FORCELM_EN "  "0 ,1 "
bitfld.long 0 1. " L2_PWRDOWN_EN "  "0 ,1 "
bitfld.long 0 2. " HAMSA_PWRDOWN_EN "  "0 ,1 "
bitfld.long 0 3. " CORE_PWRDOWN_EN "  "0 ,1 "
bitfld.long 0 4. " SWITCHOFF_L2PD_EN "  "0 ,1 "
bitfld.long 0 5. " SWITCHOFF_HAMSAPD_EN "  "0 ,1 "
bitfld.long 0 6. " L1WAITFORPLL_EN "  "0 ,1 "
bitfld.long 0 7. " L2WAITFORPLL_EN "  "0 ,1 "
bitfld.long 0 8. " COREWAITFORPLL_EN "  "0 ,1 "
;tree.end

base ad:0xB7D40028
;tree "PDCR_CLEAR"
wgroup 0--3
line.long 0 "PDCR_CLEAR"
bitfld.long 0 0. " FORCELM_DIS "  "0 ,1 "
bitfld.long 0 1. " L2_PWRDOWN_DIS "  "0 ,1 "
bitfld.long 0 2. " HAMSA_PWRDOWN_DIS "  "0 ,1 "
bitfld.long 0 3. " CORE_PWRDOWN_DIS "  "0 ,1 "
bitfld.long 0 4. " SWITCHOFF_L2PD_DIS "  "0 ,1 "
bitfld.long 0 5. " SWITCHOFF_HAMSAPD_DIS "  "0 ,1 "
bitfld.long 0 6. " L1WAITFORPLL_DIS "  "0 ,1 "
bitfld.long 0 7. " L2WAITFORPLL_DIS "  "0 ,1 "
bitfld.long 0 8. " COREWAITFORPLL_DIS "  "0 ,1 "
;tree.end

base ad:0xB7D4002C
;tree "PDCR_TOGGLE"
wgroup 0--3
line.long 0 "PDCR_TOGGLE"
bitfld.long 0 0. " FORCELM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2_PWRDOWN_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " HAMSA_PWRDOWN_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " CORE_PWRDOWN_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " SWITCHOFF_L2PD_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " SWITCHOFF_HAMSAPD_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " L1WAITFORPLL_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " L2WAITFORPLL_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " COREWAITFORPLL_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D40030
;tree "GPMMCR_STATUS"
rgroup 0--3
line.long 0 "GPMMCR_STATUS"
bitfld.long 0 0. " L1IDLEPM_EN "  "0 ,1 "
bitfld.long 0 1. " L2IDLEPM_EN "  "0 ,1 "
bitfld.long 0 2. " MEM_RET_DIS "  "0 ,1 "
bitfld.long 0 3. " MEM_ARRAY_OFF_DIS "  "0 ,1 "
;tree.end

base ad:0xB7D40034
;tree "GPMMCR_SET"
wgroup 0--3
line.long 0 "GPMMCR_SET"
bitfld.long 0 0. " L1IDLEPM_EN "  "0 ,1 "
bitfld.long 0 1. " L2IDLEPM_EN "  "0 ,1 "
bitfld.long 0 2. " MEM_RET_DIS "  "0 ,1 "
bitfld.long 0 3. " MEM_ARRAY_OFF_DIS "  "0 ,1 "
;tree.end

base ad:0xB7D40038
;tree "GPMMCR_CLEAR"
wgroup 0--3
line.long 0 "GPMMCR_CLEAR"
bitfld.long 0 0. " L1IDLEPM_DIS "  "0 ,1 "
bitfld.long 0 1. " L2IDLEPM_DIS "  "0 ,1 "
bitfld.long 0 2. " MEM_RET_NORMAL "  "0 ,1 "
bitfld.long 0 3. " MEM_ARRAY_OFF_NORMAL "  "0 ,1 "
;tree.end

base ad:0xB7D4003C
;tree "GPMMCR_TOGGLE"
wgroup 0--3
line.long 0 "GPMMCR_TOGGLE"
bitfld.long 0 0. " L1IDLEPM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2IDLEPM_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " MEM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " MEM_ARRAY_OFF_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D40040
;tree "CDSMPCR_STATUS"
rgroup 0--3
line.long 0 "CDSMPCR_STATUS"
bitfld.long 0 0. " L1_COP0_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_RET_ON "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_RET_ON "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_RET_ON "  "0 ,1 "
bitfld.long 0 5. " SRAM_RET_ON "  "0 ,1 "
bitfld.long 0 6. " ETB_MEM_RET_ON "  "0 ,1 "
bitfld.long 0 7. " L1_DCACHE_RET_ON "  "0 ,1 "
bitfld.long 0 8. " L1_ICACHE_RET_ON "  "0 ,1 "
bitfld.long 0 9. " ITCM_RET_ON "  "0 ,1 "
bitfld.long 0 10. " DTCM_RET_ON "  "0 ,1 "
bitfld.long 0 11. " L2_CACHE_RET_ON "  "0 ,1 "
;tree.end

base ad:0xB7D40044
;tree "CDSMPCR_SET"
wgroup 0--3
line.long 0 "CDSMPCR_SET"
bitfld.long 0 0. " L1_COP0_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_RET_ON "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_RET_ON "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_RET_ON "  "0 ,1 "
bitfld.long 0 5. " SRAM_RET_ON "  "0 ,1 "
bitfld.long 0 6. " ETB_MEM_RET_ON "  "0 ,1 "
bitfld.long 0 7. " L1_DCACHE_RET_ON "  "0 ,1 "
bitfld.long 0 8. " L1_ICACHE_RET_ON "  "0 ,1 "
bitfld.long 0 9. " ITCM_RET_ON "  "0 ,1 "
bitfld.long 0 10. " DTCM_RET_ON "  "0 ,1 "
bitfld.long 0 11. " L2_CACHE_RET_ON "  "0 ,1 "
;tree.end

base ad:0xB7D40048
;tree "CDSMPCR_CLEAR"
wgroup 0--3
line.long 0 "CDSMPCR_CLEAR"
bitfld.long 0 0. " L1_COP0_TCM_RET_OFF "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_OFF "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_RET_OFF "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_RET_OFF "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_RET_OFF "  "0 ,1 "
bitfld.long 0 5. " SRAM_RET_OFF "  "0 ,1 "
bitfld.long 0 6. " ETB_MEM_RET_OFF "  "0 ,1 "
bitfld.long 0 7. " L1_DCACHE_RET_OFF "  "0 ,1 "
bitfld.long 0 8. " L1_ICACHE_RET_OFF "  "0 ,1 "
bitfld.long 0 9. " ITCM_RET_OFF "  "0 ,1 "
bitfld.long 0 10. " DTCM_RET_OFF "  "0 ,1 "
bitfld.long 0 11. " L2_CACHE_RET_OFF "  "0 ,1 "
;tree.end

base ad:0xB7D4004C
;tree "CDSMPCR_TOGGLE"
wgroup 0--3
line.long 0 "CDSMPCR_TOGGLE"
bitfld.long 0 0. " L1_COP0_TCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " SRAM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " ETB_MEM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " L1_DCACHE_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " L1_ICACHE_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " ITCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " DTCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 11. " L2_CACHE_RET_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D40050
;tree "CLSMPCR_STATUS"
rgroup 0--3
line.long 0 "CLSMPCR_STATUS"
bitfld.long 0 0. " L1_COP0_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHE_RET_ON "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHE_RET_ON "  "0 ,1 "
bitfld.long 0 4. " ITCM_RET_ON "  "0 ,1 "
bitfld.long 0 5. " DTCM_RET_ON "  "0 ,1 "
bitfld.long 0 6. " L2_CACHE_RET_ON "  "0 ,1 "
;tree.end

base ad:0xB7D40054
;tree "CLSMPCR_SET"
wgroup 0--3
line.long 0 "CLSMPCR_SET"
bitfld.long 0 0. " L1_COP0_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHE_RET_ON "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHE_RET_ON "  "0 ,1 "
bitfld.long 0 4. " ITCM_RET_ON "  "0 ,1 "
bitfld.long 0 5. " DTCM_RET_ON "  "0 ,1 "
bitfld.long 0 6. " L2_CACHE_RET_ON "  "0 ,1 "
;tree.end

base ad:0xB7D40058
;tree "CLSMPCR_CLEAR"
wgroup 0--3
line.long 0 "CLSMPCR_CLEAR"
bitfld.long 0 0. " L1_COP0_TCM_RET_OFF "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_OFF "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHE_RET_OFF "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHE_RET_OFF "  "0 ,1 "
bitfld.long 0 4. " ITCM_RET_OFF "  "0 ,1 "
bitfld.long 0 5. " DTCM_RET_OFF "  "0 ,1 "
bitfld.long 0 6. " L2_CACHE_RET_OFF "  "0 ,1 "
;tree.end

base ad:0xB7D4005C
;tree "CLSMPCR_TOGGLE"
wgroup 0--3
line.long 0 "CLSMPCR_TOGGLE"
bitfld.long 0 0. " L1_COP0_TCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHE_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHE_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " ITCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " DTCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " L2_CACHE_RET_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D40060
;tree "CMMPCR_STATUS"
rgroup 0--3
line.long 0 "CMMPCR_STATUS"
bitfld.long 0 0. " L1_COP0_TCM_OFF "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_OFF "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_OFF "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_OFF "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_OFF "  "0 ,1 "
bitfld.long 0 5. " GSM_RARAM_OFF "  "0 ,1 "
bitfld.long 0 6. " GSM_DMRAM_OFF "  "0 ,1 "
bitfld.long 0 7. " CDFE1_RAM_OFF "  "0 ,1 "
bitfld.long 0 8. " CDFE2_RAM_OFF "  "0 ,1 "
bitfld.long 0 9. " CLIFF_EQDATA_OFF "  "0 ,1 "
bitfld.long 0 10. " CLIFF_IP_BUF_OFF "  "0 ,1 "
bitfld.long 0 11. " CLIFF_COEF_RAM_OFF "  "0 ,1 "
bitfld.long 0 12. " CLIFF_ST_METRIC_OFF "  "0 ,1 "
bitfld.long 0 13. " MFLINKO_RAM1_OFF "  "0 ,1 "
bitfld.long 0 14. " MFLINKO_RAM2_OFF "  "0 ,1 "
bitfld.long 0 15. " CVIT_IOTB_RAM_OFF "  "0 ,1 "
bitfld.long 0 16. " CVIT_CMS_RAM_OFF "  "0 ,1 "
bitfld.long 0 17. " CLAE_RAM1_OFF "  "0 ,1 "
bitfld.long 0 18. " CLAE_RAM2_OFF "  "0 ,1 "
bitfld.long 0 19. " SRAM_OFF "  "0 ,1 "
bitfld.long 0 20. " ETB_MEM_OFF "  "0 ,1 "
bitfld.long 0 21. " L1_DCACHE_OFF "  "0 ,1 "
bitfld.long 0 22. " L1_ICACHE_OFF "  "0 ,1 "
bitfld.long 0 23. " ITCM_OFF "  "0 ,1 "
bitfld.long 0 24. " DTCM_OFF "  "0 ,1 "
bitfld.long 0 25. " L2_CACHE_OFF "  "0 ,1 "
bitfld.long 0 26. " TAG_RAM_OFF "  "0 ,1 "
bitfld.long 0 27. " DIRTY_RAM_OFF "  "0 ,1 "
;tree.end

base ad:0xB7D40064
;tree "CMMPCR_SET"
wgroup 0--3
line.long 0 "CMMPCR_SET"
bitfld.long 0 0. " L1_COP0_TCM_OFF "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_OFF "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_OFF "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_OFF "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_OFF "  "0 ,1 "
bitfld.long 0 5. " GSM_RARAM_OFF "  "0 ,1 "
bitfld.long 0 6. " GSM_DMRAM_OFF "  "0 ,1 "
bitfld.long 0 7. " CDFE1_RAM_OFF "  "0 ,1 "
bitfld.long 0 8. " CDFE2_RAM_OFF "  "0 ,1 "
bitfld.long 0 9. " CLIFF_EQDATA_OFF "  "0 ,1 "
bitfld.long 0 10. " CLIFF_IP_BUF_OFF "  "0 ,1 "
bitfld.long 0 11. " CLIFF_COEF_RAM_OFF "  "0 ,1 "
bitfld.long 0 12. " CLIFF_ST_METRIC_OFF "  "0 ,1 "
bitfld.long 0 13. " MFLINKO_RAM1_OFF "  "0 ,1 "
bitfld.long 0 14. " MFLINKO_RAM2_OFF "  "0 ,1 "
bitfld.long 0 15. " CVIT_IOTB_RAM_OFF "  "0 ,1 "
bitfld.long 0 16. " CVIT_CMS_RAM_OFF "  "0 ,1 "
bitfld.long 0 17. " CLAE_RAM1_OFF "  "0 ,1 "
bitfld.long 0 18. " CLAE_RAM2_OFF "  "0 ,1 "
bitfld.long 0 19. " SRAM_OFF "  "0 ,1 "
bitfld.long 0 20. " ETB_MEM_OFF "  "0 ,1 "
bitfld.long 0 21. " L1_DCACHE_OFF "  "0 ,1 "
bitfld.long 0 22. " L1_ICACHE_OFF "  "0 ,1 "
bitfld.long 0 23. " ITCM_OFF "  "0 ,1 "
bitfld.long 0 24. " DTCM_OFF "  "0 ,1 "
bitfld.long 0 25. " L2_CACHE_OFF "  "0 ,1 "
bitfld.long 0 26. " TAG_RAM_OFF "  "0 ,1 "
bitfld.long 0 27. " DIRTY_RAM_OFF "  "0 ,1 "
;tree.end

base ad:0xB7D40068
;tree "CMMPCR_CLEAR"
wgroup 0--3
line.long 0 "CMMPCR_CLEAR"
bitfld.long 0 0. " L1_COP0_TCM_ON "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_ON "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_ON "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_ON "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_ON "  "0 ,1 "
bitfld.long 0 5. " GSM_RARAM_ON "  "0 ,1 "
bitfld.long 0 6. " GSM_DMRAM_ON "  "0 ,1 "
bitfld.long 0 7. " CDFE1_RAM_ON "  "0 ,1 "
bitfld.long 0 8. " CDFE2_RAM_ON "  "0 ,1 "
bitfld.long 0 9. " CLIFF_EQDATA_ON "  "0 ,1 "
bitfld.long 0 10. " CLIFF_IP_BUF_ON "  "0 ,1 "
bitfld.long 0 11. " CLIFF_COEF_RAM_ON "  "0 ,1 "
bitfld.long 0 12. " CLIFF_ST_METRIC_ON "  "0 ,1 "
bitfld.long 0 13. " MFLINKO_RAM1_ON "  "0 ,1 "
bitfld.long 0 14. " MFLINKO_RAM2_ON "  "0 ,1 "
bitfld.long 0 15. " CVIT_IOTB_RAM_ON "  "0 ,1 "
bitfld.long 0 16. " CVIT_CMS_RAM_ON "  "0 ,1 "
bitfld.long 0 17. " CLAE_RAM1_ON "  "0 ,1 "
bitfld.long 0 18. " CLAE_RAM2_ON "  "0 ,1 "
bitfld.long 0 19. " SRAM_ON "  "0 ,1 "
bitfld.long 0 20. " ETB_MEM_ON "  "0 ,1 "
bitfld.long 0 21. " L1_DCACHE_ON "  "0 ,1 "
bitfld.long 0 22. " L1_ICACHE_ON "  "0 ,1 "
bitfld.long 0 23. " ITCM_ON "  "0 ,1 "
bitfld.long 0 24. " DTCM_ON "  "0 ,1 "
bitfld.long 0 25. " L2_CACHE_ON "  "0 ,1 "
bitfld.long 0 26. " TAG_RAM_ON "  "0 ,1 "
bitfld.long 0 27. " DIRTY_RAM_ON "  "0 ,1 "
;tree.end

base ad:0xB7D4006C
;tree "CMMPCR_TOGGLE"
wgroup 0--3
line.long 0 "CMMPCR_TOGGLE"
bitfld.long 0 0. " L1_COP0_TCM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " GSM_RARAM_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " GSM_DMRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " CDFE1_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " CDFE2_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " CLIFF_EQDATA_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " CLIFF_IP_BUF_TOGGLE "  "0 ,1 "
bitfld.long 0 11. " CLIFF_COEF_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 12. " CLIFF_ST_METRIC_TOGGLE "  "0 ,1 "
bitfld.long 0 13. " MFLINKO_RAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 14. " MFLINKO_RAM2_TOGGLE "  "0 ,1 "
bitfld.long 0 15. " CVIT_IOTB_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 16. " CVIT_CMS_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 17. " CLAE_RAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 18. " CLAE_RAM2_TOGGLE "  "0 ,1 "
bitfld.long 0 19. " SRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 20. " ETB_MEM_TOGGLE "  "0 ,1 "
bitfld.long 0 21. " L1_DCACHE_TOGGLE "  "0 ,1 "
bitfld.long 0 22. " L1_ICACHE_TOGGLE "  "0 ,1 "
bitfld.long 0 23. " ITCM_TOGGLE "  "0 ,1 "
bitfld.long 0 24. " DTCM_TOGGLE "  "0 ,1 "
bitfld.long 0 25. " L2_CACHE_TOGGLE "  "0 ,1 "
bitfld.long 0 26. " TAG_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 27. " DIRTY_RAM_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D40070
;tree "L2DSMPCR_STATUS"
rgroup 0--3
line.long 0 "L2DSMPCR_STATUS"
bitfld.long 0 0. " MARVIN_RAM_RET "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_RET "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_RET "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_RET "  "0 ,1 "
bitfld.long 0 4. " ITCM_RET "  "0 ,1 "
bitfld.long 0 5. " DTCM_RET "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_RET "  "0 ,1 "
;tree.end

base ad:0xB7D40074
;tree "L2DSMPCR_SET"
wgroup 0--3
line.long 0 "L2DSMPCR_SET"
bitfld.long 0 0. " MARVIN_RAM_RET "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_RET "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_RET "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_RET "  "0 ,1 "
bitfld.long 0 4. " ITCM_RET "  "0 ,1 "
bitfld.long 0 5. " DTCM_RET "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_RET "  "0 ,1 "
;tree.end

base ad:0xB7D40078
;tree "L2DSMPCR_CLEAR"
wgroup 0--3
line.long 0 "L2DSMPCR_CLEAR"
bitfld.long 0 0. " MARVIN_RAM_NOTRET "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_NOTRET "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_NOTRET "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_NOTRET "  "0 ,1 "
bitfld.long 0 4. " ITCM_RNOTET "  "0 ,1 "
bitfld.long 0 5. " DTCM_NOTRET "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_NOTRET "  "0 ,1 "
;tree.end

base ad:0xB7D4007C
;tree "L2DSMPCR_TOGGLE"
wgroup 0--3
line.long 0 "L2DSMPCR_TOGGLE"
bitfld.long 0 0. " MARVIN_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " ITCM_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " DTCM_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D40080
;tree "L2LSMPCR_STATUS"
rgroup 0--3
line.long 0 "L2LSMPCR_STATUS"
bitfld.long 0 0. " L2COP_TCM_RET "  "0 ,1 "
bitfld.long 0 1. " L1_DCACHETCM_RET "  "0 ,1 "
bitfld.long 0 2. " L1_ICACHETCM_RET "  "0 ,1 "
bitfld.long 0 3. " ITCM_RET "  "0 ,1 "
bitfld.long 0 4. " DTCM_RET "  "0 ,1 "
bitfld.long 0 5. " L2CACHE_RET "  "0 ,1 "
;tree.end

base ad:0xB7D40084
;tree "L2LSMPCR_SET"
wgroup 0--3
line.long 0 "L2LSMPCR_SET"
bitfld.long 0 0. " L2COP_TCM_RET "  "0 ,1 "
bitfld.long 0 1. " L1_DCACHETCM_RET "  "0 ,1 "
bitfld.long 0 2. " L1_ICACHETCM_RET "  "0 ,1 "
bitfld.long 0 3. " ITCM_RET "  "0 ,1 "
bitfld.long 0 4. " DTCM_RET "  "0 ,1 "
bitfld.long 0 5. " L2CACHE_RET "  "0 ,1 "
;tree.end

base ad:0xB7D40088
;tree "L2LSMPCR_CLEAR"
wgroup 0--3
line.long 0 "L2LSMPCR_CLEAR"
bitfld.long 0 0. " L2COP_TCM_NOTRET "  "0 ,1 "
bitfld.long 0 1. " L1_DCACHETCM_NOTRET "  "0 ,1 "
bitfld.long 0 2. " L1_ICACHETCM_NOTRET "  "0 ,1 "
bitfld.long 0 3. " ITCM_RNOTET "  "0 ,1 "
bitfld.long 0 4. " DTCM_NOTRET "  "0 ,1 "
bitfld.long 0 5. " L2CACHE_NOTRET "  "0 ,1 "
;tree.end

base ad:0xB7D4008C
;tree "L2LSMPCR_TOGGLE"
wgroup 0--3
line.long 0 "L2LSMPCR_TOGGLE"
bitfld.long 0 0. " L2COP_TCM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1_DCACHETCM_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1_ICACHETCM_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " ITCM_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " DTCM_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " L2CACHE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D40090
;tree "L2MMPCR_STATUS"
rgroup 0--3
line.long 0 "L2MMPCR_STATUS"
bitfld.long 0 0. " MARVIN_RAM_OFF "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_OFF "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_OFF "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_OFF "  "0 ,1 "
bitfld.long 0 4. " ITCM_OFF "  "0 ,1 "
bitfld.long 0 5. " DTCM_OFF "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_OFF "  "0 ,1 "
;tree.end

base ad:0xB7D40094
;tree "L2MMPCR_SET"
wgroup 0--3
line.long 0 "L2MMPCR_SET"
bitfld.long 0 0. " MARVIN_RAM_OFF "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_OFF "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_OFF "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_OFF "  "0 ,1 "
bitfld.long 0 4. " ITCM_OFF "  "0 ,1 "
bitfld.long 0 5. " DTCM_OFF "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_OFF "  "0 ,1 "
;tree.end

base ad:0xB7D40098
;tree "L2MMPCR_CLEAR"
wgroup 0--3
line.long 0 "L2MMPCR_CLEAR"
bitfld.long 0 0. " MARVIN_RAM_ON "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_ON "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_ON "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_ON "  "0 ,1 "
bitfld.long 0 4. " ITCM_RNOTET "  "0 ,1 "
bitfld.long 0 5. " DTCM_ON "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_ON "  "0 ,1 "
;tree.end

base ad:0xB7D4009C
;tree "L2MMPCR_TOGGLE"
wgroup 0--3
line.long 0 "L2MMPCR_TOGGLE"
bitfld.long 0 0. " MARVIN_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " ITCM_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " DTCM_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D400A0
;tree "HDSMPCR_STATUS"
rgroup 0--3
line.long 0 "HDSMPCR_STATUS"
bitfld.long 0 0. " SEARAMMEM1_RET_EN "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_RET_EN "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_RET_EN "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_RET_EN "  "0 ,1 "
bitfld.long 0 4. " CTAPPERRAARAM_RET_EN "  "0 ,1 "
bitfld.long 0 5. " TAPPERRPRAM_RET_RET_EN "  "0 ,1 "
bitfld.long 0 6. " TAPPERRWRAM_RET_EN "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_RET_EN "  "0 ,1 "
bitfld.long 0 8. " RAKERRAM2_RET_EN "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_RET_EN "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_RET_EN "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_RET_EN "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_RET_EN "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_RET_EN "  "0 ,1 "
;tree.end

base ad:0xB7D400A4
;tree "HDSMPCR_SET"
wgroup 0--3
line.long 0 "HDSMPCR_SET"
bitfld.long 0 0. " SEARAMMEM1_RET_EN "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_RET_EN "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_RET_EN "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_RET_EN "  "0 ,1 "
bitfld.long 0 4. " CTAPPERRAARAM_RET_EN "  "0 ,1 "
bitfld.long 0 5. " TAPPERRPRAM_RET_RET_EN "  "0 ,1 "
bitfld.long 0 6. " TAPPERRWRAM_RET_EN "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_RET_EN "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_RET_EN "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_RET_EN "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_RET_EN "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_RET_EN "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_RET_EN "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_RET_EN "  "0 ,1 "
;tree.end

base ad:0xB7D400A8
;tree "HDSMPCR_CLEAR"
wgroup 0--3
line.long 0 "HDSMPCR_CLEAR"
bitfld.long 0 0. " SEARAMMEM1_RET_DIS "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_RET_DIS "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_RET_DIS "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_RET_DEFAULT "  "0 ,1 "
bitfld.long 0 4. " CTAPPERRAARAM_RET_DIS "  "0 ,1 "
bitfld.long 0 5. " TAPPERRPRAM_RET_RET_DIS "  "0 ,1 "
bitfld.long 0 6. " TAPPERRWRAM_RET_DIS "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_RET_DIS "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_RET_DIS "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_RET_DIS "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_RET_DIS "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_RET_DIS "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_RET_DIS "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_RET_DIS "  "0 ,1 "
;tree.end

base ad:0xB7D400AC
;tree "HDSMPCR_TOGGLE"
wgroup 0--3
line.long 0 "HDSMPCR_TOGGLE"
bitfld.long 0 0. " SEARAMMEM1_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " CTAPPERRAARAM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " TAPPERRPRAM_RET_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " TAPPERRWRAM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_RET_DIS "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_RET_DIS "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_RET_DIS "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_RET_DIS "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_RET_DIS "  "0 ,1 "
;tree.end

base ad:0xB7D400B0
;tree "HMMPCR1_STATUS"
rgroup 0--3
line.long 0 "HMMPCR1_STATUS"
bitfld.long 0 0. " SEARAMMEM1_OFF "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_OFF "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_OFF "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_OFF "  "0 ,1 "
bitfld.long 0 4. " TAPPERRAARAM_OFF "  "0 ,1 "
bitfld.long 0 5. " TAPPERPRAM_OFF "  "0 ,1 "
bitfld.long 0 6. " TAPPERWRAM_OFF "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_OFF "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_OFF "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_OFF "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_OFF "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_OFF "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_OFF "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_OFF "  "0 ,1 "
bitfld.long 0 14. " CDIIRAM_OFF "  "0 ,1 "
bitfld.long 0 15. " EQFEIRNBUF1_OFF "  "0 ,1 "
bitfld.long 0 16. " EQFEIRNBUF2_OFF "  "0 ,1 "
bitfld.long 0 17. " EQFEIRMBUF_OFF "  "0 ,1 "
bitfld.long 0 18. " EQDSRXBUF_OFF "  "0 ,1 "
bitfld.long 0 19. " EQDSTXBUF_OFF "  "0 ,1 "
bitfld.long 0 20. " EQDSVITBUF_OFF "  "0 ,1 "
bitfld.long 0 21. " RAIFRAARAM_OFF "  "0 ,1 "
bitfld.long 0 22. " RAIFCBINFORAM_OFF "  "0 ,1 "
bitfld.long 0 23. " RAIFCBRAM_OFF "  "0 ,1 "
bitfld.long 0 24. " CVITIOBRAM_OFF "  "0 ,1 "
bitfld.long 0 25. " HSVITTBRAM0_OFF "  "0 ,1 "
bitfld.long 0 26. " HSVITTBRAM1_OFF "  "0 ,1 "
bitfld.long 0 27. " HSTDECSYSRAM_OFF "  "0 ,1 "
bitfld.long 0 28. " HSTDECPARITYRAM_OFF "  "0 ,1 "
bitfld.long 0 29. " HSTDECOUTRAM_OFF "  "0 ,1 "
bitfld.long 0 30. " HSTDECPARARAM_OFF "  "0 ,1 "
;tree.end

base ad:0xB7D400B4
;tree "HMMPCR1_SET"
wgroup 0--3
line.long 0 "HMMPCR1_SET"
bitfld.long 0 0. " SEARAMMEM1_OFF "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_OFF "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_OFF "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_OFF "  "0 ,1 "
bitfld.long 0 4. " TAPPERRAARAM_OFF "  "0 ,1 "
bitfld.long 0 5. " TAPPERPRAM_OFF "  "0 ,1 "
bitfld.long 0 6. " TAPPERWRAM_OFF "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_OFF "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_OFF "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_OFF "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_OFF "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_OFF "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_OFF "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_OFF "  "0 ,1 "
bitfld.long 0 14. " CDIIRAM_OFF "  "0 ,1 "
bitfld.long 0 15. " EQFEIRNBUF1_OFF "  "0 ,1 "
bitfld.long 0 16. " EQFEIRNBUF2_OFF "  "0 ,1 "
bitfld.long 0 17. " EQFEIRMBUF_OFF "  "0 ,1 "
bitfld.long 0 18. " EQDSRXBUF_OFF "  "0 ,1 "
bitfld.long 0 19. " EQDSTXBUF_OFF "  "0 ,1 "
bitfld.long 0 20. " EQDSVITBUF_OFF "  "0 ,1 "
bitfld.long 0 21. " RAIFRAARAM_OFF "  "0 ,1 "
bitfld.long 0 22. " RAIFCBINFORAM_OFF "  "0 ,1 "
bitfld.long 0 23. " RAIFCBRAM_OFF "  "0 ,1 "
bitfld.long 0 24. " CVITIOBRAM_OFF "  "0 ,1 "
bitfld.long 0 25. " HSVITTBRAM0_OFF "  "0 ,1 "
bitfld.long 0 26. " HSVITTBRAM1_OFF "  "0 ,1 "
bitfld.long 0 27. " HSTDECSYSRAM_OFF "  "0 ,1 "
bitfld.long 0 28. " HSTDECPARITYRAM_OFF "  "0 ,1 "
bitfld.long 0 29. " HSTDECOUTRAM_OFF "  "0 ,1 "
bitfld.long 0 30. " HSTDECPARARAM_OFF "  "0 ,1 "
;tree.end

base ad:0xB7D400B8
;tree "HMMPCR1_CLEAR"
wgroup 0--3
line.long 0 "HMMPCR1_CLEAR"
bitfld.long 0 0. " SEARAMMEM1_ON "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_ON "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_ON "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_ON "  "0 ,1 "
bitfld.long 0 4. " TAPPERRAARAM_ON "  "0 ,1 "
bitfld.long 0 5. " TAPPERPRAM_ON "  "0 ,1 "
bitfld.long 0 6. " TAPPERWRAM_ON "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_ON "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_ON "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_ON "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_ON "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_ON "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_ON "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_ON "  "0 ,1 "
bitfld.long 0 14. " CDIIRAM_ON "  "0 ,1 "
bitfld.long 0 15. " EQFEIRNBUF1_ON "  "0 ,1 "
bitfld.long 0 16. " EQFEIRNBUF2_ON "  "0 ,1 "
bitfld.long 0 17. " EQFEIRMBUF_ON "  "0 ,1 "
bitfld.long 0 18. " EQDSRXBUF_ON "  "0 ,1 "
bitfld.long 0 19. " EQDSTXBUF_ON "  "0 ,1 "
bitfld.long 0 20. " EQDSVITBUF_ON "  "0 ,1 "
bitfld.long 0 21. " RAIFRAARAM_ON "  "0 ,1 "
bitfld.long 0 22. " RAIFCBINFORAM_ON "  "0 ,1 "
bitfld.long 0 23. " RAIFCBRAM_ON "  "0 ,1 "
bitfld.long 0 24. " CVITIOBRAM_ON "  "0 ,1 "
bitfld.long 0 25. " HSVITTBRAM0_ON "  "0 ,1 "
bitfld.long 0 26. " HSVITTBRAM1_ON "  "0 ,1 "
bitfld.long 0 27. " HSTDECSYSRAM_ON "  "0 ,1 "
bitfld.long 0 28. " HSTDECPARITYRAM_ON "  "0 ,1 "
bitfld.long 0 29. " HSTDECOUTRAM_ON "  "0 ,1 "
bitfld.long 0 30. " HSTDECPARARAM_ON "  "0 ,1 "
;tree.end

base ad:0xB7D400BC
;tree "HMMPCR1_TOGGLE"
wgroup 0--3
line.long 0 "HMMPCR1_TOGGLE"
bitfld.long 0 0. " SEARAMMEM1_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " TAPPERRAARAM_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " TAPPERPRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " TAPPERWRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_TOGGLE "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_TOGGLE "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 14. " CDIIRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 15. " EQFEIRNBUF1_TOGGLE "  "0 ,1 "
bitfld.long 0 16. " EQFEIRNBUF2_TOGGLE "  "0 ,1 "
bitfld.long 0 17. " EQFEIRMBUF_TOGGLE "  "0 ,1 "
bitfld.long 0 18. " EQDSRXBUF_TOGGLE "  "0 ,1 "
bitfld.long 0 19. " EQDSTXBUF_TOGGLE "  "0 ,1 "
bitfld.long 0 20. " EQDSVITBUF_TOGGLE "  "0 ,1 "
bitfld.long 0 21. " RAIFRAARAM_TOGGLE "  "0 ,1 "
bitfld.long 0 22. " RAIFCBINFORAM_TOGGLE "  "0 ,1 "
bitfld.long 0 23. " RAIFCBRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 28. " CVITIOBRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 25. " HSVITTBRAM0_TOGGLE "  "0 ,1 "
bitfld.long 0 26. " HSVITTBRAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 27. " HSTDECSYSRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 28. " HSTDECPARITYRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 29. " HSTDECOUTRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 30. " HSTDECPARARAM_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D400C0
;tree "HMMPCR2_STATUS"
rgroup 0--3
line.long 0 "HMMPCR2_STATUS"
bitfld.long 0 0. " E_ENCINRAM_OFF "  "0 ,1 "
bitfld.long 0 1. " E_ENCTTRAM_OFF "  "0 ,1 "
bitfld.long 0 2. " E_ENCFRAMERAM_OFF "  "0 ,1 "
bitfld.long 0 3. " ENCINRAM_OFF "  "0 ,1 "
bitfld.long 0 4. " ENCTBRAM_OFF "  "0 ,1 "
bitfld.long 0 5. " ENCTTRAM_OFF "  "0 ,1 "
bitfld.long 0 6. " ENCTTIRAM_OFF "  "0 ,1 "
bitfld.long 0 7. " ENCFRAMERAM_OFF "  "0 ,1 "
bitfld.long 0 8. " ENCTXDATARAM_OFF "  "0 ,1 "
bitfld.long 0 9. " LCVITCMSRAM_OFF "  "0 ,1 "
bitfld.long 0 10. " RASIFIFORAM1_OFF "  "0 ,1 "
bitfld.long 0 11. " RASIFIFORAM2_OFF "  "0 ,1 "
bitfld.long 0 12. " RASIFIFORAM3_OFF "  "0 ,1 "
bitfld.long 0 13. " RASIFIFORAM0_OFF "  "0 ,1 "
bitfld.long 0 14. " HSVITSCCHRAM0_OFF "  "0 ,1 "
bitfld.long 0 15. " HSVITSCCHRAM1_OFF "  "0 ,1 "
bitfld.long 0 16. " HSTDECSLIDERAM_OFF "  "0 ,1 "
bitfld.long 0 17. " HSTDECPATHRAM_OFF "  "0 ,1 "
bitfld.long 0 18. " TAPPERCMRAM_OFF "  "0 ,1 "
bitfld.long 0 19. " RAKERCMRAM_OFF "  "0 ,1 "
bitfld.long 0 20. " HSTDECBCRAM_OFF "  "0 ,1 "
;tree.end

base ad:0xB7D400C4
;tree "HMMPCR2_SET"
wgroup 0--3
line.long 0 "HMMPCR2_SET"
bitfld.long 0 0. " E_ENCINRAM_OFF "  "0 ,1 "
bitfld.long 0 1. " E_ENCTTRAM_OFF "  "0 ,1 "
bitfld.long 0 2. " E_ENCFRAMERAM_OFF "  "0 ,1 "
bitfld.long 0 3. " ENCINRAM_OFF "  "0 ,1 "
bitfld.long 0 4. " ENCTBRAM_OFF "  "0 ,1 "
bitfld.long 0 5. " ENCTTRAM_OFF "  "0 ,1 "
bitfld.long 0 7. " ENCFRAMERAM_OFF "  "0 ,1 "
bitfld.long 0 8. " ENCTXDATARAM_OFF "  "0 ,1 "
bitfld.long 0 9. " CVITCMSRAM_OFF "  "0 ,1 "
bitfld.long 0 10. " RASIFIFORAM1_OFF "  "0 ,1 "
bitfld.long 0 11. " RASIFIFORAM2_OFF "  "0 ,1 "
bitfld.long 0 12. " RASIFIFORAM3_OFF "  "0 ,1 "
bitfld.long 0 13. " RASIFIFORAM0_OFF "  "0 ,1 "
bitfld.long 0 14. " HSVITSCCHRAM0_OFF "  "0 ,1 "
bitfld.long 0 15. " HSVITSCCHRAM1_OFF "  "0 ,1 "
bitfld.long 0 16. " HSTDECSLIDERAM_OFF "  "0 ,1 "
bitfld.long 0 17. " HSTDECPATHRAM_OFF "  "0 ,1 "
bitfld.long 0 18. " TAPPERCMRAM_OFF "  "0 ,1 "
bitfld.long 0 19. " RAKERCMRAM_OFF "  "0 ,1 "
bitfld.long 0 20. " HSTDECBCRAM_OFF "  "0 ,1 "
;tree.end

base ad:0xB7D400C8
;tree "HMMPCR2_CLEAR"
wgroup 0--3
line.long 0 "HMMPCR2_CLEAR"
bitfld.long 0 0. " E_ENCINRAM_ON "  "0 ,1 "
bitfld.long 0 1. " E_ENCTTRAM_ON "  "0 ,1 "
bitfld.long 0 2. " E_ENCFRAMERAM_ON "  "0 ,1 "
bitfld.long 0 3. " ENCINRAM_ON "  "0 ,1 "
bitfld.long 0 4. " ENCTBRAM_ON "  "0 ,1 "
bitfld.long 0 5. " ENCTTRAM_ON "  "0 ,1 "
bitfld.long 0 6. " ENCTTIRAM_ON "  "0 ,1 "
bitfld.long 0 7. " ENCFRAMERAM_ON "  "0 ,1 "
bitfld.long 0 8. " ENCTXDATARAM_ON "  "0 ,1 "
bitfld.long 0 9. " CVITCMSRAM_ON "  "0 ,1 "
bitfld.long 0 10. " RASIFIFORAM1_ON "  "0 ,1 "
bitfld.long 0 11. " RASIFIFORAM2_ON "  "0 ,1 "
bitfld.long 0 12. " RASIFIFORAM3_ON "  "0 ,1 "
bitfld.long 0 13. " RASIFIFORAM0_ON "  "0 ,1 "
bitfld.long 0 14. " HSVITSCCHRAM0_ON "  "0 ,1 "
bitfld.long 0 15. " HSVITSCCHRAM1_ON "  "0 ,1 "
bitfld.long 0 16. " HSTDECSLIDERAM_ON "  "0 ,1 "
bitfld.long 0 17. " HSTDECPATHRAM_ON "  "0 ,1 "
bitfld.long 0 18. " TAPPERCMRAM_ON "  "0 ,1 "
bitfld.long 0 19. " RAKERCMRAM_ON "  "0 ,1 "
bitfld.long 0 20. " HSTDECBCRAM_ON "  "0 ,1 "
;tree.end

base ad:0xB7D400CC
;tree "HMMPCR2_TOGGLE"
wgroup 0--3
line.long 0 "HMMPCR2_TOGGLE"
bitfld.long 0 0. " E_ENCINRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " E_ENCTTRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " E_ENCFRAMERAM_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " ENCINRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " ENCTBRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " ENCTTRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " ENCTTIRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " ENCFRAMERAM_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " ENCTXDATARAM_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " CVITCMSRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " RASIFIFORAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 11. " RASIFIFORAM2_TOGGLE "  "0 ,1 "
bitfld.long 0 12. " RASIFIFORAM3_TOGGLE "  "0 ,1 "
bitfld.long 0 13. " RASIFIFORAM0_TOGGLE "  "0 ,1 "
bitfld.long 0 14. " HSVITSCCHRAM0_TOGGLE "  "0 ,1 "
bitfld.long 0 15. " HSVITSCCHRAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 16. " HSTDECSLIDERAM_TOGGLE "  "0 ,1 "
bitfld.long 0 17. " HSTDECPATHRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 18. " TAPPERCMRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 19. " RAKERCMRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 20. " HSTDECBCRAM_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D400D0
;tree "RCR_STATUS"
rgroup 0--3
line.long 0 "RCR_STATUS"
bitfld.long 0 0. " SWRESET_RST "  "0 ,1 "
bitfld.long 0 1. " LINKORESET_RST "  "0 ,1 "
bitfld.long 0 2. " HAMSARESET_RST "  "0 ,1 "
;tree.end

base ad:0xB7D400D4
;tree "RCR_SET"
wgroup 0--3
line.long 0 "RCR_SET"
bitfld.long 0 0. " SWRESET_RST "  "0 ,1 "
bitfld.long 0 1. " LINKORESET_RST "  "0 ,1 "
bitfld.long 0 2. " HAMSARESET_RST "  "0 ,1 "
;tree.end

base ad:0xB7D400D8
;tree "RCR_CLEAR"
wgroup 0--3
line.long 0 "RCR_CLEAR"
bitfld.long 0 0. " SWRESET_DEFAULT "  "0 ,1 "
bitfld.long 0 1. " LINKORESET_DEFAULT "  "0 ,1 "
bitfld.long 0 2. " HAMSARESET_DEFAULT "  "0 ,1 "
;tree.end

base ad:0xB7D400DC
;tree "RCR_TOGGLE"
wgroup 0--3
line.long 0 "RCR_TOGGLE"
bitfld.long 0 0. " SWRESET_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " LINKORESET_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " HAMSARESET_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D400E0
;tree "L1CRR_STATUS"
rgroup 0--3
line.long 0 "L1CRR_STATUS"
bitfld.long 0 0. " L1MANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 1. " L1RUNCLKREQ_EN "  "0 ,1 "
bitfld.long 0 2. " L1GPT0WAKE_EN "  "0 ,1 "
bitfld.long 0 3. " L1GPT1WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " L1GPT2WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " L1AAWAKE_EN "  "0 ,1 "
;tree.end

base ad:0xB7D400E4
;tree "L1CRR_SET"
wgroup 0--3
line.long 0 "L1CRR_SET"
bitfld.long 0 0. " L1MANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 1. " L1RUNCLKREQ_EN "  "0 ,1 "
bitfld.long 0 2. " L1GPT0WAKE_EN "  "0 ,1 "
bitfld.long 0 3. " L1GPT1WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " L1GPT2WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " L1AAWAKE_EN "  "0 ,1 "
;tree.end

base ad:0xB7D400E8
;tree "L1CRR_CLEAR"
wgroup 0--3
line.long 0 "L1CRR_CLEAR"
bitfld.long 0 0. " L1MANUALCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 1. " L1RUNCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 2. " L1GPT0WAKE_DIS "  "0 ,1 "
bitfld.long 0 3. " L1GPT1WAKE_DIS "  "0 ,1 "
bitfld.long 0 4. " L1GPT2WAKE_DIS "  "0 ,1 "
bitfld.long 0 5. " L1AAWAKE_DIS "  "0 ,1 "
;tree.end

base ad:0xB7D400EC
;tree "L1CRR_TOGGLE"
wgroup 0--3
line.long 0 "L1CRR_TOGGLE"
bitfld.long 0 0. " L1MANUALCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1RUNCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1GPT0WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L1GPT1WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " L1GPT2WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " L1AAWAKE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D400F0
;tree "L2CRR_STATUS"
rgroup 0--3
line.long 0 "L2CRR_STATUS"
bitfld.long 0 0. " L2MANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 1. " L2RUNCLKREQ_EN "  "0 ,1 "
bitfld.long 0 2. " L2GPT0WAKE_EN "  "0 ,1 "
bitfld.long 0 3. " L2GPT1WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " L2GPT2WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " L2AAWAKE_EN "  "0 ,1 "
;tree.end

base ad:0xB7D400F4
;tree "L2CRR_SET"
wgroup 0--3
line.long 0 "L2CRR_SET"
bitfld.long 0 0. " L2MANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 1. " L2RUNCLKREQ_EN "  "0 ,1 "
bitfld.long 0 2. " L2GPT0WAKE_EN "  "0 ,1 "
bitfld.long 0 3. " L2GPT1WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " L2GPT2WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " L2AAWAKE_EN "  "0 ,1 "
;tree.end

base ad:0xB7D400F8
;tree "L2CRR_CLEAR"
wgroup 0--3
line.long 0 "L2CRR_CLEAR"
bitfld.long 0 0. " L2MANUALCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 1. " L2RUNCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 2. " L2GPT0WAKE_DIS "  "0 ,1 "
bitfld.long 0 3. " L2GPT1WAKE_DIS "  "0 ,1 "
bitfld.long 0 4. " L2GPT2WAKE_DIS "  "0 ,1 "
bitfld.long 0 5. " L2AAWAKE_DIS "  "0 ,1 "
;tree.end

base ad:0xB7D400FC
;tree "L2CRR_TOGGLE"
wgroup 0--3
line.long 0 "L2CRR_TOGGLE"
bitfld.long 0 0. " L2MANUALCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2RUNCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L2GPT0WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L2GPT1WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " L2GPT2WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " L2AAWAKE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D40100
;tree "CCRR_STATUS"
rgroup 0--3
line.long 0 "CCRR_STATUS"
bitfld.long 0 0. " L1COREMANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 1. " L2COREMANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 2. " CORERUNCLKREQ_EN "  "0 ,1 "
bitfld.long 0 3. " COREGPT0WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " COREGPT1WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " COREGPT2WAKE_EN "  "0 ,1 "
bitfld.long 0 6. " COREAAWAKE_EN "  "0 ,1 "
;tree.end

base ad:0xB7D40104
;tree "CCRR_SET"
wgroup 0--3
line.long 0 "CCRR_SET"
bitfld.long 0 0. " L1COREMANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 1. " L2COREMANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 2. " CORERUNCLKREQ_EN "  "0 ,1 "
bitfld.long 0 3. " COREGPT0WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " COREGPT1WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " COREGPT2WAKE_EN "  "0 ,1 "
bitfld.long 0 6. " COREAAWAKE_EN "  "0 ,1 "
;tree.end

base ad:0xB7D40108
;tree "CCRR_CLEAR"
wgroup 0--3
line.long 0 "CCRR_CLEAR"
bitfld.long 0 0. " L1COREMANUALCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 1. " L2COREMANUALCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 2. " CORERUNCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 3. " COREGPT0WAKE_DIS "  "0 ,1 "
bitfld.long 0 4. " COREGPT1WAKE_DIS "  "0 ,1 "
bitfld.long 0 5. " COREGPT2WAKE_DIS "  "0 ,1 "
bitfld.long 0 6. " COREAAWAKE_DIS "  "0 ,1 "
;tree.end

base ad:0xB7D4010C
;tree "CCRR_TOGGLE"
wgroup 0--3
line.long 0 "CCRR_TOGGLE"
bitfld.long 0 0. " L1COREMANUALCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2COREMANUALCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " CORERUNCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " COREGPT0WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " COREGPT1WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " COREGPT2WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " COREAAWAKE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D40110
;tree "WRR_STATUS"
rgroup 0--3
line.long 0 "WRR_STATUS"
bitfld.long 0 0. " L1GPT2_WAKE_EN "  "0 ,1 "
bitfld.long 0 1. " L1GPT1_WAKE_EN "  "0 ,1 "
bitfld.long 0 2. " L1GPT0_WAKE_EN "  "0 ,1 "
bitfld.long 0 3. " L1ED1_WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " L1WAKEMODIRQ_WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " L1SHUTDOWNIRQ_WAKE_EN "  "0 ,1 "
bitfld.long 0 6. " L2GPT2_WAKE_EN "  "0 ,1 "
bitfld.long 0 7. " L2GPT1_WAKE_EN "  "0 ,1 "
bitfld.long 0 8. " L2GPT0_WAKE_EN "  "0 ,1 "
bitfld.long 0 9. " L2ED2_WAKE_EN "  "0 ,1 "
bitfld.long 0 10. " L2WAKEMODIRQ_WAKE_EN "  "0 ,1 "
bitfld.long 0 11. " L2SHUTDOWNIRQ_WAKE_EN "  "0 ,1 "
;tree.end

base ad:0xB7D40114
;tree "WRR_SET"
wgroup 0--3
line.long 0 "WRR_SET"
bitfld.long 0 0. " L1GPT2_WAKE_EN "  "0 ,1 "
bitfld.long 0 1. " L1GPT1_WAKE_EN "  "0 ,1 "
bitfld.long 0 2. " L1GPT0_WAKE_EN "  "0 ,1 "
bitfld.long 0 3. " L1ED1_WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " L1WAKEMODIRQ_WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " L1SHUTDOWNIRQ_WAKE_EN "  "0 ,1 "
bitfld.long 0 6. " L2GPT2_WAKE_EN "  "0 ,1 "
bitfld.long 0 7. " L2GPT1_WAKE_EN "  "0 ,1 "
bitfld.long 0 8. " L2GPT0_WAKE_EN "  "0 ,1 "
bitfld.long 0 9. " L2ED2_WAKE_EN "  "0 ,1 "
bitfld.long 0 10. " L2WAKEMODIRQ_WAKE_EN "  "0 ,1 "
bitfld.long 0 11. " L2SHUTDOWNIRQ_WAKE_EN "  "0 ,1 "
;tree.end

base ad:0xB7D40118
;tree "WRR_CLEAR"
wgroup 0--3
line.long 0 "WRR_CLEAR"
bitfld.long 0 0. " L1GPT2_WAKE_MASK "  "0 ,1 "
bitfld.long 0 1. " L1GPT1_WAKE_MASK "  "0 ,1 "
bitfld.long 0 2. " L1GPT0_WAKE_MASK "  "0 ,1 "
bitfld.long 0 3. " L1ED1_WAKE_MASK "  "0 ,1 "
bitfld.long 0 4. " L1WAKEMODIRQ_WAKE_MASK "  "0 ,1 "
bitfld.long 0 5. " L1SHUTDOWNIRQ_WAKE_MASK "  "0 ,1 "
bitfld.long 0 6. " L2GPT2_WAKE_MASK "  "0 ,1 "
bitfld.long 0 7. " L2GPT1_WAKE_MASK "  "0 ,1 "
bitfld.long 0 8. " L2GPT0_WAKE_MASK "  "0 ,1 "
bitfld.long 0 9. " L2ED2_WAKE_MASK "  "0 ,1 "
bitfld.long 0 10. " L2WAKEMODIRQ_WAKE_MASK "  "0 ,1 "
bitfld.long 0 11. " L2SHUTDOWNIRQ_WAKE_MASK "  "0 ,1 "
;tree.end

base ad:0xB7D4011C
;tree "WRR_TOGGLE"
wgroup 0--3
line.long 0 "WRR_TOGGLE"
bitfld.long 0 0. " L1GPT2_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1GPT1_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1GPT0_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L1ED1_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " L1WAKEMODIRQ_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " L1SHUTDOWNIRQ_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " L2GPT2_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " L2GPT1_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " L2GPT0_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " L2ED2_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " L2WAKEMODIRQ_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 11. " L2SHUTDOWNIRQ_WAKE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D40120
;tree "CRR_STATUS"
rgroup 0--3
line.long 0 "CRR_STATUS"
bitfld.long 0 0. " 3GCLKMANUALREQ_EN "  "0 ,1 "
;tree.end

base ad:0xB7D40124
;tree "CRR_SET"
wgroup 0--3
line.long 0 "CRR_SET"
bitfld.long 0 0. " 3GCLKMANUALREQ_EN "  "0 ,1 "
;tree.end

base ad:0xB7D40128
;tree "CRR_CLEAR"
wgroup 0--3
line.long 0 "CRR_CLEAR"
bitfld.long 0 0. " 3GCLKMANUALREQ_DIS "  "0 ,1 "
;tree.end

base ad:0xB7D4012C
;tree "CRR_TOGGLE"
wgroup 0--3
line.long 0 "CRR_TOGGLE"
bitfld.long 0 0. " 3GCLKMANUALREQ_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D40130
;tree "CSR_STATUS"
rgroup 0--3
line.long 0 "CSR_STATUS"
bitfld.long 0 0. " PSSPLLCLKSRCSELECT_3GHF "  "0 ,1 "
bitfld.long 0 1. " 3GPLLCLKSRCSELECT_3GHF "  "0 ,1 "
bitfld.long 0 2. " FDICLKSRCSELECT_3GHF "  "0 ,1 "
;tree.end

base ad:0xB7D40134
;tree "CSR_SET"
wgroup 0--3
line.long 0 "CSR_SET"
bitfld.long 0 0. " PSSPLLCLKSRCSELECT_3GHF "  "0 ,1 "
bitfld.long 0 1. " 3GPLLCLKSRCSELECT_3GHF "  "0 ,1 "
bitfld.long 0 2. " FDICLKSRCSELECT_3GHF "  "0 ,1 "
;tree.end

base ad:0xB7D40138
;tree "CSR_CLEAR"
wgroup 0--3
line.long 0 "CSR_CLEAR"
bitfld.long 0 0. " PSSPLLCLKSRCSELECT_PSS "  "0 ,1 "
bitfld.long 0 1. " 3GPLLCLKSRCSELECT_PSS "  "0 ,1 "
bitfld.long 0 2. " FDICLKSRCSELECT_PSS "  "0 ,1 "
;tree.end

base ad:0xB7D4013C
;tree "CSR_TOGGLE"
wgroup 0--3
line.long 0 "CSR_TOGGLE"
bitfld.long 0 0. " PSSPLLCLKSRCSELECT_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " 3GPLLCLKSRCSELECT_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " FDICLKSRCSELECT_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D40140
;tree "MACR_STATUS"
rgroup 0--3
line.long 0 "MACR_STATUS"
bitfld.long 0 0. " MAIFCLK_EN "  "0 ,1 "
bitfld.long 0 1. " MAIFRESET_RST "  "0 ,1 "
bitfld.long 0 2. " MAIFSTATE_AWAKE "  "0 ,1 "
;tree.end

base ad:0xB7D40144
;tree "MACR_SET"
wgroup 0--3
line.long 0 "MACR_SET"
bitfld.long 0 0. " MAIFCLK_EN "  "0 ,1 "
bitfld.long 0 1. " MAIFRESET_RST "  "0 ,1 "
bitfld.long 0 2. " MAIFSTATE_AWAKE "  "0 ,1 "
;tree.end

base ad:0xB7D40148
;tree "MACR_CLEAR"
wgroup 0--3
line.long 0 "MACR_CLEAR"
bitfld.long 0 0. " MAIFCLK_DIS "  "0 ,1 "
bitfld.long 0 1. " MAIFRESET_DEFAULT "  "0 ,1 "
bitfld.long 0 2. " MAIFSTATE_ASLEEP "  "0 ,1 "
;tree.end

base ad:0xB7D4014C
;tree "MACR_TOGGLE"
wgroup 0--3
line.long 0 "MACR_TOGGLE"
bitfld.long 0 0. " MAIFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " MAIFRESET_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " MAIFSTATE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7D40400
;tree "WGMIDR"
group 0--3
line.long 0 "WGMIDR"
bitfld.long 0 0.--13. " VCNUM "  " "
bitfld.long 0 0.--4. " VCPR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.word 0 " SYNC1 "
hexfld.word 0 " SYNC0 "
;tree.end

base ad:0xB7D40404
;tree "WVCOREVSETXR"
group 0--3
line.long 0 "WVCOREVSETXR"
bitfld.long 0 0. " VOLTAGESEL_ACTIVE "  "0 ,1 "
bitfld.long 0 4. " L1AAVOLTAGE_SHARED "  "0 ,1 "
;tree.end

base ad:0xB7D40408
;tree "PDSR"
group 0--3
line.long 0 "PDSR"
bitfld.long 0 0.--1. " PRC_L2STATUS_PDOWNS "  "0 ,1 ,2 ,3 "
bitfld.long 0 1. " PRC_L2STATUS_ACTIVE "  "0 ,1 "
bitfld.long 0 0. " PRC_L2STATUS_PUPS "  "0 ,1 "
bitfld.long 0 2.--3. " PRC_HAMSASTATUS_PDOWNS "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " PRC_HAMSASTATUS_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " PRC_HAMSASTATUS_PUPS "  "0 ,1 "
bitfld.long 0 4.--5. " PRC_CORESTATUS_PDOWNS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " PRC_CORESTATUS_ACTIVE "  "0 ,1 "
bitfld.long 0 4. " PRC_CORESTATUS_PUPS "  "0 ,1 "
bitfld.long 0 12. " L1_WAKEUP_STATUS_HOSTACCESSREQ "  "0 ,1 "
bitfld.long 0 11. " L1_WAKEUP_STATUS_SDOWNIRQ "  "0 ,1 "
bitfld.long 0 10. " L1_WAKEUP_STATUS_WAKEIRQ "  "0 ,1 "
bitfld.long 0 9. " L1_WAKEUP_STATUS_ED2 "  "0 ,1 "
bitfld.long 0 8. " L1_WAKEUP_STATUS_GPT0 "  "0 ,1 "
bitfld.long 0 7. " L1_WAKEUP_STATUS_GPT1 "  "0 ,1 "
bitfld.long 0 6. " L1_WAKEUP_STATUS_GPT2 "  "0 ,1 "
bitfld.long 0 19. " L2_WAKEUP_STATUS_HOSTACCESSREQ "  "0 ,1 "
bitfld.long 0 18. " L2_WAKEUP_STATUS_SDOWNIRQ "  "0 ,1 "
bitfld.long 0 17. " L2_WAKEUP_STATUS_WAKEIRQ "  "0 ,1 "
bitfld.long 0 16. " L2_WAKEUP_STATUS_ED2 "  "0 ,1 "
bitfld.long 0 15. " L2_WAKEUP_STATUS_GPT0 "  "0 ,1 "
bitfld.long 0 14. " L2_WAKEUP_STATUS_GPT1 "  "0 ,1 "
bitfld.long 0 13. " L2_WAKEUP_STATUS_GPT2 "  "0 ,1 "
;tree.end

base ad:0xB7D40410
;tree "CCR_STATUS"
rgroup 0--3
line.long 0 "CCR_STATUS"
bitfld.long 0 0. " L1HALTREL_REL "  "0 ,1 "
bitfld.long 0 1. " L2HALTREL_REL "  "0 ,1 "
;tree.end

base ad:0xB7D40414
;tree "CCR_SET"
wgroup 0--3
line.long 0 "CCR_SET"
bitfld.long 0 0. " L1HALTREL_REL "  "0 ,1 "
bitfld.long 0 1. " L2HALTREL_REL "  "0 ,1 "
;tree.end

base ad:0xB7D40418
;tree "CCR_CLEAR"
wgroup 0--3
line.long 0 "CCR_CLEAR"
bitfld.long 0 0. " L1HALTREL_HALT "  "0 ,1 "
bitfld.long 0 1. " L2HALTREL_HALT "  "0 ,1 "
;tree.end

base ad:0xB7D4041C
;tree "CCR_TOGGLE"
wgroup 0--3
line.long 0 "CCR_TOGGLE"
bitfld.long 0 0. " L1HALTREL_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2HALTREL_TOGGLE "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "SCU_AD_R4"
;==============================================================
base ad:0x17D40000
;tree "MADR"
group 0--3
line.long 0 "MADR"
hexfld.word 0 " ACCESSDELAYTIME_MAXVAL "
;tree.end

base ad:0x17D40004
;tree "RADR"
group 0--3
line.long 0 "RADR"
hexfld.word 0 " ACCESSDELAYTIME_MAXVAL "
;tree.end

base ad:0x17D4000C
;tree "CVSTR"
group 0--3
line.long 0 "CVSTR"
bitfld.long 0 0. " CVSTCOUNTER_EN "  "0 ,1 "
bitfld.long 0 1.--14. " CVSTCOUNTERVAL_MAXVAL "  " "
;tree.end

base ad:0x17D40010
;tree "WMASR"
rgroup 0--3
line.long 0 "WMASR"
bitfld.long 0 0. " L1PDARRAY_RDY "  "0 ,1 "
bitfld.long 0 1. " L2PDARRAY_RDY "  "0 ,1 "
bitfld.long 0 2. " HAMSAPDARRAY_RDY "  "0 ,1 "
;tree.end

base ad:0x17D40018
;tree "LRSR"
rgroup 0--3
line.long 0 "LRSR"
bitfld.long 0 0. " WGMRESETAX_PURX "  "0 ,1 "
bitfld.long 0 1. " SWSRESET_SWRX "  "0 ,1 "
bitfld.long 0 2. " SWDRESET_WDRX "  "0 ,1 "
;tree.end

base ad:0x17D40020
;tree "PDCR_STATUS"
rgroup 0--3
line.long 0 "PDCR_STATUS"
bitfld.long 0 0. " FORCELM_EN "  "0 ,1 "
bitfld.long 0 1. " L2_PWRDOWN_EN "  "0 ,1 "
bitfld.long 0 2. " HAMSA_PWRDOWN_EN "  "0 ,1 "
bitfld.long 0 3. " CORE_PWRDOWN_EN "  "0 ,1 "
bitfld.long 0 4. " SWITCHOFF_L2PD_EN "  "0 ,1 "
bitfld.long 0 5. " SWITCHOFF_HAMSAPD_EN "  "0 ,1 "
bitfld.long 0 6. " L1WAITFORPLL_EN "  "0 ,1 "
bitfld.long 0 7. " L2WAITFORPLL_EN "  "0 ,1 "
bitfld.long 0 8. " COREWAITFORPLL_EN "  "0 ,1 "
;tree.end

base ad:0x17D40024
;tree "PDCR_SET"
wgroup 0--3
line.long 0 "PDCR_SET"
bitfld.long 0 0. " FORCELM_EN "  "0 ,1 "
bitfld.long 0 1. " L2_PWRDOWN_EN "  "0 ,1 "
bitfld.long 0 2. " HAMSA_PWRDOWN_EN "  "0 ,1 "
bitfld.long 0 3. " CORE_PWRDOWN_EN "  "0 ,1 "
bitfld.long 0 4. " SWITCHOFF_L2PD_EN "  "0 ,1 "
bitfld.long 0 5. " SWITCHOFF_HAMSAPD_EN "  "0 ,1 "
bitfld.long 0 6. " L1WAITFORPLL_EN "  "0 ,1 "
bitfld.long 0 7. " L2WAITFORPLL_EN "  "0 ,1 "
bitfld.long 0 8. " COREWAITFORPLL_EN "  "0 ,1 "
;tree.end

base ad:0x17D40028
;tree "PDCR_CLEAR"
wgroup 0--3
line.long 0 "PDCR_CLEAR"
bitfld.long 0 0. " FORCELM_DIS "  "0 ,1 "
bitfld.long 0 1. " L2_PWRDOWN_DIS "  "0 ,1 "
bitfld.long 0 2. " HAMSA_PWRDOWN_DIS "  "0 ,1 "
bitfld.long 0 3. " CORE_PWRDOWN_DIS "  "0 ,1 "
bitfld.long 0 4. " SWITCHOFF_L2PD_DIS "  "0 ,1 "
bitfld.long 0 5. " SWITCHOFF_HAMSAPD_DIS "  "0 ,1 "
bitfld.long 0 6. " L1WAITFORPLL_DIS "  "0 ,1 "
bitfld.long 0 7. " L2WAITFORPLL_DIS "  "0 ,1 "
bitfld.long 0 8. " COREWAITFORPLL_DIS "  "0 ,1 "
;tree.end

base ad:0x17D4002C
;tree "PDCR_TOGGLE"
wgroup 0--3
line.long 0 "PDCR_TOGGLE"
bitfld.long 0 0. " FORCELM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2_PWRDOWN_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " HAMSA_PWRDOWN_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " CORE_PWRDOWN_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " SWITCHOFF_L2PD_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " SWITCHOFF_HAMSAPD_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " L1WAITFORPLL_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " L2WAITFORPLL_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " COREWAITFORPLL_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D40030
;tree "GPMMCR_STATUS"
rgroup 0--3
line.long 0 "GPMMCR_STATUS"
bitfld.long 0 0. " L1IDLEPM_EN "  "0 ,1 "
bitfld.long 0 1. " L2IDLEPM_EN "  "0 ,1 "
bitfld.long 0 2. " MEM_RET_DIS "  "0 ,1 "
bitfld.long 0 3. " MEM_ARRAY_OFF_DIS "  "0 ,1 "
;tree.end

base ad:0x17D40034
;tree "GPMMCR_SET"
wgroup 0--3
line.long 0 "GPMMCR_SET"
bitfld.long 0 0. " L1IDLEPM_EN "  "0 ,1 "
bitfld.long 0 1. " L2IDLEPM_EN "  "0 ,1 "
bitfld.long 0 2. " MEM_RET_DIS "  "0 ,1 "
bitfld.long 0 3. " MEM_ARRAY_OFF_DIS "  "0 ,1 "
;tree.end

base ad:0x17D40038
;tree "GPMMCR_CLEAR"
wgroup 0--3
line.long 0 "GPMMCR_CLEAR"
bitfld.long 0 0. " L1IDLEPM_DIS "  "0 ,1 "
bitfld.long 0 1. " L2IDLEPM_DIS "  "0 ,1 "
bitfld.long 0 2. " MEM_RET_NORMAL "  "0 ,1 "
bitfld.long 0 3. " MEM_ARRAY_OFF_NORMAL "  "0 ,1 "
;tree.end

base ad:0x17D4003C
;tree "GPMMCR_TOGGLE"
wgroup 0--3
line.long 0 "GPMMCR_TOGGLE"
bitfld.long 0 0. " L1IDLEPM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2IDLEPM_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " MEM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " MEM_ARRAY_OFF_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D40040
;tree "CDSMPCR_STATUS"
rgroup 0--3
line.long 0 "CDSMPCR_STATUS"
bitfld.long 0 0. " L1_COP0_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_RET_ON "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_RET_ON "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_RET_ON "  "0 ,1 "
bitfld.long 0 5. " SRAM_RET_ON "  "0 ,1 "
bitfld.long 0 6. " ETB_MEM_RET_ON "  "0 ,1 "
bitfld.long 0 7. " L1_DCACHE_RET_ON "  "0 ,1 "
bitfld.long 0 8. " L1_ICACHE_RET_ON "  "0 ,1 "
bitfld.long 0 9. " ITCM_RET_ON "  "0 ,1 "
bitfld.long 0 10. " DTCM_RET_ON "  "0 ,1 "
bitfld.long 0 11. " L2_CACHE_RET_ON "  "0 ,1 "
;tree.end

base ad:0x17D40044
;tree "CDSMPCR_SET"
wgroup 0--3
line.long 0 "CDSMPCR_SET"
bitfld.long 0 0. " L1_COP0_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_RET_ON "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_RET_ON "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_RET_ON "  "0 ,1 "
bitfld.long 0 5. " SRAM_RET_ON "  "0 ,1 "
bitfld.long 0 6. " ETB_MEM_RET_ON "  "0 ,1 "
bitfld.long 0 7. " L1_DCACHE_RET_ON "  "0 ,1 "
bitfld.long 0 8. " L1_ICACHE_RET_ON "  "0 ,1 "
bitfld.long 0 9. " ITCM_RET_ON "  "0 ,1 "
bitfld.long 0 10. " DTCM_RET_ON "  "0 ,1 "
bitfld.long 0 11. " L2_CACHE_RET_ON "  "0 ,1 "
;tree.end

base ad:0x17D40048
;tree "CDSMPCR_CLEAR"
wgroup 0--3
line.long 0 "CDSMPCR_CLEAR"
bitfld.long 0 0. " L1_COP0_TCM_RET_OFF "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_OFF "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_RET_OFF "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_RET_OFF "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_RET_OFF "  "0 ,1 "
bitfld.long 0 5. " SRAM_RET_OFF "  "0 ,1 "
bitfld.long 0 6. " ETB_MEM_RET_OFF "  "0 ,1 "
bitfld.long 0 7. " L1_DCACHE_RET_OFF "  "0 ,1 "
bitfld.long 0 8. " L1_ICACHE_RET_OFF "  "0 ,1 "
bitfld.long 0 9. " ITCM_RET_OFF "  "0 ,1 "
bitfld.long 0 10. " DTCM_RET_OFF "  "0 ,1 "
bitfld.long 0 11. " L2_CACHE_RET_OFF "  "0 ,1 "
;tree.end

base ad:0x17D4004C
;tree "CDSMPCR_TOGGLE"
wgroup 0--3
line.long 0 "CDSMPCR_TOGGLE"
bitfld.long 0 0. " L1_COP0_TCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " SRAM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " ETB_MEM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " L1_DCACHE_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " L1_ICACHE_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " ITCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " DTCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 11. " L2_CACHE_RET_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D40050
;tree "CLSMPCR_STATUS"
rgroup 0--3
line.long 0 "CLSMPCR_STATUS"
bitfld.long 0 0. " L1_COP0_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHE_RET_ON "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHE_RET_ON "  "0 ,1 "
bitfld.long 0 4. " ITCM_RET_ON "  "0 ,1 "
bitfld.long 0 5. " DTCM_RET_ON "  "0 ,1 "
bitfld.long 0 6. " L2_CACHE_RET_ON "  "0 ,1 "
;tree.end

base ad:0x17D40054
;tree "CLSMPCR_SET"
wgroup 0--3
line.long 0 "CLSMPCR_SET"
bitfld.long 0 0. " L1_COP0_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_ON "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHE_RET_ON "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHE_RET_ON "  "0 ,1 "
bitfld.long 0 4. " ITCM_RET_ON "  "0 ,1 "
bitfld.long 0 5. " DTCM_RET_ON "  "0 ,1 "
bitfld.long 0 6. " L2_CACHE_RET_ON "  "0 ,1 "
;tree.end

base ad:0x17D40058
;tree "CLSMPCR_CLEAR"
wgroup 0--3
line.long 0 "CLSMPCR_CLEAR"
bitfld.long 0 0. " L1_COP0_TCM_RET_OFF "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_OFF "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHE_RET_OFF "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHE_RET_OFF "  "0 ,1 "
bitfld.long 0 4. " ITCM_RET_OFF "  "0 ,1 "
bitfld.long 0 5. " DTCM_RET_OFF "  "0 ,1 "
bitfld.long 0 6. " L2_CACHE_RET_OFF "  "0 ,1 "
;tree.end

base ad:0x17D4005C
;tree "CLSMPCR_TOGGLE"
wgroup 0--3
line.long 0 "CLSMPCR_TOGGLE"
bitfld.long 0 0. " L1_COP0_TCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHE_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHE_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " ITCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " DTCM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " L2_CACHE_RET_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D40060
;tree "CMMPCR_STATUS"
rgroup 0--3
line.long 0 "CMMPCR_STATUS"
bitfld.long 0 0. " L1_COP0_TCM_OFF "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_OFF "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_OFF "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_OFF "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_OFF "  "0 ,1 "
bitfld.long 0 5. " GSM_RARAM_OFF "  "0 ,1 "
bitfld.long 0 6. " GSM_DMRAM_OFF "  "0 ,1 "
bitfld.long 0 7. " CDFE1_RAM_OFF "  "0 ,1 "
bitfld.long 0 8. " CDFE2_RAM_OFF "  "0 ,1 "
bitfld.long 0 9. " CLIFF_EQDATA_OFF "  "0 ,1 "
bitfld.long 0 10. " CLIFF_IP_BUF_OFF "  "0 ,1 "
bitfld.long 0 11. " CLIFF_COEF_RAM_OFF "  "0 ,1 "
bitfld.long 0 12. " CLIFF_ST_METRIC_OFF "  "0 ,1 "
bitfld.long 0 13. " MFLINKO_RAM1_OFF "  "0 ,1 "
bitfld.long 0 14. " MFLINKO_RAM2_OFF "  "0 ,1 "
bitfld.long 0 15. " CVIT_IOTB_RAM_OFF "  "0 ,1 "
bitfld.long 0 16. " CVIT_CMS_RAM_OFF "  "0 ,1 "
bitfld.long 0 17. " CLAE_RAM1_OFF "  "0 ,1 "
bitfld.long 0 18. " CLAE_RAM2_OFF "  "0 ,1 "
bitfld.long 0 19. " SRAM_OFF "  "0 ,1 "
bitfld.long 0 20. " ETB_MEM_OFF "  "0 ,1 "
bitfld.long 0 21. " L1_DCACHE_OFF "  "0 ,1 "
bitfld.long 0 22. " L1_ICACHE_OFF "  "0 ,1 "
bitfld.long 0 23. " ITCM_OFF "  "0 ,1 "
bitfld.long 0 24. " DTCM_OFF "  "0 ,1 "
bitfld.long 0 25. " L2_CACHE_OFF "  "0 ,1 "
bitfld.long 0 26. " TAG_RAM_OFF "  "0 ,1 "
bitfld.long 0 27. " DIRTY_RAM_OFF "  "0 ,1 "
;tree.end

base ad:0x17D40064
;tree "CMMPCR_SET"
wgroup 0--3
line.long 0 "CMMPCR_SET"
bitfld.long 0 0. " L1_COP0_TCM_OFF "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_OFF "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_OFF "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_OFF "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_OFF "  "0 ,1 "
bitfld.long 0 5. " GSM_RARAM_OFF "  "0 ,1 "
bitfld.long 0 6. " GSM_DMRAM_OFF "  "0 ,1 "
bitfld.long 0 7. " CDFE1_RAM_OFF "  "0 ,1 "
bitfld.long 0 8. " CDFE2_RAM_OFF "  "0 ,1 "
bitfld.long 0 9. " CLIFF_EQDATA_OFF "  "0 ,1 "
bitfld.long 0 10. " CLIFF_IP_BUF_OFF "  "0 ,1 "
bitfld.long 0 11. " CLIFF_COEF_RAM_OFF "  "0 ,1 "
bitfld.long 0 12. " CLIFF_ST_METRIC_OFF "  "0 ,1 "
bitfld.long 0 13. " MFLINKO_RAM1_OFF "  "0 ,1 "
bitfld.long 0 14. " MFLINKO_RAM2_OFF "  "0 ,1 "
bitfld.long 0 15. " CVIT_IOTB_RAM_OFF "  "0 ,1 "
bitfld.long 0 16. " CVIT_CMS_RAM_OFF "  "0 ,1 "
bitfld.long 0 17. " CLAE_RAM1_OFF "  "0 ,1 "
bitfld.long 0 18. " CLAE_RAM2_OFF "  "0 ,1 "
bitfld.long 0 19. " SRAM_OFF "  "0 ,1 "
bitfld.long 0 20. " ETB_MEM_OFF "  "0 ,1 "
bitfld.long 0 21. " L1_DCACHE_OFF "  "0 ,1 "
bitfld.long 0 22. " L1_ICACHE_OFF "  "0 ,1 "
bitfld.long 0 23. " ITCM_OFF "  "0 ,1 "
bitfld.long 0 24. " DTCM_OFF "  "0 ,1 "
bitfld.long 0 25. " L2_CACHE_OFF "  "0 ,1 "
bitfld.long 0 26. " TAG_RAM_OFF "  "0 ,1 "
bitfld.long 0 27. " DIRTY_RAM_OFF "  "0 ,1 "
;tree.end

base ad:0x17D40068
;tree "CMMPCR_CLEAR"
wgroup 0--3
line.long 0 "CMMPCR_CLEAR"
bitfld.long 0 0. " L1_COP0_TCM_ON "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_ON "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_ON "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_ON "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_ON "  "0 ,1 "
bitfld.long 0 5. " GSM_RARAM_ON "  "0 ,1 "
bitfld.long 0 6. " GSM_DMRAM_ON "  "0 ,1 "
bitfld.long 0 7. " CDFE1_RAM_ON "  "0 ,1 "
bitfld.long 0 8. " CDFE2_RAM_ON "  "0 ,1 "
bitfld.long 0 9. " CLIFF_EQDATA_ON "  "0 ,1 "
bitfld.long 0 10. " CLIFF_IP_BUF_ON "  "0 ,1 "
bitfld.long 0 11. " CLIFF_COEF_RAM_ON "  "0 ,1 "
bitfld.long 0 12. " CLIFF_ST_METRIC_ON "  "0 ,1 "
bitfld.long 0 13. " MFLINKO_RAM1_ON "  "0 ,1 "
bitfld.long 0 14. " MFLINKO_RAM2_ON "  "0 ,1 "
bitfld.long 0 15. " CVIT_IOTB_RAM_ON "  "0 ,1 "
bitfld.long 0 16. " CVIT_CMS_RAM_ON "  "0 ,1 "
bitfld.long 0 17. " CLAE_RAM1_ON "  "0 ,1 "
bitfld.long 0 18. " CLAE_RAM2_ON "  "0 ,1 "
bitfld.long 0 19. " SRAM_ON "  "0 ,1 "
bitfld.long 0 20. " ETB_MEM_ON "  "0 ,1 "
bitfld.long 0 21. " L1_DCACHE_ON "  "0 ,1 "
bitfld.long 0 22. " L1_ICACHE_ON "  "0 ,1 "
bitfld.long 0 23. " ITCM_ON "  "0 ,1 "
bitfld.long 0 24. " DTCM_ON "  "0 ,1 "
bitfld.long 0 25. " L2_CACHE_ON "  "0 ,1 "
bitfld.long 0 26. " TAG_RAM_ON "  "0 ,1 "
bitfld.long 0 27. " DIRTY_RAM_ON "  "0 ,1 "
;tree.end

base ad:0x17D4006C
;tree "CMMPCR_TOGGLE"
wgroup 0--3
line.long 0 "CMMPCR_TOGGLE"
bitfld.long 0 0. " L1_COP0_TCM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1_COP1_TCM_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " GSM_CMRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " GSM_RPRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " GSM_RWRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " GSM_RARAM_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " GSM_DMRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " CDFE1_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " CDFE2_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " CLIFF_EQDATA_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " CLIFF_IP_BUF_TOGGLE "  "0 ,1 "
bitfld.long 0 11. " CLIFF_COEF_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 12. " CLIFF_ST_METRIC_TOGGLE "  "0 ,1 "
bitfld.long 0 13. " MFLINKO_RAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 14. " MFLINKO_RAM2_TOGGLE "  "0 ,1 "
bitfld.long 0 15. " CVIT_IOTB_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 16. " CVIT_CMS_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 17. " CLAE_RAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 18. " CLAE_RAM2_TOGGLE "  "0 ,1 "
bitfld.long 0 19. " SRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 20. " ETB_MEM_TOGGLE "  "0 ,1 "
bitfld.long 0 21. " L1_DCACHE_TOGGLE "  "0 ,1 "
bitfld.long 0 22. " L1_ICACHE_TOGGLE "  "0 ,1 "
bitfld.long 0 23. " ITCM_TOGGLE "  "0 ,1 "
bitfld.long 0 24. " DTCM_TOGGLE "  "0 ,1 "
bitfld.long 0 25. " L2_CACHE_TOGGLE "  "0 ,1 "
bitfld.long 0 26. " TAG_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 27. " DIRTY_RAM_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D40070
;tree "L2DSMPCR_STATUS"
rgroup 0--3
line.long 0 "L2DSMPCR_STATUS"
bitfld.long 0 0. " MARVIN_RAM_RET "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_RET "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_RET "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_RET "  "0 ,1 "
bitfld.long 0 4. " ITCM_RET "  "0 ,1 "
bitfld.long 0 5. " DTCM_RET "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_RET "  "0 ,1 "
;tree.end

base ad:0x17D40074
;tree "L2DSMPCR_SET"
wgroup 0--3
line.long 0 "L2DSMPCR_SET"
bitfld.long 0 0. " MARVIN_RAM_RET "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_RET "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_RET "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_RET "  "0 ,1 "
bitfld.long 0 4. " ITCM_RET "  "0 ,1 "
bitfld.long 0 5. " DTCM_RET "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_RET "  "0 ,1 "
;tree.end

base ad:0x17D40078
;tree "L2DSMPCR_CLEAR"
wgroup 0--3
line.long 0 "L2DSMPCR_CLEAR"
bitfld.long 0 0. " MARVIN_RAM_NOTRET "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_NOTRET "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_NOTRET "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_NOTRET "  "0 ,1 "
bitfld.long 0 4. " ITCM_RNOTET "  "0 ,1 "
bitfld.long 0 5. " DTCM_NOTRET "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_NOTRET "  "0 ,1 "
;tree.end

base ad:0x17D4007C
;tree "L2DSMPCR_TOGGLE"
wgroup 0--3
line.long 0 "L2DSMPCR_TOGGLE"
bitfld.long 0 0. " MARVIN_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " ITCM_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " DTCM_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D40080
;tree "L2LSMPCR_STATUS"
rgroup 0--3
line.long 0 "L2LSMPCR_STATUS"
bitfld.long 0 0. " L2COP_TCM_RET "  "0 ,1 "
bitfld.long 0 1. " L1_DCACHETCM_RET "  "0 ,1 "
bitfld.long 0 2. " L1_ICACHETCM_RET "  "0 ,1 "
bitfld.long 0 3. " ITCM_RET "  "0 ,1 "
bitfld.long 0 4. " DTCM_RET "  "0 ,1 "
bitfld.long 0 5. " L2CACHE_RET "  "0 ,1 "
;tree.end

base ad:0x17D40084
;tree "L2LSMPCR_SET"
wgroup 0--3
line.long 0 "L2LSMPCR_SET"
bitfld.long 0 0. " L2COP_TCM_RET "  "0 ,1 "
bitfld.long 0 1. " L1_DCACHETCM_RET "  "0 ,1 "
bitfld.long 0 2. " L1_ICACHETCM_RET "  "0 ,1 "
bitfld.long 0 3. " ITCM_RET "  "0 ,1 "
bitfld.long 0 4. " DTCM_RET "  "0 ,1 "
bitfld.long 0 5. " L2CACHE_RET "  "0 ,1 "
;tree.end

base ad:0x17D40088
;tree "L2LSMPCR_CLEAR"
wgroup 0--3
line.long 0 "L2LSMPCR_CLEAR"
bitfld.long 0 0. " L2COP_TCM_NOTRET "  "0 ,1 "
bitfld.long 0 1. " L1_DCACHETCM_NOTRET "  "0 ,1 "
bitfld.long 0 2. " L1_ICACHETCM_NOTRET "  "0 ,1 "
bitfld.long 0 3. " ITCM_RNOTET "  "0 ,1 "
bitfld.long 0 4. " DTCM_NOTRET "  "0 ,1 "
bitfld.long 0 5. " L2CACHE_NOTRET "  "0 ,1 "
;tree.end

base ad:0x17D4008C
;tree "L2LSMPCR_TOGGLE"
wgroup 0--3
line.long 0 "L2LSMPCR_TOGGLE"
bitfld.long 0 0. " L2COP_TCM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1_DCACHETCM_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1_ICACHETCM_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " ITCM_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " DTCM_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " L2CACHE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D40090
;tree "L2MMPCR_STATUS"
rgroup 0--3
line.long 0 "L2MMPCR_STATUS"
bitfld.long 0 0. " MARVIN_RAM_OFF "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_OFF "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_OFF "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_OFF "  "0 ,1 "
bitfld.long 0 4. " ITCM_OFF "  "0 ,1 "
bitfld.long 0 5. " DTCM_OFF "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_OFF "  "0 ,1 "
;tree.end

base ad:0x17D40094
;tree "L2MMPCR_SET"
wgroup 0--3
line.long 0 "L2MMPCR_SET"
bitfld.long 0 0. " MARVIN_RAM_OFF "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_OFF "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_OFF "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_OFF "  "0 ,1 "
bitfld.long 0 4. " ITCM_OFF "  "0 ,1 "
bitfld.long 0 5. " DTCM_OFF "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_OFF "  "0 ,1 "
;tree.end

base ad:0x17D40098
;tree "L2MMPCR_CLEAR"
wgroup 0--3
line.long 0 "L2MMPCR_CLEAR"
bitfld.long 0 0. " MARVIN_RAM_ON "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_ON "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_ON "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_ON "  "0 ,1 "
bitfld.long 0 4. " ITCM_RNOTET "  "0 ,1 "
bitfld.long 0 5. " DTCM_ON "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_ON "  "0 ,1 "
;tree.end

base ad:0x17D4009C
;tree "L2MMPCR_TOGGLE"
wgroup 0--3
line.long 0 "L2MMPCR_TOGGLE"
bitfld.long 0 0. " MARVIN_RAM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2COP_TCM_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1_DCACHETCM_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L1_ICACHETCM_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " ITCM_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " DTCM_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " L2CACHE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D400A0
;tree "HDSMPCR_STATUS"
rgroup 0--3
line.long 0 "HDSMPCR_STATUS"
bitfld.long 0 0. " SEARAMMEM1_RET_EN "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_RET_EN "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_RET_EN "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_RET_EN "  "0 ,1 "
bitfld.long 0 4. " CTAPPERRAARAM_RET_EN "  "0 ,1 "
bitfld.long 0 5. " TAPPERRPRAM_RET_RET_EN "  "0 ,1 "
bitfld.long 0 6. " TAPPERRWRAM_RET_EN "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_RET_EN "  "0 ,1 "
bitfld.long 0 8. " RAKERRAM2_RET_EN "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_RET_EN "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_RET_EN "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_RET_EN "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_RET_EN "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_RET_EN "  "0 ,1 "
;tree.end

base ad:0x17D400A4
;tree "HDSMPCR_SET"
wgroup 0--3
line.long 0 "HDSMPCR_SET"
bitfld.long 0 0. " SEARAMMEM1_RET_EN "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_RET_EN "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_RET_EN "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_RET_EN "  "0 ,1 "
bitfld.long 0 4. " CTAPPERRAARAM_RET_EN "  "0 ,1 "
bitfld.long 0 5. " TAPPERRPRAM_RET_RET_EN "  "0 ,1 "
bitfld.long 0 6. " TAPPERRWRAM_RET_EN "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_RET_EN "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_RET_EN "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_RET_EN "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_RET_EN "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_RET_EN "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_RET_EN "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_RET_EN "  "0 ,1 "
;tree.end

base ad:0x17D400A8
;tree "HDSMPCR_CLEAR"
wgroup 0--3
line.long 0 "HDSMPCR_CLEAR"
bitfld.long 0 0. " SEARAMMEM1_RET_DIS "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_RET_DIS "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_RET_DIS "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_RET_DEFAULT "  "0 ,1 "
bitfld.long 0 4. " CTAPPERRAARAM_RET_DIS "  "0 ,1 "
bitfld.long 0 5. " TAPPERRPRAM_RET_RET_DIS "  "0 ,1 "
bitfld.long 0 6. " TAPPERRWRAM_RET_DIS "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_RET_DIS "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_RET_DIS "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_RET_DIS "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_RET_DIS "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_RET_DIS "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_RET_DIS "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_RET_DIS "  "0 ,1 "
;tree.end

base ad:0x17D400AC
;tree "HDSMPCR_TOGGLE"
wgroup 0--3
line.long 0 "HDSMPCR_TOGGLE"
bitfld.long 0 0. " SEARAMMEM1_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " CTAPPERRAARAM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " TAPPERRPRAM_RET_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " TAPPERRWRAM_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_RET_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_RET_DIS "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_RET_DIS "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_RET_DIS "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_RET_DIS "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_RET_DIS "  "0 ,1 "
;tree.end

base ad:0x17D400B0
;tree "HMMPCR1_STATUS"
rgroup 0--3
line.long 0 "HMMPCR1_STATUS"
bitfld.long 0 0. " SEARAMMEM1_OFF "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_OFF "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_OFF "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_OFF "  "0 ,1 "
bitfld.long 0 4. " TAPPERRAARAM_OFF "  "0 ,1 "
bitfld.long 0 5. " TAPPERPRAM_OFF "  "0 ,1 "
bitfld.long 0 6. " TAPPERWRAM_OFF "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_OFF "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_OFF "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_OFF "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_OFF "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_OFF "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_OFF "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_OFF "  "0 ,1 "
bitfld.long 0 14. " CDIIRAM_OFF "  "0 ,1 "
bitfld.long 0 15. " EQFEIRNBUF1_OFF "  "0 ,1 "
bitfld.long 0 16. " EQFEIRNBUF2_OFF "  "0 ,1 "
bitfld.long 0 17. " EQFEIRMBUF_OFF "  "0 ,1 "
bitfld.long 0 18. " EQDSRXBUF_OFF "  "0 ,1 "
bitfld.long 0 19. " EQDSTXBUF_OFF "  "0 ,1 "
bitfld.long 0 20. " EQDSVITBUF_OFF "  "0 ,1 "
bitfld.long 0 21. " RAIFRAARAM_OFF "  "0 ,1 "
bitfld.long 0 22. " RAIFCBINFORAM_OFF "  "0 ,1 "
bitfld.long 0 23. " RAIFCBRAM_OFF "  "0 ,1 "
bitfld.long 0 24. " CVITIOBRAM_OFF "  "0 ,1 "
bitfld.long 0 25. " HSVITTBRAM0_OFF "  "0 ,1 "
bitfld.long 0 26. " HSVITTBRAM1_OFF "  "0 ,1 "
bitfld.long 0 27. " HSTDECSYSRAM_OFF "  "0 ,1 "
bitfld.long 0 28. " HSTDECPARITYRAM_OFF "  "0 ,1 "
bitfld.long 0 29. " HSTDECOUTRAM_OFF "  "0 ,1 "
bitfld.long 0 30. " HSTDECPARARAM_OFF "  "0 ,1 "
;tree.end

base ad:0x17D400B4
;tree "HMMPCR1_SET"
wgroup 0--3
line.long 0 "HMMPCR1_SET"
bitfld.long 0 0. " SEARAMMEM1_OFF "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_OFF "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_OFF "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_OFF "  "0 ,1 "
bitfld.long 0 4. " TAPPERRAARAM_OFF "  "0 ,1 "
bitfld.long 0 5. " TAPPERPRAM_OFF "  "0 ,1 "
bitfld.long 0 6. " TAPPERWRAM_OFF "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_OFF "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_OFF "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_OFF "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_OFF "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_OFF "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_OFF "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_OFF "  "0 ,1 "
bitfld.long 0 14. " CDIIRAM_OFF "  "0 ,1 "
bitfld.long 0 15. " EQFEIRNBUF1_OFF "  "0 ,1 "
bitfld.long 0 16. " EQFEIRNBUF2_OFF "  "0 ,1 "
bitfld.long 0 17. " EQFEIRMBUF_OFF "  "0 ,1 "
bitfld.long 0 18. " EQDSRXBUF_OFF "  "0 ,1 "
bitfld.long 0 19. " EQDSTXBUF_OFF "  "0 ,1 "
bitfld.long 0 20. " EQDSVITBUF_OFF "  "0 ,1 "
bitfld.long 0 21. " RAIFRAARAM_OFF "  "0 ,1 "
bitfld.long 0 22. " RAIFCBINFORAM_OFF "  "0 ,1 "
bitfld.long 0 23. " RAIFCBRAM_OFF "  "0 ,1 "
bitfld.long 0 24. " CVITIOBRAM_OFF "  "0 ,1 "
bitfld.long 0 25. " HSVITTBRAM0_OFF "  "0 ,1 "
bitfld.long 0 26. " HSVITTBRAM1_OFF "  "0 ,1 "
bitfld.long 0 27. " HSTDECSYSRAM_OFF "  "0 ,1 "
bitfld.long 0 28. " HSTDECPARITYRAM_OFF "  "0 ,1 "
bitfld.long 0 29. " HSTDECOUTRAM_OFF "  "0 ,1 "
bitfld.long 0 30. " HSTDECPARARAM_OFF "  "0 ,1 "
;tree.end

base ad:0x17D400B8
;tree "HMMPCR1_CLEAR"
wgroup 0--3
line.long 0 "HMMPCR1_CLEAR"
bitfld.long 0 0. " SEARAMMEM1_ON "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_ON "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_ON "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_ON "  "0 ,1 "
bitfld.long 0 4. " TAPPERRAARAM_ON "  "0 ,1 "
bitfld.long 0 5. " TAPPERPRAM_ON "  "0 ,1 "
bitfld.long 0 6. " TAPPERWRAM_ON "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_ON "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_ON "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_ON "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_ON "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_ON "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_ON "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_ON "  "0 ,1 "
bitfld.long 0 14. " CDIIRAM_ON "  "0 ,1 "
bitfld.long 0 15. " EQFEIRNBUF1_ON "  "0 ,1 "
bitfld.long 0 16. " EQFEIRNBUF2_ON "  "0 ,1 "
bitfld.long 0 17. " EQFEIRMBUF_ON "  "0 ,1 "
bitfld.long 0 18. " EQDSRXBUF_ON "  "0 ,1 "
bitfld.long 0 19. " EQDSTXBUF_ON "  "0 ,1 "
bitfld.long 0 20. " EQDSVITBUF_ON "  "0 ,1 "
bitfld.long 0 21. " RAIFRAARAM_ON "  "0 ,1 "
bitfld.long 0 22. " RAIFCBINFORAM_ON "  "0 ,1 "
bitfld.long 0 23. " RAIFCBRAM_ON "  "0 ,1 "
bitfld.long 0 24. " CVITIOBRAM_ON "  "0 ,1 "
bitfld.long 0 25. " HSVITTBRAM0_ON "  "0 ,1 "
bitfld.long 0 26. " HSVITTBRAM1_ON "  "0 ,1 "
bitfld.long 0 27. " HSTDECSYSRAM_ON "  "0 ,1 "
bitfld.long 0 28. " HSTDECPARITYRAM_ON "  "0 ,1 "
bitfld.long 0 29. " HSTDECOUTRAM_ON "  "0 ,1 "
bitfld.long 0 30. " HSTDECPARARAM_ON "  "0 ,1 "
;tree.end

base ad:0x17D400BC
;tree "HMMPCR1_TOGGLE"
wgroup 0--3
line.long 0 "HMMPCR1_TOGGLE"
bitfld.long 0 0. " SEARAMMEM1_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " SEARAMMEM2_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " SEARAMMEM3_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " SEARAMMEM4_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " TAPPERRAARAM_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " TAPPERPRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " TAPPERWRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " RAKERPRAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " RAKERPRAM2_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " RAKERWRAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " RAKERWRAM2_TOGGLE "  "0 ,1 "
bitfld.long 0 11. " HS_CDIIRAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 12. " HS_CDIIRAM2_TOGGLE "  "0 ,1 "
bitfld.long 0 13. " HS_HARQRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 14. " CDIIRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 15. " EQFEIRNBUF1_TOGGLE "  "0 ,1 "
bitfld.long 0 16. " EQFEIRNBUF2_TOGGLE "  "0 ,1 "
bitfld.long 0 17. " EQFEIRMBUF_TOGGLE "  "0 ,1 "
bitfld.long 0 18. " EQDSRXBUF_TOGGLE "  "0 ,1 "
bitfld.long 0 19. " EQDSTXBUF_TOGGLE "  "0 ,1 "
bitfld.long 0 20. " EQDSVITBUF_TOGGLE "  "0 ,1 "
bitfld.long 0 21. " RAIFRAARAM_TOGGLE "  "0 ,1 "
bitfld.long 0 22. " RAIFCBINFORAM_TOGGLE "  "0 ,1 "
bitfld.long 0 23. " RAIFCBRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 28. " CVITIOBRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 25. " HSVITTBRAM0_TOGGLE "  "0 ,1 "
bitfld.long 0 26. " HSVITTBRAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 27. " HSTDECSYSRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 28. " HSTDECPARITYRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 29. " HSTDECOUTRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 30. " HSTDECPARARAM_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D400C0
;tree "HMMPCR2_STATUS"
rgroup 0--3
line.long 0 "HMMPCR2_STATUS"
bitfld.long 0 0. " E_ENCINRAM_OFF "  "0 ,1 "
bitfld.long 0 1. " E_ENCTTRAM_OFF "  "0 ,1 "
bitfld.long 0 2. " E_ENCFRAMERAM_OFF "  "0 ,1 "
bitfld.long 0 3. " ENCINRAM_OFF "  "0 ,1 "
bitfld.long 0 4. " ENCTBRAM_OFF "  "0 ,1 "
bitfld.long 0 5. " ENCTTRAM_OFF "  "0 ,1 "
bitfld.long 0 6. " ENCTTIRAM_OFF "  "0 ,1 "
bitfld.long 0 7. " ENCFRAMERAM_OFF "  "0 ,1 "
bitfld.long 0 8. " ENCTXDATARAM_OFF "  "0 ,1 "
bitfld.long 0 9. " LCVITCMSRAM_OFF "  "0 ,1 "
bitfld.long 0 10. " RASIFIFORAM1_OFF "  "0 ,1 "
bitfld.long 0 11. " RASIFIFORAM2_OFF "  "0 ,1 "
bitfld.long 0 12. " RASIFIFORAM3_OFF "  "0 ,1 "
bitfld.long 0 13. " RASIFIFORAM0_OFF "  "0 ,1 "
bitfld.long 0 14. " HSVITSCCHRAM0_OFF "  "0 ,1 "
bitfld.long 0 15. " HSVITSCCHRAM1_OFF "  "0 ,1 "
bitfld.long 0 16. " HSTDECSLIDERAM_OFF "  "0 ,1 "
bitfld.long 0 17. " HSTDECPATHRAM_OFF "  "0 ,1 "
bitfld.long 0 18. " TAPPERCMRAM_OFF "  "0 ,1 "
bitfld.long 0 19. " RAKERCMRAM_OFF "  "0 ,1 "
bitfld.long 0 20. " HSTDECBCRAM_OFF "  "0 ,1 "
;tree.end

base ad:0x17D400C4
;tree "HMMPCR2_SET"
wgroup 0--3
line.long 0 "HMMPCR2_SET"
bitfld.long 0 0. " E_ENCINRAM_OFF "  "0 ,1 "
bitfld.long 0 1. " E_ENCTTRAM_OFF "  "0 ,1 "
bitfld.long 0 2. " E_ENCFRAMERAM_OFF "  "0 ,1 "
bitfld.long 0 3. " ENCINRAM_OFF "  "0 ,1 "
bitfld.long 0 4. " ENCTBRAM_OFF "  "0 ,1 "
bitfld.long 0 5. " ENCTTRAM_OFF "  "0 ,1 "
bitfld.long 0 7. " ENCFRAMERAM_OFF "  "0 ,1 "
bitfld.long 0 8. " ENCTXDATARAM_OFF "  "0 ,1 "
bitfld.long 0 9. " CVITCMSRAM_OFF "  "0 ,1 "
bitfld.long 0 10. " RASIFIFORAM1_OFF "  "0 ,1 "
bitfld.long 0 11. " RASIFIFORAM2_OFF "  "0 ,1 "
bitfld.long 0 12. " RASIFIFORAM3_OFF "  "0 ,1 "
bitfld.long 0 13. " RASIFIFORAM0_OFF "  "0 ,1 "
bitfld.long 0 14. " HSVITSCCHRAM0_OFF "  "0 ,1 "
bitfld.long 0 15. " HSVITSCCHRAM1_OFF "  "0 ,1 "
bitfld.long 0 16. " HSTDECSLIDERAM_OFF "  "0 ,1 "
bitfld.long 0 17. " HSTDECPATHRAM_OFF "  "0 ,1 "
bitfld.long 0 18. " TAPPERCMRAM_OFF "  "0 ,1 "
bitfld.long 0 19. " RAKERCMRAM_OFF "  "0 ,1 "
bitfld.long 0 20. " HSTDECBCRAM_OFF "  "0 ,1 "
;tree.end

base ad:0x17D400C8
;tree "HMMPCR2_CLEAR"
wgroup 0--3
line.long 0 "HMMPCR2_CLEAR"
bitfld.long 0 0. " E_ENCINRAM_ON "  "0 ,1 "
bitfld.long 0 1. " E_ENCTTRAM_ON "  "0 ,1 "
bitfld.long 0 2. " E_ENCFRAMERAM_ON "  "0 ,1 "
bitfld.long 0 3. " ENCINRAM_ON "  "0 ,1 "
bitfld.long 0 4. " ENCTBRAM_ON "  "0 ,1 "
bitfld.long 0 5. " ENCTTRAM_ON "  "0 ,1 "
bitfld.long 0 6. " ENCTTIRAM_ON "  "0 ,1 "
bitfld.long 0 7. " ENCFRAMERAM_ON "  "0 ,1 "
bitfld.long 0 8. " ENCTXDATARAM_ON "  "0 ,1 "
bitfld.long 0 9. " CVITCMSRAM_ON "  "0 ,1 "
bitfld.long 0 10. " RASIFIFORAM1_ON "  "0 ,1 "
bitfld.long 0 11. " RASIFIFORAM2_ON "  "0 ,1 "
bitfld.long 0 12. " RASIFIFORAM3_ON "  "0 ,1 "
bitfld.long 0 13. " RASIFIFORAM0_ON "  "0 ,1 "
bitfld.long 0 14. " HSVITSCCHRAM0_ON "  "0 ,1 "
bitfld.long 0 15. " HSVITSCCHRAM1_ON "  "0 ,1 "
bitfld.long 0 16. " HSTDECSLIDERAM_ON "  "0 ,1 "
bitfld.long 0 17. " HSTDECPATHRAM_ON "  "0 ,1 "
bitfld.long 0 18. " TAPPERCMRAM_ON "  "0 ,1 "
bitfld.long 0 19. " RAKERCMRAM_ON "  "0 ,1 "
bitfld.long 0 20. " HSTDECBCRAM_ON "  "0 ,1 "
;tree.end

base ad:0x17D400CC
;tree "HMMPCR2_TOGGLE"
wgroup 0--3
line.long 0 "HMMPCR2_TOGGLE"
bitfld.long 0 0. " E_ENCINRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " E_ENCTTRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " E_ENCFRAMERAM_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " ENCINRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " ENCTBRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " ENCTTRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " ENCTTIRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " ENCFRAMERAM_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " ENCTXDATARAM_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " CVITCMSRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " RASIFIFORAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 11. " RASIFIFORAM2_TOGGLE "  "0 ,1 "
bitfld.long 0 12. " RASIFIFORAM3_TOGGLE "  "0 ,1 "
bitfld.long 0 13. " RASIFIFORAM0_TOGGLE "  "0 ,1 "
bitfld.long 0 14. " HSVITSCCHRAM0_TOGGLE "  "0 ,1 "
bitfld.long 0 15. " HSVITSCCHRAM1_TOGGLE "  "0 ,1 "
bitfld.long 0 16. " HSTDECSLIDERAM_TOGGLE "  "0 ,1 "
bitfld.long 0 17. " HSTDECPATHRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 18. " TAPPERCMRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 19. " RAKERCMRAM_TOGGLE "  "0 ,1 "
bitfld.long 0 20. " HSTDECBCRAM_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D400D0
;tree "RCR_STATUS"
rgroup 0--3
line.long 0 "RCR_STATUS"
bitfld.long 0 0. " SWRESET_RST "  "0 ,1 "
bitfld.long 0 1. " LINKORESET_RST "  "0 ,1 "
bitfld.long 0 2. " HAMSARESET_RST "  "0 ,1 "
;tree.end

base ad:0x17D400D4
;tree "RCR_SET"
wgroup 0--3
line.long 0 "RCR_SET"
bitfld.long 0 0. " SWRESET_RST "  "0 ,1 "
bitfld.long 0 1. " LINKORESET_RST "  "0 ,1 "
bitfld.long 0 2. " HAMSARESET_RST "  "0 ,1 "
;tree.end

base ad:0x17D400D8
;tree "RCR_CLEAR"
wgroup 0--3
line.long 0 "RCR_CLEAR"
bitfld.long 0 0. " SWRESET_DEFAULT "  "0 ,1 "
bitfld.long 0 1. " LINKORESET_DEFAULT "  "0 ,1 "
bitfld.long 0 2. " HAMSARESET_DEFAULT "  "0 ,1 "
;tree.end

base ad:0x17D400DC
;tree "RCR_TOGGLE"
wgroup 0--3
line.long 0 "RCR_TOGGLE"
bitfld.long 0 0. " SWRESET_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " LINKORESET_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " HAMSARESET_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D400E0
;tree "L1CRR_STATUS"
rgroup 0--3
line.long 0 "L1CRR_STATUS"
bitfld.long 0 0. " L1MANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 1. " L1RUNCLKREQ_EN "  "0 ,1 "
bitfld.long 0 2. " L1GPT0WAKE_EN "  "0 ,1 "
bitfld.long 0 3. " L1GPT1WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " L1GPT2WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " L1AAWAKE_EN "  "0 ,1 "
;tree.end

base ad:0x17D400E4
;tree "L1CRR_SET"
wgroup 0--3
line.long 0 "L1CRR_SET"
bitfld.long 0 0. " L1MANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 1. " L1RUNCLKREQ_EN "  "0 ,1 "
bitfld.long 0 2. " L1GPT0WAKE_EN "  "0 ,1 "
bitfld.long 0 3. " L1GPT1WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " L1GPT2WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " L1AAWAKE_EN "  "0 ,1 "
;tree.end

base ad:0x17D400E8
;tree "L1CRR_CLEAR"
wgroup 0--3
line.long 0 "L1CRR_CLEAR"
bitfld.long 0 0. " L1MANUALCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 1. " L1RUNCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 2. " L1GPT0WAKE_DIS "  "0 ,1 "
bitfld.long 0 3. " L1GPT1WAKE_DIS "  "0 ,1 "
bitfld.long 0 4. " L1GPT2WAKE_DIS "  "0 ,1 "
bitfld.long 0 5. " L1AAWAKE_DIS "  "0 ,1 "
;tree.end

base ad:0x17D400EC
;tree "L1CRR_TOGGLE"
wgroup 0--3
line.long 0 "L1CRR_TOGGLE"
bitfld.long 0 0. " L1MANUALCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1RUNCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1GPT0WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L1GPT1WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " L1GPT2WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " L1AAWAKE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D400F0
;tree "L2CRR_STATUS"
rgroup 0--3
line.long 0 "L2CRR_STATUS"
bitfld.long 0 0. " L2MANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 1. " L2RUNCLKREQ_EN "  "0 ,1 "
bitfld.long 0 2. " L2GPT0WAKE_EN "  "0 ,1 "
bitfld.long 0 3. " L2GPT1WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " L2GPT2WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " L2AAWAKE_EN "  "0 ,1 "
;tree.end

base ad:0x17D400F4
;tree "L2CRR_SET"
wgroup 0--3
line.long 0 "L2CRR_SET"
bitfld.long 0 0. " L2MANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 1. " L2RUNCLKREQ_EN "  "0 ,1 "
bitfld.long 0 2. " L2GPT0WAKE_EN "  "0 ,1 "
bitfld.long 0 3. " L2GPT1WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " L2GPT2WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " L2AAWAKE_EN "  "0 ,1 "
;tree.end

base ad:0x17D400F8
;tree "L2CRR_CLEAR"
wgroup 0--3
line.long 0 "L2CRR_CLEAR"
bitfld.long 0 0. " L2MANUALCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 1. " L2RUNCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 2. " L2GPT0WAKE_DIS "  "0 ,1 "
bitfld.long 0 3. " L2GPT1WAKE_DIS "  "0 ,1 "
bitfld.long 0 4. " L2GPT2WAKE_DIS "  "0 ,1 "
bitfld.long 0 5. " L2AAWAKE_DIS "  "0 ,1 "
;tree.end

base ad:0x17D400FC
;tree "L2CRR_TOGGLE"
wgroup 0--3
line.long 0 "L2CRR_TOGGLE"
bitfld.long 0 0. " L2MANUALCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2RUNCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L2GPT0WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L2GPT1WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " L2GPT2WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " L2AAWAKE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D40100
;tree "CCRR_STATUS"
rgroup 0--3
line.long 0 "CCRR_STATUS"
bitfld.long 0 0. " L1COREMANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 1. " L2COREMANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 2. " CORERUNCLKREQ_EN "  "0 ,1 "
bitfld.long 0 3. " COREGPT0WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " COREGPT1WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " COREGPT2WAKE_EN "  "0 ,1 "
bitfld.long 0 6. " COREAAWAKE_EN "  "0 ,1 "
;tree.end

base ad:0x17D40104
;tree "CCRR_SET"
wgroup 0--3
line.long 0 "CCRR_SET"
bitfld.long 0 0. " L1COREMANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 1. " L2COREMANUALCLKREQ_EN "  "0 ,1 "
bitfld.long 0 2. " CORERUNCLKREQ_EN "  "0 ,1 "
bitfld.long 0 3. " COREGPT0WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " COREGPT1WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " COREGPT2WAKE_EN "  "0 ,1 "
bitfld.long 0 6. " COREAAWAKE_EN "  "0 ,1 "
;tree.end

base ad:0x17D40108
;tree "CCRR_CLEAR"
wgroup 0--3
line.long 0 "CCRR_CLEAR"
bitfld.long 0 0. " L1COREMANUALCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 1. " L2COREMANUALCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 2. " CORERUNCLKREQ_DIS "  "0 ,1 "
bitfld.long 0 3. " COREGPT0WAKE_DIS "  "0 ,1 "
bitfld.long 0 4. " COREGPT1WAKE_DIS "  "0 ,1 "
bitfld.long 0 5. " COREGPT2WAKE_DIS "  "0 ,1 "
bitfld.long 0 6. " COREAAWAKE_DIS "  "0 ,1 "
;tree.end

base ad:0x17D4010C
;tree "CCRR_TOGGLE"
wgroup 0--3
line.long 0 "CCRR_TOGGLE"
bitfld.long 0 0. " L1COREMANUALCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2COREMANUALCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " CORERUNCLKREQ_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " COREGPT0WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " COREGPT1WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " COREGPT2WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " COREAAWAKE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D40110
;tree "WRR_STATUS"
rgroup 0--3
line.long 0 "WRR_STATUS"
bitfld.long 0 0. " L1GPT2_WAKE_EN "  "0 ,1 "
bitfld.long 0 1. " L1GPT1_WAKE_EN "  "0 ,1 "
bitfld.long 0 2. " L1GPT0_WAKE_EN "  "0 ,1 "
bitfld.long 0 3. " L1ED1_WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " L1WAKEMODIRQ_WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " L1SHUTDOWNIRQ_WAKE_EN "  "0 ,1 "
bitfld.long 0 6. " L2GPT2_WAKE_EN "  "0 ,1 "
bitfld.long 0 7. " L2GPT1_WAKE_EN "  "0 ,1 "
bitfld.long 0 8. " L2GPT0_WAKE_EN "  "0 ,1 "
bitfld.long 0 9. " L2ED2_WAKE_EN "  "0 ,1 "
bitfld.long 0 10. " L2WAKEMODIRQ_WAKE_EN "  "0 ,1 "
bitfld.long 0 11. " L2SHUTDOWNIRQ_WAKE_EN "  "0 ,1 "
;tree.end

base ad:0x17D40114
;tree "WRR_SET"
wgroup 0--3
line.long 0 "WRR_SET"
bitfld.long 0 0. " L1GPT2_WAKE_EN "  "0 ,1 "
bitfld.long 0 1. " L1GPT1_WAKE_EN "  "0 ,1 "
bitfld.long 0 2. " L1GPT0_WAKE_EN "  "0 ,1 "
bitfld.long 0 3. " L1ED1_WAKE_EN "  "0 ,1 "
bitfld.long 0 4. " L1WAKEMODIRQ_WAKE_EN "  "0 ,1 "
bitfld.long 0 5. " L1SHUTDOWNIRQ_WAKE_EN "  "0 ,1 "
bitfld.long 0 6. " L2GPT2_WAKE_EN "  "0 ,1 "
bitfld.long 0 7. " L2GPT1_WAKE_EN "  "0 ,1 "
bitfld.long 0 8. " L2GPT0_WAKE_EN "  "0 ,1 "
bitfld.long 0 9. " L2ED2_WAKE_EN "  "0 ,1 "
bitfld.long 0 10. " L2WAKEMODIRQ_WAKE_EN "  "0 ,1 "
bitfld.long 0 11. " L2SHUTDOWNIRQ_WAKE_EN "  "0 ,1 "
;tree.end

base ad:0x17D40118
;tree "WRR_CLEAR"
wgroup 0--3
line.long 0 "WRR_CLEAR"
bitfld.long 0 0. " L1GPT2_WAKE_MASK "  "0 ,1 "
bitfld.long 0 1. " L1GPT1_WAKE_MASK "  "0 ,1 "
bitfld.long 0 2. " L1GPT0_WAKE_MASK "  "0 ,1 "
bitfld.long 0 3. " L1ED1_WAKE_MASK "  "0 ,1 "
bitfld.long 0 4. " L1WAKEMODIRQ_WAKE_MASK "  "0 ,1 "
bitfld.long 0 5. " L1SHUTDOWNIRQ_WAKE_MASK "  "0 ,1 "
bitfld.long 0 6. " L2GPT2_WAKE_MASK "  "0 ,1 "
bitfld.long 0 7. " L2GPT1_WAKE_MASK "  "0 ,1 "
bitfld.long 0 8. " L2GPT0_WAKE_MASK "  "0 ,1 "
bitfld.long 0 9. " L2ED2_WAKE_MASK "  "0 ,1 "
bitfld.long 0 10. " L2WAKEMODIRQ_WAKE_MASK "  "0 ,1 "
bitfld.long 0 11. " L2SHUTDOWNIRQ_WAKE_MASK "  "0 ,1 "
;tree.end

base ad:0x17D4011C
;tree "WRR_TOGGLE"
wgroup 0--3
line.long 0 "WRR_TOGGLE"
bitfld.long 0 0. " L1GPT2_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1GPT1_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1GPT0_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L1ED1_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " L1WAKEMODIRQ_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " L1SHUTDOWNIRQ_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " L2GPT2_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " L2GPT1_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " L2GPT0_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " L2ED2_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " L2WAKEMODIRQ_WAKE_TOGGLE "  "0 ,1 "
bitfld.long 0 11. " L2SHUTDOWNIRQ_WAKE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D40120
;tree "CRR_STATUS"
rgroup 0--3
line.long 0 "CRR_STATUS"
bitfld.long 0 0. " 3GCLKMANUALREQ_EN "  "0 ,1 "
;tree.end

base ad:0x17D40124
;tree "CRR_SET"
wgroup 0--3
line.long 0 "CRR_SET"
bitfld.long 0 0. " 3GCLKMANUALREQ_EN "  "0 ,1 "
;tree.end

base ad:0x17D40128
;tree "CRR_CLEAR"
wgroup 0--3
line.long 0 "CRR_CLEAR"
bitfld.long 0 0. " 3GCLKMANUALREQ_DIS "  "0 ,1 "
;tree.end

base ad:0x17D4012C
;tree "CRR_TOGGLE"
wgroup 0--3
line.long 0 "CRR_TOGGLE"
bitfld.long 0 0. " 3GCLKMANUALREQ_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D40130
;tree "CSR_STATUS"
rgroup 0--3
line.long 0 "CSR_STATUS"
bitfld.long 0 0. " PSSPLLCLKSRCSELECT_3GHF "  "0 ,1 "
bitfld.long 0 1. " 3GPLLCLKSRCSELECT_3GHF "  "0 ,1 "
bitfld.long 0 2. " FDICLKSRCSELECT_3GHF "  "0 ,1 "
;tree.end

base ad:0x17D40134
;tree "CSR_SET"
wgroup 0--3
line.long 0 "CSR_SET"
bitfld.long 0 0. " PSSPLLCLKSRCSELECT_3GHF "  "0 ,1 "
bitfld.long 0 1. " 3GPLLCLKSRCSELECT_3GHF "  "0 ,1 "
bitfld.long 0 2. " FDICLKSRCSELECT_3GHF "  "0 ,1 "
;tree.end

base ad:0x17D40138
;tree "CSR_CLEAR"
wgroup 0--3
line.long 0 "CSR_CLEAR"
bitfld.long 0 0. " PSSPLLCLKSRCSELECT_PSS "  "0 ,1 "
bitfld.long 0 1. " 3GPLLCLKSRCSELECT_PSS "  "0 ,1 "
bitfld.long 0 2. " FDICLKSRCSELECT_PSS "  "0 ,1 "
;tree.end

base ad:0x17D4013C
;tree "CSR_TOGGLE"
wgroup 0--3
line.long 0 "CSR_TOGGLE"
bitfld.long 0 0. " PSSPLLCLKSRCSELECT_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " 3GPLLCLKSRCSELECT_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " FDICLKSRCSELECT_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D40140
;tree "MACR_STATUS"
rgroup 0--3
line.long 0 "MACR_STATUS"
bitfld.long 0 0. " MAIFCLK_EN "  "0 ,1 "
bitfld.long 0 1. " MAIFRESET_RST "  "0 ,1 "
bitfld.long 0 2. " MAIFSTATE_AWAKE "  "0 ,1 "
;tree.end

base ad:0x17D40144
;tree "MACR_SET"
wgroup 0--3
line.long 0 "MACR_SET"
bitfld.long 0 0. " MAIFCLK_EN "  "0 ,1 "
bitfld.long 0 1. " MAIFRESET_RST "  "0 ,1 "
bitfld.long 0 2. " MAIFSTATE_AWAKE "  "0 ,1 "
;tree.end

base ad:0x17D40148
;tree "MACR_CLEAR"
wgroup 0--3
line.long 0 "MACR_CLEAR"
bitfld.long 0 0. " MAIFCLK_DIS "  "0 ,1 "
bitfld.long 0 1. " MAIFRESET_DEFAULT "  "0 ,1 "
bitfld.long 0 2. " MAIFSTATE_ASLEEP "  "0 ,1 "
;tree.end

base ad:0x17D4014C
;tree "MACR_TOGGLE"
wgroup 0--3
line.long 0 "MACR_TOGGLE"
bitfld.long 0 0. " MAIFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " MAIFRESET_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " MAIFSTATE_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17D40400
;tree "WGMIDR"
group 0--3
line.long 0 "WGMIDR"
bitfld.long 0 0.--13. " VCNUM "  " "
bitfld.long 0 0.--4. " VCPR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.word 0 " SYNC1 "
hexfld.word 0 " SYNC0 "
;tree.end

base ad:0x17D40404
;tree "WVCOREVSETXR"
group 0--3
line.long 0 "WVCOREVSETXR"
bitfld.long 0 0. " VOLTAGESEL_ACTIVE "  "0 ,1 "
bitfld.long 0 4. " L1AAVOLTAGE_SHARED "  "0 ,1 "
;tree.end

base ad:0x17D40408
;tree "PDSR"
group 0--3
line.long 0 "PDSR"
bitfld.long 0 0.--1. " PRC_L2STATUS_PDOWNS "  "0 ,1 ,2 ,3 "
bitfld.long 0 1. " PRC_L2STATUS_ACTIVE "  "0 ,1 "
bitfld.long 0 0. " PRC_L2STATUS_PUPS "  "0 ,1 "
bitfld.long 0 2.--3. " PRC_HAMSASTATUS_PDOWNS "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " PRC_HAMSASTATUS_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " PRC_HAMSASTATUS_PUPS "  "0 ,1 "
bitfld.long 0 4.--5. " PRC_CORESTATUS_PDOWNS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " PRC_CORESTATUS_ACTIVE "  "0 ,1 "
bitfld.long 0 4. " PRC_CORESTATUS_PUPS "  "0 ,1 "
bitfld.long 0 12. " L1_WAKEUP_STATUS_HOSTACCESSREQ "  "0 ,1 "
bitfld.long 0 11. " L1_WAKEUP_STATUS_SDOWNIRQ "  "0 ,1 "
bitfld.long 0 10. " L1_WAKEUP_STATUS_WAKEIRQ "  "0 ,1 "
bitfld.long 0 9. " L1_WAKEUP_STATUS_ED2 "  "0 ,1 "
bitfld.long 0 8. " L1_WAKEUP_STATUS_GPT0 "  "0 ,1 "
bitfld.long 0 7. " L1_WAKEUP_STATUS_GPT1 "  "0 ,1 "
bitfld.long 0 6. " L1_WAKEUP_STATUS_GPT2 "  "0 ,1 "
bitfld.long 0 19. " L2_WAKEUP_STATUS_HOSTACCESSREQ "  "0 ,1 "
bitfld.long 0 18. " L2_WAKEUP_STATUS_SDOWNIRQ "  "0 ,1 "
bitfld.long 0 17. " L2_WAKEUP_STATUS_WAKEIRQ "  "0 ,1 "
bitfld.long 0 16. " L2_WAKEUP_STATUS_ED2 "  "0 ,1 "
bitfld.long 0 15. " L2_WAKEUP_STATUS_GPT0 "  "0 ,1 "
bitfld.long 0 14. " L2_WAKEUP_STATUS_GPT1 "  "0 ,1 "
bitfld.long 0 13. " L2_WAKEUP_STATUS_GPT2 "  "0 ,1 "
;tree.end

base ad:0x17D40410
;tree "CCR_STATUS"
rgroup 0--3
line.long 0 "CCR_STATUS"
bitfld.long 0 0. " L1HALTREL_REL "  "0 ,1 "
bitfld.long 0 1. " L2HALTREL_REL "  "0 ,1 "
;tree.end

base ad:0x17D40414
;tree "CCR_SET"
wgroup 0--3
line.long 0 "CCR_SET"
bitfld.long 0 0. " L1HALTREL_REL "  "0 ,1 "
bitfld.long 0 1. " L2HALTREL_REL "  "0 ,1 "
;tree.end

base ad:0x17D40418
;tree "CCR_CLEAR"
wgroup 0--3
line.long 0 "CCR_CLEAR"
bitfld.long 0 0. " L1HALTREL_HALT "  "0 ,1 "
bitfld.long 0 1. " L2HALTREL_HALT "  "0 ,1 "
;tree.end

base ad:0x17D4041C
;tree "CCR_TOGGLE"
wgroup 0--3
line.long 0 "CCR_TOGGLE"
bitfld.long 0 0. " L1HALTREL_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2HALTREL_TOGGLE "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "SCU_CD_A9"
;==============================================================
base ad:0xB7C40000
;tree "SCUCDIDR"
group 0--3
line.long 0 "SCUCDIDR"
bitfld.long 0 0.--13. " VCNUM "  " "
bitfld.long 0 0.--4. " VCPR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.word 0 " SYNC1 "
hexfld.word 0 " SYNC0 "
;tree.end

base ad:0xB7C40004
;tree "L1CDR"
group 0--3
line.long 0 "L1CDR"
bitfld.long 0 1. " L1MASTERDIV_4 "  "0 ,1 "
bitfld.long 0 0. " L1MASTERDIV_2 "  "0 ,1 "
bitfld.long 0 3. " L1SYSTEMDIV_4 "  "0 ,1 "
bitfld.long 0 2. " L1SYSTEMDIV_2 "  "0 ,1 "
bitfld.long 0 4.--5. " L1SLOWSYSTEMDIV_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " L1SLOWSYSTEMDIV_4 "  "0 ,1 "
bitfld.long 0 4. " L1SLOWSYSTEMDIV_2 "  "0 ,1 "
bitfld.long 0 6.--7. " FDICLKDIV_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " FDICLKDIV_4 "  "0 ,1 "
bitfld.long 0 6. " FDICLKDIV_2 "  "0 ,1 "
bitfld.long 0 8.--10. " GSMFASTCLKDIV_8 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " GSMFASTCLKDIV_6 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " GSMFASTCLKDIV_5 "  "0 ,1 "
bitfld.long 0 8.--10. " GSMFASTCLKDIV_4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9. " GSMFASTCLKDIV_3 "  "0 ,1 "
bitfld.long 0 8. " GSMFASTCLKDIV_2 "  "0 ,1 "
;tree.end

base ad:0xB7C40008
;tree "L2CDR"
group 0--3
line.long 0 "L2CDR"
bitfld.long 0 1. " L2MASTERDIV_4 "  "0 ,1 "
bitfld.long 0 0. " L2MASTERDIV_2 "  "0 ,1 "
bitfld.long 0 3. " L2SYSTEMDIV_4 "  "0 ,1 "
bitfld.long 0 2. " L2SYSTEMDIV_2 "  "0 ,1 "
bitfld.long 0 4.--5. " L2SLOWSYSTEMDIV_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " L2SLOWSYSTEMDIV_4 "  "0 ,1 "
bitfld.long 0 4. " L2SLOWSYSTEMDIV_2 "  "0 ,1 "
;tree.end

base ad:0xB7C4000C
;tree "CSCDR"
group 0--3
line.long 0 "CSCDR"
bitfld.long 0 1. " CORECLKDIV_4 "  "0 ,1 "
bitfld.long 0 0. " CORECLKDIV_2 "  "0 ,1 "
bitfld.long 0 2. " TRACEX2DIV_2 "  "0 ,1 "
bitfld.long 0 5. " TRACEDIV_4 "  "0 ,1 "
bitfld.long 0 4. " TRACEDIV_2 "  "0 ,1 "
bitfld.long 0 6.--7. " TRACECONFIGDIV_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " TRACECONFIGDIV_4 "  "0 ,1 "
bitfld.long 0 6. " TRACECONFIGDIV_2 "  "0 ,1 "
bitfld.long 0 8.--9. " CORERFDIVCLKDIV_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 9. " CORERFDIVCLKDIV_4 "  "0 ,1 "
bitfld.long 0 8. " CORERFDIVCLKDIV_2 "  "0 ,1 "
bitfld.long 0 11. " CORERFDIVCLKDIV_4 "  "0 ,1 "
bitfld.long 0 10. " CORERFDIVCLKDIV_2 "  "0 ,1 "
;tree.end

base ad:0xB7C40010
;tree "HCDR"
group 0--3
line.long 0 "HCDR"
bitfld.long 0 0.--1. " 3GHFCLKDIV_4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 1. " 3GHFCLKDIV_3 "  "0 ,1 "
bitfld.long 0 0. " 3GHFCLKDIV_2 "  "0 ,1 "
bitfld.long 0 2.--3. " SEAHFCLK_4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SEAHFCLK_3 "  "0 ,1 "
bitfld.long 0 2. " SEAHFCLK_2 "  "0 ,1 "
;tree.end

base ad:0xB7C40014
;tree "RCDR"
group 0--3
line.long 0 "RCDR"
bitfld.long 0 2. " DIVRFDIV_16 "  "0 ,1 "
bitfld.long 0 0.--1. " DIVRFDIV_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 1. " DIVRFDIV_4 "  "0 ,1 "
bitfld.long 0 0. " DIVRFDIV_2 "  "0 ,1 "
;tree.end

base ad:0xB7C40018
;tree "CCMSR"
rgroup 0--3
line.long 0 "CCMSR"
bitfld.long 0 0. " L1_SS_IDLE "  "0 ,1 "
bitfld.long 0 1. " L2_SS_IDLE "  "0 ,1 "
bitfld.long 0 2. " PSS_PLL_OK "  "0 ,1 "
bitfld.long 0 3. " 3G_PLL_OK "  "0 ,1 "
bitfld.long 0 4. " MEM_PLL_OK "  "0 ,1 "
bitfld.long 0 5. " WGM_PSS_CLK_OK "  "0 ,1 "
bitfld.long 0 6. " WGM_3GHF_CLK_OK "  "0 ,1 "
bitfld.long 0 7. " WGM_MEMIF_CLK_OK "  "0 ,1 "
bitfld.long 0 10. " L1_SS_CLK_SOURCE_RFSYSCLK "  "0 ,1 "
bitfld.long 0 8. " L1_SS_CLK_SOURCE_3GHFPLL "  "0 ,1 "
bitfld.long 0 12. " L2_SS_CLK_SOURCE_RFSYSCLK "  "0 ,1 "
bitfld.long 0 11. " L2_SS_CLK_SOURCE_3GHFPLL "  "0 ,1 "
bitfld.long 0 14. " TRACE_CLK_SOURCE_RFSYSCLK "  "0 ,1 "
bitfld.long 0 13. " TRACE_CLK_SOURCE_3GHFPLL "  "0 ,1 "
bitfld.long 0 15. " 3G_SS_CLK_SOURCE_PSSPLL "  "0 ,1 "
bitfld.long 0 19. " CORE_SS_IDLE "  "0 ,1 "
bitfld.long 0 22. " FDI_CLK_SOURCE_RFSYSCLK "  "0 ,1 "
bitfld.long 0 21. " FDI_CLK_SOURCE_EXTRFBB "  "0 ,1 "
bitfld.long 0 20. " FDI_CLK_SOURCE_3GHFPLL "  "0 ,1 "
bitfld.long 0 23. " WGM_MEMIF_ACCESS_OK "  "0 ,1 "
;tree.end

base ad:0xB7C40020
;tree "L1CGCR_STATUS"
rgroup 0--3
line.long 0 "L1CGCR_STATUS"
bitfld.long 0 0. " L1CPUCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 1. " L1SYSCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 2. " L1SLOWCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 3. " L1RFCLK_EN "  "0 ,1 "
bitfld.long 0 4. " L1FDICLK_EN "  "0 ,1 "
bitfld.long 0 5. " GSMHFCLK_EN "  "0 ,1 "
bitfld.long 0 7. " CDFEMAINCLK_EN "  "0 ,1 "
bitfld.long 0 8. " GSMRFCLK_EN "  "0 ,1 "
bitfld.long 0 9. " GSM38M4CLK_EN "  "0 ,1 "
bitfld.long 0 10. " GSM19M2CLK_EN "  "0 ,1 "
;tree.end

base ad:0xB7C40024
;tree "L1CGCR_SET"
wgroup 0--3
line.long 0 "L1CGCR_SET"
bitfld.long 0 0. " L1CPUCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 1. " L1SYSCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 2. " L1SLOWCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 3. " L1RFCLK_EN "  "0 ,1 "
bitfld.long 0 4. " L1FDICLK_EN "  "0 ,1 "
bitfld.long 0 5. " GSMHFCLK_EN "  "0 ,1 "
bitfld.long 0 7. " CDFEMAINCLK_EN "  "0 ,1 "
bitfld.long 0 8. " GSMRFCLK_EN "  "0 ,1 "
bitfld.long 0 9. " GSM38M4CLK_EN "  "0 ,1 "
bitfld.long 0 10. " GSM19M2CLK_EN "  "0 ,1 "
;tree.end

base ad:0xB7C40028
;tree "L1CGCR_CLEAR"
wgroup 0--3
line.long 0 "L1CGCR_CLEAR"
bitfld.long 0 0. " L1CPUCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 1. " L1SYSCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 2. " L1SLOWCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 3. " L1RFCLK_DIS "  "0 ,1 "
bitfld.long 0 4. " L1FDICLK_DIS "  "0 ,1 "
bitfld.long 0 5. " GSMHFCLK_DIS "  "0 ,1 "
bitfld.long 0 7. " CDFEMAINCLK_DIS "  "0 ,1 "
bitfld.long 0 8. " GSMRFCLK_DIS "  "0 ,1 "
bitfld.long 0 9. " GSM38M4CLK_DIS "  "0 ,1 "
bitfld.long 0 10. " GSM19M2CLK_DIS "  "0 ,1 "
;tree.end

base ad:0xB7C4002C
;tree "L1CGCR_TOGGLE"
wgroup 0--3
line.long 0 "L1CGCR_TOGGLE"
bitfld.long 0 0. " L1CPUCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1SYSCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1SLOWCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L1RFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " L1FDICLK_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " GSMHFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " CDFEMAINCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " GSMRFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " GSM38M4CLK_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " GSM19M2CLK_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7C40030
;tree "L2CGCR_STATUS"
rgroup 0--3
line.long 0 "L2CGCR_STATUS"
bitfld.long 0 0. " L2CPUCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 1. " L2SYSCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 2. " L2SLOWCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 3. " L2RFCLK_EN "  "0 ,1 "
;tree.end

base ad:0xB7C40034
;tree "L2CGCR_SET"
wgroup 0--3
line.long 0 "L2CGCR_SET"
bitfld.long 0 0. " L2CPUCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 1. " L2SYSCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 2. " L2SLOWCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 3. " L2RFCLK_EN "  "0 ,1 "
;tree.end

base ad:0xB7C40038
;tree "L2CGCR_CLEAR"
wgroup 0--3
line.long 0 "L2CGCR_CLEAR"
bitfld.long 0 0. " L2CPUCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 1. " L2SYSCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 2. " L2SLOWCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 3. " L2RFCLK_DIS "  "0 ,1 "
;tree.end

base ad:0xB7C4003C
;tree "L2CGCR_TOGGLE"
wgroup 0--3
line.long 0 "L2CGCR_TOGGLE"
bitfld.long 0 0. " L2CPUCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2SYSCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L2SLOWCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L2RFCLK_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7C40040
;tree "CSCGCR_STATUS"
rgroup 0--3
line.long 0 "CSCGCR_STATUS"
bitfld.long 0 0. " CORECLK_EN "  "0 ,1 "
bitfld.long 0 1. " TRACECLK_EN "  "0 ,1 "
bitfld.long 0 2. " TRACECFGCLK_EN "  "0 ,1 "
bitfld.long 0 3. " CORERFBUSCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 4. " CORERFCLK_EN "  "0 ,1 "
bitfld.long 0 5. " COREDIVRFCLK_EN "  "0 ,1 "
bitfld.long 0 6. " XTICLK_EN "  "0 ,1 "
bitfld.long 0 7. " RFIF_CD38M4CLK_EN "  "0 ,1 "
bitfld.long 0 8. " TRACEX2CLK_EN "  "0 ,1 "
;tree.end

base ad:0xB7C40044
;tree "CSCGCR_SET"
wgroup 0--3
line.long 0 "CSCGCR_SET"
bitfld.long 0 0. " CORECLK_EN "  "0 ,1 "
bitfld.long 0 1. " TRACECLK_EN "  "0 ,1 "
bitfld.long 0 2. " TRACECFGCLK_EN "  "0 ,1 "
bitfld.long 0 3. " CORERFBUSCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 4. " CORERFCLK_EN "  "0 ,1 "
bitfld.long 0 5. " COREDIVRFCLK_EN "  "0 ,1 "
bitfld.long 0 6. " XTICLK_EN "  "0 ,1 "
bitfld.long 0 7. " RFIF_CD38M4CLK_EN "  "0 ,1 "
bitfld.long 0 8. " TRACEX2CLK_EN "  "0 ,1 "
;tree.end

base ad:0xB7C40048
;tree "CSCGCR_CLEAR"
wgroup 0--3
line.long 0 "CSCGCR_CLEAR"
bitfld.long 0 0. " CORECLK_DIS "  "0 ,1 "
bitfld.long 0 1. " TRACECLK_DIS "  "0 ,1 "
bitfld.long 0 2. " TRACECFGCLK_DIS "  "0 ,1 "
bitfld.long 0 3. " CORERFBUSCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 4. " CORERFCLK_DIS "  "0 ,1 "
bitfld.long 0 5. " COREDIVRFCLK_DIS "  "0 ,1 "
bitfld.long 0 6. " XTICLK_DIS "  "0 ,1 "
bitfld.long 0 7. " RFIF_CD38M4CLK_DIS "  "0 ,1 "
bitfld.long 0 8. " TRACEX2CLK_DIS "  "0 ,1 "
;tree.end

base ad:0xB7C4004C
;tree "CSCGCR_TOGGLE"
wgroup 0--3
line.long 0 "CSCGCR_TOGGLE"
bitfld.long 0 0. " CORECLK_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " TRACECLK_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " TRACECFGCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " CORERFBUSCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " CORERFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " COREDIVRFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " XTICLK_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " RFIF_CD38M4CLK_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " TRACEX2CLK_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7C40050
;tree "HCGCR_STATUS"
rgroup 0--3
line.long 0 "HCGCR_STATUS"
bitfld.long 0 0. " 3GHFCLK_EN "  "0 ,1 "
bitfld.long 0 1. " 3GHFDIV2CLK_EN "  "0 ,1 "
bitfld.long 0 2. " 3GSEAHFCLK_EN "  "0 ,1 "
bitfld.long 0 3. " 3G38M4CLK_EN "  "0 ,1 "
bitfld.long 0 4. " 3G19M2CLK_EN "  "0 ,1 "
;tree.end

base ad:0xB7C40054
;tree "HCGCR_SET"
wgroup 0--3
line.long 0 "HCGCR_SET"
bitfld.long 0 0. " 3GHFCLK_EN "  "0 ,1 "
bitfld.long 0 1. " 3GHFDIV2CLK_EN "  "0 ,1 "
bitfld.long 0 2. " 3GSEAHFCLK_EN "  "0 ,1 "
bitfld.long 0 3. " 3G38M4CLK_EN "  "0 ,1 "
bitfld.long 0 4. " 3G19M2CLK_EN "  "0 ,1 "
;tree.end

base ad:0xB7C40058
;tree "HCGCR_CLEAR"
wgroup 0--3
line.long 0 "HCGCR_CLEAR"
bitfld.long 0 0. " 3GHFCLK_DIS "  "0 ,1 "
bitfld.long 0 1. " 3GHFDIV2CLK_DIS "  "0 ,1 "
bitfld.long 0 2. " 3GSEAHFCLK_DIS "  "0 ,1 "
bitfld.long 0 3. " 3G38M4CLK_DIS "  "0 ,1 "
bitfld.long 0 4. " 3G19M2CLK_DIS "  "0 ,1 "
;tree.end

base ad:0xB7C4005C
;tree "HCGCR_TOGGLE"
wgroup 0--3
line.long 0 "HCGCR_TOGGLE"
bitfld.long 0 0. " 3GHFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " 3GHFDIV2CLK_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " 3GSEAHFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " 3G38M4CLK_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " 3G19M2CLK_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7C40060
;tree "SCSR_STATUS"
rgroup 0--3
line.long 0 "SCSR_STATUS"
bitfld.long 0 0. " L1SLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 1. " L2SLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 2. " TRACESLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 3. " MEMIFSLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 4. " FORCE_MEMIF_CLKOK_EN "  "0 ,1 "
bitfld.long 0 5. " FORCE_WGM_MEMIF_ACCESSOK_EN "  "0 ,1 "
bitfld.long 0 6. " FDISLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 7. " L1FORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 8. " L2FORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 9. " TRACEFORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 10. " MEMIFFORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 11. " FDIFORCESLOWCLK_EN "  "0 ,1 "
;tree.end

base ad:0xB7C40064
;tree "SCSR_SET"
wgroup 0--3
line.long 0 "SCSR_SET"
bitfld.long 0 0. " L1SLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 1. " L2SLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 2. " TRACESLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 3. " MEMIFSLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 4. " FORCE_MEMIF_CLKOK_EN "  "0 ,1 "
bitfld.long 0 5. " FORCE_WGM_MEMIF_ACCESSOK_EN "  "0 ,1 "
bitfld.long 0 6. " FDISLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 7. " L1FORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 8. " L2FORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 9. " TRACEFORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 10. " MEMIFFORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 11. " FDIFORCESLOWCLK_EN "  "0 ,1 "
;tree.end

base ad:0xB7C40068
;tree "SCSR_CLEAR"
wgroup 0--3
line.long 0 "SCSR_CLEAR"
bitfld.long 0 0. " L1SLOWCLKONIDLE_DIS "  "0 ,1 "
bitfld.long 0 1. " L2SLOWCLKONIDLE_DIS "  "0 ,1 "
bitfld.long 0 2. " TRACESLOWCLKONIDLE_DIS "  "0 ,1 "
bitfld.long 0 3. " MEMIFSLOWCLKONIDLE_DIS "  "0 ,1 "
bitfld.long 0 4. " FORCE_MEMIF_CLKOK_DEFAULT "  "0 ,1 "
bitfld.long 0 5. " FORCE_WGM_MEMIF_ACCESSOK_DEFAULT "  "0 ,1 "
bitfld.long 0 6. " FDISLOWCLKONIDLE_DIS "  "0 ,1 "
bitfld.long 0 7. " L1FORCESLOWCLK_DEFAULT "  "0 ,1 "
bitfld.long 0 8. " L2FORCESLOWCLK_DEFAULT "  "0 ,1 "
bitfld.long 0 9. " TRACEFORCESLOWCLK_DEFAULT "  "0 ,1 "
bitfld.long 0 10. " MEMIFFORCESLOWCLK_DEFAULT "  "0 ,1 "
bitfld.long 0 11. " FDIFORCESLOWCLK_DEFAULT "  "0 ,1 "
;tree.end

base ad:0xB7C4006C
;tree "SCSR_TOGGLE"
wgroup 0--3
line.long 0 "SCSR_TOGGLE"
bitfld.long 0 0. " L1SLOWCLKONIDLE_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2SLOWCLKONIDLE_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " TRACESLOWCLKONIDLE_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " MEMIFSLOWCLKONIDLE_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_MEMIF_CLKOK_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " FORCE_WGM_MEMIF_ACCESSOK_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " FDISLOWCLKONIDLE_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " L1FORCESLOWCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " L2FORCESLOWCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " TRACEFORCESLOWCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " MEMIFFORCESLOWCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 11. " FDIFORCESLOWCLK_TOGGLE "  "0 ,1 "
;tree.end

base ad:0xB7C40070
;tree "CDCCR_STATUS"
rgroup 0--3
line.long 0 "CDCCR_STATUS"
bitfld.long 0 0. " L1FORCEMEMOFFLINE_EN "  "0 ,1 "
bitfld.long 0 1. " L2FORCEMEMOFFLINE_EN "  "0 ,1 "
;tree.end

base ad:0xB7C40074
;tree "CDCCR_SET"
wgroup 0--3
line.long 0 "CDCCR_SET"
bitfld.long 0 0. " L1FORCEMEMOFFLINE_EN "  "0 ,1 "
bitfld.long 0 1. " L2FORCEMEMOFFLINE_EN "  "0 ,1 "
;tree.end

base ad:0xB7C40078
;tree "CDCCR_CLEAR"
wgroup 0--3
line.long 0 "CDCCR_CLEAR"
bitfld.long 0 0. " L1FORCEMEMOFFLINE_DIS "  "0 ,1 "
bitfld.long 0 1. " L2FORCEMEMOFFLINE_DIS "  "0 ,1 "
;tree.end

base ad:0xB7C4007C
;tree "CDCCR_TOGGLE"
wgroup 0--3
line.long 0 "CDCCR_TOGGLE"
bitfld.long 0 0. " L1FORCEMEMOFFLINE_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2FORCEMEMOFFLINE_TOGGLE "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "SCU_CD_R4"
;==============================================================
base ad:0x17C40000
;tree "SCUCDIDR"
group 0--3
line.long 0 "SCUCDIDR"
bitfld.long 0 0.--13. " VCNUM "  " "
bitfld.long 0 0.--4. " VCPR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.word 0 " SYNC1 "
hexfld.word 0 " SYNC0 "
;tree.end

base ad:0x17C40004
;tree "L1CDR"
group 0--3
line.long 0 "L1CDR"
bitfld.long 0 1. " L1MASTERDIV_4 "  "0 ,1 "
bitfld.long 0 0. " L1MASTERDIV_2 "  "0 ,1 "
bitfld.long 0 3. " L1SYSTEMDIV_4 "  "0 ,1 "
bitfld.long 0 2. " L1SYSTEMDIV_2 "  "0 ,1 "
bitfld.long 0 4.--5. " L1SLOWSYSTEMDIV_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " L1SLOWSYSTEMDIV_4 "  "0 ,1 "
bitfld.long 0 4. " L1SLOWSYSTEMDIV_2 "  "0 ,1 "
bitfld.long 0 6.--7. " FDICLKDIV_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " FDICLKDIV_4 "  "0 ,1 "
bitfld.long 0 6. " FDICLKDIV_2 "  "0 ,1 "
bitfld.long 0 8.--10. " GSMFASTCLKDIV_8 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " GSMFASTCLKDIV_6 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " GSMFASTCLKDIV_5 "  "0 ,1 "
bitfld.long 0 8.--10. " GSMFASTCLKDIV_4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9. " GSMFASTCLKDIV_3 "  "0 ,1 "
bitfld.long 0 8. " GSMFASTCLKDIV_2 "  "0 ,1 "
;tree.end

base ad:0x17C40008
;tree "L2CDR"
group 0--3
line.long 0 "L2CDR"
bitfld.long 0 1. " L2MASTERDIV_4 "  "0 ,1 "
bitfld.long 0 0. " L2MASTERDIV_2 "  "0 ,1 "
bitfld.long 0 3. " L2SYSTEMDIV_4 "  "0 ,1 "
bitfld.long 0 2. " L2SYSTEMDIV_2 "  "0 ,1 "
bitfld.long 0 4.--5. " L2SLOWSYSTEMDIV_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " L2SLOWSYSTEMDIV_4 "  "0 ,1 "
bitfld.long 0 4. " L2SLOWSYSTEMDIV_2 "  "0 ,1 "
;tree.end

base ad:0x17C4000C
;tree "CSCDR"
group 0--3
line.long 0 "CSCDR"
bitfld.long 0 1. " CORECLKDIV_4 "  "0 ,1 "
bitfld.long 0 0. " CORECLKDIV_2 "  "0 ,1 "
bitfld.long 0 2. " TRACEX2DIV_2 "  "0 ,1 "
bitfld.long 0 5. " TRACEDIV_4 "  "0 ,1 "
bitfld.long 0 4. " TRACEDIV_2 "  "0 ,1 "
bitfld.long 0 6.--7. " TRACECONFIGDIV_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " TRACECONFIGDIV_4 "  "0 ,1 "
bitfld.long 0 6. " TRACECONFIGDIV_2 "  "0 ,1 "
bitfld.long 0 8.--9. " CORERFDIVCLKDIV_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 9. " CORERFDIVCLKDIV_4 "  "0 ,1 "
bitfld.long 0 8. " CORERFDIVCLKDIV_2 "  "0 ,1 "
bitfld.long 0 11. " CORERFDIVCLKDIV_4 "  "0 ,1 "
bitfld.long 0 10. " CORERFDIVCLKDIV_2 "  "0 ,1 "
;tree.end

base ad:0x17C40010
;tree "HCDR"
group 0--3
line.long 0 "HCDR"
bitfld.long 0 0.--1. " 3GHFCLKDIV_4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 1. " 3GHFCLKDIV_3 "  "0 ,1 "
bitfld.long 0 0. " 3GHFCLKDIV_2 "  "0 ,1 "
bitfld.long 0 2.--3. " SEAHFCLK_4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SEAHFCLK_3 "  "0 ,1 "
bitfld.long 0 2. " SEAHFCLK_2 "  "0 ,1 "
;tree.end

base ad:0x17C40014
;tree "RCDR"
group 0--3
line.long 0 "RCDR"
bitfld.long 0 2. " DIVRFDIV_16 "  "0 ,1 "
bitfld.long 0 0.--1. " DIVRFDIV_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 1. " DIVRFDIV_4 "  "0 ,1 "
bitfld.long 0 0. " DIVRFDIV_2 "  "0 ,1 "
;tree.end

base ad:0x17C40018
;tree "CCMSR"
rgroup 0--3
line.long 0 "CCMSR"
bitfld.long 0 0. " L1_SS_IDLE "  "0 ,1 "
bitfld.long 0 1. " L2_SS_IDLE "  "0 ,1 "
bitfld.long 0 2. " PSS_PLL_OK "  "0 ,1 "
bitfld.long 0 3. " 3G_PLL_OK "  "0 ,1 "
bitfld.long 0 4. " MEM_PLL_OK "  "0 ,1 "
bitfld.long 0 5. " WGM_PSS_CLK_OK "  "0 ,1 "
bitfld.long 0 6. " WGM_3GHF_CLK_OK "  "0 ,1 "
bitfld.long 0 7. " WGM_MEMIF_CLK_OK "  "0 ,1 "
bitfld.long 0 10. " L1_SS_CLK_SOURCE_RFSYSCLK "  "0 ,1 "
bitfld.long 0 8. " L1_SS_CLK_SOURCE_3GHFPLL "  "0 ,1 "
bitfld.long 0 12. " L2_SS_CLK_SOURCE_RFSYSCLK "  "0 ,1 "
bitfld.long 0 11. " L2_SS_CLK_SOURCE_3GHFPLL "  "0 ,1 "
bitfld.long 0 14. " TRACE_CLK_SOURCE_RFSYSCLK "  "0 ,1 "
bitfld.long 0 13. " TRACE_CLK_SOURCE_3GHFPLL "  "0 ,1 "
bitfld.long 0 15. " 3G_SS_CLK_SOURCE_PSSPLL "  "0 ,1 "
bitfld.long 0 19. " CORE_SS_IDLE "  "0 ,1 "
bitfld.long 0 22. " FDI_CLK_SOURCE_RFSYSCLK "  "0 ,1 "
bitfld.long 0 21. " FDI_CLK_SOURCE_EXTRFBB "  "0 ,1 "
bitfld.long 0 20. " FDI_CLK_SOURCE_3GHFPLL "  "0 ,1 "
bitfld.long 0 23. " WGM_MEMIF_ACCESS_OK "  "0 ,1 "
;tree.end

base ad:0x17C40020
;tree "L1CGCR_STATUS"
rgroup 0--3
line.long 0 "L1CGCR_STATUS"
bitfld.long 0 0. " L1CPUCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 1. " L1SYSCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 2. " L1SLOWCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 3. " L1RFCLK_EN "  "0 ,1 "
bitfld.long 0 4. " L1FDICLK_EN "  "0 ,1 "
bitfld.long 0 5. " GSMHFCLK_EN "  "0 ,1 "
bitfld.long 0 7. " CDFEMAINCLK_EN "  "0 ,1 "
bitfld.long 0 8. " GSMRFCLK_EN "  "0 ,1 "
bitfld.long 0 9. " GSM38M4CLK_EN "  "0 ,1 "
bitfld.long 0 10. " GSM19M2CLK_EN "  "0 ,1 "
;tree.end

base ad:0x17C40024
;tree "L1CGCR_SET"
wgroup 0--3
line.long 0 "L1CGCR_SET"
bitfld.long 0 0. " L1CPUCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 1. " L1SYSCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 2. " L1SLOWCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 3. " L1RFCLK_EN "  "0 ,1 "
bitfld.long 0 4. " L1FDICLK_EN "  "0 ,1 "
bitfld.long 0 5. " GSMHFCLK_EN "  "0 ,1 "
bitfld.long 0 7. " CDFEMAINCLK_EN "  "0 ,1 "
bitfld.long 0 8. " GSMRFCLK_EN "  "0 ,1 "
bitfld.long 0 9. " GSM38M4CLK_EN "  "0 ,1 "
bitfld.long 0 10. " GSM19M2CLK_EN "  "0 ,1 "
;tree.end

base ad:0x17C40028
;tree "L1CGCR_CLEAR"
wgroup 0--3
line.long 0 "L1CGCR_CLEAR"
bitfld.long 0 0. " L1CPUCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 1. " L1SYSCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 2. " L1SLOWCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 3. " L1RFCLK_DIS "  "0 ,1 "
bitfld.long 0 4. " L1FDICLK_DIS "  "0 ,1 "
bitfld.long 0 5. " GSMHFCLK_DIS "  "0 ,1 "
bitfld.long 0 7. " CDFEMAINCLK_DIS "  "0 ,1 "
bitfld.long 0 8. " GSMRFCLK_DIS "  "0 ,1 "
bitfld.long 0 9. " GSM38M4CLK_DIS "  "0 ,1 "
bitfld.long 0 10. " GSM19M2CLK_DIS "  "0 ,1 "
;tree.end

base ad:0x17C4002C
;tree "L1CGCR_TOGGLE"
wgroup 0--3
line.long 0 "L1CGCR_TOGGLE"
bitfld.long 0 0. " L1CPUCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L1SYSCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L1SLOWCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L1RFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " L1FDICLK_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " GSMHFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " CDFEMAINCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " GSMRFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " GSM38M4CLK_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " GSM19M2CLK_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17C40030
;tree "L2CGCR_STATUS"
rgroup 0--3
line.long 0 "L2CGCR_STATUS"
bitfld.long 0 0. " L2CPUCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 1. " L2SYSCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 2. " L2SLOWCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 3. " L2RFCLK_EN "  "0 ,1 "
;tree.end

base ad:0x17C40034
;tree "L2CGCR_SET"
wgroup 0--3
line.long 0 "L2CGCR_SET"
bitfld.long 0 0. " L2CPUCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 1. " L2SYSCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 2. " L2SLOWCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 3. " L2RFCLK_EN "  "0 ,1 "
;tree.end

base ad:0x17C40038
;tree "L2CGCR_CLEAR"
wgroup 0--3
line.long 0 "L2CGCR_CLEAR"
bitfld.long 0 0. " L2CPUCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 1. " L2SYSCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 2. " L2SLOWCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 3. " L2RFCLK_DIS "  "0 ,1 "
;tree.end

base ad:0x17C4003C
;tree "L2CGCR_TOGGLE"
wgroup 0--3
line.long 0 "L2CGCR_TOGGLE"
bitfld.long 0 0. " L2CPUCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2SYSCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " L2SLOWCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " L2RFCLK_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17C40040
;tree "CSCGCR_STATUS"
rgroup 0--3
line.long 0 "CSCGCR_STATUS"
bitfld.long 0 0. " CORECLK_EN "  "0 ,1 "
bitfld.long 0 1. " TRACECLK_EN "  "0 ,1 "
bitfld.long 0 2. " TRACECFGCLK_EN "  "0 ,1 "
bitfld.long 0 3. " CORERFBUSCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 4. " CORERFCLK_EN "  "0 ,1 "
bitfld.long 0 5. " COREDIVRFCLK_EN "  "0 ,1 "
bitfld.long 0 6. " XTICLK_EN "  "0 ,1 "
bitfld.long 0 7. " RFIF_CD38M4CLK_EN "  "0 ,1 "
bitfld.long 0 8. " TRACEX2CLK_EN "  "0 ,1 "
;tree.end

base ad:0x17C40044
;tree "CSCGCR_SET"
wgroup 0--3
line.long 0 "CSCGCR_SET"
bitfld.long 0 0. " CORECLK_EN "  "0 ,1 "
bitfld.long 0 1. " TRACECLK_EN "  "0 ,1 "
bitfld.long 0 2. " TRACECFGCLK_EN "  "0 ,1 "
bitfld.long 0 3. " CORERFBUSCLKFORCE_EN "  "0 ,1 "
bitfld.long 0 4. " CORERFCLK_EN "  "0 ,1 "
bitfld.long 0 5. " COREDIVRFCLK_EN "  "0 ,1 "
bitfld.long 0 6. " XTICLK_EN "  "0 ,1 "
bitfld.long 0 7. " RFIF_CD38M4CLK_EN "  "0 ,1 "
bitfld.long 0 8. " TRACEX2CLK_EN "  "0 ,1 "
;tree.end

base ad:0x17C40048
;tree "CSCGCR_CLEAR"
wgroup 0--3
line.long 0 "CSCGCR_CLEAR"
bitfld.long 0 0. " CORECLK_DIS "  "0 ,1 "
bitfld.long 0 1. " TRACECLK_DIS "  "0 ,1 "
bitfld.long 0 2. " TRACECFGCLK_DIS "  "0 ,1 "
bitfld.long 0 3. " CORERFBUSCLKFORCE_DEFAULT "  "0 ,1 "
bitfld.long 0 4. " CORERFCLK_DIS "  "0 ,1 "
bitfld.long 0 5. " COREDIVRFCLK_DIS "  "0 ,1 "
bitfld.long 0 6. " XTICLK_DIS "  "0 ,1 "
bitfld.long 0 7. " RFIF_CD38M4CLK_DIS "  "0 ,1 "
bitfld.long 0 8. " TRACEX2CLK_DIS "  "0 ,1 "
;tree.end

base ad:0x17C4004C
;tree "CSCGCR_TOGGLE"
wgroup 0--3
line.long 0 "CSCGCR_TOGGLE"
bitfld.long 0 0. " CORECLK_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " TRACECLK_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " TRACECFGCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " CORERFBUSCLKFORCE_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " CORERFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " COREDIVRFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " XTICLK_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " RFIF_CD38M4CLK_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " TRACEX2CLK_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17C40050
;tree "HCGCR_STATUS"
rgroup 0--3
line.long 0 "HCGCR_STATUS"
bitfld.long 0 0. " 3GHFCLK_EN "  "0 ,1 "
bitfld.long 0 1. " 3GHFDIV2CLK_EN "  "0 ,1 "
bitfld.long 0 2. " 3GSEAHFCLK_EN "  "0 ,1 "
bitfld.long 0 3. " 3G38M4CLK_EN "  "0 ,1 "
bitfld.long 0 4. " 3G19M2CLK_EN "  "0 ,1 "
;tree.end

base ad:0x17C40054
;tree "HCGCR_SET"
wgroup 0--3
line.long 0 "HCGCR_SET"
bitfld.long 0 0. " 3GHFCLK_EN "  "0 ,1 "
bitfld.long 0 1. " 3GHFDIV2CLK_EN "  "0 ,1 "
bitfld.long 0 2. " 3GSEAHFCLK_EN "  "0 ,1 "
bitfld.long 0 3. " 3G38M4CLK_EN "  "0 ,1 "
bitfld.long 0 4. " 3G19M2CLK_EN "  "0 ,1 "
;tree.end

base ad:0x17C40058
;tree "HCGCR_CLEAR"
wgroup 0--3
line.long 0 "HCGCR_CLEAR"
bitfld.long 0 0. " 3GHFCLK_DIS "  "0 ,1 "
bitfld.long 0 1. " 3GHFDIV2CLK_DIS "  "0 ,1 "
bitfld.long 0 2. " 3GSEAHFCLK_DIS "  "0 ,1 "
bitfld.long 0 3. " 3G38M4CLK_DIS "  "0 ,1 "
bitfld.long 0 4. " 3G19M2CLK_DIS "  "0 ,1 "
;tree.end

base ad:0x17C4005C
;tree "HCGCR_TOGGLE"
wgroup 0--3
line.long 0 "HCGCR_TOGGLE"
bitfld.long 0 0. " 3GHFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " 3GHFDIV2CLK_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " 3GSEAHFCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " 3G38M4CLK_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " 3G19M2CLK_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17C40060
;tree "SCSR_STATUS"
rgroup 0--3
line.long 0 "SCSR_STATUS"
bitfld.long 0 0. " L1SLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 1. " L2SLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 2. " TRACESLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 3. " MEMIFSLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 4. " FORCE_MEMIF_CLKOK_EN "  "0 ,1 "
bitfld.long 0 5. " FORCE_WGM_MEMIF_ACCESSOK_EN "  "0 ,1 "
bitfld.long 0 6. " FDISLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 7. " L1FORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 8. " L2FORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 9. " TRACEFORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 10. " MEMIFFORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 11. " FDIFORCESLOWCLK_EN "  "0 ,1 "
;tree.end

base ad:0x17C40064
;tree "SCSR_SET"
wgroup 0--3
line.long 0 "SCSR_SET"
bitfld.long 0 0. " L1SLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 1. " L2SLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 2. " TRACESLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 3. " MEMIFSLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 4. " FORCE_MEMIF_CLKOK_EN "  "0 ,1 "
bitfld.long 0 5. " FORCE_WGM_MEMIF_ACCESSOK_EN "  "0 ,1 "
bitfld.long 0 6. " FDISLOWCLKONIDLE_EN "  "0 ,1 "
bitfld.long 0 7. " L1FORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 8. " L2FORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 9. " TRACEFORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 10. " MEMIFFORCESLOWCLK_EN "  "0 ,1 "
bitfld.long 0 11. " FDIFORCESLOWCLK_EN "  "0 ,1 "
;tree.end

base ad:0x17C40068
;tree "SCSR_CLEAR"
wgroup 0--3
line.long 0 "SCSR_CLEAR"
bitfld.long 0 0. " L1SLOWCLKONIDLE_DIS "  "0 ,1 "
bitfld.long 0 1. " L2SLOWCLKONIDLE_DIS "  "0 ,1 "
bitfld.long 0 2. " TRACESLOWCLKONIDLE_DIS "  "0 ,1 "
bitfld.long 0 3. " MEMIFSLOWCLKONIDLE_DIS "  "0 ,1 "
bitfld.long 0 4. " FORCE_MEMIF_CLKOK_DEFAULT "  "0 ,1 "
bitfld.long 0 5. " FORCE_WGM_MEMIF_ACCESSOK_DEFAULT "  "0 ,1 "
bitfld.long 0 6. " FDISLOWCLKONIDLE_DIS "  "0 ,1 "
bitfld.long 0 7. " L1FORCESLOWCLK_DEFAULT "  "0 ,1 "
bitfld.long 0 8. " L2FORCESLOWCLK_DEFAULT "  "0 ,1 "
bitfld.long 0 9. " TRACEFORCESLOWCLK_DEFAULT "  "0 ,1 "
bitfld.long 0 10. " MEMIFFORCESLOWCLK_DEFAULT "  "0 ,1 "
bitfld.long 0 11. " FDIFORCESLOWCLK_DEFAULT "  "0 ,1 "
;tree.end

base ad:0x17C4006C
;tree "SCSR_TOGGLE"
wgroup 0--3
line.long 0 "SCSR_TOGGLE"
bitfld.long 0 0. " L1SLOWCLKONIDLE_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2SLOWCLKONIDLE_TOGGLE "  "0 ,1 "
bitfld.long 0 2. " TRACESLOWCLKONIDLE_TOGGLE "  "0 ,1 "
bitfld.long 0 3. " MEMIFSLOWCLKONIDLE_TOGGLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_MEMIF_CLKOK_TOGGLE "  "0 ,1 "
bitfld.long 0 5. " FORCE_WGM_MEMIF_ACCESSOK_TOGGLE "  "0 ,1 "
bitfld.long 0 6. " FDISLOWCLKONIDLE_TOGGLE "  "0 ,1 "
bitfld.long 0 7. " L1FORCESLOWCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 8. " L2FORCESLOWCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 9. " TRACEFORCESLOWCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 10. " MEMIFFORCESLOWCLK_TOGGLE "  "0 ,1 "
bitfld.long 0 11. " FDIFORCESLOWCLK_TOGGLE "  "0 ,1 "
;tree.end

base ad:0x17C40070
;tree "CDCCR_STATUS"
rgroup 0--3
line.long 0 "CDCCR_STATUS"
bitfld.long 0 0. " L1FORCEMEMOFFLINE_EN "  "0 ,1 "
bitfld.long 0 1. " L2FORCEMEMOFFLINE_EN "  "0 ,1 "
;tree.end

base ad:0x17C40074
;tree "CDCCR_SET"
wgroup 0--3
line.long 0 "CDCCR_SET"
bitfld.long 0 0. " L1FORCEMEMOFFLINE_EN "  "0 ,1 "
bitfld.long 0 1. " L2FORCEMEMOFFLINE_EN "  "0 ,1 "
;tree.end

base ad:0x17C40078
;tree "CDCCR_CLEAR"
wgroup 0--3
line.long 0 "CDCCR_CLEAR"
bitfld.long 0 0. " L1FORCEMEMOFFLINE_DIS "  "0 ,1 "
bitfld.long 0 1. " L2FORCEMEMOFFLINE_DIS "  "0 ,1 "
;tree.end

base ad:0x17C4007C
;tree "CDCCR_TOGGLE"
wgroup 0--3
line.long 0 "CDCCR_TOGGLE"
bitfld.long 0 0. " L1FORCEMEMOFFLINE_TOGGLE "  "0 ,1 "
bitfld.long 0 1. " L2FORCEMEMOFFLINE_TOGGLE "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "SGA"
;==============================================================
if (((data.long(ad:0x80157014)&0x100)!=0x100)||((data.long(ad:0x8015741c)&0x100)!=0x100)||((data.long(ad:0x801571ec)&0x1)!=0x1)||((data.long(ad:0x80157428)&0x20)!=0x0))

base ad:0x80157014
group 0--3
line.long 0 "PRCM_SGACLK_MGT"
bitfld.long 0 8. " SGACLKEN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 8. " SGA_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 8. " SGA_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "

else

base ad:0xa0300000
;tree "GP2_VSCL_START_ADDR"
group 0--3
line.long 0 "GP2_VSCL_START_ADDR"
bitfld.long 0 3.--31. " VSCL_START "  " "
;tree.end

base ad:0xa0300004
;tree "GP2_VSCL_END_ADDR"
group 0--3
line.long 0 "GP2_VSCL_END_ADDR"
bitfld.long 0 3.--31. " VSCL_END "  " "
;tree.end

base ad:0xa0300008
;tree "GP2_PLBCL_START_ADDR"
group 0--3
line.long 0 "GP2_PLBCL_START_ADDR"
bitfld.long 0 3.--31. " PLBCL_START "  " "
;tree.end

base ad:0xa030000c
;tree "GP2_PLBCL_END_ADDR"
group 0--3
line.long 0 "GP2_PLBCL_END_ADDR"
bitfld.long 0 3.--31. " PLBCL_END "  " "
;tree.end

base ad:0xa0300010
;tree "GP2_PLB_ALLOC_START_ADDR"
group 0--3
line.long 0 "GP2_PLB_ALLOC_START_ADDR"
bitfld.long 0 7.--31. " PLB_ALLOC_START_ADDR "  " "
;tree.end

base ad:0xa0300014
;tree "GP2_PLB_ALLOC_END_ADDR"
group 0--3
line.long 0 "GP2_PLB_ALLOC_END_ADDR"
bitfld.long 0 7.--31. " PLB_ALLOC_END_ADDR "  " "
;tree.end

base ad:0xa0300020
;tree "GP2_CMD"
group 0--3
line.long 0 "GP2_CMD"
bitfld.long 0 0. " START_VS "  "0 ,1 "
bitfld.long 0 1. " START_PLB "  "0 ,1 "
bitfld.long 0 4. " UPDATE_PLB_ALLOC "  "0 ,1 "
bitfld.long 0 5. " RESET "  "0 ,1 "
bitfld.long 0 6. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 7. " FLUSH_CACHE "  "0 ,1 "
bitfld.long 0 8. " START_BUS "  "0 ,1 "
bitfld.long 0 9. " STOP_BUS "  "0 ,1 "
bitfld.long 0 10. " SOFT_RESET "  "0 ,1 "
bitfld.long 0 11. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

base ad:0xa0300024
;tree "GP2_INT_RAWSTAT"
group 0--3
line.long 0 "GP2_INT_RAWSTAT"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
bitfld.long 0 12. " AXI_BUS_STOPPED "  "0 ,1 "
bitfld.long 0 13. " VS_INVALID_CMD "  "0 ,1 "
bitfld.long 0 14. " PLB_INVALID_CMD "  "0 ,1 "
bitfld.long 0 19. " RESET_COMPLETED "  "0 ,1 "
bitfld.long 0 20. " SEMAPHORE_UNDERFLOW "  "0 ,1 "
bitfld.long 0 21. " SEMAPHORE_OVERFLOW "  "0 ,1 "
bitfld.long 0 22. " PTR_OUT_OF_BOUNDS "  "0 ,1 "
;tree.end

base ad:0xa0300028
;tree "GP2_INT_CLEAR"
wgroup 0--3
line.long 0 "GP2_INT_CLEAR"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
bitfld.long 0 12. " AXI_BUS_STOPPED "  "0 ,1 "
bitfld.long 0 13. " VS_INVALID_CMD "  "0 ,1 "
bitfld.long 0 14. " PLB_INVALID_CMD "  "0 ,1 "
bitfld.long 0 19. " RESET_COMPLETED "  "0 ,1 "
bitfld.long 0 20. " SEMAPHORE_UNDERFLOW "  "0 ,1 "
bitfld.long 0 21. " SEMAPHORE_OVERFLOW "  "0 ,1 "
bitfld.long 0 22. " PTR_OUT_OF_BOUNDS "  "0 ,1 "
;tree.end

base ad:0xa030002c
;tree "GP2_INT_MASK"
group 0--3
line.long 0 "GP2_INT_MASK"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
bitfld.long 0 12. " AXI_BUS_STOPPED "  "0 ,1 "
bitfld.long 0 13. " VS_INVALID_CMD "  "0 ,1 "
bitfld.long 0 14. " PLB_INVALID_CMD "  "0 ,1 "
bitfld.long 0 19. " RESET_COMPLETED "  "0 ,1 "
bitfld.long 0 20. " SEMAPHORE_UNDERFLOW "  "0 ,1 "
bitfld.long 0 21. " SEMAPHORE_OVERFLOW "  "0 ,1 "
bitfld.long 0 22. " PTR_OUT_OF_BOUNDS "  "0 ,1 "
;tree.end

base ad:0xa0300030
;tree "GP2_INT_STAT"
rgroup 0--3
line.long 0 "GP2_INT_STAT"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
bitfld.long 0 12. " AXI_BUS_STOPPED "  "0 ,1 "
bitfld.long 0 13. " VS_INVALID_CMD "  "0 ,1 "
bitfld.long 0 14. " PLB_INVALID_CMD "  "0 ,1 "
bitfld.long 0 19. " RESET_COMPLETED "  "0 ,1 "
bitfld.long 0 20. " SEMAPHORE_UNDERFLOW "  "0 ,1 "
bitfld.long 0 21. " SEMAPHORE_OVERFLOW "  "0 ,1 "
bitfld.long 0 22. " PTR_OUT_OF_BOUNDS "  "0 ,1 "
;tree.end

base ad:0xa0300034
;tree "GP2_WRITE_BOUNDARY_LOW"
group 0--3
line.long 0 "GP2_WRITE_BOUNDARY_LOW"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_LOW "  " "
;tree.end

base ad:0xa0300038
;tree "GP2_WRITE_BOUNDARY_HIGH"
group 0--3
line.long 0 "GP2_WRITE_BOUNDARY_HIGH"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_HIGH "  " "
;tree.end

base ad:0xa030003c
;tree "GP2_PERF_CNT_0_ENABLE"
group 0--3
line.long 0 "GP2_PERF_CNT_0_ENABLE"
bitfld.long 0 0. " PERF_CNT_0_ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0300040
;tree "GP2_PERF_CNT_1_ENABLE"
group 0--3
line.long 0 "GP2_PERF_CNT_1_ENABLE"
bitfld.long 0 0. " PERF_CNT_1_ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0300044
;tree "GP2_PERF_CNT_0_SRC"
group 0--3
line.long 0 "GP2_PERF_CNT_0_SRC"
bitfld.long 0 0.--4. " PERF_CNT_0_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0300048
;tree "GP2_PERF_CNT_1_SRC"
group 0--3
line.long 0 "GP2_PERF_CNT_1_SRC"
bitfld.long 0 0.--4. " PERF_CNT_1_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa030004c
;tree "GP2_PERF_CNT_0_VAL"
rgroup 0--3
line.long 0 "GP2_PERF_CNT_0_VAL"
hexfld.long 0 " PERF_CNT_0_VAL "
;tree.end

base ad:0xa0300050
;tree "GP2_PERF_CNT_1_VAL"
rgroup 0--3
line.long 0 "GP2_PERF_CNT_1_VAL"
hexfld.long 0 " PERF_CNT_1_VAL "
;tree.end

base ad:0xa0300054
;tree "GP2_PERF_CNT_0_LIMIT"
group 0--3
line.long 0 "GP2_PERF_CNT_0_LIMIT"
hexfld.long 0 " PERF_CNT_0_LIMIT "
;tree.end

base ad:0xa0300058
;tree "GP2_PERF_CNT_1_LIMIT"
group 0--3
line.long 0 "GP2_PERF_CNT_1_LIMIT"
hexfld.long 0 " PERF_CNT_1_LIMIT "
;tree.end

base ad:0xa0300068
;tree "GP2_STATUS"
rgroup 0--3
line.long 0 "GP2_STATUS"
bitfld.long 0 0. " IRQ "  "0 ,1 "
bitfld.long 0 1. " VS_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " BUS_STOPPED "  "0 ,1 "
bitfld.long 0 3. " PLB_ACTIVE "  "0 ,1 "
bitfld.long 0 5. " PLB_STALLED "  "0 ,1 "
bitfld.long 0 6. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 7. " HANG "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 9. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

base ad:0xa030006c
;tree "GP2_VERSION"
rgroup 0--3
line.long 0 "GP2_VERSION"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 1 " PRODUCT_ID "
;tree.end

base ad:0xa0300080
;tree "GP2_VSCL_INITIAL_ADDR"
rgroup 0--3
line.long 0 "GP2_VSCL_INITIAL_ADDR"
bitfld.long 0 3.--31. " VSCL_INITIAL_ADDR "  " "
;tree.end

base ad:0xa0300084
;tree "GP2_PLBCL_INITIAL_ADDR"
rgroup 0--3
line.long 0 "GP2_PLBCL_INITIAL_ADDR"
bitfld.long 0 3.--31. " PLBCL_INITIAL_ADDR "  " "
;tree.end

base ad:0xa0300088
;tree "GP2_WRITE_BOUNDARY_ERROR_ADDR"
rgroup 0--3
line.long 0 "GP2_WRITE_BOUNDARY_ERROR_ADDR"
bitfld.long 0 0. " WRITE_BOUNDARY_ERROR_ADDR "  "0 ,1 "
;tree.end

base ad:0xa0300094
;tree "GP2_AXI_BUS_ERROR_STAT"
rgroup 0--3
line.long 0 "GP2_AXI_BUS_ERROR_STAT"
bitfld.long 0 0. " READ_ERROR "  "0 ,1 "
bitfld.long 0 1. " WRITE_ERROR "  "0 ,1 "
bitfld.long 0 2.--5. " READ_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--9. " WRITE_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03000a0
;tree "GP2_WATCHDOG_DISABLE"
group 0--3
line.long 0 "GP2_WATCHDOG_DISABLE"
bitfld.long 0 0. " WATCHDOG_DISABLE "  "0 ,1 "
;tree.end

base ad:0xa03000a4
;tree "GP2_WATCHDOG_TIMEOUT"
group 0--3
line.long 0 "GP2_WATCHDOG_TIMEOUT"
hexfld.long 0 " WATCHDOG_TIMEOUT "
;tree.end

base ad:0xa0301000
;tree "L2_VERSION"
rgroup 0--3
line.long 0 "L2_VERSION"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 1 " PRODUCT_ID "
;tree.end

base ad:0xa0301004
;tree "L2_SIZE"
rgroup 0--3
line.long 0 "L2_SIZE"
hexfld.byte 0 " LINE_SIZE "
hexfld.byte 1 " ASSOCIATIVITY "
hexfld.byte 2 " CACHE8SIZE "
hexfld.byte 3 " EXTERNAL_BUS_WIDTH "
;tree.end

base ad:0xa0301008
;tree "L2_STATUS"
rgroup 0--3
line.long 0 "L2_STATUS"
bitfld.long 0 0. " COMMAND_BUSY "  "0 ,1 "
bitfld.long 0 1. " DATA_BUSY "  "0 ,1 "
;tree.end

base ad:0xa0301010
;tree "L2_COMMAND"
group 0--3
line.long 0 "L2_COMMAND"
bitfld.long 0 0.--2. " COMMAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0301014
;tree "L2_CLEAR_PAGE"
group 0--3
line.long 0 "L2_CLEAR_PAGE"
hexfld.long 0 " CLEAR_PAGE "
;tree.end

base ad:0xa0301018
;tree "L2_MAX_READS"
group 0--3
line.long 0 "L2_MAX_READS"
bitfld.long 0 0.--4. " MAX_READS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa030101c
;tree "L2_ENABLE"
group 0--3
line.long 0 "L2_ENABLE"
bitfld.long 0 0. " PERMIT_CACHEABLE_ACCESSES "  "0 ,1 "
bitfld.long 0 1. " PERMIT_CACHE_READ_ALLOCATE "  "0 ,1 "
;tree.end

base ad:0xa0301020
;tree "L2_PERFCNT_SRC0"
group 0--3
line.long 0 "L2_PERFCNT_SRC0"
bitfld.long 0 0.--6. " PERFCNT_SRC0 "  " "
;tree.end

base ad:0xa0301024
;tree "L2_PERFCNT_VAL0"
group 0--3
line.long 0 "L2_PERFCNT_VAL0"
hexfld.long 0 " PERFCNT_VAL0 "
;tree.end

base ad:0xa0301028
;tree "L2_PERFCNT_SRC1"
group 0--3
line.long 0 "L2_PERFCNT_SRC1"
bitfld.long 0 0.--6. " PERFCNT_SRC1 "  " "
;tree.end

base ad:0xa030102c
;tree "L2_PERFCNT_VAL1"
group 0--3
line.long 0 "L2_PERFCNT_VAL1"
hexfld.long 0 " PERFCNT_VAL1 "
;tree.end

base ad:0xa0303000
;tree "GP_MMU_DTE_ADDR"
group 0--3
line.long 0 "GP_MMU_DTE_ADDR"
bitfld.long 0 0.--19. " DTE_ADDR "  " "
;tree.end

base ad:0xa0303004
;tree "GP_MMU_STATUS"
rgroup 0--3
line.long 0 "GP_MMU_STATUS"
bitfld.long 0 0. " PAGING_ENABLED "  "0 ,1 "
bitfld.long 0 1. " PAGE_FAULT_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " STALL_ACTIVE "  "0 ,1 "
bitfld.long 0 3. " IDLE "  "0 ,1 "
bitfld.long 0 4. " REPLAY_BUFFER_EMPTY "  "0 ,1 "
bitfld.long 0 5. " PAGE_FAULT_IS_WRITE "  "0 ,1 "
bitfld.long 0 6.--10. " PAGE_FAULT_BUS_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0303008
;tree "GP_MMU_COMMAND"
group 0--3
line.long 0 "GP_MMU_COMMAND"
bitfld.long 0 0.--2. " COMMAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa030300c
;tree "GP_MMU_PAGE_FAULT_ADDR"
rgroup 0--3
line.long 0 "GP_MMU_PAGE_FAULT_ADDR"
bitfld.long 0 0. " PAGE_FAULT_ADDR "  "0 ,1 "
;tree.end

base ad:0xa0303010
;tree "GP_MMU_ZAPE_ONE_LINE"
group 0--3
line.long 0 "GP_MMU_ZAPE_ONE_LINE"
bitfld.long 0 0. " ZAPE_ONE_LINE "  "0 ,1 "
;tree.end

base ad:0xa0303014
;tree "GP_MMU_INT_RAWSTAT"
group 0--3
line.long 0 "GP_MMU_INT_RAWSTAT"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0303018
;tree "GP_MMU_INT_CLEAR"
wgroup 0--3
line.long 0 "GP_MMU_INT_CLEAR"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa030301c
;tree "GP_MMU_INT_MASK"
group 0--3
line.long 0 "GP_MMU_INT_MASK"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0303020
;tree "GP_MMU_INT_STATUS"
rgroup 0--3
line.long 0 "GP_MMU_INT_STATUS"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0304000
;tree "PP0_MMU_DTE_ADDR"
group 0--3
line.long 0 "PP0_MMU_DTE_ADDR"
bitfld.long 0 0.--19. " DTE_ADDR "  " "
;tree.end

base ad:0xa0304004
;tree "PP0_MMU_STATUS"
rgroup 0--3
line.long 0 "PP0_MMU_STATUS"
bitfld.long 0 0. " PAGING_ENABLED "  "0 ,1 "
bitfld.long 0 1. " PAGE_FAULT_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " STALL_ACTIVE "  "0 ,1 "
bitfld.long 0 3. " IDLE "  "0 ,1 "
bitfld.long 0 4. " REPLAY_BUFFER_EMPTY "  "0 ,1 "
bitfld.long 0 5. " PAGE_FAULT_IS_WRITE "  "0 ,1 "
bitfld.long 0 6.--10. " PAGE_FAULT_BUS_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xa0304008
;tree "PP0_MMU_COMMAND"
group 0--3
line.long 0 "PP0_MMU_COMMAND"
bitfld.long 0 0.--2. " COMMAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa030400c
;tree "PP0_MMU_PAGE_FAULT_ADDR"
rgroup 0--3
line.long 0 "PP0_MMU_PAGE_FAULT_ADDR"
bitfld.long 0 0. " PAGE_FAULT_ADDR "  "0 ,1 "
;tree.end

base ad:0xa0304010
;tree "PP0_MMU_ZAPE_ONE_LINE"
group 0--3
line.long 0 "PP0_MMU_ZAPE_ONE_LINE"
bitfld.long 0 0. " ZAPE_ONE_LINE "  "0 ,1 "
;tree.end

base ad:0xa0304014
;tree "PP0_MMU_INT_RAWSTAT"
group 0--3
line.long 0 "PP0_MMU_INT_RAWSTAT"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0304018
;tree "PP0_MMU_INT_CLEAR"
wgroup 0--3
line.long 0 "PP0_MMU_INT_CLEAR"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa030401c
;tree "PP0_MMU_INT_MASK"
group 0--3
line.long 0 "PP0_MMU_INT_MASK"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0304020
;tree "PP0_MMU_INT_STATUS"
rgroup 0--3
line.long 0 "PP0_MMU_INT_STATUS"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

base ad:0xa0308000
;tree "REND_LIST_ADDR"
group 0--3
line.long 0 "REND_LIST_ADDR"
bitfld.long 0 3.--31. " REND_LIST_ADDR "  " "
;tree.end

base ad:0xa0308004
;tree "REND_RSW_BASE"
group 0--3
line.long 0 "REND_RSW_BASE"
bitfld.long 0 6.--31. " REND_RSW_BASE "  " "
;tree.end

base ad:0xa0308008
;tree "REND_VERTEX_BASE"
group 0--3
line.long 0 "REND_VERTEX_BASE"
bitfld.long 0 6.--31. " REND_VERTEX_BASE "  " "
;tree.end

base ad:0xa030800c
;tree "FEATURE_ENABLE"
group 0--3
line.long 0 "FEATURE_ENABLE"
bitfld.long 0 0. " FP_TILEBUF_ENABLE "  "0 ,1 "
bitfld.long 0 1. " EARLYZ_ENABLE "  "0 ,1 "
bitfld.long 0 3. " EARLYZ_DISABLE1 "  "0 ,1 "
bitfld.long 0 4. " EARLYZ_DISABLE2 "  "0 ,1 "
bitfld.long 0 5. " ORIGIN_LOWER_LEFT "  "0 ,1 "
bitfld.long 0 6. " SUMMATE_QUAD_COVER "  "0 ,1 "
;tree.end

base ad:0xa0308010
;tree "Z_CLEAR_VALUE"
group 0--3
line.long 0 "Z_CLEAR_VALUE"
bitfld.long 0 0.--23. " Z_CLEAR_VALUE "  " "
;tree.end

base ad:0xa0308014
;tree "STENCIL_CLEAR_VALUE"
group 0--3
line.long 0 "STENCIL_CLEAR_VALUE"
hexfld.byte 0 " STENCIL_CLEAR_VALUE "
;tree.end

base ad:0xa0308018
;tree "ARGB_CLEAR_VALUE_0"
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_0"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

base ad:0xa030801c
;tree "ARGB_CLEAR_VALUE_1"
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_1"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

base ad:0xa0308020
;tree "ARGB_CLEAR_VALUE_2"
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_2"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

base ad:0xa0308024
;tree "ARGB_CLEAR_VALUE_3"
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_3"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

base ad:0xa0308028
;tree "BOUNDING_BOX_LEFT_RIGHT"
group 0--3
line.long 0 "BOUNDING_BOX_LEFT_RIGHT"
bitfld.long 0 0.--13. " BOUNDING_BOX_RIGHT "  " "
bitfld.long 0 16.--19. " BOUNDING_BOX_LEFT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa030802c
;tree "BOUNDING_BOX_BOTTOM"
group 0--3
line.long 0 "BOUNDING_BOX_BOTTOM"
bitfld.long 0 0.--13. " BOUNDING_BOX_BOTTOM "  " "
;tree.end

base ad:0xa0308030
;tree "FS_STACK_ADDR"
group 0--3
line.long 0 "FS_STACK_ADDR"
bitfld.long 0 3.--31. " FS_STACK_ADDR "  " "
;tree.end

base ad:0xa0308034
;tree "FS_STACK_SIZE_AND_INIT_VAL"
group 0--3
line.long 0 "FS_STACK_SIZE_AND_INIT_VAL"
hexfld.word 0 " FP_STACK_SIZE "
hexfld.word 1 " FS_STACK_INIT_VAL "
;tree.end

base ad:0xa0308040
;tree "ORIGIN_OFFSET_X"
group 0--3
line.long 0 "ORIGIN_OFFSET_X"
hexfld.word 0 " ORIGIN_OFFSET_X "
;tree.end

base ad:0xa0308044
;tree "ORIGIN_OFFSET_Y"
group 0--3
line.long 0 "ORIGIN_OFFSET_Y"
hexfld.word 0 " ORIGIN_OFFSET_Y "
;tree.end

base ad:0xa0308048
;tree "SUBPIXEL_SPECIFIER"
group 0--3
line.long 0 "SUBPIXEL_SPECIFIER"
hexfld.byte 0 " SUBPIXEL_SPECIFIER "
;tree.end

base ad:0xa030804c
;tree "TIEBREAK_MODE"
group 0--3
line.long 0 "TIEBREAK_MODE"
bitfld.long 0 0.--2. " TIEBREAK_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0308050
;tree "PLIST_CONFIG"
group 0--3
line.long 0 "PLIST_CONFIG"
bitfld.long 0 0.--5. " SCALE_X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--21. " SCALE_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 28.--29. " LIST_FORMAT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0308054
;tree "SCALING_CONFIG"
group 0--3
line.long 0 "SCALING_CONFIG"
bitfld.long 0 0. " POINT_AND_LINE_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 1. " DITHERING_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 2. " FRAGCOORD_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " DERIVATIVE_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 8. " FLIP_POINT_SPRITES "  "0 ,1 "
bitfld.long 0 9. " FLIP_DITHERING_MATRIX "  "0 ,1 "
bitfld.long 0 10. " FLIP_FRAGCOORD "  "0 ,1 "
bitfld.long 0 11. " FLIP_DERIVATIVE_Y "  "0 ,1 "
bitfld.long 0 16.--18. " SCALE_X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " SCALE_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0308058
;tree "TILEBUFFER_BITS"
group 0--3
line.long 0 "TILEBUFFER_BITS"
bitfld.long 0 0.--3. " TILEBUFFER_R_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " TILEBUFFER_G_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TILEBUFFER_B_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " TILEBUFFER_A_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0308100
;tree "WB0_SOURCE_SELECT"
group 0--3
line.long 0 "WB0_SOURCE_SELECT"
bitfld.long 0 0.--1. " WB0_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0308104
;tree "WB0_TARGET_ADDR"
group 0--3
line.long 0 "WB0_TARGET_ADDR"
bitfld.long 0 3.--31. " WB0_TARGET_ADDR "  " "
;tree.end

base ad:0xa0308108
;tree "WB0_TARGET_PIXEL_FORMAT"
group 0--3
line.long 0 "WB0_TARGET_PIXEL_FORMAT"
bitfld.long 0 0.--3. " WB0_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa030810c
;tree "WB0_TARGET_AA_FORMAT"
group 0--3
line.long 0 "WB0_TARGET_AA_FORMAT"
bitfld.long 0 0.--2. " WB0_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB0_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB0_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0308110
;tree "WB0_TARGET_LAYOUT"
group 0--3
line.long 0 "WB0_TARGET_LAYOUT"
bitfld.long 0 0.--1. " WB0_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0308114
;tree "WB0_TARGET_SCANLINE_LENGTH"
group 0--3
line.long 0 "WB0_TARGET_SCANLINE_LENGTH"
hexfld.word 0 " WB0_TARGET_SCANLINE_LENGTH "
;tree.end

base ad:0xa0308118
;tree "WB0_TARGET_FLAGS"
group 0--3
line.long 0 "WB0_TARGET_FLAGS"
bitfld.long 0 0. " WB0_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB0_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB0_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB0_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB0_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB0_BIG_ENDIAN "  "0 ,1 "
;tree.end

base ad:0xa030811c
;tree "WB0_MRT_ENABLE"
group 0--3
line.long 0 "WB0_MRT_ENABLE"
bitfld.long 0 0.--3. " WB0_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0308120
;tree "WB0_MRT_OFFSET"
group 0--3
line.long 0 "WB0_MRT_OFFSET"
bitfld.long 0 3.--31. " WB0_MRT_OFFSET "  " "
;tree.end

base ad:0xa0308124
;tree "WB0_GLOBAL_TEST_ENABLE"
group 0--3
line.long 0 "WB0_GLOBAL_TEST_ENABLE"
bitfld.long 0 0. " WB0_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0308128
;tree "WB0_GLOBAL_TEST_REF_VALUE"
group 0--3
line.long 0 "WB0_GLOBAL_TEST_REF_VALUE"
hexfld.word 0 " WB0_GLOBAL_TEST_REF_VALUE "
;tree.end

base ad:0xa030812c
;tree "WB0_GLOBAL_TEST_CMP_FUNC"
group 0--3
line.long 0 "WB0_GLOBAL_TEST_CMP_FUNC"
bitfld.long 0 0.--2. " WB0_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0308200
;tree "WB1_SOURCE_SELECT"
group 0--3
line.long 0 "WB1_SOURCE_SELECT"
bitfld.long 0 0.--1. " WB1_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0308204
;tree "WB1_TARGET_ADDR"
group 0--3
line.long 0 "WB1_TARGET_ADDR"
bitfld.long 0 3.--31. " WB1_TARGET_ADDR "  " "
;tree.end

base ad:0xa0308208
;tree "WB1_TARGET_PIXEL_FORMAT"
group 0--3
line.long 0 "WB1_TARGET_PIXEL_FORMAT"
bitfld.long 0 0.--3. " WB1_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa030820c
;tree "WB1_TARGET_AA_FORMAT"
group 0--3
line.long 0 "WB1_TARGET_AA_FORMAT"
bitfld.long 0 0.--2. " WB1_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB1_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB1_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0308210
;tree "WB1_TARGET_LAYOUT"
group 0--3
line.long 0 "WB1_TARGET_LAYOUT"
bitfld.long 0 0.--1. " WB1_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0308214
;tree "WB1_TARGET_SCANLINE_LENGTH"
group 0--3
line.long 0 "WB1_TARGET_SCANLINE_LENGTH"
hexfld.word 0 " WB1_TARGET_SCANLINE_LENGTH "
;tree.end

base ad:0xa0308218
;tree "WB1_TARGET_FLAGS"
group 0--3
line.long 0 "WB1_TARGET_FLAGS"
bitfld.long 0 0. " WB1_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB1_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB1_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB1_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB1_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB1_BIG_ENDIAN "  "0 ,1 "
;tree.end

base ad:0xa030821c
;tree "WB1_MRT_ENABLE"
group 0--3
line.long 0 "WB1_MRT_ENABLE"
bitfld.long 0 0.--3. " WB1_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0308220
;tree "WB1_MRT_OFFSET"
group 0--3
line.long 0 "WB1_MRT_OFFSET"
bitfld.long 0 3.--31. " WB1_MRT_OFFSET "  " "
;tree.end

base ad:0xa0308224
;tree "WB1_GLOBAL_TEST_ENABLE"
group 0--3
line.long 0 "WB1_GLOBAL_TEST_ENABLE"
bitfld.long 0 0. " WB1_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0308228
;tree "WB1_GLOBAL_TEST_REF_VALUE"
group 0--3
line.long 0 "WB1_GLOBAL_TEST_REF_VALUE"
hexfld.word 0 " WB1_GLOBAL_TEST_REF_VALUE "
;tree.end

base ad:0xa030822c
;tree "WB1_GLOBAL_TEST_CMP_FUNC"
group 0--3
line.long 0 "WB1_GLOBAL_TEST_CMP_FUNC"
bitfld.long 0 0.--2. " WB1_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0308300
;tree "WB2_SOURCE_SELECT"
group 0--3
line.long 0 "WB2_SOURCE_SELECT"
bitfld.long 0 0.--1. " WB2_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0308304
;tree "WB2_TARGET_ADDR"
group 0--3
line.long 0 "WB2_TARGET_ADDR"
bitfld.long 0 3.--31. " WB2_TARGET_ADDR "  " "
;tree.end

base ad:0xa0308308
;tree "WB2_TARGET_PIXEL_FORMAT"
group 0--3
line.long 0 "WB2_TARGET_PIXEL_FORMAT"
bitfld.long 0 0.--3. " WB2_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa030830c
;tree "WB2_TARGET_AA_FORMAT"
group 0--3
line.long 0 "WB2_TARGET_AA_FORMAT"
bitfld.long 0 0.--2. " WB2_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB2_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB2_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0308310
;tree "WB2_TARGET_LAYOUT"
group 0--3
line.long 0 "WB2_TARGET_LAYOUT"
bitfld.long 0 0.--1. " WB2_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa0308314
;tree "WB2_TARGET_SCANLINE_LENGTH"
group 0--3
line.long 0 "WB2_TARGET_SCANLINE_LENGTH"
hexfld.word 0 " WB2_TARGET_SCANLINE_LENGTH "
;tree.end

base ad:0xa0308318
;tree "WB2_TARGET_FLAGS"
group 0--3
line.long 0 "WB2_TARGET_FLAGS"
bitfld.long 0 0. " WB2_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB2_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB2_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB2_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB2_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB2_BIG_ENDIAN "  "0 ,1 "
;tree.end

base ad:0xa030831c
;tree "WB2_MRT_ENABLE"
group 0--3
line.long 0 "WB2_MRT_ENABLE"
bitfld.long 0 0.--3. " WB2_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0308320
;tree "WB2_MRT_OFFSET"
group 0--3
line.long 0 "WB2_MRT_OFFSET"
bitfld.long 0 3.--31. " WB2_MRT_OFFSET "  " "
;tree.end

base ad:0xa0308324
;tree "WB2_GLOBAL_TEST_ENABLE"
group 0--3
line.long 0 "WB2_GLOBAL_TEST_ENABLE"
bitfld.long 0 0. " WB2_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0308328
;tree "WB2_GLOBAL_TEST_REF_VALUE"
group 0--3
line.long 0 "WB2_GLOBAL_TEST_REF_VALUE"
hexfld.word 0 " WB2_GLOBAL_TEST_REF_VALUE "
;tree.end

base ad:0xa030832c
;tree "WB2_GLOBAL_TEST_CMP_FUNC"
group 0--3
line.long 0 "WB2_GLOBAL_TEST_CMP_FUNC"
bitfld.long 0 0.--2. " WB2_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xa0309000
;tree "MGMT_VERSION"
rgroup 0--3
line.long 0 "MGMT_VERSION"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 1 " PRODUCT_ID "
;tree.end

base ad:0xa0309004
;tree "MGMT_CURRENT_REND_LIST_ADDR"
group 0--3
line.long 0 "MGMT_CURRENT_REND_LIST_ADDR"
bitfld.long 0 5.--31. " CURRENT_REND_LIST_ADDR "  " "
;tree.end

base ad:0xa0309008
;tree "MGMT_STATUS"
group 0--3
line.long 0 "MGMT_STATUS"
bitfld.long 0 0. " RENDERING_ACTIVE "  "0 ,1 "
bitfld.long 0 1. " TILE_STOPPED "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 4. " BUS_STOPPED "  "0 ,1 "
bitfld.long 0 5. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 6. " INTERRUPT_ASSERTED "  "0 ,1 "
bitfld.long 0 7. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

base ad:0xa030900c
;tree "MGMT_CTRL"
group 0--3
line.long 0 "MGMT_CTRL"
bitfld.long 0 0. " STOP_BUS "  "0 ,1 "
bitfld.long 0 1. " START_BUS "  "0 ,1 "
bitfld.long 0 2. " END_AFTER_TILE "  "0 ,1 "
bitfld.long 0 3. " FLUSH_CACHES "  "0 ,1 "
bitfld.long 0 4. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 5. " FORCE_RESET "  "0 ,1 "
bitfld.long 0 6. " START_RENDERING "  "0 ,1 "
bitfld.long 0 7. " SOFT_RESET "  "0 ,1 "
bitfld.long 0 8. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

base ad:0xa0309010
;tree "MGMT_LAST_TILE_POS_START"
rgroup 0--3
line.long 0 "MGMT_LAST_TILE_POS_START"
hexfld.byte 0 " TILEX_START "
hexfld.byte 2 " TILEY_START "
;tree.end

base ad:0xa0309014
;tree "MGMT_LAST_TILE_POS_END"
rgroup 0--3
line.long 0 "MGMT_LAST_TILE_POS_END"
hexfld.byte 0 " TILEX_END "
hexfld.byte 2 " TILEY_END "
;tree.end

base ad:0xa0309020
;tree "MGMT_INT_RAWSTAT"
group 0--3
line.long 0 "MGMT_INT_RAWSTAT"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

base ad:0xa0309024
;tree "MGMT_INT_CLEAR"
group 0--3
line.long 0 "MGMT_INT_CLEAR"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

base ad:0xa0309028
;tree "MGMT_INT_MASK"
group 0--3
line.long 0 "MGMT_INT_MASK"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

base ad:0xa030902c
;tree "MGMT_INT_STATUS"
rgroup 0--3
line.long 0 "MGMT_INT_STATUS"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

base ad:0xa0309040
;tree "MGMT_WRITE_BOUNDARY_ENABLE"
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ENABLE"
bitfld.long 0 0. " WRITE_BOUNDARY_ENABLE "  "0 ,1 "
;tree.end

base ad:0xa0309044
;tree "MGMT_WRITE_BOUNDARY_LOW"
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_LOW"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_LOW "  " "
;tree.end

base ad:0xa0309048
;tree "MGMT_WRITE_BOUNDARY_HIGH"
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_HIGH"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_HIGH "  " "
;tree.end

base ad:0xa030904c
;tree "MGMT_WRITE_BOUNDARY_ADDRESS"
rgroup 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ADDRESS"
bitfld.long 0 2.--31. " WRITE_BOUNDARY_ADDRESS "  " "
;tree.end

base ad:0xa0309050
;tree "MGMT_BUS_ERROR_STATUS"
rgroup 0--3
line.long 0 "MGMT_BUS_ERROR_STATUS"
bitfld.long 0 0. " WRITE_ERROR "  "0 ,1 "
bitfld.long 0 1. " READ_ERROR "  "0 ,1 "
bitfld.long 0 2.--5. " WRITE_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--9. " READ_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa0309060
;tree "MGMT_WATCHDOG_DISABLE"
group 0--3
line.long 0 "MGMT_WATCHDOG_DISABLE"
bitfld.long 0 0. " WATCHDOG_DISABLE "  "0 ,1 "
;tree.end

base ad:0xa0309064
;tree "MGMT_WATCHDOG_TIMEOUT"
group 0--3
line.long 0 "MGMT_WATCHDOG_TIMEOUT"
hexfld.long 0 " WATCHDOG_TIMEOUT "
;tree.end

base ad:0xa0309080
;tree "MGMT_PERF_CNT_0_ENABLE"
group 0--3
line.long 0 "MGMT_PERF_CNT_0_ENABLE"
bitfld.long 0 0. " PERF_CNT_0_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_0_LIM_EN "  "0 ,1 "
;tree.end

base ad:0xa0309084
;tree "MGMT_PERF_CNT_0_SRC"
group 0--3
line.long 0 "MGMT_PERF_CNT_0_SRC"
bitfld.long 0 0.--5. " PERF_CNT_0_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa0309088
;tree "MGMT_PERF_CNT_0_LIMIT"
group 0--3
line.long 0 "MGMT_PERF_CNT_0_LIMIT"
hexfld.long 0 " PERF_CNT_0_LIMIT "
;tree.end

base ad:0xa030908c
;tree "MGMT_PERF_CNT_0_VALUE"
group 0--3
line.long 0 "MGMT_PERF_CNT_0_VALUE"
hexfld.long 0 " PERF_CNT_0_VALUE "
;tree.end

base ad:0xa03090a0
;tree "MGMT_PERF_CNT_1_ENABLE"
group 0--3
line.long 0 "MGMT_PERF_CNT_1_ENABLE"
bitfld.long 0 0. " PERF_CNT_1_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_1_LIM_EN "  "0 ,1 "
;tree.end

base ad:0xa03090a4
;tree "MGMT_PERF_CNT_1_SRC"
group 0--3
line.long 0 "MGMT_PERF_CNT_1_SRC"
bitfld.long 0 0.--5. " PERF_CNT_1_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xa03090a8
;tree "MGMT_PERF_CNT_1_LIMIT"
group 0--3
line.long 0 "MGMT_PERF_CNT_1_LIMIT"
hexfld.long 0 " PERF_CNT_1_LIMIT "
;tree.end

base ad:0xa03090ac
;tree "MGMT_PERF_CNT_1_VALUE"
group 0--3
line.long 0 "MGMT_PERF_CNT_1_VALUE"
hexfld.long 0 " PERF_CNT_1_VALUE "
;tree.end

base ad:0xa03090b0
;tree "MGMT_PERFMON_CONTR"
group 0--3
line.long 0 "MGMT_PERFMON_CONTR"
bitfld.long 0 0. " PERFMON_ENABLE "  "0 ,1 "
bitfld.long 0 16.--25. " NUMBER_OF_TILEX "  " "
;tree.end

base ad:0xa03090b4
;tree "MGMT_PERFMON_BASE"
group 0--3
line.long 0 "MGMT_PERFMON_BASE"
bitfld.long 0 3.--31. " PERFMON_BASE_ADDR "  " "
;tree.end

endif

tree.end

;==============================================================
tree "SIA (6 instances)"
;==============================================================
base ad:0xA0254000
;********************************************
tree "SIA-SIA"
;********************************************
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x8015741c)&0x28000)!=0x28000)||((data.long(ad:0x801571ec)&0x600)!=0x600)||((data.long(ad:0x80157428)&0x300)!=0x0))

base ad:0x8015700c
group 0--3
line.long 0 "PRCM_SIAMMDSPCLK_MGT"
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SIA_PHY_EN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 15. " SIA_L_VOK "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

else

base ad:0xA0254000
;tree "SIARESET"
group 0--3
line.long 0 "RESET"
bitfld.long 0 4. " ROT "  "0 ,1 "
bitfld.long 0 3. " PROJ "  "0 ,1 "
bitfld.long 0 2. " VCF "  "0 ,1 "
bitfld.long 0 1. " IPP "  "0 ,1 "
bitfld.long 0 0. " SIA_CORE "  "0 ,1 "
;tree.end

base ad:0xA0254010
;tree "SIACLOCK_ENABLE"
group 0--3
line.long 0 "CLOCK_ENABLE"
bitfld.long 0 4. " PROJ "  "0 ,1 "
bitfld.long 0 3. " VCF "  "0 ,1 "
bitfld.long 0 2. " IPP "  "0 ,1 "
bitfld.long 0 1. " STBP "  "0 ,1 "
bitfld.long 0 0. " DMA "  "0 ,1 "
;tree.end

base ad:0xA0254020
;tree "SIAIDN_HRV"
rgroup 0--3
line.long 0 "IDN_HRV"
bitfld.long 0 0.--3. " R0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " R1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " R2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA0254030
;tree "SIAVCF_ENABLE"
group 0--3
line.long 0 "VCF_ENABLE"
bitfld.long 0 0. " EN "  "0 ,1 "
;tree.end

base ad:0xA0254032
;tree "SIAROTATION"
group 0--3
line.long 0 "ROTATION"
bitfld.long 0 0.--1. " ROTATION "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254040
;tree "SIAISP_MCU_SYS_ADDR0"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR0"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA0254042
;tree "SIAISP_MCU_SYS_SIZE0"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE0"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254044
;tree "SIAISP_MCU_SYS_ADDR1"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR1"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA0254046
;tree "SIAISP_MCU_SYS_SIZE1"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE1"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254048
;tree "SIAISP_MCU_SYS_ADDR2"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR2"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA025404A
;tree "SIAISP_MCU_SYS_SIZE2"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE2"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA025404C
;tree "SIAISP_MCU_SYS_ADDR3"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR3"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA025404E
;tree "SIAISP_MCU_SYS_SIZE3"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE3"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254050
;tree "SIAISP_MCU_SYS_ADDR4"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR4"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA0254052
;tree "SIAISP_MCU_SYS_SIZE4"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE4"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254054
;tree "SIAISP_MCU_SYS_ADDR5"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR5"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA0254056
;tree "SIAISP_MCU_SYS_SIZE5"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE5"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254058
;tree "SIAISP_MCU_SYS_ADDR6"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR6"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA025405A
;tree "SIAISP_MCU_SYS_SIZE6"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE6"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA025405C
;tree "SIAISP_MCU_SYS_ADDR7"
group 0--3
line.long 0 "ISP_MCU_SYS_ADDR7"
hexfld.word 0 " REGION_BA "
;tree.end

base ad:0xA025405E
;tree "SIAISP_MCU_SYS_SIZE7"
group 0--3
line.long 0 "ISP_MCU_SYS_SIZE7"
bitfld.long 0 0.--1. " REGION_SZ "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254060
;tree "SIAISP_MCU_IO_ADDR_0"
group 0--3
line.long 0 "ISP_MCU_IO_ADDR_0"
hexfld.byte 0 " REGION_BA "
;tree.end

base ad:0xA0254062
;tree "SIAISP_MCU_IO_ADDR_1"
group 0--3
line.long 0 "ISP_MCU_IO_ADDR_1"
hexfld.byte 0 " REGION_BA "
;tree.end

base ad:0xA0254070
;tree "SIAISP_MEM_PAGE"
group 0--3
line.long 0 "ISP_MEM_PAGE"
bitfld.long 0 0.--5. " INDEX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254072
;tree "SIAXBUS_BYTE_ENABLE"
group 0--3
line.long 0 "XBUS_BYTE_ENABLE"
bitfld.long 0 0.--1. " BE0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BE1 "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254080
;tree "SIAPIPE03_SELECT"
group 0--3
line.long 0 "PIPE03_SELECT"
bitfld.long 0 0. " AP "  "0 ,1 "
;tree.end

base ad:0xA0254090
;tree "SIALICN_ITS"
rgroup 0--3
line.long 0 "LICN_ITS"
bitfld.long 0 0. " BUSERR "  "0 ,1 "
;tree.end

base ad:0xA0254092
;tree "SIALICN_ITS_BCLR"
wgroup 0--3
line.long 0 "LICN_ITS_BCLR"
bitfld.long 0 0. " BUSERR "  "0 ,1 "
;tree.end

base ad:0xA0254094
;tree "SIALICN_ITS_BSET"
wgroup 0--3
line.long 0 "LICN_ITS_BSET"
bitfld.long 0 0. " BUSERR "  "0 ,1 "
;tree.end

base ad:0xA0254096
;tree "SIALICN_ITM"
rgroup 0--3
line.long 0 "LICN_ITM"
bitfld.long 0 0. " BUSERR "  "0 ,1 "
;tree.end

base ad:0xA0254098
;tree "SIALICN_ITM_BCLR"
wgroup 0--3
line.long 0 "LICN_ITM_BCLR"
bitfld.long 0 0. " BUSERR "  "0 ,1 "
;tree.end

base ad:0xA025409A
;tree "SIALICN_ITM_BSET"
wgroup 0--3
line.long 0 "LICN_ITM_BSET"
bitfld.long 0 0. " BUSERR "  "0 ,1 "
;tree.end

endif

tree.end

base ad:0xA0254200
;********************************************
tree "SIA-PROJ"
;********************************************
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x8015741c)&0x28000)!=0x28000)||((data.long(ad:0x801571ec)&0x600)!=0x600)||((data.long(ad:0x80157428)&0x300)!=0x0))

base ad:0x8015700c
group 0--3
line.long 0 "PRCM_SIAMMDSPCLK_MGT"
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SIA_PHY_EN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 15. " SIA_L_VOK "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

else

base ad:0xA0254200
;tree "PROJENR"
group 0--3
line.long 0 "ENR"
bitfld.long 0 0. " HCP "  "0 ,1 "
bitfld.long 0 1. " VCP "  "0 ,1 "
;tree.end

base ad:0xA0254210
;tree "PROJITS"
rgroup 0--3
line.long 0 "ITS"
bitfld.long 0 0. " HCP_EOT "  "0 ,1 "
bitfld.long 0 1. " VCP_EOT "  "0 ,1 "
bitfld.long 0 2. " VCP_ERR "  "0 ,1 "
;tree.end

base ad:0xA0254212
;tree "PROJITS_BCLR"
wgroup 0--3
line.long 0 "ITS_BCLR"
bitfld.long 0 0. " HCP_EOT "  "0 ,1 "
bitfld.long 0 1. " VCP_EOT "  "0 ,1 "
bitfld.long 0 2. " VCP_ERR "  "0 ,1 "
;tree.end

base ad:0xA0254214
;tree "PROJITS_BSET"
wgroup 0--3
line.long 0 "ITS_BSET"
bitfld.long 0 0. " HCP_EOT "  "0 ,1 "
bitfld.long 0 1. " VCP_EOT "  "0 ,1 "
bitfld.long 0 2. " VCP_ERR "  "0 ,1 "
;tree.end

base ad:0xA0254216
;tree "PROJITM"
rgroup 0--3
line.long 0 "ITM"
bitfld.long 0 0. " HCP_EOT "  "0 ,1 "
bitfld.long 0 1. " VCP_EOT "  "0 ,1 "
bitfld.long 0 2. " VCP_ERR "  "0 ,1 "
;tree.end

base ad:0xA0254218
;tree "PROJITM_BCLR"
wgroup 0--3
line.long 0 "ITM_BCLR"
bitfld.long 0 0. " HCP_EOT "  "0 ,1 "
bitfld.long 0 1. " VCP_EOT "  "0 ,1 "
bitfld.long 0 2. " VCP_ERR "  "0 ,1 "
;tree.end

base ad:0xA025421A
;tree "PROJITM_BSET"
wgroup 0--3
line.long 0 "ITM_BSET"
bitfld.long 0 0. " HCP_EOT "  "0 ,1 "
bitfld.long 0 1. " VCP_EOT "  "0 ,1 "
bitfld.long 0 2. " VCP_ERR "  "0 ,1 "
;tree.end

base ad:0xA0254220
;tree "PROJHSIZE"
group 0--3
line.long 0 "HSIZE"
bitfld.long 0 4.--12. " HSIZE "  " "
;tree.end

base ad:0xA0254222
;tree "PROJVSIZE"
group 0--3
line.long 0 "VSIZE"
bitfld.long 0 4.--12. " VSIZE "  " "
;tree.end

base ad:0xA0254230
;tree "PROJGCF_W_DIS"
group 0--3
line.long 0 "GCF_W_DIS"
bitfld.long 0 0. " GCF_W_DIS "  "0 ,1 "
;tree.end

base ad:0xA0254240
;tree "PROJENDIAN"
group 0--3
line.long 0 "ENDIAN"
bitfld.long 0 0. " ENDIAN "  "0 ,1 "
;tree.end

endif

tree.end

base ad:0xA0254400
;********************************************
tree "SIA-DMA"
;********************************************
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x8015741c)&0x28000)!=0x28000)||((data.long(ad:0x801571ec)&0x600)!=0x600)||((data.long(ad:0x80157428)&0x300)!=0x0))

base ad:0x8015700c
group 0--3
line.long 0 "PRCM_SIAMMDSPCLK_MGT"
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SIA_PHY_EN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 15. " SIA_L_VOK "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

else

base ad:0xA0254400
;tree "DMAENR"
group 0--3
line.long 0 "ENR"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254402
;tree "DMADIR"
group 0--3
line.long 0 "DIR"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254404
;tree "DMAPEN"
rgroup 0--3
line.long 0 "PEN"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254406
;tree "DMAINTERLACE_EN"
group 0--3
line.long 0 "INTERLACE_EN"
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254410
;tree "DMAITS1"
rgroup 0--3
line.long 0 "ITS1"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254412
;tree "DMAITS1_BCLR"
wgroup 0--3
line.long 0 "ITS1_BCLR"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254416
;tree "DMAIMR1"
group 0--3
line.long 0 "IMR1"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254420
;tree "DMAITS2"
rgroup 0--3
line.long 0 "ITS2"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254422
;tree "DMAITS2_BCLR"
wgroup 0--3
line.long 0 "ITS2_BCLR"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254424
;tree "DMAIMR2"
group 0--3
line.long 0 "IMR2"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254430
;tree "DMASOFT_RST"
wgroup 0--3
line.long 0 "SOFT_RST"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254432
;tree "DMAFIFO_STA"
rgroup 0--3
line.long 0 "FIFO_STA"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254434
;tree "DMAFIFO_FLUSH"
wgroup 0--3
line.long 0 "FIFO_FLUSH"
bitfld.long 0 0. " IRP3_JPG_W "  "0 ,1 "
;tree.end

base ad:0xA0254440
;tree "DMAIRP03_DLS_L"
group 0--3
line.long 0 "IRP03_DLS_L"
bitfld.long 0 2.--15. " DMA_IRP03_DLS_L "  " "
;tree.end

base ad:0xA0254442
;tree "DMAIRP03_DLS_H"
group 0--3
line.long 0 "IRP03_DLS_H"
hexfld.word 0 " DMA_IRP03_DLS_H "
;tree.end

base ad:0xA0254444
;tree "DMAIRP03_DCS_L"
group 0--3
line.long 0 "IRP03_DCS_L"
bitfld.long 0 2.--15. " DMA_IRP03_DCS_L "  " "
;tree.end

base ad:0xA0254446
;tree "DMAIRP03_DCS_H"
group 0--3
line.long 0 "IRP03_DCS_H"
hexfld.word 0 " DMA_IRP03_DCS_H "
;tree.end

base ad:0xA0254448
;tree "DMAIRP03_CLS_L"
group 0--3
line.long 0 "IRP03_CLS_L"
bitfld.long 0 2.--15. " DMA_IRP03_CLS_L "  " "
;tree.end

base ad:0xA025444A
;tree "DMAIRP03_CLS_H"
group 0--3
line.long 0 "IRP03_CLS_H"
hexfld.word 0 " DMA_IRP03_CLS_H "
;tree.end

base ad:0xA025444C
;tree "DMAIRP03_CCS_L"
group 0--3
line.long 0 "IRP03_CCS_L"
bitfld.long 0 2.--15. " DMA_IRP03_CCS_L "  " "
;tree.end

base ad:0xA025444E
;tree "DMAIRP03_CCS_H"
group 0--3
line.long 0 "IRP03_CCS_H"
hexfld.word 0 " DMA_IRP03_CCS_H "
;tree.end

base ad:0xA0254450
;tree "DMAIRP03_DC1S_L"
group 0--3
line.long 0 "IRP03_DC1S_L"
bitfld.long 0 2.--15. " DMA_IRP03_DC1S_L "  " "
;tree.end

base ad:0xA0254452
;tree "DMAIRP03_DC1S_H"
group 0--3
line.long 0 "IRP03_DC1S_H"
hexfld.word 0 " DMA_IRP03_DC1S_H "
;tree.end

base ad:0xA0254454
;tree "DMAIRP03_DC2S_L"
group 0--3
line.long 0 "IRP03_DC2S_L"
bitfld.long 0 2.--15. " DMA_IRP03_DC2S_L "  " "
;tree.end

base ad:0xA0254456
;tree "DMAIRP03_DC2S_H"
group 0--3
line.long 0 "IRP03_DC2S_H"
hexfld.word 0 " DMA_IRP03_DC2S_H "
;tree.end

base ad:0xA0254458
;tree "DMAIRP03_DRS_L"
group 0--3
line.long 0 "IRP03_DRS_L"
bitfld.long 0 2.--15. " DMA_IRP03_DRS_L "  " "
;tree.end

base ad:0xA025445A
;tree "DMAIRP03_DRS_H"
group 0--3
line.long 0 "IRP03_DRS_H"
hexfld.word 0 " DMA_IRP03_DRS_H "
;tree.end

base ad:0xA0254460
;tree "DMAIRP03_HPS_L"
group 0--3
line.long 0 "IRP03_HPS_L"
bitfld.long 0 2.--15. " DMA_IRP03_HPS_L "  " "
;tree.end

base ad:0xA0254462
;tree "DMAIRP03_HPS_H"
group 0--3
line.long 0 "IRP03_HPS_H"
hexfld.word 0 " DMA_IRP03_HPS_H "
;tree.end

base ad:0xA0254464
;tree "DMAIRP03_VPS_L"
group 0--3
line.long 0 "IRP03_VPS_L"
bitfld.long 0 2.--15. " DMA_IRP03_VPS_L "  " "
;tree.end

base ad:0xA0254466
;tree "DMAIRP03_VPS_H"
group 0--3
line.long 0 "IRP03_VPS_H"
hexfld.word 0 " DMA_IRP03_VPS_H "
;tree.end

base ad:0xA0254468
;tree "DMAIRP03_JPGS_L"
group 0--3
line.long 0 "IRP03_JPGS_L"
bitfld.long 0 2.--15. " DMA_IRP03_JPGS_L "  " "
;tree.end

base ad:0xA025446A
;tree "DMAIRP03_JPGS_H"
group 0--3
line.long 0 "IRP03_JPGS_H"
hexfld.word 0 " DMA_IRP03_JPGS_H "
;tree.end

base ad:0xA025446C
;tree "DMAIRP03_DFW"
group 0--3
line.long 0 "IRP03_DFW"
bitfld.long 0 2.--15. " DMA_IRP03_DFW "  " "
;tree.end

base ad:0xA025446E
;tree "DMAIRP03_DWW"
group 0--3
line.long 0 "IRP03_DWW"
bitfld.long 0 2.--15. " DMA_IRP03_DWW "  " "
;tree.end

base ad:0xA0254470
;tree "DMAIRP03_DWH"
group 0--3
line.long 0 "IRP03_DWH"
hexfld.word 0 " DMA_IRP03_DWH "
;tree.end

base ad:0xA0254472
;tree "DMAIRP03_JPG_DBS_L"
group 0--3
line.long 0 "IRP03_JPG_DBS_L"
bitfld.long 0 2.--15. " DMA_IRP03_JPG_DBS_L "  " "
;tree.end

base ad:0xA0254474
;tree "DMAIRP03_JPG_DBS_H"
group 0--3
line.long 0 "IRP03_JPG_DBS_H"
hexfld.word 0 " DMA_IRP03_JPG_DBS_H "
;tree.end

base ad:0xA0254476
;tree "DMAIMR1"
group 0--3
line.long 0 "IMR1"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254478
;tree "DMAIRP03_RASTER"
group 0--3
line.long 0 "IRP03_RASTER"
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA025447A
;tree "DMAIRP03_ROTATION"
group 0--3
line.long 0 "IRP03_ROTATION"
bitfld.long 0 0.--1. " DMA_IRP03_ROTATION "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254480
;tree "DMAIRP0_SRS_L"
group 0--3
line.long 0 "IRP0_SRS_L"
bitfld.long 0 2.--15. " DMA_IRP0_SRS_L "  " "
;tree.end

base ad:0xA0254482
;tree "DMAIRP0_SRS_H"
group 0--3
line.long 0 "IRP0_SRS_H"
hexfld.word 0 " DMA_IRP0_SRS_H "
;tree.end

base ad:0xA0254484
;tree "DMAIRP0_SFW"
group 0--3
line.long 0 "IRP0_SFW"
bitfld.long 0 2.--15. " DMA_IRP0_SFW "  " "
;tree.end

base ad:0xA0254486
;tree "DMAIRP0_SWW"
group 0--3
line.long 0 "IRP0_SWW"
bitfld.long 0 2.--15. " DMA_IRP0_SWW "  " "
;tree.end

base ad:0xA0254488
;tree "DMAIRP0_SWH"
group 0--3
line.long 0 "IRP0_SWH"
hexfld.word 0 " DMA_IRP0_SWH "
;tree.end

base ad:0xA0254490
;tree "DMAIRP1_DRS_L"
group 0--3
line.long 0 "IRP1_DRS_L"
bitfld.long 0 2.--15. " DMA_IRP1_DRS_L "  " "
;tree.end

base ad:0xA0254492
;tree "DMAIRP1_DRS_H"
group 0--3
line.long 0 "IRP1_DRS_H"
hexfld.word 0 " DMA_IRP1_DRS_H "
;tree.end

base ad:0xA0254494
;tree "DMAIRP1_DFW"
group 0--3
line.long 0 "IRP1_DFW"
bitfld.long 0 2.--15. " DMA_IRP1_DFW "  " "
;tree.end

base ad:0xA0254496
;tree "DMAIRP1_DWW"
group 0--3
line.long 0 "IRP1_DWW"
bitfld.long 0 2.--15. " DMA_IRP1_DWW "  " "
;tree.end

base ad:0xA0254498
;tree "DMAIRP1_DWH"
group 0--3
line.long 0 "IRP1_DWH"
hexfld.word 0 " DMA_IRP1_DWH "
;tree.end

base ad:0xA02544A0
;tree "DMAIRP2_DRS_L"
group 0--3
line.long 0 "IRP2_DRS_L"
bitfld.long 0 2.--15. " DMA_IRP2_DRS_L "  " "
;tree.end

base ad:0xA02544A2
;tree "DMAIRP2_DRS_H"
group 0--3
line.long 0 "IRP2_DRS_H"
hexfld.word 0 " DMA_IRP2_DRS_H "
;tree.end

base ad:0xA02544A4
;tree "DMAIRP2_DFW"
group 0--3
line.long 0 "IRP2_DFW"
bitfld.long 0 2.--15. " DMA_IRP2_DFW "  " "
;tree.end

base ad:0xA02544A6
;tree "DMAIRP2_DWW"
group 0--3
line.long 0 "IRP2_DWW"
bitfld.long 0 2.--15. " DMA_IRP2_DWW "  " "
;tree.end

base ad:0xA02544A8
;tree "DMAIRP2_DWH"
group 0--3
line.long 0 "IRP2_DWH"
hexfld.word 0 " DMA_IRP2_DWH "
;tree.end

base ad:0xA02544B0
;tree "DMATST_CID"
wgroup 0--3
line.long 0 "TST_CID"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA02544B4
;tree "DMATST_SADD_L"
rgroup 0--3
line.long 0 "TST_SADD_L"
bitfld.long 0 2.--15. " DMA_CURADDR_L "  " "
;tree.end

base ad:0xA02544B6
;tree "DMATST_SADD_H"
rgroup 0--3
line.long 0 "TST_SADD_H"
hexfld.word 0 " DMA_CURADDR_H "
;tree.end

endif

tree.end

base ad:0xA0254600
;********************************************
tree "SIA-STBP"
;********************************************
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x8015741c)&0x28000)!=0x28000)||((data.long(ad:0x801571ec)&0x600)!=0x600)||((data.long(ad:0x80157428)&0x300)!=0x0))

base ad:0x8015700c
group 0--3
line.long 0 "PRCM_SIAMMDSPCLK_MGT"
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SIA_PHY_EN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 15. " SIA_L_VOK "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

else

base ad:0xA0254600
;tree "STBPBSM"
group 0--3
line.long 0 "BSM"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA0254602
;tree "STBPMIN_OPC_SZ"
group 0--3
line.long 0 "MIN_OPC_SZ"
bitfld.long 0 0.--2. " MIN_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254604
;tree "STBPPAGE_SZ_SRAM"
group 0--3
line.long 0 "PAGE_SZ_SRAM"
bitfld.long 0 0.--3. " PSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA0254606
;tree "STBPPAGE_SZ_DRAM"
group 0--3
line.long 0 "PAGE_SZ_DRAM"
bitfld.long 0 0.--3. " PSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA0254608
;tree "STBPMAX_PRI"
group 0--3
line.long 0 "MAX_PRI"
bitfld.long 0 0.--3. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA0254620
;tree "STBPPEAK_LEVEL0"
group 0--3
line.long 0 "PEAK_LEVEL0"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254622
;tree "STBPPEAK_LEVEL1"
group 0--3
line.long 0 "PEAK_LEVEL1"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254624
;tree "STBPPEAK_LEVEL2"
group 0--3
line.long 0 "PEAK_LEVEL2"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254626
;tree "STBPPEAK_LEVEL3"
group 0--3
line.long 0 "PEAK_LEVEL3"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254628
;tree "STBPPEAK_LEVEL4"
group 0--3
line.long 0 "PEAK_LEVEL4"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA025462A
;tree "STBPPEAK_LEVEL5"
group 0--3
line.long 0 "PEAK_LEVEL5"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA025462C
;tree "STBPPEAK_LEVEL6"
group 0--3
line.long 0 "PEAK_LEVEL6"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA025462E
;tree "STBPPEAK_LEVEL7"
group 0--3
line.long 0 "PEAK_LEVEL7"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254630
;tree "STBPPEAK_LEVEL8"
group 0--3
line.long 0 "PEAK_LEVEL8"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254632
;tree "STBPPEAK_LEVEL9"
group 0--3
line.long 0 "PEAK_LEVEL9"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254634
;tree "STBPPEAK_LEVEL10"
group 0--3
line.long 0 "PEAK_LEVEL10"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254636
;tree "STBPPEAK_LEVEL11"
group 0--3
line.long 0 "PEAK_LEVEL11"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254638
;tree "STBPPEAK_LEVEL12"
group 0--3
line.long 0 "PEAK_LEVEL12"
bitfld.long 0 0.--8. " PEAK "  " "
;tree.end

base ad:0xA0254640
;tree "STBPMAX_OPC_SZ0"
group 0--3
line.long 0 "MAX_OPC_SZ0"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254642
;tree "STBPMAX_OPC_SZ1"
group 0--3
line.long 0 "MAX_OPC_SZ1"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254644
;tree "STBPMAX_OPC_SZ2"
group 0--3
line.long 0 "MAX_OPC_SZ2"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254646
;tree "STBPMAX_OPC_SZ3"
group 0--3
line.long 0 "MAX_OPC_SZ3"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254648
;tree "STBPMAX_OPC_SZ4"
group 0--3
line.long 0 "MAX_OPC_SZ4"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025464A
;tree "STBPMAX_OPC_SZ5"
group 0--3
line.long 0 "MAX_OPC_SZ5"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025464C
;tree "STBPMAX_OPC_SZ6"
group 0--3
line.long 0 "MAX_OPC_SZ6"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025464E
;tree "STBPMAX_OPC_SZ7"
group 0--3
line.long 0 "MAX_OPC_SZ7"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254650
;tree "STBPMAX_OPC_SZ8"
group 0--3
line.long 0 "MAX_OPC_SZ8"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254652
;tree "STBPMAX_OPC_SZ9"
group 0--3
line.long 0 "MAX_OPC_SZ9"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254654
;tree "STBPMAX_OPC_SZ10"
group 0--3
line.long 0 "MAX_OPC_SZ10"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254656
;tree "STBPMAX_OPC_SZ11"
group 0--3
line.long 0 "MAX_OPC_SZ11"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254658
;tree "STBPMAX_OPC_SZ12"
group 0--3
line.long 0 "MAX_OPC_SZ12"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254660
;tree "STBPMAX_CHCK_SZ0"
group 0--3
line.long 0 "MAX_CHCK_SZ0"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254662
;tree "STBPMAX_CHCK_SZ1"
group 0--3
line.long 0 "MAX_CHCK_SZ1"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254664
;tree "STBPMAX_CHCK_SZ2"
group 0--3
line.long 0 "MAX_CHCK_SZ2"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254666
;tree "STBPMAX_CHCK_SZ3"
group 0--3
line.long 0 "MAX_CHCK_SZ3"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254668
;tree "STBPMAX_CHCK_SZ4"
group 0--3
line.long 0 "MAX_CHCK_SZ4"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025466A
;tree "STBPMAX_CHCK_SZ5"
group 0--3
line.long 0 "MAX_CHCK_SZ5"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025466C
;tree "STBPMAX_CHCK_SZ6"
group 0--3
line.long 0 "MAX_CHCK_SZ6"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025466E
;tree "STBPMAX_CHCK_SZ7"
group 0--3
line.long 0 "MAX_CHCK_SZ7"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254670
;tree "STBPMAX_CHCK_SZ8"
group 0--3
line.long 0 "MAX_CHCK_SZ8"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254672
;tree "STBPMAX_CHCK_SZ9"
group 0--3
line.long 0 "MAX_CHCK_SZ9"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254674
;tree "STBPMAX_CHCK_SZ10"
group 0--3
line.long 0 "MAX_CHCK_SZ10"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254676
;tree "STBPMAX_CHCK_SZ11"
group 0--3
line.long 0 "MAX_CHCK_SZ11"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254678
;tree "STBPMAX_CHCK_SZ12"
group 0--3
line.long 0 "MAX_CHCK_SZ12"
bitfld.long 0 0.--2. " MAX_CHCK_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254680
;tree "STBPMAX_MSSG_SZ0"
group 0--3
line.long 0 "MAX_MSSG_SZ0"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254682
;tree "STBPMAX_MSSG_SZ1"
group 0--3
line.long 0 "MAX_MSSG_SZ1"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254684
;tree "STBPMAX_MSSG_SZ2"
group 0--3
line.long 0 "MAX_MSSG_SZ2"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254686
;tree "STBPMAX_MSSG_SZ3"
group 0--3
line.long 0 "MAX_MSSG_SZ3"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254688
;tree "STBPMAX_MSSG_SZ4"
group 0--3
line.long 0 "MAX_MSSG_SZ4"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025468A
;tree "STBPMAX_MSSG_SZ5"
group 0--3
line.long 0 "MAX_MSSG_SZ5"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025468C
;tree "STBPMAX_MSSG_SZ6"
group 0--3
line.long 0 "MAX_MSSG_SZ6"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025468E
;tree "STBPMAX_MSSG_SZ7"
group 0--3
line.long 0 "MAX_MSSG_SZ7"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254690
;tree "STBPMAX_MSSG_SZ8"
group 0--3
line.long 0 "MAX_MSSG_SZ8"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254692
;tree "STBPMAX_MSSG_SZ9"
group 0--3
line.long 0 "MAX_MSSG_SZ9"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254694
;tree "STBPMAX_MSSG_SZ10"
group 0--3
line.long 0 "MAX_MSSG_SZ10"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254696
;tree "STBPMAX_MSSG_SZ11"
group 0--3
line.long 0 "MAX_MSSG_SZ11"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254698
;tree "STBPMAX_MSSG_SZ12"
group 0--3
line.long 0 "MAX_MSSG_SZ12"
bitfld.long 0 0.--2. " MAX_MSSG_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546A0
;tree "STBPPRIO_LEVEL0"
group 0--3
line.long 0 "PRIO_LEVEL0"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546A2
;tree "STBPPRIO_LEVEL1"
group 0--3
line.long 0 "PRIO_LEVEL1"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546A4
;tree "STBPPRIO_LEVEL2"
group 0--3
line.long 0 "PRIO_LEVEL2"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546A6
;tree "STBPPRIO_LEVEL3"
group 0--3
line.long 0 "PRIO_LEVEL3"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546A8
;tree "STBPPRIO_LEVEL4"
group 0--3
line.long 0 "PRIO_LEVEL4"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546AA
;tree "STBPPRIO_LEVEL5"
group 0--3
line.long 0 "PRIO_LEVEL5"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546AC
;tree "STBPPRIO_LEVEL6"
group 0--3
line.long 0 "PRIO_LEVEL6"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546AE
;tree "STBPPRIO_LEVEL7"
group 0--3
line.long 0 "PRIO_LEVEL7"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546B0
;tree "STBPPRIO_LEVEL8"
group 0--3
line.long 0 "PRIO_LEVEL8"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546B2
;tree "STBPPRIO_LEVEL9"
group 0--3
line.long 0 "PRIO_LEVEL9"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546B4
;tree "STBPPRIO_LEVEL10"
group 0--3
line.long 0 "PRIO_LEVEL10"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546B6
;tree "STBPPRIO_LEVEL11"
group 0--3
line.long 0 "PRIO_LEVEL11"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546B8
;tree "STBPPRIO_LEVEL12"
group 0--3
line.long 0 "PRIO_LEVEL12"
bitfld.long 0 0.--10. " DYNAMIC_PRIO "  " "
bitfld.long 0 11.--13. " DYNAMIC_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA02546C0
;tree "STBPPROCESS_EN"
group 0--3
line.long 0 "PROCESS_EN"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA02546C2
;tree "STBPPORT_CTRL"
group 0--3
line.long 0 "PORT_CTRL"
bitfld.long 0 15. " IRP3_JPG_W "  "0 ,1 "
bitfld.long 0 14. " IRP2_PRA_W "  "0 ,1 "
bitfld.long 0 13. " IRP1_PRA_W "  "0 ,1 "
bitfld.long 0 12. " IRP0_PRA_R "  "0 ,1 "
bitfld.long 0 11. " IRP03_PRA_W "  "0 ,1 "
bitfld.long 0 10. " IRP03_HCP_R "  "0 ,1 "
bitfld.long 0 9. " IRP03_HCP_W "  "0 ,1 "
bitfld.long 0 8. " IRP03_VPC_W "  "0 ,1 "
bitfld.long 0 7. " IRP03_GCF_C_R "  "0 ,1 "
bitfld.long 0 6. " IRP03_GCF_L_R "  "0 ,1 "
bitfld.long 0 5. " IRP03_GCF_C_W "  "0 ,1 "
bitfld.long 0 4. " IRP03_GCF_L_W "  "0 ,1 "
bitfld.long 0 3. " IRP03_C2_W "  "0 ,1 "
bitfld.long 0 2. " IRP03_C1_W "  "0 ,1 "
bitfld.long 0 1. " IRP03_C_W "  "0 ,1 "
bitfld.long 0 0. " IRP03_L_W "  "0 ,1 "
;tree.end

base ad:0xA02546D0
;tree "STBPERR_ITS"
rgroup 0--3
line.long 0 "ERR_ITS"
bitfld.long 0 0. " ERR "  "0 ,1 "
;tree.end

base ad:0xA02546D2
;tree "STBPERR_ITS_BSET"
wgroup 0--3
line.long 0 "ERR_ITS_BSET"
bitfld.long 0 0. " ERR "  "0 ,1 "
;tree.end

base ad:0xA02546D4
;tree "STBPERR_ITS_BCLR"
wgroup 0--3
line.long 0 "ERR_ITS_BCLR"
bitfld.long 0 0. " ERR "  "0 ,1 "
;tree.end

base ad:0xA02546D6
;tree "STBPERR_ITM"
rgroup 0--3
line.long 0 "ERR_ITM"
bitfld.long 0 0. " ERR "  "0 ,1 "
;tree.end

base ad:0xA02546D8
;tree "STBPERR_ITM_BSET"
wgroup 0--3
line.long 0 "ERR_ITM_BSET"
bitfld.long 0 0. " ERR "  "0 ,1 "
;tree.end

base ad:0xA02546DA
;tree "STBPERR_ITM_BCLR"
wgroup 0--3
line.long 0 "ERR_ITM_BCLR"
bitfld.long 0 0. " ERR "  "0 ,1 "
;tree.end

base ad:0xA02546DC
;tree "STBPERR_INFO"
rgroup 0--3
line.long 0 "ERR_INFO"
hexfld.byte 0 " R_OPC "
bitfld.long 0 7.--15. " R_SRC "  " "
;tree.end

base ad:0xA02546DE
;tree "STBPERR_INFO_CLR"
wgroup 0--3
line.long 0 "ERR_INFO_CLR"
bitfld.long 0 0. " CLR "  "0 ,1 "
;tree.end

endif

tree.end

base ad:0xA0254800
;********************************************
tree "SIA-IPP"
;********************************************
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x8015741c)&0x28000)!=0x28000)||((data.long(ad:0x801571ec)&0x600)!=0x600)||((data.long(ad:0x80157428)&0x300)!=0x0))

base ad:0x8015700c
group 0--3
line.long 0 "PRCM_SIAMMDSPCLK_MGT"
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SIA_PHY_EN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 15. " SIA_L_VOK "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

else

base ad:0xA0254010
sgroup "CLOCK_ENABLE"
constx 0 %l 0x4
setx 0 %l 0
line.long 0 "CLOCK_ENABLE"
base ad:0xA0254010
group 0--3
line.long 0 "CLOCK_ENABLE"

if ((data.long(ad:0xA0254010)&0x4)==0x4)

base ad:0xA0254800
;tree "IPPDPHY_TOP_IF_EN"
group 0--3
line.long 0 "DPHY_TOP_IF_EN"
bitfld.long 0 0. " DPHY_TOP_IF_EN "  "0 ,1 "
;tree.end

base ad:0xA0254802
;tree "IPPSTATIC_TOP_IF_SEL"
group 0--3
line.long 0 "STATIC_TOP_IF_SEL"
bitfld.long 0 0.--1. " STATIC_TOP_IF_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254804
;tree "IPPSTATIC_CCP_IF"
group 0--3
line.long 0 "STATIC_CCP_IF"
bitfld.long 0 0. " STATIC_CCP_DSCLK "  "0 ,1 "
bitfld.long 0 7.--11. " STATIC_CCP_BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0254806
;tree "IPPINTERNAL_EN_CLK_CPP"
group 0--3
line.long 0 "INTERNAL_EN_CLK_CPP"
bitfld.long 0 0. " INTERNAL_EN_CLK_CPP "  "0 ,1 "
;tree.end

base ad:0xA0254808
;tree "IPPDPHY_COMPENSATION_CTRL"
group 0--3
line.long 0 "DPHY_COMPENSATION_CTRL"
bitfld.long 0 0. " CLK_1_5M_COMPENSATION_EN "  "0 ,1 "
bitfld.long 0 4. " DPHY_COMPENSATION_CALIB_START "  "0 ,1 "
bitfld.long 0 2. " DPHY_COMPENSATION_CALIB_WRITE_EN "  "0 ,1 "
bitfld.long 0 3.--5. " DPHY_COMPENSATION_CALIB_WRITE_CODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA025480A
;tree "IPPDPHY_COMPENSATION_STATUS"
rgroup 0--3
line.long 0 "DPHY_COMPENSATION_STATUS"
bitfld.long 0 0. " DPHY_COMPENSATION_OK "  "0 ,1 "
bitfld.long 0 1.--3. " DPHY_COMPENSATION_CALIB_READ_CODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4. " DPHY_COMPENSATION_DBG_COMP_FLAG "  "0 ,1 "
;tree.end

base ad:0xA025480C
;tree "IPPSTATIC_CSI0_DATA_LANES"
group 0--3
line.long 0 "STATIC_CSI0_DATA_LANES"
bitfld.long 0 0.--1. " STATIC_CSI0_DATA_LANES_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--12. " STATIC_CSI0_DATA_LANES_MAP "  " "
;tree.end

base ad:0xA025480E
;tree "IPPCSI2_DPHY0_CL_CTRL"
group 0--3
line.long 0 "CSI2_DPHY0_CL_CTRL"
bitfld.long 0 0.--5. " CSI0_UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8. " CSI0_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 9. " CSI0_SWAP_PINS_CL "  "0 ,1 "
bitfld.long 0 10. " CSI0_HS_INVERT_CL "  "0 ,1 "
bitfld.long 0 11. " CSI0_HSRX_TERM_SHIFT_UP_CL "  "0 ,1 "
bitfld.long 0 12. " CSI0_HSRX_TERM_SHIFT_DOWN_CL "  "0 ,1 "
bitfld.long 0 13. " CSI0_TEST_RESERVED_1_CL "  "0 ,1 "
;tree.end

base ad:0xA0254810
;tree "IPPCSI2_DPHY0_DL1_CTRL"
group 0--3
line.long 0 "CSI2_DPHY0_DL1_CTRL"
bitfld.long 0 0. " CSI0_SWAP_PINS_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI0_HS_INVERT_DL1 "  "0 ,1 "
bitfld.long 0 2. " CSI0_FORCE_RX_MODE_DL1 "  "0 ,1 "
bitfld.long 0 3. " CSI0_CD_OFF_DL1 "  "0 ,1 "
bitfld.long 0 4. " CSI0_EOT_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 5. " CSI0_HSRX_TERM_SHIFT_UP_DL1 "  "0 ,1 "
bitfld.long 0 6. " CSI0_HSRX_TERM_SHIFT_DOWN_DL1 "  "0 ,1 "
bitfld.long 0 7. " CSI0_TEST_RESERVED_1_DL1 "  "0 ,1 "
;tree.end

base ad:0xA0254812
;tree "IPPCSI2_DPHY0_DL2_CTRL"
group 0--3
line.long 0 "CSI2_DPHY0_DL2_CTRL"
bitfld.long 0 0. " CSI0_SWAP_PINS_DL2 "  "0 ,1 "
bitfld.long 0 1. " CSI0_HS_INVERT_DL2 "  "0 ,1 "
bitfld.long 0 2. " CSI0_FORCE_RX_MODE_DL2 "  "0 ,1 "
bitfld.long 0 3. " CSI0_CD_OFF_DL2 "  "0 ,1 "
bitfld.long 0 4. " CSI0_EOT_BYPASS_DL2 "  "0 ,1 "
bitfld.long 0 5. " CSI0_HSRX_TERM_SHIFT_UP_DL2 "  "0 ,1 "
bitfld.long 0 6. " CSI0_HSRX_TERM_SHIFT_DOWN_DL2 "  "0 ,1 "
bitfld.long 0 7. " CSI0_TEST_RESERVED_1_DL2 "  "0 ,1 "
;tree.end

base ad:0xA0254814
;tree "IPPCSI2_DPHY0_DL3_CTRL"
group 0--3
line.long 0 "CSI2_DPHY0_DL3_CTRL"
bitfld.long 0 0. " CSI0_SWAP_PINS_DL3 "  "0 ,1 "
bitfld.long 0 1. " CSI0_HS_INVERT_DL3 "  "0 ,1 "
bitfld.long 0 2. " CSI0_FORCE_RX_MODE_DL3 "  "0 ,1 "
bitfld.long 0 3. " CSI0_CD_OFF_DL3 "  "0 ,1 "
bitfld.long 0 4. " CSI0_EOT_BYPASS_DL3 "  "0 ,1 "
bitfld.long 0 5. " CSI0_HSRX_TERM_SHIFT_UP_DL3 "  "0 ,1 "
bitfld.long 0 6. " CSI0_HSRX_TERM_SHIFT_DOWN_DL3 "  "0 ,1 "
bitfld.long 0 7. " CSI0_TEST_RESERVED_1_DL3 "  "0 ,1 "
;tree.end

base ad:0xA0254816
;tree "IPPCSI2_DPHY0_CL_DBG"
group 0--3
line.long 0 "CSI2_DPHY0_CL_DBG"
bitfld.long 0 0.--2. " CSI0_HS_RX_OFFSET_CL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CSI0_MIPI_IN_SHORT_CL "  "0 ,1 "
bitfld.long 0 8. " CSI0_LP_HS_BYPASS_CL "  "0 ,1 "
bitfld.long 0 9.--10. " CSI0_LP_RX_VIL_CL "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " CSI0_DIRECT_DYN_ACCESS_CL "  "0 ,1 "
;tree.end

base ad:0xA0254818
;tree "IPPCSI2_DPHY0_DL1_DBG"
group 0--3
line.long 0 "CSI2_DPHY0_DL1_DBG"
bitfld.long 0 0.--2. " CSI0_HS_RX_OFFSET_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CSI0_MIPI_IN_SHORT_DL1 "  "0 ,1 "
bitfld.long 0 4.--6. " CSI0_SKEW_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " CSI0_OVERSAMPLE_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 8. " CSI0_LP_HS_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 9.--10. " CSI0_LP_RX_VIL_DL1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " CSI0_DIRECT_DYN_ACCESS_DL1 "  "0 ,1 "
;tree.end

base ad:0xA025481A
;tree "IPPCSI2_DPHY0_DL2_DBG"
group 0--3
line.long 0 "CSI2_DPHY0_DL2_DBG"
bitfld.long 0 0.--2. " CSI0_HS_RX_OFFSET_DL2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CSI0_MIPI_IN_SHORT_DL2 "  "0 ,1 "
bitfld.long 0 4.--6. " CSI0_SKEW_DL2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " CSI0_OVERSAMPLE_BYPASS_DL2 "  "0 ,1 "
bitfld.long 0 8. " CSI0_LP_HS_BYPASS_DL2 "  "0 ,1 "
bitfld.long 0 9.--10. " CSI0_LP_RX_VIL_DL2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " CSI0_DIRECT_DYN_ACCESS_DL2 "  "0 ,1 "
;tree.end

base ad:0xA025481C
;tree "IPPCSI2_DPHY0_DL3_DBG"
group 0--3
line.long 0 "CSI2_DPHY0_DL3_DBG"
bitfld.long 0 0.--2. " CSI0_HS_RX_OFFSET_DL3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CSI0_MIPI_IN_SHORT_DL3 "  "0 ,1 "
bitfld.long 0 4.--6. " CSI0_SKEW_DL3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " CSI0_OVERSAMPLE_BYPASS_DL3 "  "0 ,1 "
bitfld.long 0 8. " CSI0_LP_HS_BYPASS_DL3 "  "0 ,1 "
bitfld.long 0 9.--10. " CSI0_LP_RX_VIL_DL3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " CSI0_DIRECT_DYN_ACCESS_DL3 "  "0 ,1 "
;tree.end

base ad:0xA025481E
;tree "IPPCSI2_DPHY0_XL_DBG0_OBS"
rgroup 0--3
line.long 0 "CSI2_DPHY0_XL_DBG0_OBS"
bitfld.long 0 0. " CSI0_OVERSAMPLE_FLAG1_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI0_OVERSAMPLE_FLAG1_DL2 "  "0 ,1 "
bitfld.long 0 2. " CSI0_OVERSAMPLE_FLAG1_DL3 "  "0 ,1 "
bitfld.long 0 3. " CSI0_OVERSAMPLE_FLAG2_DL1 "  "0 ,1 "
bitfld.long 0 4. " CSI0_OVERSAMPLE_FLAG2_DL2 "  "0 ,1 "
bitfld.long 0 5. " CSI0_OVERSAMPLE_FLAG2_DL3 "  "0 ,1 "
bitfld.long 0 6. " CSI0_HS_RX_ZM_CL "  "0 ,1 "
bitfld.long 0 7. " CSI0_HS_RX_ZM_DL1 "  "0 ,1 "
bitfld.long 0 8. " CSI0_HS_RX_ZM_DL2 "  "0 ,1 "
bitfld.long 0 9. " CSI0_HS_RX_ZM_DL3 "  "0 ,1 "
bitfld.long 0 10. " CSI0_RX_INIT_CLK "  "0 ,1 "
;tree.end

base ad:0xA0254820
;tree "IPPCSI2_DPHY0_XL_DBG1_OBS"
rgroup 0--3
line.long 0 "CSI2_DPHY0_XL_DBG1_OBS"
bitfld.long 0 0. " CSI0_STOP_STATE_CL "  "0 ,1 "
bitfld.long 0 1. " CSI0_STOP_STATE_DL1 "  "0 ,1 "
bitfld.long 0 2. " CSI0_STOP_STATE_DL2 "  "0 ,1 "
bitfld.long 0 3. " CSI0_STOP_STATE_DL3 "  "0 ,1 "
bitfld.long 0 4. " CSI0_ULP_ACTIVE_NOT_CL "  "0 ,1 "
bitfld.long 0 5. " CSI0_ULP_ACTIVE_NOT_DL1 "  "0 ,1 "
bitfld.long 0 6. " CSI0_ULP_ACTIVE_NOT_DL2 "  "0 ,1 "
bitfld.long 0 7. " CSI0_ULP_ACTIVE_NOT_DL3 "  "0 ,1 "
;tree.end

base ad:0xA0254822
;tree "IPPCSI2_DPHY1_CL_CTRL"
group 0--3
line.long 0 "CSI2_DPHY1_CL_CTRL"
bitfld.long 0 0.--5. " CSI0_UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8. " CSI0_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 9. " CSI0_SWAP_PINS_CL "  "0 ,1 "
bitfld.long 0 10. " CSI0_HS_INVERT_CL "  "0 ,1 "
bitfld.long 0 11. " CSI0_HSRX_TERM_SHIFT_UP_CL "  "0 ,1 "
bitfld.long 0 12. " CSI0_HSRX_TERM_SHIFT_DOWN_CL "  "0 ,1 "
bitfld.long 0 13. " CSI0_TEST_RESERVED_1_CL "  "0 ,1 "
;tree.end

base ad:0xA0254824
;tree "IPPCSI2_DPHY1_DL1_CTRL"
group 0--3
line.long 0 "CSI2_DPHY1_DL1_CTRL"
bitfld.long 0 0. " CSI0_SWAP_PINS_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI0_HS_INVERT_DL1 "  "0 ,1 "
bitfld.long 0 2. " CSI0_FORCE_RX_MODE_DL1 "  "0 ,1 "
bitfld.long 0 3. " CSI0_CD_OFF_DL1 "  "0 ,1 "
bitfld.long 0 4. " CSI0_EOT_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 5. " CSI0_HSRX_TERM_SHIFT_UP_DL1 "  "0 ,1 "
bitfld.long 0 6. " CSI0_HSRX_TERM_SHIFT_DOWN_DL1 "  "0 ,1 "
bitfld.long 0 7. " CSI0_TEST_RESERVED_1_DL1 "  "0 ,1 "
;tree.end

base ad:0xA0254826
;tree "IPPCSI2_DPHY1_CL_DBG"
group 0--3
line.long 0 "CSI2_DPHY1_CL_DBG"
bitfld.long 0 0.--2. " CSI0_HS_RX_OFFSET_CL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CSI0_MIPI_IN_SHORT_CL "  "0 ,1 "
bitfld.long 0 8. " CSI0_LP_HS_BYPASS_CL "  "0 ,1 "
bitfld.long 0 9.--10. " CSI0_LP_RX_VIL_CL "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " CSI0_DIRECT_DYN_ACCESS_CL "  "0 ,1 "
;tree.end

base ad:0xA0254828
;tree "IPPCSI2_DPHY1_DL1_DBG"
group 0--3
line.long 0 "CSI2_DPHY1_DL1_DBG"
bitfld.long 0 0.--2. " CSI0_HS_RX_OFFSET_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CSI0_MIPI_IN_SHORT_DL1 "  "0 ,1 "
bitfld.long 0 4.--6. " CSI0_SKEW_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " CSI0_OVERSAMPLE_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 8. " CSI0_LP_HS_BYPASS_DL1 "  "0 ,1 "
bitfld.long 0 9.--10. " CSI0_LP_RX_VIL_DL1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " CSI0_DIRECT_DYN_ACCESS_DL1 "  "0 ,1 "
;tree.end

base ad:0xA025482A
;tree "IPPCSI2_DPHY1_XL_DBG_OBS"
rgroup 0--3
line.long 0 "CSI2_DPHY1_XL_DBG_OBS"
bitfld.long 0 0. " CSI1_OVERSAMPLE_FLAG1_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI1_OVERSAMPLE_FLAG2_DL1 "  "0 ,1 "
bitfld.long 0 2. " CSI1_HS_RX_ZM_CL "  "0 ,1 "
bitfld.long 0 3. " CSI1_HS_RX_ZM_DL1 "  "0 ,1 "
bitfld.long 0 4. " CSI1_RX_INIT_CLK "  "0 ,1 "
bitfld.long 0 8. " CSI1_STOP_STATE_CL "  "0 ,1 "
bitfld.long 0 9. " CSI1_STOP_STATE_DL1 "  "0 ,1 "
bitfld.long 0 10. " CSI1_ULP_ACTIVE_NOT_CL "  "0 ,1 "
bitfld.long 0 11. " CSI1_ULP_ACTIVE_NOT_DL1 "  "0 ,1 "
;tree.end

base ad:0xA025482C
;tree "IPPCSI2_DPHY0_DBG_ITS"
rgroup 0--3
line.long 0 "CSI2_DPHY0_DBG_ITS"
bitfld.long 0 0. " CSI0_ERR_ESC_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI0_ERR_ESC_DL2 "  "0 ,1 "
bitfld.long 0 2. " CSI0_ERR_ESC_DL3 "  "0 ,1 "
bitfld.long 0 3. " CSI0_ERR_SYNC_ESC_DL1 "  "0 ,1 "
bitfld.long 0 4. " CSI0_ERR_SYNC_ESC_DL2 "  "0 ,1 "
bitfld.long 0 5. " CSI0_ERR_SYNC_ESC_DL3 "  "0 ,1 "
;tree.end

base ad:0xA025482E
;tree "IPPCSI2_DPHY0_DBG_ITS_BCLR"
wgroup 0--3
line.long 0 "CSI2_DPHY0_DBG_ITS_BCLR"
bitfld.long 0 0.--5. " CSI0_DBG_ITS_BCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254830
;tree "IPPCSI2_DPHY0_DBG_ITS_BSET"
wgroup 0--3
line.long 0 "CSI2_DPHY0_DBG_ITS_BSET"
bitfld.long 0 0.--5. " CSI0_DBG_ITS_BSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254832
;tree "IPPCSI2_DPHY0_DBG_ITM"
rgroup 0--3
line.long 0 "CSI2_DPHY0_DBG_ITM"
bitfld.long 0 0.--5. " CSI0_DBG_ITM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254834
;tree "IPPCSI2_DPHY0_DBG_ITM_BCLR"
wgroup 0--3
line.long 0 "CSI2_DPHY0_DBG_ITM_BCLR"
bitfld.long 0 0.--5. " CSI0_DBG_ITM_BCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254836
;tree "IPPCSI2_DPHY0_DBG_ITM_BSET"
wgroup 0--3
line.long 0 "CSI2_DPHY0_DBG_ITM_BSET"
bitfld.long 0 0.--5. " CSI0_DBG_ITM_BSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254838
;tree "IPPCSI2_DPHY1_DBG_ITS"
rgroup 0--3
line.long 0 "CSI2_DPHY1_DBG_ITS"
bitfld.long 0 0. " CSI1_ERR_ESC_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI1_ERR_SYNC_ESC_DL1 "  "0 ,1 "
;tree.end

base ad:0xA025483A
;tree "IPPCSI2_DPHY1_DBG_ITS_BCLR"
wgroup 0--3
line.long 0 "CSI2_DPHY1_DBG_ITS_BCLR"
bitfld.long 0 0.--1. " CSI1_DBG_ITS_BCLR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA025483C
;tree "IPPCSI2_DPHY1_DBG_ITS_BSET"
wgroup 0--3
line.long 0 "CSI2_DPHY1_DBG_ITS_BSET"
bitfld.long 0 0.--1. " CSI1_DBG_ITS_BSET "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA025483E
;tree "IPPCSI2_DPHY1_DBG_ITM"
rgroup 0--3
line.long 0 "CSI2_DPHY1_DBG_ITM"
bitfld.long 0 0.--1. " CSI1_DBG_ITM "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254840
;tree "IPPCSI2_DPHY1_DBG_ITM_BCLR"
wgroup 0--3
line.long 0 "CSI2_DPHY1_DBG_ITM_BCLR"
bitfld.long 0 0.--1. " CSI1_DBG_ITM_BCLR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254842
;tree "IPPCSI2_DPHY1_DBG_ITM_BSET"
wgroup 0--3
line.long 0 "CSI2_DPHY1_DBG_ITM_BSET"
bitfld.long 0 0.--1. " CSI1_DBG_ITM_BSET "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254844
;tree "IPPCSI2_PACKET_DBG_ITS"
rgroup 0--3
line.long 0 "CSI2_PACKET_DBG_ITS"
bitfld.long 0 0. " CSI2_PACKET_ECC_CORRECTED_DBG "  "0 ,1 "
;tree.end

base ad:0xA0254846
;tree "IPPCSI2_PACKET_DBG_ITS_BCLR"
wgroup 0--3
line.long 0 "CSI2_PACKET_DBG_ITS_BCLR"
bitfld.long 0 0. " CSI2_PACKET_DBG_ITS_BCLR "  "0 ,1 "
;tree.end

base ad:0xA0254848
;tree "IPPCSI2_PACKET_DBG_ITS_BSET"
wgroup 0--3
line.long 0 "CSI2_PACKET_DBG_ITS_BSET"
bitfld.long 0 0. " CSI2_PACKET_DBG_ITS_BSET "  "0 ,1 "
;tree.end

base ad:0xA025484A
;tree "IPPCSI2_PACKET_DBG_ITM"
rgroup 0--3
line.long 0 "CSI2_PACKET_DBG_ITM"
bitfld.long 0 0. " CSI2_PACKET_ECC_CORRECTED_DBG "  "0 ,1 "
;tree.end

base ad:0xA025484C
;tree "IPPCSI2_PACKET_DBG_ITM_BCLR"
wgroup 0--3
line.long 0 "CSI2_PACKET_DBG_ITM_BCLR"
bitfld.long 0 0. " CSI2_PACKET_DBG_ITM_BCLR "  "0 ,1 "
;tree.end

base ad:0xA025484E
;tree "IPPCSI2_PACKET_DBG_ITM_BSET"
wgroup 0--3
line.long 0 "CSI2_PACKET_DBG_ITM_BSET"
bitfld.long 0 0. " CSI2_PACKET_DBG_ITM_BSET "  "0 ,1 "
;tree.end

base ad:0xA0254850
;tree "IPPCSI2RX_VC_DATA_TYPE_R"
rgroup 0--3
line.long 0 "CSI2RX_VC_DATA_TYPE_R"
bitfld.long 0 0.--5. " CSI2RX_VC_DATA_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--7. " CSI2RX_VIRTUAL_CHANNEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254852
;tree "IPPSTATIC_CSI2RX_VC_DATA_TYPE_W"
group 0--3
line.long 0 "STATIC_CSI2RX_VC_DATA_TYPE_W"
bitfld.long 0 0.--5. " CSI2RX_IMAGE_DATA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8.--13. " CSI2RX_NON_IMAGE_DATA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0xA0254854
;tree "IPPSTATIC_CSI2RX_VC_W"
wgroup 0--3
line.long 0 "STATIC_CSI2RX_VC_W"
bitfld.long 0 0.--1. " STATIC_CSI2RX_VC "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254856
;tree "IPPCSI2RX_FRAME_NB_R"
rgroup 0--3
line.long 0 "CSI2RX_FRAME_NB_R"
hexfld.word 0 " CSI2RX_FRAME_NB "
;tree.end

base ad:0xA0254858
;tree "IPPCSI2RX_DATA_FIELD_R"
rgroup 0--3
line.long 0 "CSI2RX_DATA_FIELD_R"
hexfld.word 0 " CSI2RX_DATA_FIELD "
;tree.end

base ad:0xA025485A
;tree "IPPSTATIC_CSI2RX_PIX_WIDTH_W"
group 0--3
line.long 0 "STATIC_CSI2RX_PIX_WIDTH_W"
bitfld.long 0 0.--3. " STATIC_CSI2RX_ACTDATA_PIXWIDTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " STATIC_CSI2RX_EMBDATA_PIXWIDTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA025485C
;tree "IPPCSI2_DPHY_ERROR_ITS"
rgroup 0--3
line.long 0 "CSI2_DPHY_ERROR_ITS"
bitfld.long 0 0. " CSI0_ERR_EOT_SYNC_HS_DL1 "  "0 ,1 "
bitfld.long 0 1. " CSI0_ERR_EOT_SYNC_HS_DL2 "  "0 ,1 "
bitfld.long 0 2. " CSI0_ERR_EOT_SYNC_HS_DL3 "  "0 ,1 "
bitfld.long 0 3. " CSI0_ERR_SOT_HS_DL1 "  "0 ,1 "
bitfld.long 0 4. " CSI0_ERR_SOT_HS_DL2 "  "0 ,1 "
bitfld.long 0 5. " CSI0_ERR_SOT_HS_DL3 "  "0 ,1 "
bitfld.long 0 6. " CSI0_ERR_SOT_SYNC_HS_DL1 "  "0 ,1 "
bitfld.long 0 7. " CSI0_ERR_SOT_SYNC_HS_DL2 "  "0 ,1 "
bitfld.long 0 8. " CSI0_ERR_SOT_SYNC_HS_DL3 "  "0 ,1 "
bitfld.long 0 9. " CSI0_ERR_CONTROL_DL1 "  "0 ,1 "
bitfld.long 0 10. " CSI0_ERR_CONTROL_DL2 "  "0 ,1 "
bitfld.long 0 11. " CSI0_ERR_CONTROL_DL3 "  "0 ,1 "
bitfld.long 0 12. " CSI1_ERR_EOT_SYNC_HS_DL1 "  "0 ,1 "
bitfld.long 0 13. " CSI1_ERR_SOT_HS_DL1 "  "0 ,1 "
bitfld.long 0 14. " CSI1_ERR_SOT_SYNC_HS_DL1 "  "0 ,1 "
bitfld.long 0 15. " CSI1_ERR_CONTROL_DL1 "  "0 ,1 "
;tree.end

base ad:0xA025485E
;tree "IPPCSI2_DPHY_ERROR_ITS_BCLR"
wgroup 0--3
line.long 0 "CSI2_DPHY_ERROR_ITS_BCLR"
hexfld.word 0 " CSI_DPHY_ERROR_ITS_BCLR "
;tree.end

base ad:0xA0254860
;tree "IPPCSI2_DPHY_ERROR_ITS_BSET"
wgroup 0--3
line.long 0 "CSI2_DPHY_ERROR_ITS_BSET"
hexfld.word 0 " CSI_DPHY_ERROR_ITS_BSET "
;tree.end

base ad:0xA0254862
;tree "IPPCSI2_DPHY_ERROR_ITM"
rgroup 0--3
line.long 0 "CSI2_DPHY_ERROR_ITM"
hexfld.word 0 " CSI_DPHY_ERROR_ITM "
;tree.end

base ad:0xA0254864
;tree "IPPCSI2_DPHY_ERROR_ITM_BCLR"
wgroup 0--3
line.long 0 "CSI2_DPHY_ERROR_ITM_BCLR"
hexfld.word 0 " CSI_DPHY_ERROR_ITM_BCLR "
;tree.end

base ad:0xA0254866
;tree "IPPCSI2_DPHY_ERROR_ITM_BSET"
wgroup 0--3
line.long 0 "CSI2_DPHY_ERROR_ITM_BSET"
hexfld.word 0 " CSI_DPHY_ERROR_ITM_BSET "
;tree.end

base ad:0xA0254868
;tree "IPPCSI2_PACKET_ERROR_ITS"
rgroup 0--3
line.long 0 "CSI2_PACKET_ERROR_ITS"
bitfld.long 0 0. " CSI2_PACKET_PAYLOAD_CRC_ERROR "  "0 ,1 "
bitfld.long 0 1. " CSI2_PACKET_HEADER_ECC_ERROR "  "0 ,1 "
;tree.end

base ad:0xA025486A
;tree "IPPCSI2_PACKET_ERROR_ITS_BCLR"
wgroup 0--3
line.long 0 "CSI2_PACKET_ERROR_ITS_BCLR"
bitfld.long 0 0.--1. " CSI_PACKET_ERROR_ITS_BCLR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA025486C
;tree "IPPCSI2_PACKET_ERROR_ITS_BSET"
wgroup 0--3
line.long 0 "CSI2_PACKET_ERROR_ITS_BSET"
bitfld.long 0 0.--1. " CSI_PACKET_ERROR_ITS_BSET "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA025486E
;tree "IPPCSI2_PACKET_ERROR_ITM"
rgroup 0--3
line.long 0 "CSI2_PACKET_ERROR_ITM"
bitfld.long 0 0.--1. " CSI_PACKET_ERROR_ITM "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254870
;tree "IPPCSI2_PACKET_ERROR_ITM_BCLR"
wgroup 0--3
line.long 0 "CSI2_PACKET_ERROR_ITM_BCLR"
bitfld.long 0 0.--1. " CSI_PACKET_ERROR_ITM_BCLR "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254872
;tree "IPPCSI2_PACKET_ERROR_ITM_BSET"
wgroup 0--3
line.long 0 "CSI2_PACKET_ERROR_ITM_BSET"
bitfld.long 0 0.--1. " CSI_PACKET_ERROR_ITM_BSET "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254874
;tree "IPPSTATIC_OPIPE03_SEL"
group 0--3
line.long 0 "STATIC_OPIPE03_SEL"
bitfld.long 0 0. " STATIC_OPIPE03_SEL "  "0 ,1 "
;tree.end

base ad:0xA0254880
;tree "IPPISP_ASYNC_RESET"
wgroup 0--3
line.long 0 "ISP_ASYNC_RESET"
hexfld.long 0 " ISP_ASYNC_RESET "
;tree.end

base ad:0xA0254882
;tree "IPPISP_SD_RESET"
wgroup 0--3
line.long 0 "ISP_SD_RESET"
hexfld.long 0 " ISP_SD_RESET "
;tree.end

base ad:0xA0254884
;tree "IPPSD_STATIC_CCP_EN"
group 0--3
line.long 0 "SD_STATIC_CCP_EN"
bitfld.long 0 0. " STATIC_SD_CCP_EN "  "0 ,1 "
;tree.end

base ad:0xA0254886
;tree "IPPSD_STATIC_SDG_CSI_MODE"
group 0--3
line.long 0 "SD_STATIC_SDG_CSI_MODE"
bitfld.long 0 0. " STATIC_SDG_CSI_MODE "  "0 ,1 "
;tree.end

base ad:0xA0254888
;tree "IPPSD_PRY0_ENABLE_SET"
wgroup 0--3
line.long 0 "SD_PRY0_ENABLE_SET"
hexfld.long 0 " SD_PRY0_ENABLE_SET "
;tree.end

base ad:0xA025488A
;tree "IPPSD_PRY1_ENABLE_SET"
wgroup 0--3
line.long 0 "SD_PRY1_ENABLE_SET"
hexfld.long 0 " SD_PRY1_ENABLE_SET "
;tree.end

base ad:0xA025488C
;tree "IPPSD_PRY1_ENABLE_CLR"
wgroup 0--3
line.long 0 "SD_PRY1_ENABLE_CLR"
hexfld.long 0 " SD_PRY1_ENABLE_CLR "
;tree.end

base ad:0xA025488E
;tree "IPPSD_PRY1_ENABLE_CLR"
wgroup 0--3
line.long 0 "SD_PRY1_ENABLE_CLR"
hexfld.long 0 " SD_PRY1_ENABLE_CLR "
;tree.end

base ad:0xA0254890
;tree "IPPSD_PRY0_ENABLE_STATUS"
rgroup 0--3
line.long 0 "SD_PRY0_ENABLE_STATUS"
bitfld.long 0 0. " PRY0_ENABLE_STATUS "  "0 ,1 "
;tree.end

base ad:0xA0254892
;tree "IPPSD_PRY1_ENABLE_STATUS"
rgroup 0--3
line.long 0 "SD_PRY1_ENABLE_STATUS"
bitfld.long 0 0. " PRY1_ENABLE_STATUS "  "0 ,1 "
;tree.end

base ad:0xA0254894
;tree "IPPSD_BMS_ENABLE_SET"
wgroup 0--3
line.long 0 "SD_BMS_ENABLE_SET"
hexfld.long 0 " SD_BMS_ENABLE_SET "
;tree.end

base ad:0xA0254896
;tree "IPPSD_BMS_ENABLE_CLR"
wgroup 0--3
line.long 0 "SD_BMS_ENABLE_CLR"
hexfld.long 0 " SD_BMS_ENABLE_CLR "
;tree.end

base ad:0xA0254898
;tree "IPPSD_BMS_ENABLE_STATUS"
rgroup 0--3
line.long 0 "SD_BMS_ENABLE_STATUS"
bitfld.long 0 0. " BMS_ENABLE_STATUS "  "0 ,1 "
;tree.end

base ad:0xA025489A
;tree "IPPSD_PRY0_FORMAT"
group 0--3
line.long 0 "SD_PRY0_FORMAT"
bitfld.long 0 8.--11. " PRY0_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA025489C
;tree "IPPSD_PRY1_FORMAT"
group 0--3
line.long 0 "SD_PRY1_FORMAT"
hexfld.byte 0 " PRY1_ALPHA "
bitfld.long 0 8.--11. " PRY1_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA025489E
;tree "IPPSD_BMS_FORMAT"
group 0--3
line.long 0 "SD_BMS_FORMAT"
bitfld.long 0 0. " BMS_RAW_FORMAT "  "0 ,1 "
bitfld.long 0 1. " BMS_RAW_SEL "  "0 ,1 "
;tree.end

base ad:0xA02548A0
;tree "IPPSD_STATIC_MEM_LOAD_EN"
group 0--3
line.long 0 "SD_STATIC_MEM_LOAD_EN"
bitfld.long 0 0. " STATIC_MEM_LOAD_EN "  "0 ,1 "
;tree.end

base ad:0xA02548A2
;tree "IPPSD_STATIC_LOAD_FORMAT"
group 0--3
line.long 0 "SD_STATIC_LOAD_FORMAT"
bitfld.long 0 0.--1. " STATIC_LOAD_FORMAT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " STATIC_LOAD_RAW_SEL "  "0 ,1 "
;tree.end

base ad:0xA02548A4
;tree "IPPSD_STATIC_LOAD_LINE_TIME_LSB_EN"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TIME_LSB_EN"
bitfld.long 0 0. " STATIC_LOAD_LINE_TIME_EN "  "0 ,1 "
bitfld.long 0 1.--15. " STATIC_LOAD_LINE_TIME_LSB "  " "
;tree.end

base ad:0xA02548A6
;tree "IPPSD_STATIC_LOAD_LINE_TIME_MSB"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TIME_MSB"
bitfld.long 0 0.--4. " STATIC_INTERLINE_TIME_MSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA02548A8
;tree "IPPSD_STATIC_LOAD_WW"
group 0--3
line.long 0 "SD_STATIC_LOAD_WW"
bitfld.long 0 0.--11. " STATIC_LOAD_WW "  " "
;tree.end

base ad:0xA02548AA
;tree "IPPSD_STATIC_LOAD_BML_PIXEL_ORDER"
group 0--3
line.long 0 "SD_STATIC_LOAD_BML_PIXEL_ORDER"
bitfld.long 0 0.--1. " STATIC_LOAD_BML_PIXEL_ORDER "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA02548AC
;tree "IPPSD_STATIC_LOAD_LINE_TYPE0"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE0"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT0 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548AE
;tree "IPPSD_STATIC_LOAD_LINE_TYPE1"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE1"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT1 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548B0
;tree "IPPSD_STATIC_LOAD_LINE_TYPE2"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE2"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT2 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548B2
;tree "IPPSD_STATIC_LOAD_LINE_TYPE3"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE3"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT3 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548B4
;tree "IPPSD_STATIC_LOAD_LINE_TYPE4"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE4"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT4 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548B6
;tree "IPPSD_STATIC_LOAD_LINE_TYPE5"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE5"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT5 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID5 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548B8
;tree "IPPSD_STATIC_LOAD_LINE_TYPE6"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE6"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT6 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID6 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548BA
;tree "IPPSD_STATIC_LOAD_LINE_TYPE7"
group 0--3
line.long 0 "SD_STATIC_LOAD_LINE_TYPE7"
bitfld.long 0 0.--11. " STATIC_LOAD_LINETYPE_HEIGHT7 "  " "
bitfld.long 0 12.--15. " STATIC_LOAD_LINETYPE_ID7 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA02548BC
;tree "IPPSD_ERROR_ITS"
rgroup 0--3
line.long 0 "SD_ERROR_ITS"
bitfld.long 0 0. " CCP_SHIFT_SYNC "  "0 ,1 "
bitfld.long 0 1. " CCP_FALSE_SYNC "  "0 ,1 "
bitfld.long 0 2. " CCP_CRC_ERROR "  "0 ,1 "
bitfld.long 0 3. " OPIPE0_CH0_OVERFLOW "  "0 ,1 "
bitfld.long 0 4. " OPIPE0_CH1_OVERFLOW "  "0 ,1 "
bitfld.long 0 5. " OPIPE0_CH2_OVERFLOW "  "0 ,1 "
bitfld.long 0 6. " OPIPE1_OVERFLOW "  "0 ,1 "
bitfld.long 0 7. " OPIPE2_OVERFLOW "  "0 ,1 "
bitfld.long 0 8. " OPIPE0_MULT_ERR "  "0 ,1 "
bitfld.long 0 9. " OPIPE1_MULT_ERR "  "0 ,1 "
bitfld.long 0 10. " SD_CSI2_PACKET_ERROR "  "0 ,1 "
bitfld.long 0 11. " SD_CSI2_DPHY_ERROR "  "0 ,1 "
;tree.end

base ad:0xA02548BE
;tree "IPPSD_ERROR_ITS_BCLR"
wgroup 0--3
line.long 0 "SD_ERROR_ITS_BCLR"
bitfld.long 0 0.--11. " SD_ERROR_ITS_BCLR "  " "
;tree.end

base ad:0xA02548C0
;tree "IPPSD_ERROR_ITS_BSET"
wgroup 0--3
line.long 0 "SD_ERROR_ITS_BSET"
bitfld.long 0 0.--11. " SD_ERROR_ITS_BSET "  " "
;tree.end

base ad:0xA02548C2
;tree "IPPSD_ERROR_ITM"
rgroup 0--3
line.long 0 "SD_ERROR_ITM"
bitfld.long 0 0.--11. " SD_ERROR_ITM "  " "
;tree.end

base ad:0xA02548C4
;tree "IPPSD_ERROR_ITM_BCLR"
wgroup 0--3
line.long 0 "SD_ERROR_ITM_BCLR"
bitfld.long 0 0.--11. " SD_ERROR_ITM_BCLR "  " "
;tree.end

base ad:0xA02548C6
;tree "IPPSD_ERROR_ITM_BSET"
wgroup 0--3
line.long 0 "SD_ERROR_ITM_BSET"
bitfld.long 0 0.--11. " SD_ERROR_ITM_BSET "  " "
;tree.end

base ad:0xA02548C8
;tree "IPPSD_OPIPE0_MULT_ERR_DBG"
rgroup 0--3
line.long 0 "SD_OPIPE0_MULT_ERR_DBG"
bitfld.long 0 0. " SD_OPIPE0_CH0_MULT_ERR_DBG "  "0 ,1 "
bitfld.long 0 1. " SD_OPIPE0_CH1_MULT_ERR_DBG "  "0 ,1 "
bitfld.long 0 2. " SD_OPIPE0_CH2_MULT_ERR_DBG "  "0 ,1 "
;tree.end

base ad:0xA02548D0
;tree "IPPCD_RESET"
wgroup 0--3
line.long 0 "CD_RESET"
hexfld.long 0 " CD_RESET "
;tree.end

base ad:0xA02548D2
;tree "IPPCD_START"
wgroup 0--3
line.long 0 "CD_START"
hexfld.long 0 " CD_START "
;tree.end

base ad:0xA02548D4
;tree "IPPCD_STATIC_EN"
group 0--3
line.long 0 "CD_STATIC_EN"
bitfld.long 0 0. " STATIC_CD_EN "  "0 ,1 "
;tree.end

base ad:0xA02548D6
;tree "IPPCD_STATIC_CDG_CSI_PADD_EN"
group 0--3
line.long 0 "CD_STATIC_CDG_CSI_PADD_EN"
bitfld.long 0 0. " STATIC_CDG_CSI_PADD_EN "  "0 ,1 "
;tree.end

base ad:0xA02548D8
;tree "IPPCD_STATIC_CCP_FC"
group 0--3
line.long 0 "CD_STATIC_CCP_FC"
hexfld.byte 0 " STATIC_CCP_FS "
bitfld.long 0 7.--15. " STATIC_CCP_FE "  " "
;tree.end

base ad:0xA02548DA
;tree "IPPCD_STATIC_CCP_LC"
group 0--3
line.long 0 "CD_STATIC_CCP_LC"
hexfld.byte 0 " STATIC_CCP_LS "
bitfld.long 0 7.--15. " STATIC_CCP_LE "  " "
;tree.end

base ad:0xA02548DC
;tree "IPPCD_RAW"
group 0--3
line.long 0 "CD_RAW"
bitfld.long 0 0. " JPEG_PADD_EN "  "0 ,1 "
bitfld.long 0 1.--2. " CCP_RAW_SWAP "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA02548DE
;tree "IPPCD_PIPE3_FORMAT"
group 0--3
line.long 0 "CD_PIPE3_FORMAT"
bitfld.long 0 0.--2. " PIPE3_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BT601_EN "  "0 ,1 "
;tree.end

base ad:0xA02548E0
;tree "IPPCD_CROP_EN"
group 0--3
line.long 0 "CD_CROP_EN"
bitfld.long 0 0. " CROP_EN "  "0 ,1 "
;tree.end

base ad:0xA02548E2
;tree "IPPCD_CROP_H0"
group 0--3
line.long 0 "CD_CROP_H0"
bitfld.long 0 1.--11. " CROP_H0 "  " "
;tree.end

base ad:0xA02548E4
;tree "IPPCD_CROP_V0"
group 0--3
line.long 0 "CD_CROP_V0"
bitfld.long 0 1.--11. " CROP_V0 "  " "
;tree.end

base ad:0xA02548E6
;tree "IPPCD_CROP_H1"
group 0--3
line.long 0 "CD_CROP_H1"
bitfld.long 0 1.--11. " CROP_H1 "  " "
;tree.end

base ad:0xA02548E8
;tree "IPPCD_CROP_V1"
group 0--3
line.long 0 "CD_CROP_V1"
bitfld.long 0 1.--11. " CROP_V1 "  " "
;tree.end

base ad:0xA02548EA
;tree "IPPCD_ERROR_ITS"
rgroup 0--3
line.long 0 "CD_ERROR_ITS"
bitfld.long 0 1. " CCP_ERROR "  "0 ,1 "
bitfld.long 0 2. " RAW_DATA_ERROR_NOT_X8_BYTES "  "0 ,1 "
bitfld.long 0 3. " RAW_DATA_ERROR_OVERFLOW "  "0 ,1 "
bitfld.long 0 4. " LUMA_ERROR_NOT_X8_LUMA_BYTES "  "0 ,1 "
bitfld.long 0 5. " LUMA_ERROR_OVERFLOW "  "0 ,1 "
bitfld.long 0 6. " CHROMA_ERROR_NOT_X16BYTES_3BUF "  "0 ,1 "
bitfld.long 0 7. " CHROMA_ERROR_NOT_X8BYTES_2BUF "  "0 ,1 "
bitfld.long 0 8. " CHROMA_ERROR_OVERFLOW "  "0 ,1 "
bitfld.long 0 9. " CD_CSI2_PACKET_ERROR "  "0 ,1 "
bitfld.long 0 10. " CD_CSI2_DPHY_ERROR "  "0 ,1 "
;tree.end

base ad:0xA02548EC
;tree "IPPCD_ERROR_ITS_BCLR"
wgroup 0--3
line.long 0 "CD_ERROR_ITS_BCLR"
bitfld.long 0 0.--10. " CD_ERROR_ITS_BCLR "  " "
;tree.end

base ad:0xA02548EE
;tree "IPPCD_ERROR_ITS_BSET"
wgroup 0--3
line.long 0 "CD_ERROR_ITS_BSET"
bitfld.long 0 0.--10. " CD_ERROR_ITS_BSET "  " "
;tree.end

base ad:0xA02548F0
;tree "IPPCD_ERROR_ITM"
rgroup 0--3
line.long 0 "CD_ERROR_ITM"
bitfld.long 0 0.--10. " CD_ERROR_ITM "  " "
;tree.end

base ad:0xA02548F2
;tree "IPPCD_ERROR_ITM_BCLR"
wgroup 0--3
line.long 0 "CD_ERROR_ITM_BCLR"
bitfld.long 0 0.--10. " CD_ERROR_ITM_BCLR "  " "
;tree.end

base ad:0xA02548F4
;tree "IPPCD_ERROR_ITM_BSET"
wgroup 0--3
line.long 0 "CD_ERROR_ITM_BSET"
bitfld.long 0 0.--10. " CD_ERROR_ITM_BSET "  " "
;tree.end

base ad:0xA02548F6
;tree "IPPCD_RAW_EOF_ITS"
rgroup 0--3
line.long 0 "CD_RAW_EOF_ITS"
bitfld.long 0 0. " CD_RAW_EOF_ITS "  "0 ,1 "
;tree.end

base ad:0xA02548F8
;tree "IPPCD_RAW_EOF_ITS_BCLR"
wgroup 0--3
line.long 0 "CD_RAW_EOF_ITS_BCLR"
bitfld.long 0 0. " CD_RAW_EOF_ITS_BCLR "  "0 ,1 "
;tree.end

base ad:0xA02548FA
;tree "IPPCD_RAW_EOF_ITS_BSET"
wgroup 0--3
line.long 0 "CD_RAW_EOF_ITS_BSET"
bitfld.long 0 0. " CD_RAW_EOF_ITS_BSET "  "0 ,1 "
;tree.end

base ad:0xA02548FC
;tree "IPPCD_RAW_EOF_ITM"
rgroup 0--3
line.long 0 "CD_RAW_EOF_ITM"
bitfld.long 0 0. " CD_RAW_EOF_ITM "  "0 ,1 "
;tree.end

base ad:0xA02548FE
;tree "IPPCD_RAW_EOF_ITM_BCLR"
wgroup 0--3
line.long 0 "CD_RAW_EOF_ITM_BCLR"
bitfld.long 0 0. " CD_RAW_EOF_ITM_BCLR "  "0 ,1 "
;tree.end

base ad:0xA0254900
;tree "IPPCD_RAW_EOF_ITM_BSET"
wgroup 0--3
line.long 0 "CD_RAW_EOF_ITM_BSET"
bitfld.long 0 0. " CD_RAW_EOF_ITM_BSET "  "0 ,1 "
;tree.end

base ad:0xA0254902
;tree "IPPCD_CCP_ERR_DBG_ITS"
rgroup 0--3
line.long 0 "CD_CCP_ERR_DBG_ITS"
bitfld.long 0 0.--2. " CD_CCP_ERR_DBG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0254920
;tree "IPPISP_INTERNAL_ITS_L"
rgroup 0--3
line.long 0 "ISP_INTERNAL_ITS_L"
bitfld.long 0 0. " USER_IF "  "0 ,1 "
bitfld.long 0 2. " MASTER_CCI "  "0 ,1 "
bitfld.long 0 3. " LBE "  "0 ,1 "
bitfld.long 0 5. " ISP_RX "  "0 ,1 "
bitfld.long 0 6. " VIDEO_COMPLETE_PIPE0 "  "0 ,1 "
bitfld.long 0 7. " VIDEO_COMPLETE_PIPE1 "  "0 ,1 "
bitfld.long 0 8. " HISTOGRAM_256_BINS "  "0 ,1 "
bitfld.long 0 9. " EXPOSURE_6X8 "  "0 ,1 "
bitfld.long 0 10. " AF_STATS "  "0 ,1 "
bitfld.long 0 11. " WB_STATS "  "0 ,1 "
bitfld.long 0 12. " SKIN_TONE_STATS "  "0 ,1 "
bitfld.long 0 14. " ARCTIC "  "0 ,1 "
bitfld.long 0 15. " ACCWGZONE "  "0 ,1 "
;tree.end

base ad:0xA0254922
;tree "IPPISP_INTERNAL_ITS_BCLR_L"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITS_BCLR_L"
bitfld.long 0 0. " USER_IF "  "0 ,1 "
bitfld.long 0 2. " MASTER_CCI "  "0 ,1 "
bitfld.long 0 3. " LBE "  "0 ,1 "
bitfld.long 0 5. " ISP_RX "  "0 ,1 "
bitfld.long 0 6. " VIDEO_COMPLETE_PIPE0 "  "0 ,1 "
bitfld.long 0 7. " VIDEO_COMPLETE_PIPE1 "  "0 ,1 "
bitfld.long 0 8. " HISTOGRAM_256_BINS "  "0 ,1 "
bitfld.long 0 9. " EXPOSURE_6X8 "  "0 ,1 "
bitfld.long 0 10. " AF_STATS "  "0 ,1 "
bitfld.long 0 11. " WB_STATS "  "0 ,1 "
bitfld.long 0 12. " SKIN_TONE_STATS "  "0 ,1 "
bitfld.long 0 14. " ARCTIC "  "0 ,1 "
bitfld.long 0 15. " ACCWGZONE "  "0 ,1 "
;tree.end

base ad:0xA0254924
;tree "IPPISP_INTERNAL_ITS_BSET_L"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITS_BSET_L"
bitfld.long 0 0. " USER_IF "  "0 ,1 "
bitfld.long 0 2. " MASTER_CCI "  "0 ,1 "
bitfld.long 0 3. " LBE "  "0 ,1 "
bitfld.long 0 5. " ISP_RX "  "0 ,1 "
bitfld.long 0 6. " VIDEO_COMPLETE_PIPE0 "  "0 ,1 "
bitfld.long 0 7. " VIDEO_COMPLETE_PIPE1 "  "0 ,1 "
bitfld.long 0 8. " HISTOGRAM_256_BINS "  "0 ,1 "
bitfld.long 0 9. " EXPOSURE_6X8 "  "0 ,1 "
bitfld.long 0 10. " AF_STATS "  "0 ,1 "
bitfld.long 0 11. " WB_STATS "  "0 ,1 "
bitfld.long 0 12. " SKIN_TONE_STATS "  "0 ,1 "
bitfld.long 0 14. " ARCTIC "  "0 ,1 "
bitfld.long 0 15. " ACCWGZONE "  "0 ,1 "
;tree.end

base ad:0xA0254926
;tree "IPPISP_INTERNAL_ITM_L"
rgroup 0--3
line.long 0 "ISP_INTERNAL_ITM_L"
bitfld.long 0 0. " USER_IF "  "0 ,1 "
bitfld.long 0 2. " MASTER_CCI "  "0 ,1 "
bitfld.long 0 3. " LBE "  "0 ,1 "
bitfld.long 0 5. " ISP_RX "  "0 ,1 "
bitfld.long 0 6. " VIDEO_COMPLETE_PIPE0 "  "0 ,1 "
bitfld.long 0 7. " VIDEO_COMPLETE_PIPE1 "  "0 ,1 "
bitfld.long 0 8. " HISTOGRAM_256_BINS "  "0 ,1 "
bitfld.long 0 9. " EXPOSURE_6X8 "  "0 ,1 "
bitfld.long 0 10. " AF_STATS "  "0 ,1 "
bitfld.long 0 11. " WB_STATS "  "0 ,1 "
bitfld.long 0 12. " SKIN_TONE_STATS "  "0 ,1 "
bitfld.long 0 14. " ARCTIC "  "0 ,1 "
bitfld.long 0 15. " ACCWGZONE "  "0 ,1 "
;tree.end

base ad:0xA0254928
;tree "IPPISP_INTERNAL_ITM_BCLR_L"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITM_BCLR_L"
bitfld.long 0 0. " USER_IF "  "0 ,1 "
bitfld.long 0 2. " MASTER_CCI "  "0 ,1 "
bitfld.long 0 3. " LBE "  "0 ,1 "
bitfld.long 0 5. " ISP_RX "  "0 ,1 "
bitfld.long 0 6. " VIDEO_COMPLETE_PIPE0 "  "0 ,1 "
bitfld.long 0 7. " VIDEO_COMPLETE_PIPE1 "  "0 ,1 "
bitfld.long 0 8. " HISTOGRAM_256_BINS "  "0 ,1 "
bitfld.long 0 9. " EXPOSURE_6X8 "  "0 ,1 "
bitfld.long 0 10. " AF_STATS "  "0 ,1 "
bitfld.long 0 11. " WB_STATS "  "0 ,1 "
bitfld.long 0 12. " SKIN_TONE_STATS "  "0 ,1 "
bitfld.long 0 14. " ARCTIC "  "0 ,1 "
bitfld.long 0 15. " ACCWGZONE "  "0 ,1 "
;tree.end

base ad:0xA025492A
;tree "IPPISP_INTERNAL_ITM_BSET_L"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITM_BSET_L"
bitfld.long 0 0. " USER_IF "  "0 ,1 "
bitfld.long 0 2. " MASTER_CCI "  "0 ,1 "
bitfld.long 0 3. " LBE "  "0 ,1 "
bitfld.long 0 5. " ISP_RX "  "0 ,1 "
bitfld.long 0 6. " VIDEO_COMPLETE_PIPE0 "  "0 ,1 "
bitfld.long 0 7. " VIDEO_COMPLETE_PIPE1 "  "0 ,1 "
bitfld.long 0 8. " HISTOGRAM_256_BINS "  "0 ,1 "
bitfld.long 0 9. " EXPOSURE_6X8 "  "0 ,1 "
bitfld.long 0 10. " AF_STATS "  "0 ,1 "
bitfld.long 0 11. " WB_STATS "  "0 ,1 "
bitfld.long 0 12. " SKIN_TONE_STATS "  "0 ,1 "
bitfld.long 0 14. " ARCTIC "  "0 ,1 "
bitfld.long 0 15. " ACCWGZONE "  "0 ,1 "
;tree.end

base ad:0xA0254930
;tree "IPPISP_INTERNAL_ITS_H"
rgroup 0--3
line.long 0 "ISP_INTERNAL_ITS_H"
bitfld.long 0 0. " GLACE "  "0 ,1 "
;tree.end

base ad:0xA0254932
;tree "IPPISP_INTERNAL_ITS_BCLR_H"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITS_BCLR_H"
bitfld.long 0 0. " GLACE "  "0 ,1 "
;tree.end

base ad:0xA0254934
;tree "IPPISP_INTERNAL_ITS_BSET_H"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITS_BSET_H"
bitfld.long 0 0. " GLACE "  "0 ,1 "
;tree.end

base ad:0xA0254936
;tree "IPPISP_INTERNAL_ITM_H"
rgroup 0--3
line.long 0 "ISP_INTERNAL_ITM_H"
bitfld.long 0 0. " GLACE "  "0 ,1 "
;tree.end

base ad:0xA0254938
;tree "IPPISP_INTERNAL_ITM_BCLR_H"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITM_BCLR_H"
bitfld.long 0 0. " GLACE "  "0 ,1 "
;tree.end

base ad:0xA025493A
;tree "IPPISP_INTERNAL_ITM_BSET_H"
wgroup 0--3
line.long 0 "ISP_INTERNAL_ITM_BSET_H"
bitfld.long 0 0. " GLACE "  "0 ,1 "
;tree.end

base ad:0xA0254940
;tree "IPPSIA_ITEXT_ITS"
rgroup 0--3
line.long 0 "SIA_ITEXT_ITS"
bitfld.long 0 0. " ITEXT0 "  "0 ,1 "
bitfld.long 0 1. " ITEXT1 "  "0 ,1 "
bitfld.long 0 2. " ITEXT2 "  "0 ,1 "
bitfld.long 0 3. " ITEXT3 "  "0 ,1 "
bitfld.long 0 4. " ITEXT4 "  "0 ,1 "
bitfld.long 0 5. " ITEXT5 "  "0 ,1 "
bitfld.long 0 6. " ITEXT6 "  "0 ,1 "
bitfld.long 0 7. " ITEXT7 "  "0 ,1 "
bitfld.long 0 8. " ITEXT8 "  "0 ,1 "
bitfld.long 0 9. " ITEXT9 "  "0 ,1 "
bitfld.long 0 10. " ITEXT10 "  "0 ,1 "
bitfld.long 0 11. " ITEXT11 "  "0 ,1 "
bitfld.long 0 12. " ITEXT12 "  "0 ,1 "
;tree.end

base ad:0xA0254942
;tree "IPPSIA_ITEXT_ITS_BCLR"
wgroup 0--3
line.long 0 "SIA_ITEXT_ITS_BCLR"
bitfld.long 0 0. " ITEXT0 "  "0 ,1 "
bitfld.long 0 1. " ITEXT1 "  "0 ,1 "
bitfld.long 0 2. " ITEXT2 "  "0 ,1 "
bitfld.long 0 3. " ITEXT3 "  "0 ,1 "
bitfld.long 0 4. " ITEXT4 "  "0 ,1 "
bitfld.long 0 5. " ITEXT5 "  "0 ,1 "
bitfld.long 0 6. " ITEXT6 "  "0 ,1 "
bitfld.long 0 7. " ITEXT7 "  "0 ,1 "
bitfld.long 0 8. " ITEXT8 "  "0 ,1 "
bitfld.long 0 9. " ITEXT9 "  "0 ,1 "
bitfld.long 0 10. " ITEXT10 "  "0 ,1 "
bitfld.long 0 11. " ITEXT11 "  "0 ,1 "
bitfld.long 0 12. " ITEXT12 "  "0 ,1 "
;tree.end

base ad:0xA0254944
;tree "IPPSIA_ITEXT_ITS_BSET"
wgroup 0--3
line.long 0 "SIA_ITEXT_ITS_BSET"
bitfld.long 0 0. " ITEXT0 "  "0 ,1 "
bitfld.long 0 1. " ITEXT1 "  "0 ,1 "
bitfld.long 0 2. " ITEXT2 "  "0 ,1 "
bitfld.long 0 3. " ITEXT3 "  "0 ,1 "
bitfld.long 0 4. " ITEXT4 "  "0 ,1 "
bitfld.long 0 5. " ITEXT5 "  "0 ,1 "
bitfld.long 0 6. " ITEXT6 "  "0 ,1 "
bitfld.long 0 7. " ITEXT7 "  "0 ,1 "
bitfld.long 0 8. " ITEXT8 "  "0 ,1 "
bitfld.long 0 9. " ITEXT9 "  "0 ,1 "
bitfld.long 0 10. " ITEXT10 "  "0 ,1 "
bitfld.long 0 11. " ITEXT11 "  "0 ,1 "
bitfld.long 0 12. " ITEXT12 "  "0 ,1 "
;tree.end

base ad:0xA0254946
;tree "IPPSIA_ITEXT_ITM"
rgroup 0--3
line.long 0 "SIA_ITEXT_ITM"
bitfld.long 0 0. " ITEXT0 "  "0 ,1 "
bitfld.long 0 1. " ITEXT1 "  "0 ,1 "
bitfld.long 0 2. " ITEXT2 "  "0 ,1 "
bitfld.long 0 3. " ITEXT3 "  "0 ,1 "
bitfld.long 0 4. " ITEXT4 "  "0 ,1 "
bitfld.long 0 5. " ITEXT5 "  "0 ,1 "
bitfld.long 0 6. " ITEXT6 "  "0 ,1 "
bitfld.long 0 7. " ITEXT7 "  "0 ,1 "
bitfld.long 0 8. " ITEXT8 "  "0 ,1 "
bitfld.long 0 9. " ITEXT9 "  "0 ,1 "
bitfld.long 0 10. " ITEXT10 "  "0 ,1 "
bitfld.long 0 11. " ITEXT11 "  "0 ,1 "
bitfld.long 0 12. " ITEXT12 "  "0 ,1 "
;tree.end

base ad:0xA0254948
;tree "IPPSIA_ITEXT_ITM_BCLR"
wgroup 0--3
line.long 0 "SIA_ITEXT_ITM_BCLR"
bitfld.long 0 0. " ITEXT0 "  "0 ,1 "
bitfld.long 0 1. " ITEXT1 "  "0 ,1 "
bitfld.long 0 2. " ITEXT2 "  "0 ,1 "
bitfld.long 0 3. " ITEXT3 "  "0 ,1 "
bitfld.long 0 4. " ITEXT4 "  "0 ,1 "
bitfld.long 0 5. " ITEXT5 "  "0 ,1 "
bitfld.long 0 6. " ITEXT6 "  "0 ,1 "
bitfld.long 0 7. " ITEXT7 "  "0 ,1 "
bitfld.long 0 8. " ITEXT8 "  "0 ,1 "
bitfld.long 0 9. " ITEXT9 "  "0 ,1 "
bitfld.long 0 10. " ITEXT10 "  "0 ,1 "
bitfld.long 0 11. " ITEXT11 "  "0 ,1 "
bitfld.long 0 12. " ITEXT12 "  "0 ,1 "
;tree.end

base ad:0xA025494A
;tree "IPPSIA_ITEXT_ITM_BSET"
wgroup 0--3
line.long 0 "SIA_ITEXT_ITM_BSET"
bitfld.long 0 0. " ITEXT0 "  "0 ,1 "
bitfld.long 0 1. " ITEXT1 "  "0 ,1 "
bitfld.long 0 2. " ITEXT2 "  "0 ,1 "
bitfld.long 0 3. " ITEXT3 "  "0 ,1 "
bitfld.long 0 4. " ITEXT4 "  "0 ,1 "
bitfld.long 0 5. " ITEXT5 "  "0 ,1 "
bitfld.long 0 6. " ITEXT6 "  "0 ,1 "
bitfld.long 0 7. " ITEXT7 "  "0 ,1 "
bitfld.long 0 8. " ITEXT8 "  "0 ,1 "
bitfld.long 0 9. " ITEXT9 "  "0 ,1 "
bitfld.long 0 10. " ITEXT10 "  "0 ,1 "
bitfld.long 0 11. " ITEXT11 "  "0 ,1 "
bitfld.long 0 12. " ITEXT12 "  "0 ,1 "
;tree.end

base ad:0xA0254950
;tree "IPPEVT_ITS"
rgroup 0--3
line.long 0 "EVT_ITS"
bitfld.long 0 0. " SD_ERROR "  "0 ,1 "
bitfld.long 0 1. " CD_ERROR "  "0 ,1 "
bitfld.long 0 2. " CD_RAW_EOF "  "0 ,1 "
;tree.end

base ad:0xA0254952
;tree "IPPEVT_ITS_BCLR"
wgroup 0--3
line.long 0 "EVT_ITS_BCLR"
bitfld.long 0 0. " SD_ERROR "  "0 ,1 "
bitfld.long 0 1. " CD_ERROR "  "0 ,1 "
bitfld.long 0 2. " CD_RAW_EOF "  "0 ,1 "
;tree.end

base ad:0xA0254954
;tree "IPPEVT_ITS_BSET"
wgroup 0--3
line.long 0 "EVT_ITS_BSET"
bitfld.long 0 0. " SD_ERROR "  "0 ,1 "
bitfld.long 0 1. " CD_ERROR "  "0 ,1 "
bitfld.long 0 2. " CD_RAW_EOF "  "0 ,1 "
;tree.end

base ad:0xA0254956
;tree "IPPEVT_ITM"
rgroup 0--3
line.long 0 "EVT_ITM"
bitfld.long 0 0. " SD_ERROR "  "0 ,1 "
bitfld.long 0 1. " CD_ERROR "  "0 ,1 "
bitfld.long 0 2. " CD_RAW_EOF "  "0 ,1 "
;tree.end

base ad:0xA0254958
;tree "IPPEVT_ITM_BCLR"
wgroup 0--3
line.long 0 "EVT_ITM_BCLR"
bitfld.long 0 0. " SD_ERROR "  "0 ,1 "
bitfld.long 0 1. " CD_ERROR "  "0 ,1 "
bitfld.long 0 2. " CD_RAW_EOF "  "0 ,1 "
;tree.end

base ad:0xA025495A
;tree "IPPEVT_ITM_BSET"
wgroup 0--3
line.long 0 "EVT_ITM_BSET"
bitfld.long 0 0. " SD_ERROR "  "0 ,1 "
bitfld.long 0 1. " CD_ERROR "  "0 ,1 "
bitfld.long 0 2. " CD_RAW_EOF "  "0 ,1 "
;tree.end

endif

endif

tree.end

base ad:0xA0254A00
;********************************************
tree "SIA-CRM"
;********************************************
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x8015741c)&0x28000)!=0x28000)||((data.long(ad:0x801571ec)&0x600)!=0x600)||((data.long(ad:0x80157428)&0x300)!=0x0))

base ad:0x8015700c
group 0--3
line.long 0 "PRCM_SIAMMDSPCLK_MGT"
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SIA_PHY_EN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 15. " SIA_L_VOK "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "

else

base ad:0xA0254010
sgroup "CLOCK_ENABLE"
constx 0 %l 0x4
setx 0 %l 0
line.long 0 "CLOCK_ENABLE"
base ad:0xA0254010
group 0--3
line.long 0 "CLOCK_ENABLE"

if ((data.long(ad:0xA0254010)&0x4)==0x4)

base ad:0xA0254A00
;tree "CRMEN_CLK_SD_HISPEED"
group 0--3
line.long 0 "EN_CLK_SD_HISPEED"
bitfld.long 0 0. " EN_CLK_SD_HISPEED "  "0 ,1 "
;tree.end

base ad:0xA0254A04
;tree "CRMEN_CLK_SD_LOSPEED"
group 0--3
line.long 0 "EN_CLK_SD_LOSPEED"
bitfld.long 0 0. " EN_CLK_SD_LOSPEED "  "0 ,1 "
;tree.end

base ad:0xA0254A08
;tree "CRMEN_CLK_PIPE"
group 0--3
line.long 0 "EN_CLK_PIPE"
bitfld.long 0 0. " EN_CLK_PIPE "  "0 ,1 "
;tree.end

base ad:0xA0254A0C
;tree "CRMEN_CLK_BML"
group 0--3
line.long 0 "EN_CLK_BML"
bitfld.long 0 0. " EN_CLK_BML "  "0 ,1 "
;tree.end

base ad:0xA0254A10
;tree "CRMEN_CLK_BMS"
group 0--3
line.long 0 "EN_CLK_BMS"
bitfld.long 0 0. " EN_CLK_BMS "  "0 ,1 "
;tree.end

base ad:0xA0254A14
;tree "CRMEN_CLK_PIPE_IN"
group 0--3
line.long 0 "EN_CLK_PIPE_IN"
bitfld.long 0 0. " EN_CLK_PIPE_IN "  "0 ,1 "
;tree.end

base ad:0xA0254A18
;tree "CRMEN_CLK_PICTOR_GPIO"
group 0--3
line.long 0 "EN_CLK_PICTOR_GPIO"
bitfld.long 0 0. " EN_CLK_PICTOR_GPIO "  "0 ,1 "
;tree.end

base ad:0xA0254A1C
;tree "CRMEN_CLK_PIPE_IN_DIV"
group 0--3
line.long 0 "EN_CLK_PIPE_IN_DIV"
bitfld.long 0 0.--4. " EN_CLK_PIPE_IN_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0254A20
;tree "CRMEN_CLK_HOST_IPP_DIV"
group 0--3
line.long 0 "EN_CLK_HOST_IPP_DIV"
bitfld.long 0 0.--4. " EN_CLK_HOST_IPP_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0254A24
;tree "CRMEN_CLK_PICTOR_GPIO_DIV"
group 0--3
line.long 0 "EN_CLK_PICTOR_GPIO_DIV"
bitfld.long 0 0.--4. " EN_CLK_PICTOR_GPIO_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0254A28
;tree "CRMEN_CLK_STATIC_SD_CCP_PIXEL_CLOCK_DIV"
group 0--3
line.long 0 "EN_CLK_STATIC_SD_CCP_PIXEL_CLOCK_DIV"
bitfld.long 0 0.--4. " EN_CLK_STATIC_SD_CCP_PIXEL_CLOCK_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0254A2C
;tree "CRMEN_CLK_STATIC_SD_HISPEED_SOURCE_SEL"
group 0--3
line.long 0 "EN_CLK_STATIC_SD_HISPEED_SOURCE_SEL"
bitfld.long 0 0.--1. " EN_CLK_STATIC_SD_HISPEED_SOURCE_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254A30
;tree "CRMEN_CLK_STATIC_SD_LOSPEED_SOURCE_SEL"
group 0--3
line.long 0 "EN_CLK_STATIC_SD_LOSPEED_SOURCE_SEL"
bitfld.long 0 0.--1. " EN_CLK_STATIC_SD_LOSPEED_SOURCE_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254A34
;tree "CRMEN_CLK_STATIC_SD_PIPE_SOURCE_SEL"
group 0--3
line.long 0 "EN_CLK_STATIC_SD_PIPE_SOURCE_SEL"
bitfld.long 0 0.--1. " EN_CLK_STATIC_SD_PIPE_SOURCE_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254A38
;tree "CRMEN_CLK_STATIC_SD_BMS_SOURCE_SEL"
group 0--3
line.long 0 "EN_CLK_STATIC_SD_BMS_SOURCE_SEL"
bitfld.long 0 0.--1. " EN_CLK_STATIC_SD_BMS_SOURCE_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254A3C
;tree "CRMEN_CLK_STATIC_SD_PICTOR_GPIO_SOURCE_SEL"
group 0--3
line.long 0 "EN_CLK_STATIC_SD_PICTOR_GPIO_SOURCE_SEL"
bitfld.long 0 0.--1. " EN_CLK_STATIC_SD_PICTOR_GPIO_SOURCE_SEL "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xA0254A50
;tree "CRMEMUL_SENSOR_CLOCK"
group 0--3
line.long 0 "EMUL_SENSOR_CLOCK"
bitfld.long 0 0. " EMUL_SENSOR_CLOCK "  "0 ,1 "
;tree.end

base ad:0xA0254A54
;tree "CRMCHEKER_LOST_EN_CTRL_N"
group 0--3
line.long 0 "CHEKER_LOST_EN_CTRL_N"
bitfld.long 0 0. " CHEKER_LOST_EN_CTRL_N "  "0 ,1 "
;tree.end

base ad:0xA0254A58
;tree "CRMCHEKER_RESET"
group 0--3
line.long 0 "CHEKER_RESET"
hexfld.long 0 " CHEKER_RESET "
;tree.end

base ad:0xA0254A5C
;tree "CRMCHEKER_ITS"
rgroup 0--3
line.long 0 "CHEKER_ITS"
bitfld.long 0 0. " CKC_CK_ITS "  "0 ,1 "
bitfld.long 0 1. " CKC_LOST_ITS "  "0 ,1 "
;tree.end

base ad:0xA0254A60
;tree "CRMCHEKER_ITS_BCLR"
wgroup 0--3
line.long 0 "CHEKER_ITS_BCLR"
bitfld.long 0 0. " CKC_CK_ITS_BCLR "  "0 ,1 "
bitfld.long 0 1. " CKC_LOST_ITS_BCLR "  "0 ,1 "
;tree.end

base ad:0xA0254A64
;tree "CRMCHEKER_ITS_BSET"
wgroup 0--3
line.long 0 "CHEKER_ITS_BSET"
bitfld.long 0 0. " CKC_CK_ITS_BSET "  "0 ,1 "
bitfld.long 0 1. " CKC_LOST_ITS_BSET "  "0 ,1 "
;tree.end

base ad:0xA0254A68
;tree "CRMCHEKER_ITM"
rgroup 0--3
line.long 0 "CHEKER_ITM"
bitfld.long 0 0. " CKC_CK_ITM "  "0 ,1 "
bitfld.long 0 1. " CKC_LOST_ITM "  "0 ,1 "
;tree.end

base ad:0xA0254A6C
;tree "CRMCHEKER_ITM_BCLR"
wgroup 0--3
line.long 0 "CHEKER_ITM_BCLR"
bitfld.long 0 0. " CKC_CK_ITM_BCLR "  "0 ,1 "
bitfld.long 0 1. " CKC_LOST_ITM_BCLR "  "0 ,1 "
;tree.end

base ad:0xA0254A70
;tree "CRMCHEKER_ITM_BSET"
wgroup 0--3
line.long 0 "CHEKER_ITM_BSET"
bitfld.long 0 0. " CKC_CK_ITM_BSET "  "0 ,1 "
bitfld.long 0 1. " CKC_LOST_ITM_BSET "  "0 ,1 "
;tree.end

base ad:0xA0254A74
;tree "CRMCHEKER_DETECT_WDW"
group 0--3
line.long 0 "CHEKER_DETECT_WDW"
bitfld.long 0 0.--6. " CKC_DETECT_WDW "  " "
;tree.end

endif

endif

tree.end

tree.end

;==============================================================
tree "SKE"
;==============================================================
base ad:0x80006000
;tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SKEN0 "  "0 ,1 "
bitfld.long 0 1. " SKEN1 "  "0 ,1 "
bitfld.long 0 2. " KPASEN "  "0 ,1 "
bitfld.long 0 3.--5. " KPCN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6. " KPMLT "  "0 ,1 "
bitfld.long 0 7. " KPSON "  "0 ,1 "
bitfld.long 0 8. " KPOC0 "  "0 ,1 "
bitfld.long 0 9. " KPOC1 "  "0 ,1 "
bitfld.long 0 10. " KPOC2 "  "0 ,1 "
bitfld.long 0 11. " KPOC3 "  "0 ,1 "
bitfld.long 0 12. " KPOC4 "  "0 ,1 "
bitfld.long 0 13. " KPOC5 "  "0 ,1 "
bitfld.long 0 14. " KPOC6 "  "0 ,1 "
bitfld.long 0 15. " KPOC7 "  "0 ,1 "
;tree.end

base ad:0x80006004
;tree "VAL0"
group 0--3
line.long 0 "VAL0"
hexfld.byte 0 " SKEVAL0 "
bitfld.long 0 14. " UDF0 "  "0 ,1 "
bitfld.long 0 15. " OVF0 "  "0 ,1 "
;tree.end

base ad:0x80006008
;tree "VAL1"
group 0--3
line.long 0 "VAL1"
hexfld.byte 0 " SKEVAL1 "
bitfld.long 0 14. " UDF1 "  "0 ,1 "
bitfld.long 0 15. " OVF1 "  "0 ,1 "
;tree.end

base ad:0x8000600c
;tree "DBCR"
group 0--3
line.long 0 "DBCR"
hexfld.byte 0 " SKEDBC "
hexfld.byte 1 " KPDBC "
;tree.end

base ad:0x80006010
;tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " SKEIM0 "  "0 ,1 "
bitfld.long 0 1. " SKEIM1 "  "0 ,1 "
bitfld.long 0 2. " KPIMA "  "0 ,1 "
bitfld.long 0 3. " KPIMS "  "0 ,1 "
;tree.end

base ad:0x80006014
;tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " SKERIS0 "  "0 ,1 "
bitfld.long 0 1. " SKERIS1 "  "0 ,1 "
bitfld.long 0 2. " KPRISA "  "0 ,1 "
bitfld.long 0 3. " KPRISS "  "0 ,1 "
;tree.end

base ad:0x80006018
;tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " SKEMIS0 "  "0 ,1 "
bitfld.long 0 1. " SKEMIS1 "  "0 ,1 "
bitfld.long 0 2. " KPMISA "  "0 ,1 "
bitfld.long 0 3. " KPMISS "  "0 ,1 "
;tree.end

base ad:0x8000601c
;tree "ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " SKEIC0 "  "0 ,1 "
bitfld.long 0 1. " SKEIC1 "  "0 ,1 "
bitfld.long 0 2. " KPICA "  "0 ,1 "
bitfld.long 0 3. " KPICS "  "0 ,1 "
;tree.end

base ad:0x80006020
;tree "ASR0"
group 0--3
line.long 0 "ASR0"
hexfld.byte 0 " KPRVAL0 "
hexfld.byte 1 " KPRVAL1 "
;tree.end

base ad:0x80006024
;tree "ASR1"
group 0--3
line.long 0 "ASR1"
hexfld.byte 0 " KPRVAL2 "
hexfld.byte 1 " KPRVAL3 "
;tree.end

base ad:0x80006028
;tree "ASR2"
group 0--3
line.long 0 "ASR2"
hexfld.byte 0 " KPRVAL4 "
hexfld.byte 1 " KPRVAL5 "
;tree.end

base ad:0x8000602c
;tree "ASR3"
group 0--3
line.long 0 "ASR3"
hexfld.byte 0 " KPRVAL6 "
hexfld.byte 1 " KPRVAL7 "
;tree.end

base ad:0x80006080
;tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " RITEN "  "0 ,1 "
bitfld.long 0 1. " KBD_ERR "  "0 ,1 "
;tree.end

base ad:0x80006084
;tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " PKI0 "  "0 ,1 "
bitfld.long 0 1. " PKI1 "  "0 ,1 "
bitfld.long 0 2. " PKI2 "  "0 ,1 "
bitfld.long 0 3. " PKI3 "  "0 ,1 "
bitfld.long 0 4. " PKI4 "  "0 ,1 "
bitfld.long 0 5. " PKI5 "  "0 ,1 "
bitfld.long 0 6. " PKI6 "  "0 ,1 "
bitfld.long 0 7. " PKI7 "  "0 ,1 "
bitfld.long 0 8. " SKA0 "  "0 ,1 "
bitfld.long 0 9. " SKB0 "  "0 ,1 "
bitfld.long 0 10. " SKA1 "  "0 ,1 "
bitfld.long 0 11. " SKB1 "  "0 ,1 "
;tree.end

base ad:0x80006088
;tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " KPO0 "  "0 ,1 "
bitfld.long 0 1. " KPO1 "  "0 ,1 "
bitfld.long 0 2. " KPO2 "  "0 ,1 "
bitfld.long 0 3. " KPO3 "  "0 ,1 "
bitfld.long 0 4. " KPO4 "  "0 ,1 "
bitfld.long 0 5. " KPO5 "  "0 ,1 "
bitfld.long 0 6. " KPO6 "  "0 ,1 "
bitfld.long 0 7. " KPO7 "  "0 ,1 "
bitfld.long 0 8. " SKEINTR0 "  "0 ,1 "
bitfld.long 0 9. " SKEINTR1 "  "0 ,1 "
bitfld.long 0 10. " KPINTR "  "0 ,1 "
;tree.end

base ad:0x80006fe0
;tree "SKEPeriphID0"
rgroup 0--3
line.long 0 "SKEPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80006fe4
;tree "SKEPeriphID1"
rgroup 0--3
line.long 0 "SKEPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80006fe8
;tree "SKEPeriphID2"
rgroup 0--3
line.long 0 "SKEPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80006fec
;tree "SKEPeriphID3"
rgroup 0--3
line.long 0 "SKEPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80006ff0
;tree "SKEPCellID0"
rgroup 0--3
line.long 0 "SKEPCellID0"
hexfld.byte 0 " SKEPCellID0 "
;tree.end

base ad:0x80006ff4
;tree "SKEPCellID1"
rgroup 0--3
line.long 0 "SKEPCellID1"
hexfld.byte 0 " SKEPCellID1 "
;tree.end

base ad:0x80006ff8
;tree "SKEPCellID2"
rgroup 0--3
line.long 0 "SKEPCellID2"
hexfld.byte 0 " SKEPCellID2 "
;tree.end

base ad:0x80006ffc
;tree "SKEPCellID3"
rgroup 0--3
line.long 0 "SKEPCellID3"
hexfld.byte 0 " SKEPCellID3 "
;tree.end

tree.end

;==============================================================
tree "SLIMBUS"
;==============================================================
base ad:0x8012b000
;tree "IER"
group 0--3
line.long 0 "IER"
bitfld.long 0 0. " TX_MSG_PACK_EN "  "0 ,1 "
bitfld.long 0 1. " TX_MSG_NACK_EN "  "0 ,1 "
bitfld.long 0 2. " TX_MSG_NORE_EN "  "0 ,1 "
bitfld.long 0 3. " TX_MSG_UDEF_EN "  "0 ,1 "
bitfld.long 0 4. " RX_MSG_PACK_EN "  "0 ,1 "
bitfld.long 0 5. " RX_MSG_NACK_EN "  "0 ,1 "
bitfld.long 0 6. " RX_MSG_NORE_EN "  "0 ,1 "
bitfld.long 0 7. " RX_MSG_UDEF_EN "  "0 ,1 "
bitfld.long 0 8. " RECONFIG_SET_EN "  "0 ,1 "
bitfld.long 0 9. " RECONFIG_CLEAR_EN "  "0 ,1 "
bitfld.long 0 10. " EX_ERROR_EN "  "0 ,1 "
bitfld.long 0 11. " DATA_TX_COL_EN "  "0 ,1 "
bitfld.long 0 12. " UNSPRTD_MSG_EN "  "0 ,1 "
bitfld.long 0 13. " AM_H_INTA_N "  "0 ,1 "
bitfld.long 0 14. " GD0_H_INTA_N "  "0 ,1 "
bitfld.long 0 15. " 4 "  "0 ,1 "
bitfld.long 0 16. " prep_cont_sts_en "  "0 ,1 "
bitfld.long 0 17. " Rx_Msp_OFL_en "  "0 ,1 "
bitfld.long 0 18. " clk_pause_sts_en "  "0 ,1 "
;tree.end

base ad:0x8012b004
;tree "ISR"
group 0--3
line.long 0 "ISR"
bitfld.long 0 0. " TX_MSG_PACK "  "0 ,1 "
bitfld.long 0 1. " TX_MSG_NACK "  "0 ,1 "
bitfld.long 0 2. " TX_MSG_NORE "  "0 ,1 "
bitfld.long 0 3. " TX_MSG_UDEF "  "0 ,1 "
bitfld.long 0 4. " RX_MSG_PACK "  "0 ,1 "
bitfld.long 0 5. " RX_MSG_NACK "  "0 ,1 "
bitfld.long 0 6. " RX_MSG_NORE "  "0 ,1 "
bitfld.long 0 7. " RX_MSG_UDEF "  "0 ,1 "
bitfld.long 0 8. " RECONFIG_SET "  "0 ,1 "
bitfld.long 0 9. " RECONFIG_CLEAR "  "0 ,1 "
bitfld.long 0 10. " EX_ERROR "  "0 ,1 "
bitfld.long 0 11. " DATA_TX_COL "  "0 ,1 "
bitfld.long 0 12. " UNSPRTD_MSG "  "0 ,1 "
bitfld.long 0 13. " prep_cont_sts "  "0 ,1 "
bitfld.long 0 14. " Rx_Msp_OFL_sts "  "0 ,1 "
bitfld.long 0 15. " clk_pause_sts "  "0 ,1 "
;tree.end

base ad:0x8012b008
;tree "TA_1"
group 0--3
line.long 0 "TA_1"
bitfld.long 0 0.--2. " ARBITRTION_PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " AE "  "0 ,1 "
bitfld.long 0 4.--7. " ARBITRATION_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " Source_LA_EA "
hexfld.word 1 " Source_EA "
;tree.end

base ad:0x8012b00c
;tree "TA_2"
group 0--3
line.long 0 "TA_2"
bitfld.long 0 0.--23. " Source_EA "  " "
;tree.end

base ad:0x8012b010
;tree "TMH_1"
group 0--3
line.long 0 "TMH_1"
bitfld.long 0 0.--4. " REMAINING_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " MESSAGE_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--14. " MESSAGE_CODE "  " "
bitfld.long 0 16.--19. " PRIMARY_INTEGRITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--21. " DESTINATION_TYPE "  "0 ,1 ,2 ,3 "
hexfld.byte 3 " DEST_EA "
;tree.end

base ad:0x8012b014
;tree "TMH_2"
group 0--3
line.long 0 "TMH_2"
hexfld.long 0 " DEST_EA "
;tree.end

base ad:0x8012b018
;tree "TMH_3"
group 0--3
line.long 0 "TMH_3"
hexfld.byte 0 " DEST_EA "
;tree.end

base ad:0x8012b01c
;tree "TMP_1"
group 0--3
line.long 0 "TMP_1"
hexfld.long 0 " TX_MSG_PAYLOAD1 "
;tree.end

base ad:0x8012b020
;tree "TMP_2"
group 0--3
line.long 0 "TMP_2"
hexfld.long 0 " TX_MSG_PAYLOAD2 "
;tree.end

base ad:0x8012b024
;tree "TMP_3"
group 0--3
line.long 0 "TMP_3"
hexfld.byte 0 " TX_MSG_PAYLOAD3 "
bitfld.long 0 8. " MSG_RDY "  "0 ,1 "
;tree.end

base ad:0x8012b038
;tree "RA_1"
rgroup 0--3
line.long 0 "RA_1"
bitfld.long 0 0.--2. " ARBITRATION_PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " AE "  "0 ,1 "
bitfld.long 0 4.--7. " ARBITRATION_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " SOURCE_LA_EA "
hexfld.word 1 " SOURCE_EA "
;tree.end

base ad:0x8012b03c
;tree "RA_2"
rgroup 0--3
line.long 0 "RA_2"
bitfld.long 0 0.--23. " SOURCE_EA "  " "
bitfld.long 0 24.--27. " msg_resp "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8012b040
;tree "RMH_1"
rgroup 0--3
line.long 0 "RMH_1"
bitfld.long 0 0.--4. " REMAINING_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " MESSAGE_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--14. " MESSAGE_CODE "  " "
bitfld.long 0 16.--19. " PRIMARY_INTEGRITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--21. " DESTINATION_TYPE "  "0 ,1 ,2 ,3 "
hexfld.byte 3 " DEST_EA "
;tree.end

base ad:0x8012b044
;tree "RMH_2"
rgroup 0--3
line.long 0 "RMH_2"
hexfld.long 0 " DEST_EA "
;tree.end

base ad:0x8012b048
;tree "RMH_3"
rgroup 0--3
line.long 0 "RMH_3"
hexfld.byte 0 " DEST_EA "
;tree.end

base ad:0x8012b04c
;tree "RMP_1"
rgroup 0--3
line.long 0 "RMP_1"
hexfld.long 0 " RX_MSG_PAYLOAD1 "
;tree.end

base ad:0x8012b050
;tree "RMP_2"
rgroup 0--3
line.long 0 "RMP_2"
hexfld.long 0 " RX_MSG_PAYLOAD2 "
;tree.end

base ad:0x8012b068
;tree "IFEA31"
group 0--3
line.long 0 "IFEA31"
hexfld.long 0 " IF_EA_31_0 "
;tree.end

base ad:0x8012b06c
;tree "IFEA47"
group 0--3
line.long 0 "IFEA47"
hexfld.word 0 " IF_EA_47_32 "
;tree.end

base ad:0x8012b074
;tree "FEA31"
group 0--3
line.long 0 "FEA31"
bitfld.long 0 0. " F_EA "  "0 ,1 "
;tree.end

base ad:0x8012b078
;tree "FEA47"
group 0--3
line.long 0 "FEA47"
hexfld.word 0 " F_EA "
;tree.end

base ad:0x8012b080
;tree "CONFIG"
group 0--3
line.long 0 "CONFIG"
bitfld.long 0 0. " FR_PRI_SEC "  "0 ,1 "
bitfld.long 0 1. " AM_EN "  "0 ,1 "
bitfld.long 0 2. " FR_EN "  "0 ,1 "
bitfld.long 0 3. " GD0_EN "  "0 ,1 "
bitfld.long 0 4.--7. " FR_CLK_FREQ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--12. " FR_CLK_GEAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13.--17. " FR_BOOT_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 18.--21. " FR_BOOT_GEAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 22. " FR_CLK_PAUSE "  "0 ,1 "
bitfld.long 0 23. " if_en "  "0 ,1 "
;tree.end

base ad:0x8012b084
;tree "SIR"
rgroup 0--3
line.long 0 "SIR"
bitfld.long 0 0. " AM_IF_INT "  "0 ,1 "
bitfld.long 0 1. " GD0_INT "  "0 ,1 "
;tree.end

base ad:0x8012b088
;tree "RP_PRE_EN"
group 0--3
line.long 0 "RP_PRE_EN"
bitfld.long 0 0. " af_rp_pre_en "  "0 ,1 "
bitfld.long 0 1. " if_rp_pre_en "  "0 ,1 "
bitfld.long 0 2. " gd0_rp_pre_en "  "0 ,1 "
bitfld.long 0 8. " fr_enumeration "  "0 ,1 "
bitfld.long 0 9. " if_enumeration "  "0 ,1 "
bitfld.long 0 10. " gd0_enumeration "  "0 ,1 "
;tree.end

base ad:0x8012b150
;tree "GD0EA31"
group 0--3
line.long 0 "GD0EA31"
hexfld.long 0 " GD0_EA_31_0 "
;tree.end

base ad:0x8012b154
;tree "GD0EA47"
group 0--3
line.long 0 "GD0EA47"
hexfld.long 0 " GD0_EA_47_32 "
;tree.end

base ad:0x8012b158
;tree "GD0LA"
rgroup 0--3
line.long 0 "GD0LA"
hexfld.byte 0 " GD0_LA "
;tree.end

base ad:0x8012b15c
;tree "GD0IE"
group 0--3
line.long 0 "GD0IE"
bitfld.long 0 0. " gd0_p0_int_en "  "0 ,1 "
bitfld.long 0 1. " gd0_p1_int_en "  "0 ,1 "
bitfld.long 0 2. " gd0_p2_int_en "  "0 ,1 "
bitfld.long 0 3. " gd0_p3_int_en "  "0 ,1 "
bitfld.long 0 4. " gd0_p4_int_en "  "0 ,1 "
bitfld.long 0 5. " gd0_p5_int_en "  "0 ,1 "
bitfld.long 0 6. " gd0_p6_int_en "  "0 ,1 "
bitfld.long 0 7. " gd0_p7_int_en "  "0 ,1 "
bitfld.long 0 8. " gd0_p8_int_en "  "0 ,1 "
bitfld.long 0 9. " gd0_p9_int_en "  "0 ,1 "
;tree.end

base ad:0x8012b160
;tree "GD0IS"
rgroup 0--3
line.long 0 "GD0IS"
bitfld.long 0 0. " gd0_p0_int_sts "  "0 ,1 "
bitfld.long 0 1. " gd0_p1_int_sts "  "0 ,1 "
bitfld.long 0 2. " gd0_p2_int_sts "  "0 ,1 "
bitfld.long 0 3. " gd0_p3_int_sts "  "0 ,1 "
bitfld.long 0 4. " gd0_p4_int_sts "  "0 ,1 "
bitfld.long 0 5. " gd0_p5_int_sts "  "0 ,1 "
bitfld.long 0 6. " gd0_p6_int_sts "  "0 ,1 "
bitfld.long 0 7. " gd0_p7_int_sts "  "0 ,1 "
bitfld.long 0 8. " gd0_p8_int_sts "  "0 ,1 "
bitfld.long 0 9. " gd0_p9_int_sts "  "0 ,1 "
;tree.end

base ad:0x8012b164
;tree "D0P0_IE"
group 0--3
line.long 0 "D0P0_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
;tree.end

base ad:0x8012b168
;tree "D0P0_IS"
group 0--3
line.long 0 "D0P0_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
;tree.end

base ad:0x8012b16c
;tree "D0P0_config"
group 0--3
line.long 0 "D0P0_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
;tree.end

base ad:0x8012b170
;tree "D0P0DP"
group 0--3
line.long 0 "D0P0DP"
hexfld.long 0 " DATA_PORT "
;tree.end

base ad:0x8012b174
;tree "D0P1_IE"
group 0--3
line.long 0 "D0P1_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
;tree.end

base ad:0x8012b178
;tree "D0P1_IS"
group 0--3
line.long 0 "D0P1_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
;tree.end

base ad:0x8012b17c
;tree "D0P1_config"
group 0--3
line.long 0 "D0P1_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
;tree.end

base ad:0x8012b180
;tree "D0P1DP"
group 0--3
line.long 0 "D0P1DP"
hexfld.long 0 " DATA_PORT "
;tree.end

base ad:0x8012b184
;tree "D0P2_IE"
group 0--3
line.long 0 "D0P2_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
;tree.end

base ad:0x8012b188
;tree "D0P2_IS"
group 0--3
line.long 0 "D0P2_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
;tree.end

base ad:0x8012b18c
;tree "D0P2_config"
group 0--3
line.long 0 "D0P2_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
;tree.end

base ad:0x8012b190
;tree "D0P2DP"
group 0--3
line.long 0 "D0P2DP"
hexfld.long 0 " DATA_PORT "
;tree.end

base ad:0x8012b194
;tree "D0P3_IE"
group 0--3
line.long 0 "D0P3_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
;tree.end

base ad:0x8012b198
;tree "D0P3_IS"
group 0--3
line.long 0 "D0P3_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
;tree.end

base ad:0x8012b19c
;tree "D0P3_config"
group 0--3
line.long 0 "D0P3_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
;tree.end

base ad:0x8012b1a0
;tree "D0P3DP"
group 0--3
line.long 0 "D0P3DP"
hexfld.long 0 " DATA_PORT "
;tree.end

base ad:0x8012b1a4
;tree "D0P4_IE"
group 0--3
line.long 0 "D0P4_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
;tree.end

base ad:0x8012b1a8
;tree "D0P4_IS"
group 0--3
line.long 0 "D0P4_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
;tree.end

base ad:0x8012b1ac
;tree "D0P4_config"
group 0--3
line.long 0 "D0P4_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
;tree.end

base ad:0x8012b1b0
;tree "D0P4DP"
group 0--3
line.long 0 "D0P4DP"
hexfld.long 0 " DATA_PORT "
;tree.end

base ad:0x8012b1b4
;tree "D0P5_IE"
group 0--3
line.long 0 "D0P5_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
;tree.end

base ad:0x8012b1b8
;tree "D0P5_IS"
group 0--3
line.long 0 "D0P5_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
;tree.end

base ad:0x8012b1bc
;tree "D0P5_config"
group 0--3
line.long 0 "D0P5_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
;tree.end

base ad:0x8012b1c0
;tree "D0P5DP"
group 0--3
line.long 0 "D0P5DP"
hexfld.long 0 " DATA_PORT "
;tree.end

base ad:0x8012b1c4
;tree "D0P6_IE"
group 0--3
line.long 0 "D0P6_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
;tree.end

base ad:0x8012b1c8
;tree "D0P6_IS"
group 0--3
line.long 0 "D0P6_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
;tree.end

base ad:0x8012b1cc
;tree "D0P6_config"
group 0--3
line.long 0 "D0P6_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
;tree.end

base ad:0x8012b1d0
;tree "D0P6DP"
group 0--3
line.long 0 "D0P6DP"
hexfld.long 0 " DATA_PORT "
;tree.end

base ad:0x8012b1d4
;tree "D0P7_IE"
group 0--3
line.long 0 "D0P7_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
;tree.end

base ad:0x8012b1d8
;tree "D0P7_IS"
group 0--3
line.long 0 "D0P7_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
;tree.end

base ad:0x8012b1dc
;tree "D0P7_config"
group 0--3
line.long 0 "D0P7_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
;tree.end

base ad:0x8012b1e0
;tree "D0P7DP"
group 0--3
line.long 0 "D0P7DP"
hexfld.long 0 " DATA_PORT "
;tree.end

base ad:0x8012b1e4
;tree "D0P8_IE"
group 0--3
line.long 0 "D0P8_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
;tree.end

base ad:0x8012b1e8
;tree "D0P8_IS"
group 0--3
line.long 0 "D0P8_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
;tree.end

base ad:0x8012b1ec
;tree "D0P8_config"
group 0--3
line.long 0 "D0P8_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
;tree.end

base ad:0x8012b1f0
;tree "D0P8DP"
group 0--3
line.long 0 "D0P8DP"
hexfld.long 0 " DATA_PORT "
;tree.end

base ad:0x8012b1f4
;tree "D0P9_IE"
group 0--3
line.long 0 "D0P9_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
;tree.end

base ad:0x8012b1f8
;tree "D0P9_IS"
group 0--3
line.long 0 "D0P9_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
;tree.end

base ad:0x8012b1fc
;tree "D0P9_config"
group 0--3
line.long 0 "D0P9_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
;tree.end

base ad:0x8012b200
;tree "D0P9DP"
group 0--3
line.long 0 "D0P9DP"
hexfld.long 0 " DATA_PORT "
;tree.end

base ad:0x8012b400
;tree "SDMA0C"
group 0--3
line.long 0 "SDMA0C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012b404
;tree "SDMA1C"
group 0--3
line.long 0 "SDMA1C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012b408
;tree "SDMA2C"
group 0--3
line.long 0 "SDMA2C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012b40c
;tree "SDMA3C"
group 0--3
line.long 0 "SDMA3C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012b410
;tree "SDMA4C"
group 0--3
line.long 0 "SDMA4C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012b414
;tree "SDMA5C"
group 0--3
line.long 0 "SDMA5C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012b418
;tree "SDMA6C"
group 0--3
line.long 0 "SDMA6C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012b41c
;tree "SDMA7C"
group 0--3
line.long 0 "SDMA7C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012b420
;tree "SDMA8C"
group 0--3
line.long 0 "SDMA8C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012b424
;tree "SDMA9C"
group 0--3
line.long 0 "SDMA9C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012b900
;tree "fl_con_sav_reg1"
group 0--3
line.long 0 "fl_con_sav_reg1"
bitfld.long 0 0.--4. " next_frame_state "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--27. " cell1_count "  " "
bitfld.long 0 28.--30. " current_clk_rx_state "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8012b934
;tree "mh_con_sav_reg1"
group 0--3
line.long 0 "mh_con_sav_reg1"
bitfld.long 0 0.--4. " sig_guide_val "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--8. " sig_clk_gear "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 9.--12. " sig_root_freq "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--17. " sig_subfr_mode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8012b948
;tree "af_con_sav_reg1"
group 0--3
line.long 0 "af_con_sav_reg1"
bitfld.long 0 0.--2. " slim_fr_fl_info_cnt "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--6. " sig_slim_fr_fl_info "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 7.--10. " cur_boot_st "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 11.--18. " fr_log_addr "  " "
bitfld.long 0 19.--31. " root_supr_fr_cnt "  " "
;tree.end

base ad:0x8012b94c
;tree "af_con_sav_reg2"
group 0--3
line.long 0 "af_con_sav_reg2"
bitfld.long 0 0.--1. " curr_enum_st "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " cur_fr_st "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " core_info "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--9. " dev_info "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8012b968
;tree "if_con_sav_reg1"
group 0--3
line.long 0 "if_con_sav_reg1"
hexfld.byte 0 " logical_addr "
bitfld.long 0 8. " receive_ala "  "0 ,1 "
bitfld.long 0 9.--11. " arb_pri "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--13. " curr_enu_state "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012b978
;tree "gd0_msg_con_sav_reg1"
group 0--3
line.long 0 "gd0_msg_con_sav_reg1"
bitfld.long 0 0. " sig_channel_1 "  "0 ,1 "
bitfld.long 0 1. " sig_channel_2 "  "0 ,1 "
bitfld.long 0 2. " sig_channel_3 "  "0 ,1 "
bitfld.long 0 3. " sig_channel_4 "  "0 ,1 "
bitfld.long 0 4. " sig_channel_5 "  "0 ,1 "
bitfld.long 0 5. " sig_channel_6 "  "0 ,1 "
bitfld.long 0 6. " sig_channel_7 "  "0 ,1 "
bitfld.long 0 7. " sig_channel_8 "  "0 ,1 "
bitfld.long 0 8. " sig_channel_9 "  "0 ,1 "
bitfld.long 0 9. " sig_channel_10 "  "0 ,1 "
bitfld.long 0 10. " sig_channel_11 "  "0 ,1 "
bitfld.long 0 11. " sig_channel_12 "  "0 ,1 "
bitfld.long 0 12. " sig_channel_13 "  "0 ,1 "
bitfld.long 0 13. " sig_channel_14 "  "0 ,1 "
bitfld.long 0 14. " sig_channel_15 "  "0 ,1 "
bitfld.long 0 15. " sig_act_channel_1 "  "0 ,1 "
bitfld.long 0 16. " sig_act_channel_2 "  "0 ,1 "
bitfld.long 0 17. " sig_act_channel_3 "  "0 ,1 "
bitfld.long 0 18. " sig_act_channel_4 "  "0 ,1 "
bitfld.long 0 19. " sig_act_channel_5 "  "0 ,1 "
bitfld.long 0 20. " sig_act_channel_6 "  "0 ,1 "
bitfld.long 0 21. " sig_act_channel_7 "  "0 ,1 "
bitfld.long 0 22. " sig_act_channel_8 "  "0 ,1 "
bitfld.long 0 23. " sig_act_channel_9 "  "0 ,1 "
bitfld.long 0 24. " sig_act_channel_10 "  "0 ,1 "
bitfld.long 0 25. " sig_act_channel_11 "  "0 ,1 "
bitfld.long 0 26. " sig_act_channel_12 "  "0 ,1 "
bitfld.long 0 27. " sig_act_channel_13 "  "0 ,1 "
bitfld.long 0 28. " sig_act_channel_14 "  "0 ,1 "
bitfld.long 0 29. " sig_act_channel_15 "  "0 ,1 "
bitfld.long 0 30. " sig_act_channel_16 "  "0 ,1 "
;tree.end

base ad:0x8012b97c
;tree "gd0_msg_con_sav_reg2"
group 0--3
line.long 0 "gd0_msg_con_sav_reg2"
hexfld.byte 0 " sig_gd_log_addr "
bitfld.long 0 8. " receive_ala "  "0 ,1 "
bitfld.long 0 9.--11. " arb_pri "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--13. " curr_enu_state "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x8012b980
;tree "gd0_port0_con_sav_reg1"
group 0--3
line.long 0 "gd0_port0_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p0_seg_length "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--9. " sig_gd_p0_dat_len "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--13. " sig_gd_p0_protocol "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14. " sig_gd_p0_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p0_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p0_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p0_ch "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 21. " sig_gd_p0_freq_lock "  "0 ,1 "
;tree.end

base ad:0x8012b984
;tree "gd0_port1_con_sav_reg1"
group 0--3
line.long 0 "gd0_port1_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p1_seg_length "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--9. " sig_gd_p1_dat_len "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--13. " sig_gd_p1_protocol "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14. " sig_gd_p1_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p1_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p1_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p1_ch "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 21. " sig_gd_p1_freq_lock "  "0 ,1 "
;tree.end

base ad:0x8012b988
;tree "gd0_port2_con_sav_reg1"
group 0--3
line.long 0 "gd0_port2_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p2_seg_length "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--9. " sig_gd_p2_dat_len "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--13. " sig_gd_p2_protocol "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14. " sig_gd_p2_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p2_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p2_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p2_ch "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 21. " sig_gd_p2_freq_lock "  "0 ,1 "
;tree.end

base ad:0x8012b98c
;tree "gd0_port3_con_sav_reg1"
group 0--3
line.long 0 "gd0_port3_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p3_seg_length "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--9. " sig_gd_p3_dat_len "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--13. " sig_gd_p3_protocol "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14. " sig_gd_p3_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p3_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p3_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p3_ch "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 21. " sig_gd_p3_freq_lock "  "0 ,1 "
;tree.end

base ad:0x8012b990
;tree "gd0_port4_con_sav_reg1"
group 0--3
line.long 0 "gd0_port4_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p4_seg_length "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--9. " sig_gd_p4_dat_len "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--13. " sig_gd_p4_protocol "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14. " sig_gd_p4_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p4_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p4_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p4_ch "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 21. " sig_gd_p4_freq_lock "  "0 ,1 "
;tree.end

base ad:0x8012b994
;tree "gd0_port5_con_sav_reg1"
group 0--3
line.long 0 "gd0_port5_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p5_seg_length "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--9. " sig_gd_p5_dat_len "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--13. " sig_gd_p5_protocol "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14. " sig_gd_p5_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p5_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p5_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p5_ch "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 21. " sig_gd_p5_freq_lock "  "0 ,1 "
;tree.end

base ad:0x8012b998
;tree "gd0_port6_con_sav_reg1"
group 0--3
line.long 0 "gd0_port6_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p6_seg_length "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--9. " sig_gd_p6_dat_len "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--13. " sig_gd_p6_protocol "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14. " sig_gd_p6_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p6_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p6_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p6_ch "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 21. " sig_gd_p6_freq_lock "  "0 ,1 "
;tree.end

base ad:0x8012b99c
;tree "gd0_port7_con_sav_reg1"
group 0--3
line.long 0 "gd0_port7_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p7_seg_length "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--9. " sig_gd_p7_dat_len "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--13. " sig_gd_p7_protocol "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14. " sig_gd_p7_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p7_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p7_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p7_ch "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 21. " sig_gd_p7_freq_lock "  "0 ,1 "
;tree.end

base ad:0x8012b9a0
;tree "gd0_port8_con_sav_reg1"
group 0--3
line.long 0 "gd0_port8_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p8_seg_length "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--9. " sig_gd_p8_dat_len "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--13. " sig_gd_p8_protocol "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14. " sig_gd_p8_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p8_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p8_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p8_ch "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 21. " sig_gd_p8_freq_lock "  "0 ,1 "
;tree.end

base ad:0x8012b9a4
;tree "gd0_port9_con_sav_reg1"
group 0--3
line.long 0 "gd0_port9_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p9_seg_length "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--9. " sig_gd_p9_dat_len "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--13. " sig_gd_p9_protocol "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14. " sig_gd_p9_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p9_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p9_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p9_ch "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 21. " sig_gd_p9_freq_lock "  "0 ,1 "
;tree.end

base ad:0x8012ba00
;tree "ch_con_sav_reg1"
group 0--3
line.long 0 "ch_con_sav_reg1"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch1 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch1 "  " "
;tree.end

base ad:0x8012ba04
;tree "GD0_P0_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P0_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p0 "  " "
;tree.end

base ad:0x8012ba08
;tree "ch_con_sav_reg2"
group 0--3
line.long 0 "ch_con_sav_reg2"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch2 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch2 "  " "
;tree.end

base ad:0x8012ba0c
;tree "GD0_P1_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P1_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p1 "  " "
;tree.end

base ad:0x8012ba10
;tree "ch_con_sav_reg3"
group 0--3
line.long 0 "ch_con_sav_reg3"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch3 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch3 "  " "
;tree.end

base ad:0x8012ba14
;tree "GD0_P2_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P2_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p2 "  " "
;tree.end

base ad:0x8012ba18
;tree "ch_con_sav_reg4"
group 0--3
line.long 0 "ch_con_sav_reg4"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch4 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch4 "  " "
;tree.end

base ad:0x8012ba1c
;tree "GD0_P3_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P3_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p3 "  " "
;tree.end

base ad:0x8012ba20
;tree "ch_con_sav_reg5"
group 0--3
line.long 0 "ch_con_sav_reg5"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch5 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch5 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch5 "  " "
;tree.end

base ad:0x8012ba24
;tree "GD0_P4_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P4_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p4 "  " "
;tree.end

base ad:0x8012ba28
;tree "ch_con_sav_reg6"
group 0--3
line.long 0 "ch_con_sav_reg6"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch6 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch6 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch6 "  " "
;tree.end

base ad:0x8012ba2c
;tree "GD0_P5_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P5_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p5 "  " "
;tree.end

base ad:0x8012ba30
;tree "ch_con_sav_reg7"
group 0--3
line.long 0 "ch_con_sav_reg7"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch7 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch7 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch7 "  " "
;tree.end

base ad:0x8012ba34
;tree "GD0_P6_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P6_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p6 "  " "
;tree.end

base ad:0x8012ba38
;tree "ch_con_sav_reg8"
group 0--3
line.long 0 "ch_con_sav_reg8"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch8 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch8 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch8 "  " "
;tree.end

base ad:0x8012ba3c
;tree "GD0_P7_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P7_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p7 "  " "
;tree.end

base ad:0x8012ba40
;tree "ch_con_sav_reg9"
group 0--3
line.long 0 "ch_con_sav_reg9"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch9 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch9 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch9 "  " "
;tree.end

base ad:0x8012ba44
;tree "GD0_P8_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P8_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p8 "  " "
;tree.end

base ad:0x8012ba48
;tree "ch_con_sav_reg10"
group 0--3
line.long 0 "ch_con_sav_reg10"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch10 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch10 "  " "
;tree.end

base ad:0x8012ba4c
;tree "GD0_P9_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P9_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p9 "  " "
;tree.end

tree.end

;==============================================================
tree "SPI (4 instances)"
;==============================================================
base ad:0x80129000
;********************************************
tree "SPI-3"
;********************************************
base ad:0x80129000
;tree "3CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

base ad:0x80129004
;tree "3CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80129008
;tree "3DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8012900c
;tree "3SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

base ad:0x80129010
;tree "3CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

base ad:0x80129014
;tree "3IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

base ad:0x80129018
;tree "3RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

base ad:0x8012901c
;tree "3MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

base ad:0x80129020
;tree "3ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

base ad:0x80129024
;tree "3DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

base ad:0x80129fe0
;tree "3PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80129fe4
;tree "3PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80129fe8
;tree "3PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80129fec
;tree "3PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80129ff0
;tree "3PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
;tree.end

base ad:0x80129ff4
;tree "3PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
;tree.end

base ad:0x80129ff8
;tree "3PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
;tree.end

base ad:0x80129ffc
;tree "3PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
;tree.end

tree.end

base ad:0x80111000
;********************************************
tree "SPI-2"
;********************************************
base ad:0x80111000
;tree "2CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

base ad:0x80111004
;tree "2CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80111008
;tree "2DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8011100c
;tree "2SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

base ad:0x80111010
;tree "2CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

base ad:0x80111014
;tree "2IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

base ad:0x80111018
;tree "2RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

base ad:0x8011101c
;tree "2MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

base ad:0x80111020
;tree "2ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

base ad:0x80111024
;tree "2DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

base ad:0x80111fe0
;tree "2PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80111fe4
;tree "2PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80111fe8
;tree "2PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80111fec
;tree "2PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80111ff0
;tree "2PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
;tree.end

base ad:0x80111ff4
;tree "2PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
;tree.end

base ad:0x80111ff8
;tree "2PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
;tree.end

base ad:0x80111ffc
;tree "2PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
;tree.end

tree.end

base ad:0x80112000
;********************************************
tree "SPI-1"
;********************************************
base ad:0x80112000
;tree "1CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

base ad:0x80112004
;tree "1CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80112008
;tree "1DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8011200c
;tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

base ad:0x80112010
;tree "1CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

base ad:0x80112014
;tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

base ad:0x80112018
;tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

base ad:0x8011201c
;tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

base ad:0x80112020
;tree "1ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

base ad:0x80112024
;tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

base ad:0x80112fe0
;tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80112fe4
;tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80112fe8
;tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80112fec
;tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80112ff0
;tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
;tree.end

base ad:0x80112ff4
;tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
;tree.end

base ad:0x80112ff8
;tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
;tree.end

base ad:0x80112ffc
;tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
;tree.end

tree.end

base ad:0x8011a000
;********************************************
tree "SPI-0"
;********************************************
base ad:0x8011a000
;tree "0CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

base ad:0x8011a004
;tree "0CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8011a008
;tree "0DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8011a00c
;tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

base ad:0x8011a010
;tree "0CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

base ad:0x8011a014
;tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

base ad:0x8011a018
;tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

base ad:0x8011a01c
;tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

base ad:0x8011a020
;tree "0ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

base ad:0x8011a024
;tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

base ad:0x8011afe0
;tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x8011afe4
;tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011afe8
;tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8011afec
;tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8011aff0
;tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
;tree.end

base ad:0x8011aff4
;tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
;tree.end

base ad:0x8011aff8
;tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
;tree.end

base ad:0x8011affc
;tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "SSP (2 instances)"
;==============================================================
base ad:0x80002000
;********************************************
tree "SSP-0"
;********************************************
base ad:0x80002000
;tree "0CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " HALFDUP "  "0 ,1 "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
bitfld.long 0 16.--20. " CSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21.--22. " FRF "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80002004
;tree "0CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " LBM "  "0 ,1 "
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 6. " MWAIT "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80002008
;tree "0DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8000200c
;tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

base ad:0x80002010
;tree "0CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

base ad:0x80002014
;tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

base ad:0x80002018
;tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

base ad:0x8000201c
;tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

base ad:0x80002020
;tree "0ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

base ad:0x80002024
;tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

base ad:0x80002080
;tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

base ad:0x80002084
;tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SSPRXD "  "0 ,1 "
bitfld.long 0 1. " SSPFSSIN "  "0 ,1 "
bitfld.long 0 2. " SSPCLKIN "  "0 ,1 "
bitfld.long 0 3. " RXDMAC "  "0 ,1 "
bitfld.long 0 4. " TXDMAC "  "0 ,1 "
bitfld.long 0 5. " SSPTXDIN "  "0 ,1 "
;tree.end

base ad:0x80002088
;tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " SSTXDOUT "  "0 ,1 "
bitfld.long 0 1. " SSPFSSOUT "  "0 ,1 "
bitfld.long 0 2. " SSPCLKOUT "  "0 ,1 "
bitfld.long 0 3. " SSPOEn "  "0 ,1 "
bitfld.long 0 4. " SSPCTLOEn "  "0 ,1 "
bitfld.long 0 5. " RORINTR "  "0 ,1 "
bitfld.long 0 6. " RINTR "  "0 ,1 "
bitfld.long 0 7. " RXINTR "  "0 ,1 "
bitfld.long 0 8. " TXINTR "  "0 ,1 "
bitfld.long 0 9. " INTR "  "0 ,1 "
bitfld.long 0 10. " RXDMABREQ "  "0 ,1 "
bitfld.long 0 11. " RXDMASREQ "  "0 ,1 "
bitfld.long 0 12. " TXDMABREQ "  "0 ,1 "
bitfld.long 0 13. " TXDMASREQ "  "0 ,1 "
;tree.end

base ad:0x8000208c
;tree "0TDR"
group 0--3
line.long 0 "TDR"
hexfld.long 0 " TestDATA "
;tree.end

base ad:0x80002fe0
;tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80002fe4
;tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80002fe8
;tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80002fec
;tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80002ff0
;tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SSPPCellID0 "
;tree.end

base ad:0x80002ff4
;tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SSPPCellID1 "
;tree.end

base ad:0x80002ff8
;tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SSPPCellID2 "
;tree.end

base ad:0x80002ffc
;tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SSPPCellID3 "
;tree.end

tree.end

base ad:0x80003000
;********************************************
tree "SSP-1"
;********************************************
base ad:0x80003000
;tree "1CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " HALFDUP "  "0 ,1 "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
bitfld.long 0 16.--20. " CSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21.--22. " FRF "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80003004
;tree "1CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " LBM "  "0 ,1 "
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 6. " MWAIT "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80003008
;tree "1DR"
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

base ad:0x8000300c
;tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

base ad:0x80003010
;tree "1CPSR"
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

base ad:0x80003014
;tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

base ad:0x80003018
;tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

base ad:0x8000301c
;tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

base ad:0x80003020
;tree "1ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

base ad:0x80003024
;tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

base ad:0x80003080
;tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

base ad:0x80003084
;tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SSPRXD "  "0 ,1 "
bitfld.long 0 1. " SSPFSSIN "  "0 ,1 "
bitfld.long 0 2. " SSPCLKIN "  "0 ,1 "
bitfld.long 0 3. " RXDMAC "  "0 ,1 "
bitfld.long 0 4. " TXDMAC "  "0 ,1 "
bitfld.long 0 5. " SSPTXDIN "  "0 ,1 "
;tree.end

base ad:0x80003088
;tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " SSTXDOUT "  "0 ,1 "
bitfld.long 0 1. " SSPFSSOUT "  "0 ,1 "
bitfld.long 0 2. " SSPCLKOUT "  "0 ,1 "
bitfld.long 0 3. " SSPOEn "  "0 ,1 "
bitfld.long 0 4. " SSPCTLOEn "  "0 ,1 "
bitfld.long 0 5. " RORINTR "  "0 ,1 "
bitfld.long 0 6. " RINTR "  "0 ,1 "
bitfld.long 0 7. " RXINTR "  "0 ,1 "
bitfld.long 0 8. " TXINTR "  "0 ,1 "
bitfld.long 0 9. " INTR "  "0 ,1 "
bitfld.long 0 10. " RXDMABREQ "  "0 ,1 "
bitfld.long 0 11. " RXDMASREQ "  "0 ,1 "
bitfld.long 0 12. " TXDMABREQ "  "0 ,1 "
bitfld.long 0 13. " TXDMASREQ "  "0 ,1 "
;tree.end

base ad:0x8000308c
;tree "1TDR"
group 0--3
line.long 0 "TDR"
hexfld.long 0 " TestDATA "
;tree.end

base ad:0x80003fe0
;tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

base ad:0x80003fe4
;tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80003fe8
;tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80003fec
;tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80003ff0
;tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SSPPCellID0 "
;tree.end

base ad:0x80003ff4
;tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SSPPCellID1 "
;tree.end

base ad:0x80003ff8
;tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SSPPCellID2 "
;tree.end

base ad:0x80003ffc
;tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SSPPCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "STM"
;==============================================================
base ad:0x8010f000
;tree "CR_L"
group 0--3
line.long 0 "CR_L"
bitfld.long 0 0. " PLP0 "  "0 ,1 "
bitfld.long 0 1. " PLP1 "  "0 ,1 "
bitfld.long 0 2. " PLP2 "  "0 ,1 "
bitfld.long 0 3. " TSnTS "  "0 ,1 "
bitfld.long 0 4.--5. " DWNG "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--8. " XCKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9. " SWAP_PRCMU "  "0 ,1 "
;tree.end

base ad:0x8010f004
;tree "CR_H"
group 0--3
line.long 0 "CR_H"
;tree.end

base ad:0x8010f008
;tree "MMCR_L"
group 0--3
line.long 0 "MMCR_L"
bitfld.long 0 0. " HWnSW0 "  "0 ,1 "
bitfld.long 0 1. " HWnSW1 "  "0 ,1 "
bitfld.long 0 2. " HWnSW2 "  "0 ,1 "
bitfld.long 0 3. " HWnSW3 "  "0 ,1 "
bitfld.long 0 4. " HWnSW4 "  "0 ,1 "
bitfld.long 0 5. " HWnSW5 "  "0 ,1 "
;tree.end

base ad:0x8010f00c
;tree "MMCR_H"
group 0--3
line.long 0 "MMCR_H"
;tree.end

base ad:0x8010f010
;tree "TER_L"
group 0--3
line.long 0 "TER_L"
bitfld.long 0 0. " TE0 "  "0 ,1 "
bitfld.long 0 2. " TE2 "  "0 ,1 "
bitfld.long 0 3. " TE3 "  "0 ,1 "
bitfld.long 0 4. " TE4 "  "0 ,1 "
bitfld.long 0 5. " TE5 "  "0 ,1 "
bitfld.long 0 9. " TE9 "  "0 ,1 "
;tree.end

base ad:0x8010f014
;tree "TER_H"
group 0--3
line.long 0 "TER_H"
;tree.end

base ad:0x8010f018
;tree "TDSR_L"
rgroup 0--3
line.long 0 "TDSR_L"
bitfld.long 0 0. " TDis0 "  "0 ,1 "
bitfld.long 0 1. " TDis1 "  "0 ,1 "
bitfld.long 0 2. " TDis2 "  "0 ,1 "
bitfld.long 0 3. " TDis3 "  "0 ,1 "
bitfld.long 0 4. " TDis4 "  "0 ,1 "
bitfld.long 0 5. " TDis5 "  "0 ,1 "
bitfld.long 0 9. " TDis9 "  "0 ,1 "
;tree.end

base ad:0x8010f01c
;tree "TDSR_H"
rgroup 0--3
line.long 0 "TDSR_H"
;tree.end

base ad:0x8010f020
;tree "OFSR_L"
rgroup 0--3
line.long 0 "OFSR_L"
bitfld.long 0 0. " ovF0 "  "0 ,1 "
bitfld.long 0 1. " ovF1 "  "0 ,1 "
bitfld.long 0 2. " ovF2 "  "0 ,1 "
bitfld.long 0 3. " ovF3 "  "0 ,1 "
bitfld.long 0 4. " ovF4 "  "0 ,1 "
bitfld.long 0 5. " ovF5 "  "0 ,1 "
bitfld.long 0 9. " ovF9 "  "0 ,1 "
bitfld.long 0 10. " SecTrej "  "0 ,1 "
bitfld.long 0 11. " DecErr "  "0 ,1 "
bitfld.long 0 12.--16. " AddrErr "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8010f024
;tree "OFSR_H"
rgroup 0--3
line.long 0 "OFSR_H"
;tree.end

base ad:0x8010f028
;tree "TFSR_L"
rgroup 0--3
line.long 0 "TFSR_L"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TFF "  "0 ,1 "
bitfld.long 0 2. " PRCME "  "0 ,1 "
bitfld.long 0 3. " PRCMF "  "0 ,1 "
bitfld.long 0 4. " CHGCFG "  "0 ,1 "
;tree.end

base ad:0x8010f02c
;tree "TFSR_H"
rgroup 0--3
line.long 0 "TFSR_H"
;tree.end

base ad:0x8010f030
;tree "SBSR_L"
rgroup 0--3
line.long 0 "SBSR_L"
bitfld.long 0 0. " SBFE "  "0 ,1 "
bitfld.long 0 1. " SBFF "  "0 ,1 "
bitfld.long 0 2. " SBOv "  "0 ,1 "
bitfld.long 0 3.--7. " SBOvNb "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0x8010f034
;tree "SBSR_H"
rgroup 0--3
line.long 0 "SBSR_H"
;tree.end

base ad:0x8010f050
;tree "TSR_L"
rgroup 0--3
line.long 0 "TSR_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " Stamp "  "0 ,1 "
bitfld.long 0 2. " Time "  "0 ,1 "
;tree.end

base ad:0x8010f054
;tree "TSR_H"
rgroup 0--3
line.long 0 "TSR_H"
;tree.end

base ad:0x8010f058
;tree "SCCR_L"
group 0--3
line.long 0 "SCCR_L"
hexfld.long 0 " SCC "
;tree.end

base ad:0x8010f05c
;tree "SCCR_H"
group 0--3
line.long 0 "SCCR_H"
;tree.end

base ad:0x8010f038
;tree "DBG_L"
group 0--3
line.long 0 "DBG_L"
bitfld.long 0 0. " DBGEn "  "0 ,1 "
bitfld.long 0 1. " DBGM "  "0 ,1 "
bitfld.long 0 3.--5. " PTICSSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--10. " FTFSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 12. " FSBFF "  "0 ,1 "
bitfld.long 0 16.--24. " PTI_State "  " "
;tree.end

base ad:0x8010f03c
;tree "DBG_H"
group 0--3
line.long 0 "DBG_H"
;tree.end

base ad:0x8010ffc0
;tree "PeriphlD0_L"
rgroup 0--3
line.long 0 "PeriphlD0_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " PartNumber0 "  "0 ,1 "
;tree.end

base ad:0x8010ffc4
;tree "PeriphlD0_H"
rgroup 0--3
line.long 0 "PeriphlD0_H"
;tree.end

base ad:0x8010ffc8
;tree "PeriphlD1_L"
rgroup 0--3
line.long 0 "PeriphlD1_L"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8010ffcc
;tree "PeriphlD1_H"
rgroup 0--3
line.long 0 "PeriphlD1_H"
;tree.end

base ad:0x8010ffd0
;tree "PeriphlD2_L"
rgroup 0--3
line.long 0 "PeriphlD2_L"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x8010ffd4
;tree "PeriphlD2_H"
rgroup 0--3
line.long 0 "PeriphlD2_H"
;tree.end

base ad:0x8010ffd8
;tree "PeriphlD3_L"
rgroup 0--3
line.long 0 "PeriphlD3_L"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x8010ffdc
;tree "PeriphD3_H"
rgroup 0--3
line.long 0 "PeriphD3_H"
;tree.end

base ad:0x8010ffe0
;tree "PCelllD0_L"
rgroup 0--3
line.long 0 "PCelllD0_L"
hexfld.byte 0 " STMPCelllD0 "
;tree.end

base ad:0x8010ffe4
;tree "PCelllD0_H"
rgroup 0--3
line.long 0 "PCelllD0_H"
;tree.end

base ad:0x8010ffe8
;tree "PCelllD1_L"
rgroup 0--3
line.long 0 "PCelllD1_L"
hexfld.byte 0 " STMPCelllD1 "
;tree.end

base ad:0x8010ffec
;tree "PCelllD1_H"
rgroup 0--3
line.long 0 "PCelllD1_H"
;tree.end

base ad:0x8010fff0
;tree "PCelllD2_L"
rgroup 0--3
line.long 0 "PCelllD2_L"
hexfld.byte 0 " STMPCelllD2 "
;tree.end

base ad:0x8010fff4
;tree "PCelllD2_H"
rgroup 0--3
line.long 0 "PCelllD2_H"
;tree.end

base ad:0x8010fff8
;tree "PCelllD3_L"
rgroup 0--3
line.long 0 "PCelllD3_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " STMPCelllD3 "  "0 ,1 "
;tree.end

base ad:0x8010fffc
;tree "PCelllD3_H"
rgroup 0--3
line.long 0 "PCelllD3_H"
;tree.end

tree.end

;==============================================================
tree "SVA"
;==============================================================
if (((data.long(ad:0x80157008)&0x1100)!=0x1100)||((data.long(ad:0x8015741c)&0x1400)!=0x1400)||((data.long(ad:0x801571ec)&0x30)!=0x30)||((data.long(ad:0x80157428)&0xC0)!=0x0))

base ad:0x80157008
group 0--3
line.long 0 "PRCM_SVAMMDSPCLK_MGT"
bitfld.long 0 8. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 12. " SVA_PHY_EN "  "0 ,1 "

base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_ON "  "0 ,1 "

base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 10. " SVA_L_VOK "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_VOK "  "0 ,1 "

base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_L_RESETN "  "0 ,1 "

base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_CLAMP "  "0 ,1 "

base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_CLAMP "  "0 ,1 "

else

base ad:0xA0158804
sgroup "CKG_CKEN"
constx 0 %l 0xFFFFFFFF
setx 0 %l 0
line.long 0 "CKG_CKEN"
base ad:0xA0158804
group 0--3
line.long 0 "CKG_CKEN"

if ((data.long(ad:0xA0158804)&0x7FFFFFFF)==0x7FFF0000)

base ad:0xA0158600
;tree "DMA_MAX_OPC_SZ0"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ0"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158602
;tree "DMA_MAX_OPC_SZ1"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ1"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158604
;tree "DMA_MAX_OPC_SZ2"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ2"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158606
;tree "DMA_MAX_OPC_SZ3"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ3"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158608
;tree "DMA_MAX_OPC_SZ4"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ4"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015860A
;tree "DMA_MAX_OPC_SZ5"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ5"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015860C
;tree "DMA_MAX_OPC_SZ6"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ6"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015860E
;tree "DMA_MAX_OPC_SZ7"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ7"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158610
;tree "DMA_MAX_OPC_SZ8"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ8"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158612
;tree "DMA_MAX_OPC_SZ9"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ9"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158614
;tree "DMA_MAX_OPC_SZ10"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ10"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158616
;tree "DMA_MAX_OPC_SZ11"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ11"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158618
;tree "DMA_MAX_OPC_SZ12"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ12"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015861A
;tree "DMA_MAX_OPC_SZ13"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ13"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015861C
;tree "DMA_MAX_OPC_SZ14"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ14"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015861E
;tree "DMA_MAX_OPC_SZ15"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ15"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158620
;tree "DMA_MAX_OPC_SZ16"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ16"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158622
;tree "DMA_MAX_OPC_SZ17"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ17"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158624
;tree "DMA_MAX_OPC_SZ18"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ18"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158626
;tree "DMA_MAX_OPC_SZ19"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ19"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158628
;tree "DMA_MAX_OPC_SZ20"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ20"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015862A
;tree "DMA_MAX_OPC_SZ21"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ21"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015862C
;tree "DMA_MAX_OPC_SZ22"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ22"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA015862E
;tree "DMA_MAX_OPC_SZ23"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ23"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158630
;tree "DMA_MAX_OPC_SZ24"
group 0--3
line.long 0 "DMA_MAX_OPC_SZ24"
bitfld.long 0 0.--2. " MAX_OPC_SZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0xA0158640
;tree "DMA_PRIO_0"
group 0--3
line.long 0 "DMA_PRIO_0"
;tree.end

base ad:0xA0158642
;tree "DMA_PRIO_1"
group 0--3
line.long 0 "DMA_PRIO_1"
;tree.end

base ad:0xA0158644
;tree "DMA_PRIO_2"
group 0--3
line.long 0 "DMA_PRIO_2"
;tree.end

base ad:0xA0158646
;tree "DMA_PRIO_3"
group 0--3
line.long 0 "DMA_PRIO_3"
;tree.end

base ad:0xA0158648
;tree "DMA_PRIO_4"
group 0--3
line.long 0 "DMA_PRIO_4"
;tree.end

base ad:0xA015864A
;tree "DMA_PRIO_5"
group 0--3
line.long 0 "DMA_PRIO_5"
;tree.end

base ad:0xA015864C
;tree "DMA_PRIO_6"
group 0--3
line.long 0 "DMA_PRIO_6"
;tree.end

base ad:0xA015864E
;tree "DMA_PRIO_7"
group 0--3
line.long 0 "DMA_PRIO_7"
;tree.end

base ad:0xA0158650
;tree "DMA_PRIO_8"
group 0--3
line.long 0 "DMA_PRIO_8"
;tree.end

base ad:0xA0158652
;tree "DMA_PRIO_9"
group 0--3
line.long 0 "DMA_PRIO_9"
;tree.end

base ad:0xA0158654
;tree "DMA_PRIO_10"
group 0--3
line.long 0 "DMA_PRIO_10"
;tree.end

base ad:0xA0158656
;tree "DMA_PRIO_11"
group 0--3
line.long 0 "DMA_PRIO_11"
;tree.end

base ad:0xA0158658
;tree "DMA_PRIO_12"
group 0--3
line.long 0 "DMA_PRIO_12"
;tree.end

base ad:0xA015865A
;tree "DMA_PRIO_13"
group 0--3
line.long 0 "DMA_PRIO_13"
;tree.end

base ad:0xA015865C
;tree "DMA_PRIO_14"
group 0--3
line.long 0 "DMA_PRIO_14"
;tree.end

base ad:0xA015865E
;tree "DMA_PRIO_15"
group 0--3
line.long 0 "DMA_PRIO_15"
;tree.end

base ad:0xA0158660
;tree "DMA_PRIO_16"
group 0--3
line.long 0 "DMA_PRIO_16"
;tree.end

base ad:0xA0158662
;tree "DMA_PRIO_17"
group 0--3
line.long 0 "DMA_PRIO_17"
;tree.end

base ad:0xA0158664
;tree "DMA_PRIO_18"
group 0--3
line.long 0 "DMA_PRIO_18"
;tree.end

base ad:0xA0158666
;tree "DMA_PRIO_19"
group 0--3
line.long 0 "DMA_PRIO_19"
;tree.end

base ad:0xA0158668
;tree "DMA_PRIO_20"
group 0--3
line.long 0 "DMA_PRIO_20"
;tree.end

base ad:0xA015866A
;tree "DMA_PRIO_21"
group 0--3
line.long 0 "DMA_PRIO_21"
;tree.end

base ad:0xA015866C
;tree "DMA_PRIO_22"
group 0--3
line.long 0 "DMA_PRIO_22"
;tree.end

base ad:0xA015866E
;tree "DMA_PRIO_23"
group 0--3
line.long 0 "DMA_PRIO_23"
;tree.end

base ad:0xA0158670
;tree "DMA_PRIO_24"
group 0--3
line.long 0 "DMA_PRIO_24"
;tree.end

base ad:0xA0158680
;tree "DMA_MAX_MSSG_SZ0"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ0"
;tree.end

base ad:0xA0158682
;tree "DMA_MAX_MSSG_SZ1"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ1"
;tree.end

base ad:0xA0158684
;tree "DMA_MAX_MSSG_SZ2"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ2"
;tree.end

base ad:0xA0158686
;tree "DMA_MAX_MSSG_SZ3"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ3"
;tree.end

base ad:0xA0158688
;tree "DMA_MAX_MSSG_SZ4"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ4"
;tree.end

base ad:0xA015868A
;tree "DMA_MAX_MSSG_SZ5"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ5"
;tree.end

base ad:0xA015868C
;tree "DMA_MAX_MSSG_SZ6"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ6"
;tree.end

base ad:0xA015868E
;tree "DMA_MAX_MSSG_SZ7"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ7"
;tree.end

base ad:0xA0158690
;tree "DMA_MAX_MSSG_SZ8"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ8"
;tree.end

base ad:0xA0158692
;tree "DMA_MAX_MSSG_SZ9"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ9"
;tree.end

base ad:0xA0158694
;tree "DMA_MAX_MSSG_SZ10"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ10"
;tree.end

base ad:0xA0158696
;tree "DMA_MAX_MSSG_SZ11"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ11"
;tree.end

base ad:0xA0158698
;tree "DMA_MAX_MSSG_SZ12"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ12"
;tree.end

base ad:0xA015869A
;tree "DMA_MAX_MSSG_SZ13"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ13"
;tree.end

base ad:0xA015869C
;tree "DMA_MAX_MSSG_SZ14"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ14"
;tree.end

base ad:0xA015869E
;tree "DMA_MAX_MSSG_SZ15"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ15"
;tree.end

base ad:0xA01586A0
;tree "DMA_MAX_MSSG_SZ16"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ16"
;tree.end

base ad:0xA01586A2
;tree "DMA_MAX_MSSG_SZ17"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ17"
;tree.end

base ad:0xA01586A4
;tree "DMA_MAX_MSSG_SZ18"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ18"
;tree.end

base ad:0xA01586A6
;tree "DMA_MAX_MSSG_SZ19"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ19"
;tree.end

base ad:0xA01586A8
;tree "DMA_MAX_MSSG_SZ20"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ20"
;tree.end

base ad:0xA01586AA
;tree "DMA_MAX_MSSG_SZ21"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ21"
;tree.end

base ad:0xA01586AC
;tree "DMA_MAX_MSSG_SZ22"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ22"
;tree.end

base ad:0xA01586AE
;tree "DMA_MAX_MSSG_SZ23"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ23"
;tree.end

base ad:0xA01586B0
;tree "DMA_MAX_MSSG_SZ24"
group 0--3
line.long 0 "DMA_MAX_MSSG_SZ24"
;tree.end

base ad:0xA01586C0
;tree "DMA_MAX_CHCK_SZ0"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ0"
;tree.end

base ad:0xA01586C2
;tree "DMA_MAX_CHCK_SZ1"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ1"
;tree.end

base ad:0xA01586C4
;tree "DMA_MAX_CHCK_SZ2"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ2"
;tree.end

base ad:0xA01586C6
;tree "DMA_MAX_CHCK_SZ3"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ3"
;tree.end

base ad:0xA01586C8
;tree "DMA_MAX_CHCK_SZ4"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ4"
;tree.end

base ad:0xA01586CA
;tree "DMA_MAX_CHCK_SZ5"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ5"
;tree.end

base ad:0xA01586CC
;tree "DMA_MAX_CHCK_SZ6"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ6"
;tree.end

base ad:0xA01586CE
;tree "DMA_MAX_CHCK_SZ7"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ7"
;tree.end

base ad:0xA01586D0
;tree "DMA_MAX_CHCK_SZ8"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ8"
;tree.end

base ad:0xA01586D2
;tree "DMA_MAX_CHCK_SZ9"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ9"
;tree.end

base ad:0xA01586D4
;tree "DMA_MAX_CHCK_SZ10"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ10"
;tree.end

base ad:0xA01586D6
;tree "DMA_MAX_CHCK_SZ11"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ11"
;tree.end

base ad:0xA01586D8
;tree "DMA_MAX_CHCK_SZ12"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ12"
;tree.end

base ad:0xA01586DA
;tree "DMA_MAX_CHCK_SZ13"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ13"
;tree.end

base ad:0xA01586DC
;tree "DMA_MAX_CHCK_SZ14"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ14"
;tree.end

base ad:0xA01586DE
;tree "DMA_MAX_CHCK_SZ15"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ15"
;tree.end

base ad:0xA01586E0
;tree "DMA_MAX_CHCK_SZ16"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ16"
;tree.end

base ad:0xA01586E2
;tree "DMA_MAX_CHCK_SZ17"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ17"
;tree.end

base ad:0xA01586E4
;tree "DMA_MAX_CHCK_SZ18"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ18"
;tree.end

base ad:0xA01586E6
;tree "DMA_MAX_CHCK_SZ19"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ19"
;tree.end

base ad:0xA01586E8
;tree "DMA_MAX_CHCK_SZ20"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ20"
;tree.end

base ad:0xA01586EA
;tree "DMA_MAX_CHCK_SZ21"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ21"
;tree.end

base ad:0xA01586EC
;tree "DMA_MAX_CHCK_SZ22"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ22"
;tree.end

base ad:0xA01586EE
;tree "DMA_MAX_CHCK_SZ23"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ23"
;tree.end

base ad:0xA01586F0
;tree "DMA_MAX_CHCK_SZ24"
group 0--3
line.long 0 "DMA_MAX_CHCK_SZ24"
;tree.end

base ad:0xA01586FE
;tree "DMA_MAX_PRI"
group 0--3
line.long 0 "DMA_MAX_PRI"
bitfld.long 0 0.--3. " STBUS_PRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xA0158700
;tree "NODE_INIT_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_INIT_1_PRIORITY_REG"
bitfld.long 0 5. " MIR1 "  "0 ,1 "
bitfld.long 0 0.--4. " PRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158704
;tree "NODE_INIT_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_INIT_2_PRIORITY_REG"
bitfld.long 0 5. " MIR2 "  "0 ,1 "
bitfld.long 0 0.--4. " PRI2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158708
;tree "NODE_INIT_3_PRIORITY_REG"
group 0--3
line.long 0 "NODE_INIT_3_PRIORITY_REG"
bitfld.long 0 5. " MIR3 "  "0 ,1 "
bitfld.long 0 0.--4. " PRI3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

bitfld.long 0 0.--18. " G "  " "
base ad:0xA015870C
;tree "NODE_INIT_1_LATENCY_REG"
group 0--3
line.long 0 "NODE_INIT_1_LATENCY_REG"
bitfld.long 0 0.--16. " LAT1 "  " "
;tree.end

bitfld.long 0 0.--18. " G "  " "
base ad:0xA0158710
;tree "NODE_INIT_2_LATENCY_REG"
group 0--3
line.long 0 "NODE_INIT_2_LATENCY_REG"
bitfld.long 0 0.--16. " LAT2 "  " "
;tree.end

bitfld.long 0 0.--18. " G "  " "
base ad:0xA0158714
;tree "NODE_INIT_3_LATENCY_REG"
group 0--3
line.long 0 "NODE_INIT_3_LATENCY_REG"
bitfld.long 0 0.--16. " LAT3 "  " "
;tree.end

base ad:0xA0158724
;tree "NODE_INIT_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_INIT_1_LIMIT_REG"
bitfld.long 0 12.--16. " LIMIT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 4.--12. " FSIZE1 "  " "
bitfld.long 0 0.--4. " NEWPRI1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158728
;tree "NODE_INIT_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_INIT_2_LIMIT_REG"
bitfld.long 0 12.--16. " LIMIT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 4.--12. " FSIZE2 "  " "
bitfld.long 0 0.--4. " NEWPRI2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA015872C
;tree "NODE_INIT_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_INIT_3_LIMIT_REG"
bitfld.long 0 12.--16. " LIMIT3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 4.--12. " FSIZE3 "  " "
bitfld.long 0 0.--4. " NEWPRI3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

base ad:0xA0158800
;tree "CFG_RST"
group 0--3
line.long 0 "CFG_RST"
bitfld.long 0 0. " SRS "  "0 ,1 "
;tree.end

base ad:0xA0158804
;tree "CKG_CKEN"
group 0--3
line.long 0 "CKG_CKEN"
bitfld.long 0 0. " ENABLE_CLK_DMA "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_HED "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_IME "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_VLC "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_FIFO2 "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_VBF "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_DMA "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_VC1IT "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_QTAB "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_FIFO "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_REC "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_PA "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_IACDC "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_RLC "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_SCN "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_IQ "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_Q "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_IDCT "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_DCT "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_H264FITQ "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_H264VLC "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_IPA "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_IMC "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_BPU "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_BDU "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_DFI "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_VPP "  "0 ,1 "
bitfld.long 0 0. " ENABLE_CLK_MTF "  "0 ,1 "
;tree.end

base ad:0xA0158808
;tree "IDN_HRV"
group 0--3
line.long 0 "IDN_HRV"
hexfld.word 0 " HRV "
;tree.end

endif

endif

tree.end

;==============================================================
tree "TIMER (2 instances)"
;==============================================================
base ad:0xa03c6000
;********************************************
tree "TIMER-0"
;********************************************
base ad:0xa03c6000
;tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " T0IM "  "0 ,1 "
bitfld.long 0 1. " T1IM "  "0 ,1 "
bitfld.long 0 2. " T2IM "  "0 ,1 "
bitfld.long 0 3. " T3IM "  "0 ,1 "
;tree.end

base ad:0xa03c6004
;tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " T0RIS "  "0 ,1 "
bitfld.long 0 1. " T1RIS "  "0 ,1 "
bitfld.long 0 2. " T2RIS "  "0 ,1 "
bitfld.long 0 3. " T3RIS "  "0 ,1 "
;tree.end

base ad:0xa03c6008
;tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " T0MIS "  "0 ,1 "
bitfld.long 0 1. " T1MIS "  "0 ,1 "
bitfld.long 0 2. " T2MIS "  "0 ,1 "
bitfld.long 0 3. " T3MIS "  "0 ,1 "
;tree.end

base ad:0xa03c600c
;tree "0ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " T0IC "  "0 ,1 "
bitfld.long 0 1. " T1IC "  "0 ,1 "
bitfld.long 0 2. " T2IC "  "0 ,1 "
bitfld.long 0 3. " T3IC "  "0 ,1 "
;tree.end

base ad:0xa03c6010
;tree "0T0LR"
group 0--3
line.long 0 "T0LR"
hexfld.long 0 " T0LOAD "
;tree.end

base ad:0xa03c6014
;tree "0T0VAL"
rgroup 0--3
line.long 0 "T0VAL"
;tree.end

base ad:0xa03c6018
;tree "0T0CR"
group 0--3
line.long 0 "T0CR"
bitfld.long 0 0. " T0OS "  "0 ,1 "
bitfld.long 0 1. " T0SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T0PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T0MOD "  "0 ,1 "
bitfld.long 0 7. " T0En "  "0 ,1 "
;tree.end

base ad:0xa03c601c
;tree "0T0BGLR"
group 0--3
line.long 0 "T0BGLR"
bitfld.long 0 0. " T0BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03c6020
;tree "0T1LR"
group 0--3
line.long 0 "T1LR"
hexfld.long 0 " T1LOAD "
;tree.end

base ad:0xa03c6024
;tree "0T1VAL"
rgroup 0--3
line.long 0 "T1VAL"
;tree.end

base ad:0xa03c6028
;tree "0T1CR"
group 0--3
line.long 0 "T1CR"
bitfld.long 0 0. " T1OS "  "0 ,1 "
bitfld.long 0 1. " T1SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T1PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T1MOD "  "0 ,1 "
bitfld.long 0 7. " T1En "  "0 ,1 "
;tree.end

base ad:0xa03c602c
;tree "0T1BGLR"
group 0--3
line.long 0 "T1BGLR"
bitfld.long 0 0. " T1BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03c6030
;tree "0T2LR"
group 0--3
line.long 0 "T2LR"
hexfld.long 0 " T2LOAD "
;tree.end

base ad:0xa03c6034
;tree "0T2VAL"
rgroup 0--3
line.long 0 "T2VAL"
;tree.end

base ad:0xa03c6038
;tree "0T2CR"
group 0--3
line.long 0 "T2CR"
bitfld.long 0 0. " T2OS "  "0 ,1 "
bitfld.long 0 1. " T2SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T2PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T2MOD "  "0 ,1 "
bitfld.long 0 7. " T2En "  "0 ,1 "
;tree.end

base ad:0xa03c603c
;tree "0T2BGLR"
group 0--3
line.long 0 "T2BGLR"
bitfld.long 0 0. " T2BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03c6040
;tree "0T3LR"
group 0--3
line.long 0 "T3LR"
hexfld.long 0 " T3LOAD "
;tree.end

base ad:0xa03c6044
;tree "0T3VAL"
rgroup 0--3
line.long 0 "T3VAL"
;tree.end

base ad:0xa03c6048
;tree "0T3CR"
group 0--3
line.long 0 "T3CR"
bitfld.long 0 0. " T3OS "  "0 ,1 "
bitfld.long 0 1. " T3SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T3PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T3MOD "  "0 ,1 "
bitfld.long 0 7. " T3En "  "0 ,1 "
;tree.end

base ad:0xa03c604c
;tree "0T3BGLR"
group 0--3
line.long 0 "T3BGLR"
bitfld.long 0 0. " T3BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03c6f00
;tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITME "  "0 ,1 "
;tree.end

base ad:0xa03c6f04
;tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " INTCT0 "  "0 ,1 "
bitfld.long 0 1. " INTCT1 "  "0 ,1 "
bitfld.long 0 2. " INTCT2 "  "0 ,1 "
bitfld.long 0 3. " INTCT3 "  "0 ,1 "
;tree.end

base ad:0xa03c6fe0
;tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03c6fe4
;tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c6fe8
;tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c6fec
;tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03c6ff0
;tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " MTUPCellID0 "
;tree.end

base ad:0xa03c6ff4
;tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " MTUPCellID1 "
;tree.end

base ad:0xa03c6ff8
;tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " MTUPCellID2 "
;tree.end

base ad:0xa03c6ffc
;tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " MTUPCellID3 "
;tree.end

tree.end

base ad:0xa03c7000
;********************************************
tree "TIMER-1"
;********************************************
base ad:0xa03c7000
;tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " T0IM "  "0 ,1 "
bitfld.long 0 1. " T1IM "  "0 ,1 "
bitfld.long 0 2. " T2IM "  "0 ,1 "
bitfld.long 0 3. " T3IM "  "0 ,1 "
;tree.end

base ad:0xa03c7004
;tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " T0RIS "  "0 ,1 "
bitfld.long 0 1. " T1RIS "  "0 ,1 "
bitfld.long 0 2. " T2RIS "  "0 ,1 "
bitfld.long 0 3. " T3RIS "  "0 ,1 "
;tree.end

base ad:0xa03c7008
;tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " T0MIS "  "0 ,1 "
bitfld.long 0 1. " T1MIS "  "0 ,1 "
bitfld.long 0 2. " T2MIS "  "0 ,1 "
bitfld.long 0 3. " T3MIS "  "0 ,1 "
;tree.end

base ad:0xa03c700c
;tree "1ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " T0IC "  "0 ,1 "
bitfld.long 0 1. " T1IC "  "0 ,1 "
bitfld.long 0 2. " T2IC "  "0 ,1 "
bitfld.long 0 3. " T3IC "  "0 ,1 "
;tree.end

base ad:0xa03c7010
;tree "1T0LR"
group 0--3
line.long 0 "T0LR"
hexfld.long 0 " T0LOAD "
;tree.end

base ad:0xa03c7014
;tree "1T0VAL"
rgroup 0--3
line.long 0 "T0VAL"
;tree.end

base ad:0xa03c7018
;tree "1T0CR"
group 0--3
line.long 0 "T0CR"
bitfld.long 0 0. " T0OS "  "0 ,1 "
bitfld.long 0 1. " T0SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T0PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T0MOD "  "0 ,1 "
bitfld.long 0 7. " T0En "  "0 ,1 "
;tree.end

base ad:0xa03c701c
;tree "1T0BGLR"
group 0--3
line.long 0 "T0BGLR"
bitfld.long 0 0. " T0BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03c7020
;tree "1T1LR"
group 0--3
line.long 0 "T1LR"
hexfld.long 0 " T1LOAD "
;tree.end

base ad:0xa03c7024
;tree "1T1VAL"
rgroup 0--3
line.long 0 "T1VAL"
;tree.end

base ad:0xa03c7028
;tree "1T1CR"
group 0--3
line.long 0 "T1CR"
bitfld.long 0 0. " T1OS "  "0 ,1 "
bitfld.long 0 1. " T1SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T1PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T1MOD "  "0 ,1 "
bitfld.long 0 7. " T1En "  "0 ,1 "
;tree.end

base ad:0xa03c702c
;tree "1T1BGLR"
group 0--3
line.long 0 "T1BGLR"
bitfld.long 0 0. " T1BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03c7030
;tree "1T2LR"
group 0--3
line.long 0 "T2LR"
hexfld.long 0 " T2LOAD "
;tree.end

base ad:0xa03c7034
;tree "1T2VAL"
rgroup 0--3
line.long 0 "T2VAL"
;tree.end

base ad:0xa03c7038
;tree "1T2CR"
group 0--3
line.long 0 "T2CR"
bitfld.long 0 0. " T2OS "  "0 ,1 "
bitfld.long 0 1. " T2SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T2PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T2MOD "  "0 ,1 "
bitfld.long 0 7. " T2En "  "0 ,1 "
;tree.end

base ad:0xa03c703c
;tree "1T2BGLR"
group 0--3
line.long 0 "T2BGLR"
bitfld.long 0 0. " T2BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03c7040
;tree "1T3LR"
group 0--3
line.long 0 "T3LR"
hexfld.long 0 " T3LOAD "
;tree.end

base ad:0xa03c7044
;tree "1T3VAL"
rgroup 0--3
line.long 0 "T3VAL"
;tree.end

base ad:0xa03c7048
;tree "1T3CR"
group 0--3
line.long 0 "T3CR"
bitfld.long 0 0. " T3OS "  "0 ,1 "
bitfld.long 0 1. " T3SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T3PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T3MOD "  "0 ,1 "
bitfld.long 0 7. " T3En "  "0 ,1 "
;tree.end

base ad:0xa03c704c
;tree "1T3BGLR"
group 0--3
line.long 0 "T3BGLR"
bitfld.long 0 0. " T3BGLOAD "  "0 ,1 "
;tree.end

base ad:0xa03c7f00
;tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITME "  "0 ,1 "
;tree.end

base ad:0xa03c7f04
;tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " INTCT0 "  "0 ,1 "
bitfld.long 0 1. " INTCT1 "  "0 ,1 "
bitfld.long 0 2. " INTCT2 "  "0 ,1 "
bitfld.long 0 3. " INTCT3 "  "0 ,1 "
;tree.end

base ad:0xa03c7fe0
;tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0xa03c7fe4
;tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c7fe8
;tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03c7fec
;tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0xa03c7ff0
;tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " MTUPCellID0 "
;tree.end

base ad:0xa03c7ff4
;tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " MTUPCellID1 "
;tree.end

base ad:0xa03c7ff8
;tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " MTUPCellID2 "
;tree.end

base ad:0xa03c7ffc
;tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " MTUPCellID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "TPIU"
;==============================================================
base ad:0x80190000
;tree "PortSize"
rgroup 0--3
line.long 0 "PortSize"
bitfld.long 0 0. " PortSize "  "0 ,1 "
;tree.end

base ad:0x80190004
;tree "CurrPortSize"
group 0--3
line.long 0 "CurrPortSize"
bitfld.long 0 0. " CurrPortSize "  "0 ,1 "
;tree.end

base ad:0x80190100
;tree "SuppTrigMod"
rgroup 0--3
line.long 0 "SuppTrigMod"
bitfld.long 0 0. " SuppTrigMod "  "0 ,1 "
;tree.end

base ad:0x80190104
;tree "TrigCountVal"
group 0--3
line.long 0 "TrigCountVal"
bitfld.long 0 0. " TrigCountVal "  "0 ,1 "
;tree.end

base ad:0x80190108
;tree "TrigMult"
group 0--3
line.long 0 "TrigMult"
bitfld.long 0 0. " TrigMult "  "0 ,1 "
;tree.end

base ad:0x80190200
;tree "SuppTest"
rgroup 0--3
line.long 0 "SuppTest"
bitfld.long 0 0. " SuppTest "  "0 ,1 "
;tree.end

base ad:0x80190204
;tree "CurrTest"
group 0--3
line.long 0 "CurrTest"
bitfld.long 0 0. " CurrTest "  "0 ,1 "
;tree.end

base ad:0x80190208
;tree "TestPatt"
group 0--3
line.long 0 "TestPatt"
bitfld.long 0 0. " TestPatt "  "0 ,1 "
;tree.end

base ad:0x80190300
;tree "FormatStat"
group 0--3
line.long 0 "FormatStat"
bitfld.long 0 0. " FormatStat "  "0 ,1 "
;tree.end

base ad:0x80190304
;tree "FormatCtrl"
group 0--3
line.long 0 "FormatCtrl"
bitfld.long 0 0. " FormatCtrl "  "0 ,1 "
;tree.end

base ad:0x80190308
;tree "FormatSync"
group 0--3
line.long 0 "FormatSync"
bitfld.long 0 0. " FormatSync "  "0 ,1 "
;tree.end

base ad:0x80190400
;tree "EXTCTLIN"
group 0--3
line.long 0 "EXTCTLIN"
bitfld.long 0 0. " EXTCTLIN "  "0 ,1 "
;tree.end

base ad:0x80190404
;tree "EXTCTLOUT"
group 0--3
line.long 0 "EXTCTLOUT"
bitfld.long 0 0. " EXTCTLOUT "  "0 ,1 "
;tree.end

base ad:0x80190ee4
;tree "ITTRFLINACK"
wgroup 0--3
line.long 0 "ITTRFLINACK"
bitfld.long 0 0. " ITTRFLINACK "  "0 ,1 "
;tree.end

base ad:0x80190ee8
;tree "ITTRFLIN"
group 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0. " ITTRFLIN "  "0 ,1 "
;tree.end

base ad:0x80190eec
;tree "ITATBDATA0"
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ITATBDATA0 "  "0 ,1 "
;tree.end

base ad:0x80190ef0
;tree "ITATBCTR2"
wgroup 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ITATBCTR2 "  "0 ,1 "
;tree.end

base ad:0x80190ef4
;tree "ITATBCTR1"
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0. " ITATBCTR1 "  "0 ,1 "
;tree.end

base ad:0x80190ef8
;tree "ITATBCTR0"
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ITATBCTR0 "  "0 ,1 "
;tree.end

base ad:0x80190f00
;tree "IntModCTRLReg"
group 0--3
line.long 0 "IntModCTRLReg"
bitfld.long 0 0. " IntModCTRLReg "  "0 ,1 "
;tree.end

base ad:0x80190fa0
;tree "CTS"
group 0--3
line.long 0 "CTS"
bitfld.long 0 0. " CTS "  "0 ,1 "
;tree.end

base ad:0x80190fa4
;tree "CTC"
group 0--3
line.long 0 "CTC"
bitfld.long 0 0. " CTC "  "0 ,1 "
;tree.end

base ad:0x80190fb0
;tree "LockA"
wgroup 0--3
line.long 0 "LockA"
bitfld.long 0 0. " LockA "  "0 ,1 "
;tree.end

base ad:0x80190fb4
;tree "Lock"
rgroup 0--3
line.long 0 "Lock"
bitfld.long 0 0. " Lock "  "0 ,1 "
;tree.end

base ad:0x80190fb8
;tree "Aut"
rgroup 0--3
line.long 0 "Aut"
bitfld.long 0 0. " Aut "  "0 ,1 "
;tree.end

base ad:0x80190fc8
;tree "DevID"
rgroup 0--3
line.long 0 "DevID"
bitfld.long 0 0. " DevID "  "0 ,1 "
;tree.end

base ad:0x80190fcc
;tree "Dev"
rgroup 0--3
line.long 0 "Dev"
bitfld.long 0 0. " Dev "  "0 ,1 "
;tree.end

base ad:0x80190fd0
;tree "PeriphID4"
rgroup 0--3
line.long 0 "PeriphID4"
bitfld.long 0 0. " PeriphID4 "  "0 ,1 "
;tree.end

base ad:0x80190fd4
;tree "PeriphID5"
group 0--3
line.long 0 "PeriphID5"
bitfld.long 0 0. " PeriphID5 "  "0 ,1 "
;tree.end

base ad:0x80190fd8
;tree "PeriphID6"
group 0--3
line.long 0 "PeriphID6"
bitfld.long 0 0. " PeriphID6 "  "0 ,1 "
;tree.end

base ad:0x80190fdc
;tree "PeriphID7"
group 0--3
line.long 0 "PeriphID7"
bitfld.long 0 0. " PeriphID7 "  "0 ,1 "
;tree.end

base ad:0x80190fe0
;tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0. " PeriphID0 "  "0 ,1 "
;tree.end

base ad:0x80190fe4
;tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0. " PeriphID1 "  "0 ,1 "
;tree.end

base ad:0x80190fe8
;tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0. " PeriphID2 "  "0 ,1 "
;tree.end

base ad:0x80190fec
;tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0. " PeriphID3 "  "0 ,1 "
;tree.end

base ad:0x80190ff0
;tree "CompID0"
rgroup 0--3
line.long 0 "CompID0"
bitfld.long 0 0. " CompID0 "  "0 ,1 "
;tree.end

base ad:0x80190ff4
;tree "CompID1"
rgroup 0--3
line.long 0 "CompID1"
bitfld.long 0 0. " CompID1 "  "0 ,1 "
;tree.end

base ad:0x80190ff8
;tree "CompID2"
rgroup 0--3
line.long 0 "CompID2"
bitfld.long 0 0. " CompID2 "  "0 ,1 "
;tree.end

base ad:0x80190ffc
;tree "CompID3"
rgroup 0--3
line.long 0 "CompID3"
bitfld.long 0 0. " CompID3 "  "0 ,1 "
;tree.end

tree.end

;==============================================================
tree "UART (3 instances)"
;==============================================================
base ad:0x80120000
;********************************************
tree "UART-0"
;********************************************
base ad:0x80120000
;tree "0DR"
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
;tree.end

base ad:0x80120004
;tree "0RSR_ECR"
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
;tree.end

base ad:0x80120008
;tree "0DMAWM"
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8012000c
;tree "0TIMEOUT"
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0. " TIMEOUT_PERIOD "  "0 ,1 "
;tree.end

base ad:0x80120018
;tree "0FR"
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
;tree.end

base ad:0x8012001c
;tree "0LCRH_RX"
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
;tree.end

base ad:0x80120020
;tree "0ILPR"
group 0--3
line.long 0 "ILPR"
hexfld.byte 0 " ILPDVSR "
;tree.end

base ad:0x80120024
;tree "0IBRD"
group 0--3
line.long 0 "IBRD"
hexfld.word 0 " DIVINT "
;tree.end

base ad:0x80120028
;tree "0FBRD"
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8012002c
;tree "0LCRH_TX"
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
;tree.end

base ad:0x80120030
;tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
;tree.end

base ad:0x80120034
;tree "0IFLS"
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80120038
;tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
;tree.end

base ad:0x8012003c
;tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
;tree.end

base ad:0x80120040
;tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
;tree.end

base ad:0x80120044
;tree "0ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
;tree.end

base ad:0x80120048
;tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
;tree.end

base ad:0x80120050
;tree "0XFCR"
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
;tree.end

base ad:0x80120054
;tree "0XON1"
group 0--3
line.long 0 "XON1"
hexfld.byte 0 " XON1 "
;tree.end

base ad:0x80120058
;tree "0XON2"
group 0--3
line.long 0 "XON2"
hexfld.byte 0 " XON2 "
;tree.end

base ad:0x8012005c
;tree "0XOFF1"
group 0--3
line.long 0 "XOFF1"
hexfld.byte 0 " XOFF1 "
;tree.end

base ad:0x80120060
;tree "0XOFF2"
group 0--3
line.long 0 "XOFF2"
hexfld.byte 0 " XOFF2 "
;tree.end

base ad:0x80120080
;tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80120084
;tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
;tree.end

base ad:0x80120088
;tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
;tree.end

base ad:0x8012008c
;tree "0TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
;tree.end

base ad:0x80120100
;tree "0ABCR"
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
;tree.end

base ad:0x80120104
;tree "0ABSR"
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " BYTE1S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
;tree.end

base ad:0x80120108
;tree "0ABFMT"
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80120150
;tree "0ABDR"
rgroup 0--3
line.long 0 "ABDR"
hexfld.word 0 " AUTOBAUDBDR "
;tree.end

base ad:0x80120154
;tree "0ABDFR"
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80120158
;tree "0ABMR"
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
;tree.end

base ad:0x8012015c
;tree "0ABIMSC"
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
;tree.end

base ad:0x80120160
;tree "0ABRIS"
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
;tree.end

base ad:0x80120164
;tree "0ABMIS"
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
;tree.end

base ad:0x80120168
;tree "0ABICR"
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
;tree.end

base ad:0x80120fe0
;tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80120fe4
;tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80120fe8
;tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80120fec
;tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80120ff0
;tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " IDO "
;tree.end

base ad:0x80120ff4
;tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " ID1 "
;tree.end

base ad:0x80120ff8
;tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " ID2 "
;tree.end

base ad:0x80120ffc
;tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " ID3 "
;tree.end

tree.end

base ad:0x80121000
;********************************************
tree "UART-1"
;********************************************
base ad:0x80121000
;tree "1DR"
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
;tree.end

base ad:0x80121004
;tree "1RSR_ECR"
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
;tree.end

base ad:0x80121008
;tree "1DMAWM"
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8012100c
;tree "1TIMEOUT"
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0. " TIMEOUT_PERIOD "  "0 ,1 "
;tree.end

base ad:0x80121018
;tree "1FR"
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
;tree.end

base ad:0x8012101c
;tree "1LCRH_RX"
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
;tree.end

base ad:0x80121020
;tree "1ILPR"
group 0--3
line.long 0 "ILPR"
hexfld.byte 0 " ILPDVSR "
;tree.end

base ad:0x80121024
;tree "1IBRD"
group 0--3
line.long 0 "IBRD"
hexfld.word 0 " DIVINT "
;tree.end

base ad:0x80121028
;tree "1FBRD"
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8012102c
;tree "1LCRH_TX"
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
;tree.end

base ad:0x80121030
;tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
;tree.end

base ad:0x80121034
;tree "1IFLS"
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80121038
;tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
;tree.end

base ad:0x8012103c
;tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
;tree.end

base ad:0x80121040
;tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
;tree.end

base ad:0x80121044
;tree "1ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
;tree.end

base ad:0x80121048
;tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
;tree.end

base ad:0x80121050
;tree "1XFCR"
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
;tree.end

base ad:0x80121054
;tree "1XON1"
group 0--3
line.long 0 "XON1"
hexfld.byte 0 " XON1 "
;tree.end

base ad:0x80121058
;tree "1XON2"
group 0--3
line.long 0 "XON2"
hexfld.byte 0 " XON2 "
;tree.end

base ad:0x8012105c
;tree "1XOFF1"
group 0--3
line.long 0 "XOFF1"
hexfld.byte 0 " XOFF1 "
;tree.end

base ad:0x80121060
;tree "1XOFF2"
group 0--3
line.long 0 "XOFF2"
hexfld.byte 0 " XOFF2 "
;tree.end

base ad:0x80121080
;tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80121084
;tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
;tree.end

base ad:0x80121088
;tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
;tree.end

base ad:0x8012108c
;tree "1TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
;tree.end

base ad:0x80121100
;tree "1ABCR"
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
;tree.end

base ad:0x80121104
;tree "1ABSR"
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " BYTE1S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
;tree.end

base ad:0x80121108
;tree "1ABFMT"
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80121150
;tree "1ABDR"
rgroup 0--3
line.long 0 "ABDR"
hexfld.word 0 " AUTOBAUDBDR "
;tree.end

base ad:0x80121154
;tree "1ABDFR"
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80121158
;tree "1ABMR"
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
;tree.end

base ad:0x8012115c
;tree "1ABIMSC"
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
;tree.end

base ad:0x80121160
;tree "1ABRIS"
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
;tree.end

base ad:0x80121164
;tree "1ABMIS"
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
;tree.end

base ad:0x80121168
;tree "1ABICR"
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
;tree.end

base ad:0x80121fe0
;tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80121fe4
;tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80121fe8
;tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80121fec
;tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80121ff0
;tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " IDO "
;tree.end

base ad:0x80121ff4
;tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " ID1 "
;tree.end

base ad:0x80121ff8
;tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " ID2 "
;tree.end

base ad:0x80121ffc
;tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " ID3 "
;tree.end

tree.end

base ad:0x80007000
;********************************************
tree "UART-2"
;********************************************
base ad:0x80007000
;tree "2DR"
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
;tree.end

base ad:0x80007004
;tree "2RSR_ECR"
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
;tree.end

base ad:0x80007008
;tree "2DMAWM"
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x8000700c
;tree "2TIMEOUT"
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0. " TIMEOUT_PERIOD "  "0 ,1 "
;tree.end

base ad:0x80007018
;tree "2FR"
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
;tree.end

base ad:0x8000701c
;tree "2LCRH_RX"
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
;tree.end

base ad:0x80007020
;tree "2ILPR"
group 0--3
line.long 0 "ILPR"
hexfld.byte 0 " ILPDVSR "
;tree.end

base ad:0x80007024
;tree "2IBRD"
group 0--3
line.long 0 "IBRD"
hexfld.word 0 " DIVINT "
;tree.end

base ad:0x80007028
;tree "2FBRD"
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x8000702c
;tree "2LCRH_TX"
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
;tree.end

base ad:0x80007030
;tree "2CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
;tree.end

base ad:0x80007034
;tree "2IFLS"
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

base ad:0x80007038
;tree "2IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
;tree.end

base ad:0x8000703c
;tree "2RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
;tree.end

base ad:0x80007040
;tree "2MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
;tree.end

base ad:0x80007044
;tree "2ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
;tree.end

base ad:0x80007048
;tree "2DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
;tree.end

base ad:0x80007050
;tree "2XFCR"
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
;tree.end

base ad:0x80007054
;tree "2XON1"
group 0--3
line.long 0 "XON1"
hexfld.byte 0 " XON1 "
;tree.end

base ad:0x80007058
;tree "2XON2"
group 0--3
line.long 0 "XON2"
hexfld.byte 0 " XON2 "
;tree.end

base ad:0x8000705c
;tree "2XOFF1"
group 0--3
line.long 0 "XOFF1"
hexfld.byte 0 " XOFF1 "
;tree.end

base ad:0x80007060
;tree "2XOFF2"
group 0--3
line.long 0 "XOFF2"
hexfld.byte 0 " XOFF2 "
;tree.end

base ad:0x80007080
;tree "2ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

base ad:0x80007084
;tree "2ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
;tree.end

base ad:0x80007088
;tree "2ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
;tree.end

base ad:0x8000708c
;tree "2TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
;tree.end

base ad:0x80007100
;tree "2ABCR"
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
;tree.end

base ad:0x80007104
;tree "2ABSR"
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " BYTE1S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
;tree.end

base ad:0x80007108
;tree "2ABFMT"
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0x80007150
;tree "2ABDR"
rgroup 0--3
line.long 0 "ABDR"
hexfld.word 0 " AUTOBAUDBDR "
;tree.end

base ad:0x80007154
;tree "2ABDFR"
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

base ad:0x80007158
;tree "2ABMR"
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
;tree.end

base ad:0x8000715c
;tree "2ABIMSC"
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
;tree.end

base ad:0x80007160
;tree "2ABRIS"
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
;tree.end

base ad:0x80007164
;tree "2ABMIS"
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
;tree.end

base ad:0x80007168
;tree "2ABICR"
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
;tree.end

base ad:0x80007fe0
;tree "2PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

base ad:0x80007fe4
;tree "2PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80007fe8
;tree "2PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0x80007fec
;tree "2PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

base ad:0x80007ff0
;tree "2PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " IDO "
;tree.end

base ad:0x80007ff4
;tree "2PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " ID1 "
;tree.end

base ad:0x80007ff8
;tree "2PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " ID2 "
;tree.end

base ad:0x80007ffc
;tree "2PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " ID3 "
;tree.end

tree.end

tree.end

;==============================================================
tree "USB"
;==============================================================
base ad:0xa03e0000
;tree "INTTX_PWR_FADDR"
group 0--3
line.long 0 "INTTX_PWR_FADDR"
bitfld.long 0 0.--6. " FADDR "  " "
bitfld.long 0 8. " SUSPEN "  "0 ,1 "
bitfld.long 0 9. " SUSPM "  "0 ,1 "
bitfld.long 0 10. " RSM "  "0 ,1 "
bitfld.long 0 11. " RST "  "0 ,1 "
bitfld.long 0 12. " HSMD "  "0 ,1 "
bitfld.long 0 13. " HSEN "  "0 ,1 "
bitfld.long 0 14. " SFCN "  "0 ,1 "
bitfld.long 0 15. " ISO_UP "  "0 ,1 "
hexfld.word 1 " EPTX "
;tree.end

base ad:0xa03e0004
;tree "INTTXEN_INTRX"
group 0--3
line.long 0 "INTTXEN_INTRX"
bitfld.long 0 1.--15. " EPRX "  " "
hexfld.word 1 " EPTXEN "
;tree.end

base ad:0xa03e0008
;tree "INTRUSB_INTRXEN"
group 0--3
line.long 0 "INTRUSB_INTRXEN"
bitfld.long 0 1.--15. " EPRXEN "  " "
bitfld.long 0 16. " SUSP "  "0 ,1 "
bitfld.long 0 17. " RES "  "0 ,1 "
bitfld.long 0 18. " RST "  "0 ,1 "
bitfld.long 0 19. " SOF "  "0 ,1 "
bitfld.long 0 20. " CONN "  "0 ,1 "
bitfld.long 0 21. " DISCON "  "0 ,1 "
bitfld.long 0 22. " SESSREQ "  "0 ,1 "
bitfld.long 0 23. " VBERR "  "0 ,1 "
bitfld.long 0 24. " SUSPEN "  "0 ,1 "
bitfld.long 0 25. " RESEN "  "0 ,1 "
bitfld.long 0 26. " RSTEN "  "0 ,1 "
bitfld.long 0 27. " SOFEN "  "0 ,1 "
bitfld.long 0 28. " CONNEN "  "0 ,1 "
bitfld.long 0 29. " DISCONEN "  "0 ,1 "
bitfld.long 0 30. " SESSREDEN "  "0 ,1 "
bitfld.long 0 31. " VBERREN "  "0 ,1 "
;tree.end

base ad:0xa03e000c
;tree "TM_INDX_FMNO"
group 0--3
line.long 0 "TM_INDX_FMNO"
bitfld.long 0 0.--10. " FMNO "  " "
bitfld.long 0 16.--19. " EPNO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24. " TSTNAK "  "0 ,1 "
bitfld.long 0 25. " TSTJ "  "0 ,1 "
bitfld.long 0 26. " TSTK "  "0 ,1 "
bitfld.long 0 27. " TSTPKT "  "0 ,1 "
bitfld.long 0 28. " FHS "  "0 ,1 "
bitfld.long 0 29. " FFS "  "0 ,1 "
bitfld.long 0 30. " FIFOA "  "0 ,1 "
bitfld.long 0 31. " FRH "  "0 ,1 "
;tree.end

base ad:0xa03e0010
;tree "TXCSR_TXMAXP"
group 0--3
line.long 0 "TXCSR_TXMAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TXPKTRDY "  "0 ,1 "
bitfld.long 0 17. " FNOTEM "  "0 ,1 "
bitfld.long 0 18. " ERR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " STPPKT "  "0 ,1 "
bitfld.long 0 21. " RXSTALL "  "0 ,1 "
bitfld.long 0 22. " CLRDTTOG "  "0 ,1 "
bitfld.long 0 23. " INCTX "  "0 ,1 "
bitfld.long 0 24. " DTTOG "  "0 ,1 "
bitfld.long 0 25. " DTTOGW "  "0 ,1 "
bitfld.long 0 26. " DMAREQMD "  "0 ,1 "
bitfld.long 0 27. " FDTTOG "  "0 ,1 "
bitfld.long 0 28. " DMAREQEN "  "0 ,1 "
bitfld.long 0 29. " MODE "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
bitfld.long 0 0.--11. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TXPKTRDY "  "0 ,1 "
bitfld.long 0 17. " FNOTEM "  "0 ,1 "
bitfld.long 0 18. " URUN "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SDSTALL "  "0 ,1 "
bitfld.long 0 21. " STSTALL "  "0 ,1 "
bitfld.long 0 22. " CLRDTTOG "  "0 ,1 "
bitfld.long 0 23. " INCTX "  "0 ,1 "
bitfld.long 0 26. " DMAREQMD "  "0 ,1 "
bitfld.long 0 27. " FDTTOG "  "0 ,1 "
bitfld.long 0 28. " DMAREQEN "  "0 ,1 "
bitfld.long 0 29. " MODE "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0014
;tree "RXCSR_RXMAXP"
group 0--3
line.long 0 "RXCSR_RXMAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RXPKTRDY "  "0 ,1 "
bitfld.long 0 17. " FF "  "0 ,1 "
bitfld.long 0 18. " ERR "  "0 ,1 "
bitfld.long 0 19. " DTERR "  "0 ,1 "
bitfld.long 0 20. " FLUSHF "  "0 ,1 "
bitfld.long 0 21. " REQPKT "  "0 ,1 "
bitfld.long 0 22. " RXSTALL "  "0 ,1 "
bitfld.long 0 23. " CLRDTTOG "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 25. " DTTOG "  "0 ,1 "
bitfld.long 0 26. " DTTOGW "  "0 ,1 "
bitfld.long 0 27. " DMAREQMD "  "0 ,1 "
bitfld.long 0 28. " PIDERR "  "0 ,1 "
bitfld.long 0 29. " DMAREQEN "  "0 ,1 "
bitfld.long 0 30. " AREQ "  "0 ,1 "
bitfld.long 0 31. " ACLR "  "0 ,1 "
bitfld.long 0 0.--11. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RXPKTRDY "  "0 ,1 "
bitfld.long 0 17. " FF "  "0 ,1 "
bitfld.long 0 18. " ORUN "  "0 ,1 "
bitfld.long 0 19. " DTERR "  "0 ,1 "
bitfld.long 0 20. " FLUSHF "  "0 ,1 "
bitfld.long 0 21. " SDTALL "  "0 ,1 "
bitfld.long 0 22. " STSTALL "  "0 ,1 "
bitfld.long 0 23. " CLRDTTOG "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMAREQMD "  "0 ,1 "
bitfld.long 0 28. " PIDERR "  "0 ,1 "
bitfld.long 0 29. " DMAREQEN "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ACLR "  "0 ,1 "
;tree.end

base ad:0xa03e0018
;tree "TXIN_TXTYPE_RXCOUNT"
group 0--3
line.long 0 "TXIN_TXTYPE_RXCOUNT"
bitfld.long 0 0.--13. " RXCOUNT "  " "
bitfld.long 0 16.--19. " TEPNO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--21. " PROT "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " SPEED "  "0 ,1 ,2 ,3 "
hexfld.byte 3 " TXPI "
bitfld.long 0 0.--14. " RXCOUNT "  " "
;tree.end

base ad:0xa03e001c
;tree "CFG_RXIN_RXTYPE"
group 0--3
line.long 0 "CFG_RXIN_RXTYPE"
bitfld.long 0 0.--3. " TEP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " PROT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " SPEED "  "0 ,1 ,2 ,3 "
hexfld.byte 1 " RXPI "
bitfld.long 0 24. " UI "  "0 ,1 "
bitfld.long 0 25. " SC "  "0 ,1 "
bitfld.long 0 26. " DYNF "  "0 ,1 "
bitfld.long 0 27. " HBTXE "  "0 ,1 "
bitfld.long 0 28. " HBRXE "  "0 ,1 "
bitfld.long 0 29. " BE "  "0 ,1 "
bitfld.long 0 30. " MPTXE "  "0 ,1 "
bitfld.long 0 31. " MPRXE "  "0 ,1 "
;tree.end

base ad:0xa03e0020
;tree "EP0_FIFO"
group 0--3
line.long 0 "EP0_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0024
;tree "EP1_FIFO"
group 0--3
line.long 0 "EP1_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0028
;tree "EP2_FIFO"
group 0--3
line.long 0 "EP2_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e002c
;tree "EP3_FIFO"
group 0--3
line.long 0 "EP3_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0030
;tree "EP4_FIFO"
group 0--3
line.long 0 "EP4_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0034
;tree "EP5_FIFO"
group 0--3
line.long 0 "EP5_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0038
;tree "EP6_FIFO"
group 0--3
line.long 0 "EP6_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e003c
;tree "EP7_FIFO"
group 0--3
line.long 0 "EP7_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0040
;tree "EP8_FIFO"
group 0--3
line.long 0 "EP8_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0044
;tree "EP9_FIFO"
group 0--3
line.long 0 "EP9_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0048
;tree "EP10_FIFO"
group 0--3
line.long 0 "EP10_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e004c
;tree "EP11_FIFO"
group 0--3
line.long 0 "EP11_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0050
;tree "EP12_FIFO"
group 0--3
line.long 0 "EP12_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0054
;tree "EP13_FIFO"
group 0--3
line.long 0 "EP13_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0058
;tree "EP14_FIFO"
group 0--3
line.long 0 "EP14_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e005c
;tree "EP15_FIFO"
group 0--3
line.long 0 "EP15_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0060
;tree "FIFOSZ_DEVCTL"
group 0--3
line.long 0 "FIFOSZ_DEVCTL"
bitfld.long 0 0. " SESS "  "0 ,1 "
bitfld.long 0 1. " HREQ "  "0 ,1 "
bitfld.long 0 2. " HOST "  "0 ,1 "
bitfld.long 0 3.--4. " VBUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " LSDEV "  "0 ,1 "
bitfld.long 0 6. " FSDEV "  "0 ,1 "
bitfld.long 0 7. " BDEV "  "0 ,1 "
bitfld.long 0 8. " RXEDMA "  "0 ,1 "
bitfld.long 0 9. " TXEDMA "  "0 ,1 "
bitfld.long 0 16.--19. " TXFSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20. " DPB "  "0 ,1 "
bitfld.long 0 24.--27. " RXFSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28. " DPB "  "0 ,1 "
;tree.end

base ad:0xa03e0064
;tree "FIFOADDR"
group 0--3
line.long 0 "FIFOADDR"
bitfld.long 0 0.--13. " TXFADDDR "  " "
bitfld.long 0 16.--29. " RXFADDR "  " "
;tree.end

base ad:0xa03e0068
;tree "VCNTL"
group 0--3
line.long 0 "VCNTL"
hexfld.byte 0 " VCNTL "
hexfld.byte 1 " VSTATUS "
;tree.end

base ad:0xa03e006c
;tree "HWVER"
rgroup 0--3
line.long 0 "HWVER"
bitfld.long 0 0.--9. " VMIN "  " "
bitfld.long 0 10.--14. " VMAJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 15. " RC "  "0 ,1 "
;tree.end

base ad:0xa03e0070
;tree "ULPI_1"
group 0--3
line.long 0 "ULPI_1"
bitfld.long 0 0. " EXTVB "  "0 ,1 "
bitfld.long 0 1. " EXTVI "  "0 ,1 "
bitfld.long 0 2. " STP "  "0 ,1 "
bitfld.long 0 8. " DISU "  "0 ,1 "
bitfld.long 0 9. " CKACT "  "0 ,1 "
bitfld.long 0 10. " ALTINT "  "0 ,1 "
bitfld.long 0 11. " CANCK "  "0 ,1 "
bitfld.long 0 12. " RXCMD "  "0 ,1 "
bitfld.long 0 13. " CKAE "  "0 ,1 "
bitfld.long 0 16. " REGINT_INEN "  "0 ,1 "
bitfld.long 0 17. " ALTINT_INEN "  "0 ,1 "
bitfld.long 0 18. " AEND_INEN "  "0 ,1 "
bitfld.long 0 19. " RXCMD_IE "  "0 ,1 "
bitfld.long 0 24. " REGINT "  "0 ,1 "
bitfld.long 0 25. " ALTINT "  "0 ,1 "
bitfld.long 0 26. " AENDI "  "0 ,1 "
bitfld.long 0 27. " RXCMDI "  "0 ,1 "
;tree.end

base ad:0xa03e0074
;tree "ULPI_2"
group 0--3
line.long 0 "ULPI_2"
hexfld.byte 0 " UREGDATA "
hexfld.byte 1 " UREGADDR "
bitfld.long 0 16. " UREGREQ "  "0 ,1 "
bitfld.long 0 17. " UREGC "  "0 ,1 "
bitfld.long 0 18. " URW "  "0 ,1 "
hexfld.byte 3 " URAWDATA "
;tree.end

base ad:0xa03e0078
;tree "EP_INFO"
group 0--3
line.long 0 "EP_INFO"
bitfld.long 0 0.--3. " TXEPINFO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " RXEPINFO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e007c
;tree "EOF_REG"
group 0--3
line.long 0 "EOF_REG"
hexfld.byte 0 " HSEOF1 "
hexfld.byte 1 " FSEOF1 "
hexfld.byte 2 " LSEOF1 "
bitfld.long 0 24.--25. " SRST "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa03e0080
;tree "TXFUNCADDR_EP0"
group 0--3
line.long 0 "TXFUNCADDR_EP0"
bitfld.long 0 0.--6. " TXADDR0 "  " "
;tree.end

base ad:0xa03e0088
;tree "TXFUNCADDR_EP1"
group 0--3
line.long 0 "TXFUNCADDR_EP1"
bitfld.long 0 0.--6. " TXADDR "  " "
;tree.end

base ad:0xa03e008c
;tree "RXFUNCADDR_EP1"
group 0--3
line.long 0 "RXFUNCADDR_EP1"
bitfld.long 0 0.--6. " RXADDR "  " "
;tree.end

base ad:0xa03e0090
;tree "TXFUNCADDR_EP2"
group 0--3
line.long 0 "TXFUNCADDR_EP2"
bitfld.long 0 0.--6. " TXADDR2 "  " "
;tree.end

base ad:0xa03e0094
;tree "RXFUNCADDR_EP2"
group 0--3
line.long 0 "RXFUNCADDR_EP2"
bitfld.long 0 0.--6. " RXADDR2 "  " "
;tree.end

base ad:0xa03e0098
;tree "TXFUNCADDR_EP3"
group 0--3
line.long 0 "TXFUNCADDR_EP3"
bitfld.long 0 0.--6. " TXADDR3 "  " "
;tree.end

base ad:0xa03e00a0
;tree "RXFUNCADDR_EP3"
group 0--3
line.long 0 "RXFUNCADDR_EP3"
bitfld.long 0 0.--6. " RXADDR3 "  " "
;tree.end

base ad:0xa03e00a4
;tree "TXFUNCADDR_EP4"
group 0--3
line.long 0 "TXFUNCADDR_EP4"
bitfld.long 0 0.--6. " TXADDR4 "  " "
;tree.end

base ad:0xa03e00a8
;tree "RXFUNCADDR_EP4"
group 0--3
line.long 0 "RXFUNCADDR_EP4"
bitfld.long 0 0.--6. " RXADDR4 "  " "
;tree.end

base ad:0xa03e00ac
;tree "TXFUNCADDR_EP5"
group 0--3
line.long 0 "TXFUNCADDR_EP5"
bitfld.long 0 0.--6. " TXADDR5 "  " "
;tree.end

base ad:0xa03e00b0
;tree "RXFUNCADDR_EP5"
group 0--3
line.long 0 "RXFUNCADDR_EP5"
bitfld.long 0 0.--6. " RXADDR5 "  " "
;tree.end

base ad:0xa03e00b4
;tree "RXFUNCADDR_EP6"
group 0--3
line.long 0 "RXFUNCADDR_EP6"
bitfld.long 0 0.--6. " RXADDR6 "  " "
bitfld.long 0 0.--6. " RXADDR6 "  " "
;tree.end

base ad:0xa03e00b8
;tree "RXFUNCADDR_EP6"
group 0--3
line.long 0 "RXFUNCADDR_EP6"
bitfld.long 0 0.--6. " RXADDR6 "  " "
bitfld.long 0 0.--6. " RXADDR6 "  " "
;tree.end

base ad:0xa03e00bc
;tree "RXFUNCADDR_EP7"
group 0--3
line.long 0 "RXFUNCADDR_EP7"
bitfld.long 0 0.--6. " RXADDR7 "  " "
;tree.end

base ad:0xa03e00c0
;tree "RXFUNCADDR_EP8"
group 0--3
line.long 0 "RXFUNCADDR_EP8"
bitfld.long 0 0.--6. " RXADDR8 "  " "
bitfld.long 0 0.--6. " RXADDR8 "  " "
;tree.end

base ad:0xa03e00c4
;tree "RXFUNCADDR_EP8"
group 0--3
line.long 0 "RXFUNCADDR_EP8"
bitfld.long 0 0.--6. " RXADDR8 "  " "
bitfld.long 0 0.--6. " RXADDR8 "  " "
;tree.end

base ad:0xa03e00c8
;tree "RXFUNCADDR_EP9"
group 0--3
line.long 0 "RXFUNCADDR_EP9"
bitfld.long 0 0.--6. " RXADDR9 "  " "
bitfld.long 0 0.--6. " RXADDR9 "  " "
;tree.end

base ad:0xa03e00cc
;tree "RXFUNCADDR_EP9"
group 0--3
line.long 0 "RXFUNCADDR_EP9"
bitfld.long 0 0.--6. " RXADDR9 "  " "
bitfld.long 0 0.--6. " RXADDR9 "  " "
;tree.end

base ad:0xa03e00d0
;tree "RXFUNCADDR_EP10"
group 0--3
line.long 0 "RXFUNCADDR_EP10"
bitfld.long 0 0.--6. " RXADDR10 "  " "
bitfld.long 0 0.--6. " RXADDR10 "  " "
;tree.end

base ad:0xa03e00d4
;tree "RXFUNCADDR_EP10"
group 0--3
line.long 0 "RXFUNCADDR_EP10"
bitfld.long 0 0.--6. " RXADDR10 "  " "
bitfld.long 0 0.--6. " RXADDR10 "  " "
;tree.end

base ad:0xa03e00d8
;tree "RXFUNCADDR_EP11"
group 0--3
line.long 0 "RXFUNCADDR_EP11"
bitfld.long 0 0.--6. " RXADDR11 "  " "
bitfld.long 0 0.--6. " RXADDR11 "  " "
;tree.end

base ad:0xa03e00dc
;tree "RXFUNCADDR_EP11"
group 0--3
line.long 0 "RXFUNCADDR_EP11"
bitfld.long 0 0.--6. " RXADDR11 "  " "
bitfld.long 0 0.--6. " RXADDR11 "  " "
;tree.end

base ad:0xa03e00e0
;tree "RXFUNCADDR_EP12"
group 0--3
line.long 0 "RXFUNCADDR_EP12"
bitfld.long 0 0.--6. " RXADDR12 "  " "
bitfld.long 0 0.--6. " RXADDR12 "  " "
;tree.end

base ad:0xa03e00e4
;tree "RXFUNCADDR_EP12"
group 0--3
line.long 0 "RXFUNCADDR_EP12"
bitfld.long 0 0.--6. " RXADDR12 "  " "
bitfld.long 0 0.--6. " RXADDR12 "  " "
;tree.end

base ad:0xa03e00e8
;tree "RXFUNCADDR_EP13"
group 0--3
line.long 0 "RXFUNCADDR_EP13"
bitfld.long 0 0.--6. " RXADDR13 "  " "
bitfld.long 0 0.--6. " RXADDR13 "  " "
;tree.end

base ad:0xa03e00ec
;tree "RXFUNCADDR_EP13"
group 0--3
line.long 0 "RXFUNCADDR_EP13"
bitfld.long 0 0.--6. " RXADDR13 "  " "
bitfld.long 0 0.--6. " RXADDR13 "  " "
;tree.end

base ad:0xa03e00f0
;tree "RXFUNCADDR_EP14"
group 0--3
line.long 0 "RXFUNCADDR_EP14"
bitfld.long 0 0.--6. " RXADDR14 "  " "
bitfld.long 0 0.--6. " RXADDR14 "  " "
;tree.end

base ad:0xa03e00f4
;tree "RXFUNCADDR_EP14"
group 0--3
line.long 0 "RXFUNCADDR_EP14"
bitfld.long 0 0.--6. " RXADDR14 "  " "
bitfld.long 0 0.--6. " RXADDR14 "  " "
;tree.end

base ad:0xa03e00f8
;tree "RXFUNCADDR_EP15"
group 0--3
line.long 0 "RXFUNCADDR_EP15"
bitfld.long 0 0.--6. " RXADDR15 "  " "
bitfld.long 0 0.--6. " RXADDR15 "  " "
;tree.end

base ad:0xa03e00fc
;tree "RXFUNCADDR_EP15"
group 0--3
line.long 0 "RXFUNCADDR_EP15"
bitfld.long 0 0.--6. " RXADDR15 "  " "
bitfld.long 0 0.--6. " RXADDR15 "  " "
;tree.end

base ad:0xa03e0200
;tree "DMA_INTR"
group 0--3
line.long 0 "DMA_INTR"
bitfld.long 0 0. " DMAINTR "  "0 ,1 "
;tree.end

base ad:0xa03e0304
;tree "EP1_RQPKTCOUNT"
group 0--3
line.long 0 "EP1_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0308
;tree "EP2_RQPKTCOUNT"
group 0--3
line.long 0 "EP2_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e030c
;tree "EP3_RQPKTCOUNT"
group 0--3
line.long 0 "EP3_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0310
;tree "EP4_RQPKTCOUNT"
group 0--3
line.long 0 "EP4_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0314
;tree "EP5_RQPKTCOUNT"
group 0--3
line.long 0 "EP5_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0318
;tree "EP6_RQPKTCOUNT"
group 0--3
line.long 0 "EP6_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e031c
;tree "EP7_RQPKTCOUNT"
group 0--3
line.long 0 "EP7_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0320
;tree "EP8_RQPKTCOUNT"
group 0--3
line.long 0 "EP8_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0324
;tree "EP9_RQPKTCOUNT"
group 0--3
line.long 0 "EP9_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0328
;tree "EP10_RQPKTCOUNT"
group 0--3
line.long 0 "EP10_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e032c
;tree "EP11_RQPKTCOUNT"
group 0--3
line.long 0 "EP11_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0330
;tree "EP12_RQPKTCOUNT"
group 0--3
line.long 0 "EP12_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0334
;tree "EP13_RQPKTCOUNT"
group 0--3
line.long 0 "EP13_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0338
;tree "EP14_RQPKTCOUNT"
group 0--3
line.long 0 "EP14_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e033c
;tree "EP15_RQPKTCOUNT"
group 0--3
line.long 0 "EP15_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0340
;tree "DPKTBUFDIS"
group 0--3
line.long 0 "DPKTBUFDIS"
bitfld.long 0 1.--15. " EP_RXDIS "  " "
bitfld.long 0 17.--31. " EP_TXDIS "  " "
;tree.end

base ad:0xa03e0344
;tree "C_T_UCH"
group 0--3
line.long 0 "C_T_UCH"
hexfld.word 0 " C_T_UCH "
hexfld.word 1 " C_T_HSRTN "
;tree.end

base ad:0xa03e0348
;tree "C_T_HSBT"
group 0--3
line.long 0 "C_T_HSBT"
bitfld.long 0 0.--3. " HSTADDR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0360
;tree "LPM_ATTR"
group 0--3
line.long 0 "LPM_ATTR"
bitfld.long 0 0.--3. " LINKSTATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " HIRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " RMTWAK "  "0 ,1 "
bitfld.long 0 12.--15. " EP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " LPMXMT "  "0 ,1 "
bitfld.long 0 17. " LPMRES "  "0 ,1 "
bitfld.long 0 18.--19. " LPMEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " LPMNAK "  "0 ,1 "
bitfld.long 0 21. " LPMSTEN "  "0 ,1 "
bitfld.long 0 22. " LPMNYEN "  "0 ,1 "
bitfld.long 0 23. " LPMACKEN "  "0 ,1 "
bitfld.long 0 24. " LPMNCEN "  "0 ,1 "
bitfld.long 0 25. " LPMRESEN "  "0 ,1 "
bitfld.long 0 26. " LPMERREN "  "0 ,1 "
;tree.end

base ad:0xa03e0364
;tree "LPM_INTR"
group 0--3
line.long 0 "LPM_INTR"
bitfld.long 0 0. " LPMST "  "0 ,1 "
bitfld.long 0 1. " LPMNY "  "0 ,1 "
bitfld.long 0 2. " LPMACK "  "0 ,1 "
bitfld.long 0 3. " LPMNC "  "0 ,1 "
bitfld.long 0 4. " LPMRES "  "0 ,1 "
bitfld.long 0 5. " LPMERR "  "0 ,1 "
bitfld.long 0 8.--14. " FADDR "  " "
;tree.end

tree.end

;==============================================================
tree "USBOTGM"
;==============================================================
base ad:0xa03e0000
;tree "INTTX_PWR_FADDR"
group 0--3
line.long 0 "INTTX_PWR_FADDR"
bitfld.long 0 0.--6. " FADDR "  " "
bitfld.long 0 8. " SUSPM "  "0 ,1 "
bitfld.long 0 9. " SUSP "  "0 ,1 "
bitfld.long 0 10. " RSM "  "0 ,1 "
bitfld.long 0 11. " RST "  "0 ,1 "
bitfld.long 0 12. " HSMD "  "0 ,1 "
bitfld.long 0 13. " HSEN "  "0 ,1 "
bitfld.long 0 14. " SFCN "  "0 ,1 "
bitfld.long 0 15. " ISO_UP "  "0 ,1 "
hexfld.word 1 " EPTX "
;tree.end

base ad:0xa03e0004
;tree "INTTXEN_RX"
group 0--3
line.long 0 "INTTXEN_RX"
hexfld.word 0 " EPRX "
hexfld.word 1 " EPTXEN "
;tree.end

base ad:0xa03e0008
;tree "INTRXEN"
group 0--3
line.long 0 "INTRXEN"
hexfld.word 0 " EPRXEN "
hexfld.word 1 " INTUSB "
;tree.end

base ad:0xa03e000c
;tree "TM_INDX_FMNO"
group 0--3
line.long 0 "TM_INDX_FMNO"
bitfld.long 0 0.--10. " FMNO "  " "
bitfld.long 0 16.--19. " EPNO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24. " TSTNAK "  "0 ,1 "
bitfld.long 0 25. " TSTJ "  "0 ,1 "
bitfld.long 0 26. " TSTK "  "0 ,1 "
bitfld.long 0 27. " TSTPKT "  "0 ,1 "
bitfld.long 0 28. " FHS "  "0 ,1 "
bitfld.long 0 29. " FFS "  "0 ,1 "
bitfld.long 0 30. " FIFOA "  "0 ,1 "
bitfld.long 0 31. " FRH "  "0 ,1 "
;tree.end

base ad:0xa03e0010
;tree "INDX_TXCSR"
group 0--3
line.long 0 "INDX_TXCSR"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.word 1 " TXCSR0 "
;tree.end

base ad:0xa03e0014
;tree "INDX_RXCSR"
group 0--3
line.long 0 "INDX_RXCSR"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.word 1 " RXCSR "
;tree.end

base ad:0xa03e0018
;tree "INDX_COUNT0"
group 0--3
line.long 0 "INDX_COUNT0"
bitfld.long 0 0.--12. " RXCOUNT "  " "
bitfld.long 0 13.--16. " EP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--18. " PROT "  "0 ,1 ,2 ,3 "
bitfld.long 0 19.--20. " SPEED "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--28. " TXPI "  " "
;tree.end

base ad:0xa03e001c
;tree "INDX_CFD"
rgroup 0--3
line.long 0 "INDX_CFD"
bitfld.long 0 0. " UI "  "0 ,1 "
bitfld.long 0 1. " SC "  "0 ,1 "
bitfld.long 0 2. " DYNF "  "0 ,1 "
bitfld.long 0 3. " HBTXE "  "0 ,1 "
bitfld.long 0 4. " HBRXE "  "0 ,1 "
bitfld.long 0 5. " BE "  "0 ,1 "
bitfld.long 0 6. " MPTXE "  "0 ,1 "
bitfld.long 0 7. " MPRXE "  "0 ,1 "
;tree.end

base ad:0xa03e0020
;tree "EP0_FIFO"
group 0--3
line.long 0 "EP0_FIFO"
hexfld.long 0 " FIFO "
;tree.end

base ad:0xa03e0060
;tree "FIFOSZ_DEVCTL"
group 0--3
line.long 0 "FIFOSZ_DEVCTL"
bitfld.long 0 0. " SESS "  "0 ,1 "
bitfld.long 0 1. " HREQ "  "0 ,1 "
bitfld.long 0 2. " HOST "  "0 ,1 "
bitfld.long 0 3.--4. " VBUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " LSDEV "  "0 ,1 "
bitfld.long 0 6. " FSDEV "  "0 ,1 "
bitfld.long 0 7. " BDEV "  "0 ,1 "
bitfld.long 0 8.--11. " TXSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " TXDPB "  "0 ,1 "
bitfld.long 0 16.--19. " RXSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20. " RXDPB "  "0 ,1 "
;tree.end

base ad:0xa03e0064
;tree "FIFOADDR"
group 0--3
line.long 0 "FIFOADDR"
bitfld.long 0 0.--12. " TXAD "  " "
bitfld.long 0 16.--28. " RXAD "  " "
;tree.end

base ad:0xa03e0068
;tree "VCNTL"
rgroup 0--3
line.long 0 "VCNTL"
hexfld.byte 0 " VCNTL "
;tree.end

base ad:0xa03e006c
;tree "HWVER"
rgroup 0--3
line.long 0 "HWVER"
bitfld.long 0 0.--9. " VMIN "  " "
bitfld.long 0 10.--14. " VMAJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 15. " RC "  "0 ,1 "
;tree.end

base ad:0xa03e0070
;tree "ULPI_1"
group 0--3
line.long 0 "ULPI_1"
hexfld.byte 0 " UVBCTRL "
hexfld.byte 1 " UCKIT "
hexfld.byte 2 " UINTMASK "
hexfld.byte 3 " UINT "
;tree.end

base ad:0xa03e0074
;tree "ULPI_2"
group 0--3
line.long 0 "ULPI_2"
hexfld.byte 0 " UREGDATA "
hexfld.byte 1 " UREGADDR "
hexfld.byte 2 " UREGCTRL "
hexfld.byte 3 " URAWDATA "
;tree.end

base ad:0xa03e0078
;tree "INFO_REG"
rgroup 0--3
line.long 0 "INFO_REG"
hexfld.byte 0 " EPINFO "
hexfld.byte 1 " RAMINFO "
hexfld.byte 2 " LINKINFO "
hexfld.byte 3 " VPLEN "
;tree.end

base ad:0xa03e007c
;tree "EOF_REG"
group 0--3
line.long 0 "EOF_REG"
hexfld.byte 0 " HSEOF "
hexfld.byte 1 " FSEOF "
hexfld.byte 2 " LSEOF "
bitfld.long 0 24.--25. " SRST "  "0 ,1 ,2 ,3 "
;tree.end

base ad:0xa03e0100
;tree "EP0_TXCSR0"
group 0--3
line.long 0 "EP0_TXCSR0"
hexfld.word 1 " TXCSR0 "
;tree.end

base ad:0xa03e0108
;tree "EP0_COUNT0"
rgroup 0--3
line.long 0 "EP0_COUNT0"
bitfld.long 0 0.--6. " RXCOUNT "  " "
;tree.end

base ad:0xa03e010c
;tree "EP0_CFD"
rgroup 0--3
line.long 0 "EP0_CFD"
bitfld.long 0 24. " UI "  "0 ,1 "
bitfld.long 0 25. " SC "  "0 ,1 "
bitfld.long 0 26. " DYNF "  "0 ,1 "
bitfld.long 0 27. " HBTXE "  "0 ,1 "
bitfld.long 0 28. " HBRXE "  "0 ,1 "
bitfld.long 0 29. " BE "  "0 ,1 "
bitfld.long 0 30. " MPTXE "  "0 ,1 "
bitfld.long 0 31. " MPRXE "  "0 ,1 "
;tree.end

base ad:0xa03e0110
;tree "EP1_TXCSR_MAXP"
group 0--3
line.long 0 "EP1_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0114
;tree "EP1_RXCSR_MAXP"
group 0--3
line.long 0 "EP1_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0118
;tree "EP1_RXCOUNT"
rgroup 0--3
line.long 0 "EP1_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e011c
;tree "EP1_FIFOSZ"
rgroup 0--3
line.long 0 "EP1_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0120
;tree "EP2_TXCSR_MAXP"
group 0--3
line.long 0 "EP2_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0124
;tree "EP2_RXCSR_MAXP"
group 0--3
line.long 0 "EP2_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0128
;tree "EP2_RXCOUNT"
rgroup 0--3
line.long 0 "EP2_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e012c
;tree "EP2_FIFOSZ"
rgroup 0--3
line.long 0 "EP2_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0130
;tree "EP3_TXCSR_MAXP"
group 0--3
line.long 0 "EP3_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0134
;tree "EP3_RXCSR_MAXP"
group 0--3
line.long 0 "EP3_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0138
;tree "EP3_RXCOUNT"
rgroup 0--3
line.long 0 "EP3_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e013c
;tree "EP3_FIFOSZ"
rgroup 0--3
line.long 0 "EP3_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0140
;tree "EP4_TXCSR_MAXP"
group 0--3
line.long 0 "EP4_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0144
;tree "EP4_RXCSR_MAXP"
group 0--3
line.long 0 "EP4_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0148
;tree "EP4_RXCOUNT"
rgroup 0--3
line.long 0 "EP4_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e014c
;tree "EP4_FIFOSZ"
rgroup 0--3
line.long 0 "EP4_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0150
;tree "EP5_TXCSR_MAXP"
group 0--3
line.long 0 "EP5_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0154
;tree "EP5_RXCSR_MAXP"
group 0--3
line.long 0 "EP5_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0158
;tree "EP5_RXCOUNT"
rgroup 0--3
line.long 0 "EP5_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e015c
;tree "EP5_FIFOSZ"
rgroup 0--3
line.long 0 "EP5_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0160
;tree "EP6_TXCSR_MAXP"
group 0--3
line.long 0 "EP6_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0164
;tree "EP6_RXCSR_MAXP"
group 0--3
line.long 0 "EP6_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0168
;tree "EP6_RXCOUNT"
rgroup 0--3
line.long 0 "EP6_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e016c
;tree "EP6_FIFOSZ"
rgroup 0--3
line.long 0 "EP6_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0170
;tree "EP7_TXCSR_MAXP"
group 0--3
line.long 0 "EP7_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0174
;tree "EP7_RXCSR_MAXP"
group 0--3
line.long 0 "EP7_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
;tree.end

base ad:0xa03e0178
;tree "EP7_RXCOUNT"
rgroup 0--3
line.long 0 "EP7_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
;tree.end

base ad:0xa03e017c
;tree "EP7_FIFOSZ"
rgroup 0--3
line.long 0 "EP7_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " RXSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

base ad:0xa03e0204
;tree "TOPCTRL"
group 0--3
line.long 0 "TOPCTRL"
bitfld.long 0 0. " ULPI_ON "  "0 ,1 "
bitfld.long 0 3. " XGATE "  "0 ,1 "
bitfld.long 0 4.--5. " FSINTF "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " HDEV "  "0 ,1 "
bitfld.long 0 7. " VP_DAT "  "0 ,1 "
bitfld.long 0 8. " USEL "  "0 ,1 "
bitfld.long 0 9. " I2C_OFF "  "0 ,1 "
bitfld.long 0 10. " VBUSLO "  "0 ,1 "
;tree.end

base ad:0xa03e0208
;tree "IRQMUX"
group 0--3
line.long 0 "IRQMUX"
hexfld.byte 0 " INTRX "
hexfld.byte 1 " INTTX "
;tree.end

base ad:0xa03e0300
;tree "EP0_RQPKTCOUNT"
group 0--3
line.long 0 "EP0_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0304
;tree "EP1_RQPKTCOUNT"
group 0--3
line.long 0 "EP1_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0308
;tree "EP2_RQPKTCOUNT"
group 0--3
line.long 0 "EP2_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e030c
;tree "EP3_RQPKTCOUNT"
group 0--3
line.long 0 "EP3_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0310
;tree "EP4_RQPKTCOUNT"
group 0--3
line.long 0 "EP4_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0314
;tree "EP5_RQPKTCOUNT"
group 0--3
line.long 0 "EP5_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0318
;tree "EP6_RQPKTCOUNT"
group 0--3
line.long 0 "EP6_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e031c
;tree "EP7_RQPKTCOUNT"
group 0--3
line.long 0 "EP7_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0320
;tree "EP8_RQPKTCOUNT"
group 0--3
line.long 0 "EP8_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0324
;tree "EP9_RQPKTCOUNT"
group 0--3
line.long 0 "EP9_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0328
;tree "EP10_RQPKTCOUNT"
group 0--3
line.long 0 "EP10_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e032c
;tree "EP11_RQPKTCOUNT"
group 0--3
line.long 0 "EP11_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0330
;tree "EP12_RQPKTCOUNT"
group 0--3
line.long 0 "EP12_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0334
;tree "EP13_RQPKTCOUNT"
group 0--3
line.long 0 "EP13_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0338
;tree "EP14_RQPKTCOUNT"
group 0--3
line.long 0 "EP14_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e033c
;tree "EP15_RQPKTCOUNT"
group 0--3
line.long 0 "EP15_RQPKTCOUNT"
hexfld.word 0 " RQPKTCOUNT "
;tree.end

base ad:0xa03e0340
;tree "DPKTBUFDIS"
group 0--3
line.long 0 "DPKTBUFDIS"
hexfld.word 0 " EP_RXDIS "
hexfld.word 1 " EP_TXDIS "
;tree.end

base ad:0xa03e0344
;tree "C_T_CTRL"
group 0--3
line.long 0 "C_T_CTRL"
hexfld.word 0 " C_T_UCH_CTRL "
hexfld.word 1 " C_T_HSRTN_CTRL "
;tree.end

tree.end

