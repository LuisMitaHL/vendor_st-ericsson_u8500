;PER file generated for DB9540 
;PER file generated from c:/perl/convert/9540/hfile 
;by script version 1.15 8-February-12
;Author : N. PERRIN - Modified : F.GOHIER, O.BECQUET

config 16. 8.
width  55. 8.

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "A9CTI (3 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "A9CTI-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1CTICONTROL"
base eapb:0x801ac000
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
;tree.end

;tree "1CTIINTACK"
base eapb:0x801ac010
wgroup 0--3
line.long 0 "CTIINTACK"
hexfld.byte 0 " INTACK "
;tree.end

;tree "1CTIAPPSET"
base eapb:0x801ac014
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIAPPCLEAR"
base eapb:0x801ac018
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIAPPPULSE"
base eapb:0x801ac01c
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIINEN0"
base eapb:0x801ac020
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIINEN1"
base eapb:0x801ac024
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIINEN2"
base eapb:0x801ac028
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIINEN3"
base eapb:0x801ac02c
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIINEN4"
base eapb:0x801ac030
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIINEN5"
base eapb:0x801ac034
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIINEN6"
base eapb:0x801ac038
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIINEN7"
base eapb:0x801ac03c
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIOUTEN0"
base eapb:0x801ac0a0
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIOUTEN1"
base eapb:0x801ac0a4
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIOUTEN2"
base eapb:0x801ac0a8
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIOUTEN3"
base eapb:0x801ac0ac
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIOUTEN4"
base eapb:0x801ac0b0
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIOUTEN5"
base eapb:0x801ac0b4
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIOUTEN6"
base eapb:0x801ac0b8
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIOUTEN7"
base eapb:0x801ac0bc
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTITRIGINSTATUS"
base eapb:0x801ac130
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
hexfld.byte 0 " TRIGINSTATUS "
;tree.end

;tree "1CTITRIGOUTSTATUS"
base eapb:0x801ac134
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
hexfld.byte 0 " TRIGOUTSTATUS "
;tree.end

;tree "1CTICHINSTATUS"
base eapb:0x801ac138
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTICHOUTSTATUS"
base eapb:0x801ac13c
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTIGATE"
base eapb:0x801ac140
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
;tree.end

;tree "1ASICCTL"
base eapb:0x801ac144
group 0--3
line.long 0 "ASICCTL"
hexfld.byte 0 " ASICCTL "
;tree.end

;tree "1ITCHINACK"
base eapb:0x801acedc
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1ITTRIGINACK"
base eapb:0x801acee0
wgroup 0--3
line.long 0 "ITTRIGINACK"
hexfld.byte 0 " CTTRIGINACK "
;tree.end

;tree "1ITCHOUT"
base eapb:0x801acee4
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1ITTRFLIN"
base eapb:0x801acee8
wgroup 0--3
line.long 0 "ITTRFLIN"
hexfld.byte 0 " CTTRIGOUT "
;tree.end

;tree "1ITCHOUTACK"
base eapb:0x801aceec
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1ITTRIGOUTACK"
base eapb:0x801acef0
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
hexfld.byte 0 " CTTRIGOUTACK "
;tree.end

;tree "1ITCHIN"
base eapb:0x801acef4
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1ITRIGIN"
base eapb:0x801acef8
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
;tree.end

;tree "1CTSR"
base eapb:0x801acfa0
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CTCR"
base eapb:0x801acfa4
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1LAR"
base eapb:0x801acfb0
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

;tree "1LSR"
base eapb:0x801acfb4
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

;tree "1ASR"
base eapb:0x801acfb8
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1DID"
base eapb:0x801acfc8
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
;tree.end

;tree "1DTIR"
base eapb:0x801acfcc
rgroup 0--3
line.long 0 "DTIR"
hexfld.byte 0 " DTIR "
;tree.end

;tree "1PERIPHERAL_ID4"
base eapb:0x801acfd0
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

;tree "1PERIPHERAL_ID5"
base eapb:0x801acfd4
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

;tree "1PERIPHERAL_ID6"
base eapb:0x801acfd8
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

;tree "1PERIPHERAL_ID7"
base eapb:0x801acfdc
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

;tree "1PERIPHERAL_ID0"
base eapb:0x801acfe0
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

;tree "1PERIPHERAL_ID1"
base eapb:0x801acfe4
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

;tree "1PERIPHERAL_ID2"
base eapb:0x801acfe8
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

;tree "1PERIPHERAL_ID3"
base eapb:0x801acfec
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

;tree "1COMPONENT_ID0"
base eapb:0x801acff0
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

;tree "1COMPONENT_ID1"
base eapb:0x801acff4
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

;tree "1COMPONENT_ID2"
base eapb:0x801acff8
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

;tree "1COMPONENT_ID3"
base eapb:0x801acffc
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "A9CTI-2"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "2CTICONTROL"
base eapb:0x801ad000
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
;tree.end

;tree "2CTIINTACK"
base eapb:0x801ad010
wgroup 0--3
line.long 0 "CTIINTACK"
hexfld.byte 0 " INTACK "
;tree.end

;tree "2CTIAPPSET"
base eapb:0x801ad014
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIAPPCLEAR"
base eapb:0x801ad018
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIAPPPULSE"
base eapb:0x801ad01c
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIINEN0"
base eapb:0x801ad020
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIINEN1"
base eapb:0x801ad024
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIINEN2"
base eapb:0x801ad028
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIINEN3"
base eapb:0x801ad02c
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIINEN4"
base eapb:0x801ad030
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIINEN5"
base eapb:0x801ad034
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIINEN6"
base eapb:0x801ad038
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIINEN7"
base eapb:0x801ad03c
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIOUTEN0"
base eapb:0x801ad0a0
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIOUTEN1"
base eapb:0x801ad0a4
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIOUTEN2"
base eapb:0x801ad0a8
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIOUTEN3"
base eapb:0x801ad0ac
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIOUTEN4"
base eapb:0x801ad0b0
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIOUTEN5"
base eapb:0x801ad0b4
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIOUTEN6"
base eapb:0x801ad0b8
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIOUTEN7"
base eapb:0x801ad0bc
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTITRIGINSTATUS"
base eapb:0x801ad130
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
hexfld.byte 0 " TRIGINSTATUS "
;tree.end

;tree "2CTITRIGOUTSTATUS"
base eapb:0x801ad134
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
hexfld.byte 0 " TRIGOUTSTATUS "
;tree.end

;tree "2CTICHINSTATUS"
base eapb:0x801ad138
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTICHOUTSTATUS"
base eapb:0x801ad13c
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTIGATE"
base eapb:0x801ad140
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
;tree.end

;tree "2ASICCTL"
base eapb:0x801ad144
group 0--3
line.long 0 "ASICCTL"
hexfld.byte 0 " ASICCTL "
;tree.end

;tree "2ITCHINACK"
base eapb:0x801adedc
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2ITTRIGINACK"
base eapb:0x801adee0
wgroup 0--3
line.long 0 "ITTRIGINACK"
hexfld.byte 0 " CTTRIGINACK "
;tree.end

;tree "2ITCHOUT"
base eapb:0x801adee4
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2ITTRFLIN"
base eapb:0x801adee8
wgroup 0--3
line.long 0 "ITTRFLIN"
hexfld.byte 0 " CTTRIGOUT "
;tree.end

;tree "2ITCHOUTACK"
base eapb:0x801adeec
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2ITTRIGOUTACK"
base eapb:0x801adef0
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
hexfld.byte 0 " CTTRIGOUTACK "
;tree.end

;tree "2ITCHIN"
base eapb:0x801adef4
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2ITRIGIN"
base eapb:0x801adef8
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
;tree.end

;tree "2CTSR"
base eapb:0x801adfa0
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2CTCR"
base eapb:0x801adfa4
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2LAR"
base eapb:0x801adfb0
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

;tree "2LSR"
base eapb:0x801adfb4
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

;tree "2ASR"
base eapb:0x801adfb8
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2DID"
base eapb:0x801adfc8
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
;tree.end

;tree "2DTIR"
base eapb:0x801adfcc
rgroup 0--3
line.long 0 "DTIR"
hexfld.byte 0 " DTIR "
;tree.end

;tree "2PERIPHERAL_ID4"
base eapb:0x801adfd0
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

;tree "2PERIPHERAL_ID5"
base eapb:0x801adfd4
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

;tree "2PERIPHERAL_ID6"
base eapb:0x801adfd8
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

;tree "2PERIPHERAL_ID7"
base eapb:0x801adfdc
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

;tree "2PERIPHERAL_ID0"
base eapb:0x801adfe0
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

;tree "2PERIPHERAL_ID1"
base eapb:0x801adfe4
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

;tree "2PERIPHERAL_ID2"
base eapb:0x801adfe8
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

;tree "2PERIPHERAL_ID3"
base eapb:0x801adfec
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

;tree "2COMPONENT_ID0"
base eapb:0x801adff0
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

;tree "2COMPONENT_ID1"
base eapb:0x801adff4
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

;tree "2COMPONENT_ID2"
base eapb:0x801adff8
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

;tree "2COMPONENT_ID3"
base eapb:0x801adffc
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "A9CTI-TI"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "TICTICONTROL"
base eapb:0x801a5000
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
;tree.end

;tree "TICTIINTACK"
base eapb:0x801a5010
wgroup 0--3
line.long 0 "CTIINTACK"
hexfld.byte 0 " INTACK "
;tree.end

;tree "TICTIAPPSET"
base eapb:0x801a5014
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIAPPCLEAR"
base eapb:0x801a5018
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIAPPPULSE"
base eapb:0x801a501c
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIINEN0"
base eapb:0x801a5020
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIINEN1"
base eapb:0x801a5024
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIINEN2"
base eapb:0x801a5028
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIINEN3"
base eapb:0x801a502c
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIINEN4"
base eapb:0x801a5030
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIINEN5"
base eapb:0x801a5034
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIINEN6"
base eapb:0x801a5038
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIINEN7"
base eapb:0x801a503c
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIOUTEN0"
base eapb:0x801a50a0
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIOUTEN1"
base eapb:0x801a50a4
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIOUTEN2"
base eapb:0x801a50a8
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIOUTEN3"
base eapb:0x801a50ac
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIOUTEN4"
base eapb:0x801a50b0
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIOUTEN5"
base eapb:0x801a50b4
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIOUTEN6"
base eapb:0x801a50b8
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIOUTEN7"
base eapb:0x801a50bc
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTITRIGINSTATUS"
base eapb:0x801a5130
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
hexfld.byte 0 " TRIGINSTATUS "
;tree.end

;tree "TICTITRIGOUTSTATUS"
base eapb:0x801a5134
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
hexfld.byte 0 " TRIGOUTSTATUS "
;tree.end

;tree "TICTICHINSTATUS"
base eapb:0x801a5138
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTICHOUTSTATUS"
base eapb:0x801a513c
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTIGATE"
base eapb:0x801a5140
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
;tree.end

;tree "TIASICCTL"
base eapb:0x801a5144
group 0--3
line.long 0 "ASICCTL"
hexfld.byte 0 " ASICCTL "
;tree.end

;tree "TIITCHINACK"
base eapb:0x801a5edc
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TIITTRIGINACK"
base eapb:0x801a5ee0
wgroup 0--3
line.long 0 "ITTRIGINACK"
hexfld.byte 0 " CTTRIGINACK "
;tree.end

;tree "TIITCHOUT"
base eapb:0x801a5ee4
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TIITTRFLIN"
base eapb:0x801a5ee8
wgroup 0--3
line.long 0 "ITTRFLIN"
hexfld.byte 0 " CTTRIGOUT "
;tree.end

;tree "TIITCHOUTACK"
base eapb:0x801a5eec
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TIITTRIGOUTACK"
base eapb:0x801a5ef0
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
hexfld.byte 0 " CTTRIGOUTACK "
;tree.end

;tree "TIITCHIN"
base eapb:0x801a5ef4
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TIITRIGIN"
base eapb:0x801a5ef8
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
;tree.end

;tree "TICTSR"
base eapb:0x801a5fa0
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TICTCR"
base eapb:0x801a5fa4
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TILAR"
base eapb:0x801a5fb0
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

;tree "TILSR"
base eapb:0x801a5fb4
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

;tree "TIASR"
base eapb:0x801a5fb8
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TIDID"
base eapb:0x801a5fc8
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
;tree.end

;tree "TIDTIR"
base eapb:0x801a5fcc
rgroup 0--3
line.long 0 "DTIR"
hexfld.byte 0 " DTIR "
;tree.end

;tree "TIPERIPHERAL_ID4"
base eapb:0x801a5fd0
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

;tree "TIPERIPHERAL_ID5"
base eapb:0x801a5fd4
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

;tree "TIPERIPHERAL_ID6"
base eapb:0x801a5fd8
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

;tree "TIPERIPHERAL_ID7"
base eapb:0x801a5fdc
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

;tree "TIPERIPHERAL_ID0"
base eapb:0x801a5fe0
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

;tree "TIPERIPHERAL_ID1"
base eapb:0x801a5fe4
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

;tree "TIPERIPHERAL_ID2"
base eapb:0x801a5fe8
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

;tree "TIPERIPHERAL_ID3"
base eapb:0x801a5fec
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

;tree "TICOMPONENT_ID0"
base eapb:0x801a5ff0
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

;tree "TICOMPONENT_ID1"
base eapb:0x801a5ff4
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

;tree "TICOMPONENT_ID2"
base eapb:0x801a5ff8
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

;tree "TICOMPONENT_ID3"
base eapb:0x801a5ffc
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "B2R2"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
if (((data.long(ad:0x80157078)&0x100)!=0x100)||((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x8015741c)&0x100000)!=0x100000)||((data.long(ad:0x801571ec)&0x4)!=0x4)||((data.long(ad:0x80157428)&0x400)!=0x0))
base ad:0x0
hgroup 0--3
TEXTLINE "B2R2 is not acessible. Please activate its clock or release its reset"
else
;tree "BLT_CTL"
base ad:0x80130a00
group 0--3
line.long 0 "BLT_CTL"
bitfld.long 0 28. " Big_not_little "  "0 ,1 "
bitfld.long 0 29. " Step_By_Step "  "0 ,1 "
bitfld.long 0 31. " GLOBAL_soft_reset "  "0 ,1 "
;tree.end

;tree "BLT_ITS"
base ad:0x80130a04
group 0--3
line.long 0 "BLT_ITS"
bitfld.long 0 0. " CQ1_completed "  "0 ,1 "
bitfld.long 0 1. " CQ1_retriggered "  "0 ,1 "
bitfld.long 0 2. " CQ1_Node_Notif "  "0 ,1 "
bitfld.long 0 3. " CQ1_Repaced "  "0 ,1 "
bitfld.long 0 4. " CQ2_completed "  "0 ,1 "
bitfld.long 0 5. " CQ2_retriggered "  "0 ,1 "
bitfld.long 0 6. " CQ2_Node_Notif "  "0 ,1 "
bitfld.long 0 7. " CQ2_Repaced "  "0 ,1 "
bitfld.long 0 12. " AQ1_LNA_Reached "  "0 ,1 "
bitfld.long 0 13. " AQ1_Stopped "  "0 ,1 "
bitfld.long 0 14. " AQ1_Node_repeat "  "0 ,1 "
bitfld.long 0 15. " AQ1_Node_Notif "  "0 ,1 "
bitfld.long 0 16. " AQ2_LNA_Reached "  "0 ,1 "
bitfld.long 0 17. " AQ2_Stopped "  "0 ,1 "
bitfld.long 0 18. " AQ2_Node_repeat "  "0 ,1 "
bitfld.long 0 19. " AQ2_Node_Notif "  "0 ,1 "
bitfld.long 0 20. " AQ3_LNA_Reached "  "0 ,1 "
bitfld.long 0 21. " AQ3_Stopped "  "0 ,1 "
bitfld.long 0 22. " AQ3_Node_repeat "  "0 ,1 "
bitfld.long 0 23. " AQ3_Node_Notif "  "0 ,1 "
bitfld.long 0 24. " AQ4_LNA_Reached "  "0 ,1 "
bitfld.long 0 25. " AQ4_Stopped "  "0 ,1 "
bitfld.long 0 26. " AQ4_Node_repeat "  "0 ,1 "
bitfld.long 0 27. " AQ4_Node_Notif "  "0 ,1 "
bitfld.long 0 31. " RLD_ERROR "  "0 ,1 "
;tree.end

;tree "BLT_STA1"
base ad:0x80130a08
group 0--3
line.long 0 "BLT_STA1"
bitfld.long 0 0. " BDISP_IDLE "  "0 ,1 "
;tree.end

;tree "BLT_SSBA1"
base ad:0x80130a10
group 0--3
line.long 0 "BLT_SSBA1"
bitfld.long 0 0.--25. " SSBA1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA1_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA2"
base ad:0x80130a14
group 0--3
line.long 0 "BLT_SSBA2"
bitfld.long 0 0.--25. " SSBA2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA2_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA3"
base ad:0x80130a18
group 0--3
line.long 0 "BLT_SSBA3"
bitfld.long 0 0.--25. " SSBA3_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA3_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA4"
base ad:0x80130a1c
group 0--3
line.long 0 "BLT_SSBA4"
bitfld.long 0 0.--25. " SSBA4_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA4_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA5"
base ad:0x80130a20
group 0--3
line.long 0 "BLT_SSBA5"
bitfld.long 0 0.--25. " SSBA5_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA5_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA6"
base ad:0x80130a24
group 0--3
line.long 0 "BLT_SSBA6"
bitfld.long 0 0.--25. " SSBA6_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA6_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA7"
base ad:0x80130a28
group 0--3
line.long 0 "BLT_SSBA7"
bitfld.long 0 0.--25. " SSBA7_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA7_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA8"
base ad:0x80130a2c
group 0--3
line.long 0 "BLT_SSBA8"
bitfld.long 0 0.--25. " SSBA8_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA8_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA9"
base ad:0x80130aa0
group 0--3
line.long 0 "BLT_SSBA9"
bitfld.long 0 0.--25. " SSBA9_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA9_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA10"
base ad:0x80130aa4
group 0--3
line.long 0 "BLT_SSBA10"
bitfld.long 0 0.--25. " SSBA10_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA10_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA11"
base ad:0x80130aa8
group 0--3
line.long 0 "BLT_SSBA11"
bitfld.long 0 0.--25. " SSBA11_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA11_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA12"
base ad:0x80130aac
group 0--3
line.long 0 "BLT_SSBA12"
bitfld.long 0 0.--25. " SSBA12_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA12_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA13"
base ad:0x80130ab0
group 0--3
line.long 0 "BLT_SSBA13"
bitfld.long 0 0.--25. " SSBA13_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA13_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA14"
base ad:0x80130ab4
group 0--3
line.long 0 "BLT_SSBA14"
bitfld.long 0 0.--25. " SSBA14_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA14_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA15"
base ad:0x80130ab8
group 0--3
line.long 0 "BLT_SSBA15"
bitfld.long 0 0.--25. " SSBA15_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA15_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA16"
base ad:0x80130abc
group 0--3
line.long 0 "BLT_SSBA16"
bitfld.long 0 0.--25. " SSBA16_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA16_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA1"
base ad:0x80130a30
group 0--3
line.long 0 "BLT_STBA1"
bitfld.long 0 0.--25. " STBA1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA1_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA2"
base ad:0x80130a34
group 0--3
line.long 0 "BLT_STBA2"
bitfld.long 0 0.--25. " STBA2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA2_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA3"
base ad:0x80130a38
group 0--3
line.long 0 "BLT_STBA3"
bitfld.long 0 0.--25. " STBA3_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA3_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA4"
base ad:0x80130a3c
group 0--3
line.long 0 "BLT_STBA4"
bitfld.long 0 0.--25. " STBA4_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA4_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_CQ1_TRIG_IP"
base ad:0x80130a40
group 0--3
line.long 0 "BLT_CQ1_TRIG_IP"
bitfld.long 0 0.--25. " CQ1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " TRIG_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_CQ2_TRIG_IP"
base ad:0x80130a50
group 0--3
line.long 0 "BLT_CQ2_TRIG_IP"
bitfld.long 0 0.--25. " CQ2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " TRIG_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_CQ1_TRIG_CTL"
base ad:0x80130a44
group 0--3
line.long 0 "BLT_CQ1_TRIG_CTL"
bitfld.long 0 0.--11. " Trigger_line_num "  " "
bitfld.long 0 12.--15. " Trig_cond "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " Retrig_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

;tree "BLT_CQ2_TRIG_CTL"
base ad:0x80130a54
group 0--3
line.long 0 "BLT_CQ2_TRIG_CTL"
bitfld.long 0 0.--11. " Trigger_line_num "  " "
bitfld.long 0 12.--15. " Trig_cond "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " Retrig_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

;tree "BLT_CQ1_PACE_CTL"
base ad:0x80130a48
group 0--3
line.long 0 "BLT_CQ1_PACE_CTL"
bitfld.long 0 0.--11. " Pace_start "  " "
bitfld.long 0 16.--27. " Pace_Count "  " "
bitfld.long 0 31. " Dynamic_Pace "  "0 ,1 "
;tree.end

;tree "BLT_CQ2_PACE_CTL"
base ad:0x80130a58
group 0--3
line.long 0 "BLT_CQ2_PACE_CTL"
bitfld.long 0 0.--11. " Pace_start "  " "
bitfld.long 0 16.--27. " Pace_Count "  " "
bitfld.long 0 31. " Dynamic_Pace "  "0 ,1 "
;tree.end

;tree "BLT_CQ1_IP"
base ad:0x80130a4c
rgroup 0--3
line.long 0 "BLT_CQ1_IP"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_CQ2_IP"
base ad:0x80130a5c
rgroup 0--3
line.long 0 "BLT_CQ2_IP"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ1_CTL"
base ad:0x80130a60
group 0--3
line.long 0 "BLT_AQ1_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

;tree "BLT_AQ2_CTL"
base ad:0x80130a70
group 0--3
line.long 0 "BLT_AQ2_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

;tree "BLT_AQ3_CTL"
base ad:0x80130a80
group 0--3
line.long 0 "BLT_AQ3_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

;tree "BLT_AQ4_CTL"
base ad:0x80130a90
group 0--3
line.long 0 "BLT_AQ4_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

;tree "BLT_AQ1_IP"
base ad:0x80130a64
group 0--3
line.long 0 "BLT_AQ1_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ2_IP"
base ad:0x80130a74
group 0--3
line.long 0 "BLT_AQ2_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ3_IP"
base ad:0x80130a84
group 0--3
line.long 0 "BLT_AQ3_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ4_IP"
base ad:0x80130a94
group 0--3
line.long 0 "BLT_AQ4_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ1_LNA"
base ad:0x80130a68
group 0--3
line.long 0 "BLT_AQ1_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ2_LNA"
base ad:0x80130a78
group 0--3
line.long 0 "BLT_AQ2_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ3_LNA"
base ad:0x80130a88
group 0--3
line.long 0 "BLT_AQ3_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ4_LNA"
base ad:0x80130a98
group 0--3
line.long 0 "BLT_AQ4_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ1_STA"
base ad:0x80130a6c
rgroup 0--3
line.long 0 "BLT_AQ1_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ2_STA"
base ad:0x80130a7c
rgroup 0--3
line.long 0 "BLT_AQ2_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ3_STA"
base ad:0x80130a8c
rgroup 0--3
line.long 0 "BLT_AQ3_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ4_STA"
base ad:0x80130a9c
rgroup 0--3
line.long 0 "BLT_AQ4_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SGA1"
base ad:0x80130ac0
group 0--3
line.long 0 "BLT_SGA1"
hexfld.byte 0 " Alpha1 "
hexfld.byte 1 " Alpha2 "
hexfld.byte 2 " Alpha3 "
hexfld.byte 3 " Alpha4 "
;tree.end

;tree "BLT_SGA2"
base ad:0x80130ac4
group 0--3
line.long 0 "BLT_SGA2"
hexfld.byte 0 " Alpha5 "
hexfld.byte 1 " Alpha6 "
hexfld.byte 2 " Alpha7 "
hexfld.byte 3 " Alpha8 "
;tree.end

;tree "BLT_ITM0"
base ad:0x80130ad0
group 0--3
line.long 0 "BLT_ITM0"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

;tree "BLT_ITM1"
base ad:0x80130ad4
group 0--3
line.long 0 "BLT_ITM1"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

;tree "BLT_ITM2"
base ad:0x80130ad8
group 0--3
line.long 0 "BLT_ITM2"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

;tree "BLT_ITM3"
base ad:0x80130adc
group 0--3
line.long 0 "BLT_ITM3"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

;tree "BLT_DFV1"
base ad:0x80130af4
group 0--3
line.long 0 "BLT_DFV1"
bitfld.long 0 0.--11. " DFV1_Line_count "  " "
bitfld.long 0 12. " DFV1_ITM0_IT "  "0 ,1 "
bitfld.long 0 13. " DFV1_ITM1_IT "  "0 ,1 "
bitfld.long 0 14. " DFV1_ITM2_IT "  "0 ,1 "
bitfld.long 0 15. " DFV1_ITM3_IT "  "0 ,1 "
bitfld.long 0 16. " DFV1_AQ1_IT "  "0 ,1 "
bitfld.long 0 17. " DFV1_AQ2_IT "  "0 ,1 "
bitfld.long 0 18. " DFV1_AQ3_IT "  "0 ,1 "
bitfld.long 0 19. " DFV1_AQ4_IT "  "0 ,1 "
bitfld.long 0 20. " DFV1_CQ1_IT "  "0 ,1 "
bitfld.long 0 21. " DFV1_CQ2_IT "  "0 ,1 "
bitfld.long 0 24. " DFV1_GPO "  "0 ,1 "
bitfld.long 0 28. " DFV1_req "  "0 ,1 "
bitfld.long 0 29. " DFV1_ntop_bot "  "0 ,1 "
bitfld.long 0 30. " DFV1_Vsync "  "0 ,1 "
bitfld.long 0 31. " DFV1_Mode_En "  "0 ,1 "
;tree.end

;tree "BLT_DFV2"
base ad:0x80130af0
group 0--3
line.long 0 "BLT_DFV2"
bitfld.long 0 0.--11. " DFV2_Line_count "  " "
bitfld.long 0 28. " DFV2_req "  "0 ,1 "
bitfld.long 0 29. " DFV2_ntop_bot "  "0 ,1 "
bitfld.long 0 30. " DFV2_Vsync "  "0 ,1 "
bitfld.long 0 31. " DFV2_Mode_En "  "0 ,1 "
;tree.end

;tree "BLT_PRI"
base ad:0x80130af8
group 0--3
line.long 0 "BLT_PRI"
bitfld.long 0 0.--3. " CQ1_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " CQ2_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " AQ1_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " AQ2_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " AQ3_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " AQ4_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "BLT_SSBA17"
base ad:0x80130900
group 0--3
line.long 0 "BLT_SSBA17"
bitfld.long 0 0.--25. " SSBA17_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA17_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA18"
base ad:0x80130904
group 0--3
line.long 0 "BLT_SSBA18"
bitfld.long 0 0.--25. " SSBA18_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA18_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA19"
base ad:0x80130908
group 0--3
line.long 0 "BLT_SSBA19"
bitfld.long 0 0.--25. " SSBA19_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA19_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA20"
base ad:0x8013090c
group 0--3
line.long 0 "BLT_SSBA20"
bitfld.long 0 0.--25. " SSBA20_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA20_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA21"
base ad:0x80130910
group 0--3
line.long 0 "BLT_SSBA21"
bitfld.long 0 0.--25. " SSBA21_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA21_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA22"
base ad:0x80130914
group 0--3
line.long 0 "BLT_SSBA22"
bitfld.long 0 0.--25. " SSBA22_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA22_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA23"
base ad:0x80130918
group 0--3
line.long 0 "BLT_SSBA23"
bitfld.long 0 0.--25. " SSBA23_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA23_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA24"
base ad:0x8013091c
group 0--3
line.long 0 "BLT_SSBA24"
bitfld.long 0 0.--25. " SSBA24_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA24_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA5"
base ad:0x80130940
group 0--3
line.long 0 "BLT_STBA5"
bitfld.long 0 0.--25. " STBA5_Mem_address "  " "
bitfld.long 0 26.--31. " STBA5_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA6"
base ad:0x80130944
group 0--3
line.long 0 "BLT_STBA6"
bitfld.long 0 0.--25. " STBA6_Mem_address "  " "
bitfld.long 0 26.--31. " STBA6_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA7"
base ad:0x80130948
group 0--3
line.long 0 "BLT_STBA7"
bitfld.long 0 0.--25. " STBA7_Mem_address "  " "
bitfld.long 0 26.--31. " STBA7_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA8"
base ad:0x8013094c
group 0--3
line.long 0 "BLT_STBA8"
bitfld.long 0 0.--25. " STBA8_Mem_address "  " "
bitfld.long 0 26.--31. " STBA8_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "PLUGS1_OP2"
base ad:0x80130b04
group 0--3
line.long 0 "PLUGS1_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGS2_OP2"
base ad:0x80130b24
group 0--3
line.long 0 "PLUGS2_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGS3_OP2"
base ad:0x80130b44
group 0--3
line.long 0 "PLUGS3_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGS1_CHZ"
base ad:0x80130b08
group 0--3
line.long 0 "PLUGS1_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGS2_CHZ"
base ad:0x80130b28
group 0--3
line.long 0 "PLUGS2_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGS3_CHZ"
base ad:0x80130b48
group 0--3
line.long 0 "PLUGS3_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGS1_MSZ"
base ad:0x80130b0c
group 0--3
line.long 0 "PLUGS1_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " MinSpaceBetweenReq "
;tree.end

;tree "PLUGS2_MSZ"
base ad:0x80130b2c
group 0--3
line.long 0 "PLUGS2_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " MinSpaceBetweenReq "
;tree.end

;tree "PLUGS3_MSZ"
base ad:0x80130b4c
group 0--3
line.long 0 "PLUGS3_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " MinSpaceBetweenReq "
;tree.end

;tree "PLUGS1_PGZ"
base ad:0x80130b10
group 0--3
line.long 0 "PLUGS1_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PLUGS2_PGZ"
base ad:0x80130b30
group 0--3
line.long 0 "PLUGS2_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PLUGS3_PGZ"
base ad:0x80130b50
group 0--3
line.long 0 "PLUGS3_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PLUGT_OP2"
base ad:0x80130b84
group 0--3
line.long 0 "PLUGT_OP2"
bitfld.long 0 0.--2. " Max_code "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGT_CHZ"
base ad:0x80130b88
group 0--3
line.long 0 "PLUGT_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGT_MSZ"
base ad:0x80130b8c
group 0--3
line.long 0 "PLUGT_MSZ"
bitfld.long 0 0.--2. " Message_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " MinSpaceBetweenReq "
;tree.end

;tree "PLUGT_PGZ"
base ad:0x80130b90
group 0--3
line.long 0 "PLUGT_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "BLT_NIP"
base ad:0x80130c00
group 0--3
line.long 0 "BLT_NIP"
bitfld.long 0 0.--25. " NIP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " NIP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_CIC"
base ad:0x80130c04
group 0--3
line.long 0 "BLT_CIC"
bitfld.long 0 2. " Group2 "  "0 ,1 "
bitfld.long 0 3. " Group3 "  "0 ,1 "
bitfld.long 0 4. " Group4 "  "0 ,1 "
bitfld.long 0 5. " Group5 "  "0 ,1 "
bitfld.long 0 6. " Group6 "  "0 ,1 "
bitfld.long 0 7. " Group7 "  "0 ,1 "
bitfld.long 0 8. " Group8 "  "0 ,1 "
bitfld.long 0 9. " Group9 "  "0 ,1 "
bitfld.long 0 10. " Group10 "  "0 ,1 "
bitfld.long 0 11. " Group11 "  "0 ,1 "
bitfld.long 0 12. " Group12 "  "0 ,1 "
bitfld.long 0 13. " Group13 "  "0 ,1 "
bitfld.long 0 14. " Group14 "  "0 ,1 "
bitfld.long 0 15. " Group15 "  "0 ,1 "
bitfld.long 0 16. " Group16 "  "0 ,1 "
bitfld.long 0 17. " Group17 "  "0 ,1 "
bitfld.long 0 18. " Group18 "  "0 ,1 "
;tree.end

;tree "BLT_INS"
base ad:0x80130c08
group 0--3
line.long 0 "BLT_INS"
bitfld.long 0 0.--2. " SOURCE1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--4. " SOURCE2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " SOURCE3 "  "0 ,1 "
bitfld.long 0 6. " IVMX "  "0 ,1 "
bitfld.long 0 7. " CLUTOP "  "0 ,1 "
bitfld.long 0 8. " 2DRESCALE "  "0 ,1 "
bitfld.long 0 9. " FILCK_FILT "  "0 ,1 "
bitfld.long 0 10. " RECT_CLIP "  "0 ,1 "
bitfld.long 0 11. " CKEY "  "0 ,1 "
bitfld.long 0 12. " OVMX "  "0 ,1 "
bitfld.long 0 13. " DEI "  "0 ,1 "
bitfld.long 0 14. " PLANE_MASK "  "0 ,1 "
bitfld.long 0 15. " XYL "  "0 ,1 "
bitfld.long 0 16. " DOT "  "0 ,1 "
bitfld.long 0 17. " VC1R "  "0 ,1 "
bitfld.long 0 18. " ROTATION "  "0 ,1 "
bitfld.long 0 30. " Pace_down "  "0 ,1 "
bitfld.long 0 31. " BlitCompIRQ "  "0 ,1 "
;tree.end

;tree "BLT_ACK"
base ad:0x80130c0c
group 0--3
line.long 0 "BLT_ACK"
bitfld.long 0 0.--3. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " SWAP_FG_BG "  "0 ,1 "
hexfld.byte 1 " GALPHA_ROPID "
bitfld.long 0 16.--21. " ACK_CKEY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--23. " CKEY_SEL "  "0 ,1 ,2 ,3 "
;tree.end

;tree "BLT_TBA"
base ad:0x80130c10
group 0--3
line.long 0 "BLT_TBA"
bitfld.long 0 0.--25. " TBA_mem_addr "  " "
bitfld.long 0 26.--31. " TBA_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_TTY"
base ad:0x80130c14
group 0--3
line.long 0 "BLT_TTY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 26. " RGB_ROUND "  "0 ,1 "
bitfld.long 0 27. " CHROMA_notLUMA "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

;tree "BLT_TXY"
base ad:0x80130c18
group 0--3
line.long 0 "BLT_TXY"
hexfld.word 0 " XCOORD "
hexfld.word 2 " YCOORD "
;tree.end

;tree "BLT_TSZ"
base ad:0x80130c1c
group 0--3
line.long 0 "BLT_TSZ"
bitfld.long 0 0.--11. " WIN_WIDTH "  " "
bitfld.long 0 16.--27. " WIN_HEIGHT "  " "
;tree.end

;tree "BLT_S1CF"
base ad:0x80130c20
group 0--3
line.long 0 "BLT_S1CF"
hexfld.long 0 " SRC1_COLOR_FILL "
;tree.end

;tree "BLT_S2CF"
base ad:0x80130c24
group 0--3
line.long 0 "BLT_S2CF"
hexfld.long 0 " SRC2_COLOR_FILL "
;tree.end

;tree "BLT_S1BA"
base ad:0x80130c28
group 0--3
line.long 0 "BLT_S1BA"
bitfld.long 0 0.--25. " S1BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S1BA_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_S1TY"
base ad:0x80130c2c
group 0--3
line.long 0 "BLT_S1TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 22. " A1_SUBST "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 27. " ROTATION "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 29. " RGB_EXP "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

;tree "BLT_S1XY"
base ad:0x80130c30
group 0--3
line.long 0 "BLT_S1XY"
hexfld.word 0 " XCOORD "
hexfld.word 2 " YCOORD "
;tree.end

;tree "BLT_S2BA"
base ad:0x80130c38
group 0--3
line.long 0 "BLT_S2BA"
bitfld.long 0 0.--25. " S2BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S2BA_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_S2TY"
base ad:0x80130c3c
group 0--3
line.long 0 "BLT_S2TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 22. " A1_SUBST "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 26. " CHROMA_LEFT "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 29. " RGB_EXP "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

;tree "BLT_S2XY"
base ad:0x80130c40
group 0--3
line.long 0 "BLT_S2XY"
hexfld.word 0 " XCOORD "
hexfld.word 2 " YCOORD "
;tree.end

;tree "BLT_S2SZ"
base ad:0x80130c44
group 0--3
line.long 0 "BLT_S2SZ"
bitfld.long 0 0.--11. " SRC2_WIN_WIDTH "  " "
bitfld.long 0 16.--27. " SRC2_WIN_HEIGHT "  " "
;tree.end

;tree "BLT_S3BA"
base ad:0x80130c48
group 0--3
line.long 0 "BLT_S3BA"
bitfld.long 0 0.--25. " S3BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S3BA_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_S3TY"
base ad:0x80130c4c
group 0--3
line.long 0 "BLT_S3TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " VSO "  "0 ,1 "
bitfld.long 0 25. " HSO "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

;tree "BLT_S3XY"
base ad:0x80130c50
group 0--3
line.long 0 "BLT_S3XY"
hexfld.word 0 " XCOORD "
hexfld.word 2 " YCOORD "
;tree.end

;tree "BLT_S3SZ"
base ad:0x80130c54
group 0--3
line.long 0 "BLT_S3SZ"
bitfld.long 0 0.--11. " SRC3_WIN_WIDTH "  " "
bitfld.long 0 16.--27. " SRC3_WIN_HEIGHT "  " "
;tree.end

;tree "BLT_CWO"
base ad:0x80130c58
group 0--3
line.long 0 "BLT_CWO"
bitfld.long 0 0.--14. " XDO "  " "
bitfld.long 0 16.--26. " YDO "  " "
bitfld.long 0 27. " INTNL "  "0 ,1 "
;tree.end

;tree "BLT_CWS"
base ad:0x80130c5c
group 0--3
line.long 0 "BLT_CWS"
bitfld.long 0 0.--14. " XDS "  " "
bitfld.long 0 16.--26. " YDS "  " "
;tree.end

;tree "BLT_CCO"
base ad:0x80130c60
group 0--3
line.long 0 "BLT_CCO"
bitfld.long 0 15. " CLUT_NS2_1S1 "  "0 ,1 "
bitfld.long 0 16.--17. " CLUT_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " CLUT_UPDATE "  "0 ,1 "
bitfld.long 0 19.--22. " CLUT_ERRDIFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "BLT_CML"
base ad:0x80130c64
group 0--3
line.long 0 "BLT_CML"
bitfld.long 0 4.--25. " CML_MEM_ADDR "  " "
bitfld.long 0 26.--31. " CML_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_FCTL"
base ad:0x80130c68
group 0--3
line.long 0 "BLT_FCTL"
bitfld.long 0 0.--2. " 2DHF_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " 2DVF_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12. " AB_Right "  "0 ,1 "
bitfld.long 0 13. " AB_Left "  "0 ,1 "
bitfld.long 0 14. " AB_BOT "  "0 ,1 "
bitfld.long 0 15. " AB_TOP "  "0 ,1 "
bitfld.long 0 24.--25. " Luma_2Dhf_mode "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " Luma_2Dvf_mode "  "0 ,1 ,2 ,3 "
;tree.end

;tree "BLT_PMK"
base ad:0x80130c6c
group 0--3
line.long 0 "BLT_PMK"
bitfld.long 0 0. " PLANE_MASK "  "0 ,1 "
;tree.end

;tree "BLT_RSF"
base ad:0x80130c70
group 0--3
line.long 0 "BLT_RSF"
hexfld.word 0 " HSRC_INC "
hexfld.word 2 " VSRC_INC "
;tree.end

;tree "BLT_RZI"
base ad:0x80130c74
group 0--3
line.long 0 "BLT_RZI"
bitfld.long 0 0.--9. " HSRC_INIT "  " "
bitfld.long 0 12.--14. " Hnb_repeat "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--25. " VSRC_INIT "  " "
bitfld.long 0 28.--30. " Vnb_repeat "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "BLT_HFP"
base ad:0x80130c78
group 0--3
line.long 0 "BLT_HFP"
bitfld.long 0 0.--25. " HFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " HFP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_VFP"
base ad:0x80130c7c
group 0--3
line.long 0 "BLT_VFP"
bitfld.long 0 0.--25. " VFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " VFP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_Y_RSF"
base ad:0x80130c80
group 0--3
line.long 0 "BLT_Y_RSF"
hexfld.word 0 " Luma_HSRC_INC "
hexfld.word 2 " Luma_VSRC_INC "
;tree.end

;tree "BLT_Y_RZI"
base ad:0x80130c84
group 0--3
line.long 0 "BLT_Y_RZI"
bitfld.long 0 0.--9. " Hsrc_init_luma "  " "
bitfld.long 0 12.--14. " Hnb_repeat_luma "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--25. " Vsrc_init_luma "  " "
bitfld.long 0 28.--30. " Vnb_repeat_Luma "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "BLT_Y_HFP"
base ad:0x80130c88
group 0--3
line.long 0 "BLT_Y_HFP"
bitfld.long 0 0.--25. " Y_HFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " Y_Hfp_Bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_Y_VFP"
base ad:0x80130c8c
group 0--3
line.long 0 "BLT_Y_VFP"
bitfld.long 0 0.--25. " Y_VFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " Y_Vfp_Bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_KEY1"
base ad:0x80130ca0
group 0--3
line.long 0 "BLT_KEY1"
hexfld.byte 0 " BLUE_MIN "
hexfld.byte 1 " GREEN_MIN "
hexfld.byte 2 " RED_MIN "
hexfld.byte 3 " ALPHA0 "
;tree.end

;tree "BLT_KEY2"
base ad:0x80130ca4
group 0--3
line.long 0 "BLT_KEY2"
hexfld.byte 0 " BLUE_MAX "
hexfld.byte 1 " GREEN_MAX "
hexfld.byte 2 " RED_MAX "
hexfld.byte 3 " ALPHA1 "
;tree.end

;tree "BLT_SAR"
base ad:0x80130cb0
group 0--3
line.long 0 "BLT_SAR"
bitfld.long 0 0.--4. " S1_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " S2_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " S3_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--27. " T_STBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " A_SGA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "BLT_USR"
base ad:0x80130cb4
group 0--3
line.long 0 "BLT_USR"
hexfld.long 0 " GENERAL_PURPOSE "
;tree.end

;tree "BLT_IVMX0"
base ad:0x80130cc0
group 0--3
line.long 0 "BLT_IVMX0"
bitfld.long 0 0.--9. " Coeff13 "  " "
bitfld.long 0 10.--20. " Coeff12 "  " "
bitfld.long 0 21.--31. " Coeff11 "  " "
;tree.end

;tree "BLT_IVMX1"
base ad:0x80130cc4
group 0--3
line.long 0 "BLT_IVMX1"
bitfld.long 0 0.--9. " Coeff23 "  " "
bitfld.long 0 10.--20. " Coeff22 "  " "
bitfld.long 0 21.--31. " Coeff21 "  " "
;tree.end

;tree "BLT_IVMX2"
base ad:0x80130cc8
group 0--3
line.long 0 "BLT_IVMX2"
bitfld.long 0 0.--9. " Coeff33 "  " "
bitfld.long 0 10.--20. " Coeff32 "  " "
bitfld.long 0 21.--31. " Coeff31 "  " "
;tree.end

;tree "BLT_IVMX3"
base ad:0x80130ccc
group 0--3
line.long 0 "BLT_IVMX3"
bitfld.long 0 0.--9. " Offset3 "  " "
bitfld.long 0 10.--19. " Offset2 "  " "
bitfld.long 0 20.--29. " Offset1 "  " "
;tree.end

;tree "BLT_OVMX0"
base ad:0x80130cd0
group 0--3
line.long 0 "BLT_OVMX0"
bitfld.long 0 0.--9. " Coeff13 "  " "
bitfld.long 0 10.--20. " Coeff12 "  " "
bitfld.long 0 21.--31. " Coeff11 "  " "
;tree.end

;tree "BLT_OVMX1"
base ad:0x80130cd4
group 0--3
line.long 0 "BLT_OVMX1"
bitfld.long 0 0.--9. " Coeff23 "  " "
bitfld.long 0 10.--20. " Coeff22 "  " "
bitfld.long 0 21.--31. " Coeff21 "  " "
;tree.end

;tree "BLT_OVMX2"
base ad:0x80130cd8
group 0--3
line.long 0 "BLT_OVMX2"
bitfld.long 0 0.--9. " Coeff33 "  " "
bitfld.long 0 10.--20. " Coeff32 "  " "
bitfld.long 0 21.--31. " Coeff31 "  " "
;tree.end

;tree "BLT_OVMX3"
base ad:0x80130cdc
group 0--3
line.long 0 "BLT_OVMX3"
bitfld.long 0 0.--9. " Offset3 "  " "
bitfld.long 0 10.--19. " Offset2 "  " "
bitfld.long 0 20.--29. " Offset1 "  " "
;tree.end

;tree "BLT_VC1R"
base ad:0x80130ce8
group 0--3
line.long 0 "BLT_VC1R"
bitfld.long 0 0.--2. " Luma_coeff "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " Luma_Map "  "0 ,1 "
bitfld.long 0 4.--6. " Chroma_coeff "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " Chroma_map "  "0 ,1 "
;tree.end

;tree "BLT_HFC0"
base ad:0x80130e00
group 0--3
line.long 0 "BLT_HFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

;tree "BLT_HFC1"
base ad:0x80130e04
group 0--3
line.long 0 "BLT_HFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K5 "
hexfld.byte 2 " K6 "
hexfld.byte 3 " K7 "
;tree.end

;tree "BLT_HFC2"
base ad:0x80130e08
group 0--3
line.long 0 "BLT_HFC2"
hexfld.byte 0 " K10 "
hexfld.byte 1 " K11 "
hexfld.byte 2 " K12 "
hexfld.byte 3 " K13 "
;tree.end

;tree "BLT_HFC3"
base ad:0x80130e0c
group 0--3
line.long 0 "BLT_HFC3"
hexfld.byte 0 " K14 "
hexfld.byte 1 " K15 "
hexfld.byte 2 " K16 "
hexfld.byte 3 " K17 "
;tree.end

;tree "BLT_HFC4"
base ad:0x80130e10
group 0--3
line.long 0 "BLT_HFC4"
hexfld.byte 0 " K20 "
hexfld.byte 1 " K21 "
hexfld.byte 2 " K22 "
hexfld.byte 3 " K23 "
;tree.end

;tree "BLT_HFC5"
base ad:0x80130e14
group 0--3
line.long 0 "BLT_HFC5"
hexfld.byte 0 " K24 "
hexfld.byte 1 " K25 "
hexfld.byte 2 " K26 "
hexfld.byte 3 " K27 "
;tree.end

;tree "BLT_HFC6"
base ad:0x80130e18
group 0--3
line.long 0 "BLT_HFC6"
hexfld.byte 0 " K30 "
hexfld.byte 1 " K31 "
hexfld.byte 2 " K32 "
hexfld.byte 3 " K33 "
;tree.end

;tree "BLT_HFC7"
base ad:0x80130e1c
group 0--3
line.long 0 "BLT_HFC7"
hexfld.byte 0 " K34 "
hexfld.byte 1 " K35 "
hexfld.byte 2 " K36 "
hexfld.byte 3 " K37 "
;tree.end

;tree "BLT_HFC8"
base ad:0x80130e20
group 0--3
line.long 0 "BLT_HFC8"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

;tree "BLT_HFC9"
base ad:0x80130e24
group 0--3
line.long 0 "BLT_HFC9"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K45 "
hexfld.byte 2 " K46 "
hexfld.byte 3 " K47 "
;tree.end

;tree "BLT_HFC10"
base ad:0x80130e28
group 0--3
line.long 0 "BLT_HFC10"
hexfld.byte 0 " K50 "
hexfld.byte 1 " K51 "
hexfld.byte 2 " K52 "
hexfld.byte 3 " K53 "
;tree.end

;tree "BLT_HFC11"
base ad:0x80130e2c
group 0--3
line.long 0 "BLT_HFC11"
hexfld.byte 0 " K54 "
hexfld.byte 1 " K55 "
hexfld.byte 2 " K56 "
hexfld.byte 3 " K57 "
;tree.end

;tree "BLT_HFC12"
base ad:0x80130e30
group 0--3
line.long 0 "BLT_HFC12"
hexfld.byte 0 " K60 "
hexfld.byte 1 " K61 "
hexfld.byte 2 " K62 "
hexfld.byte 3 " K63 "
;tree.end

;tree "BLT_HFC13"
base ad:0x80130e34
group 0--3
line.long 0 "BLT_HFC13"
hexfld.byte 0 " K64 "
hexfld.byte 1 " K65 "
hexfld.byte 2 " K66 "
hexfld.byte 3 " K67 "
;tree.end

;tree "BLT_HFC14"
base ad:0x80130e38
group 0--3
line.long 0 "BLT_HFC14"
hexfld.byte 0 " K70 "
hexfld.byte 1 " K71 "
hexfld.byte 2 " K72 "
hexfld.byte 3 " K73 "
;tree.end

;tree "BLT_HFC15"
base ad:0x80130e3c
group 0--3
line.long 0 "BLT_HFC15"
hexfld.byte 0 " K74 "
hexfld.byte 1 " K75 "
hexfld.byte 2 " K76 "
hexfld.byte 3 " K77 "
;tree.end

;tree "BLT_VFC0"
base ad:0x80130e90
group 0--3
line.long 0 "BLT_VFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

;tree "BLT_VFC1"
base ad:0x80130e94
group 0--3
line.long 0 "BLT_VFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K10 "
hexfld.byte 2 " K11 "
hexfld.byte 3 " K12 "
;tree.end

;tree "BLT_VFC2"
base ad:0x80130e98
group 0--3
line.long 0 "BLT_VFC2"
hexfld.byte 0 " K13 "
hexfld.byte 1 " K14 "
hexfld.byte 2 " K20 "
hexfld.byte 3 " K21 "
;tree.end

;tree "BLT_VFC3"
base ad:0x80130e9c
group 0--3
line.long 0 "BLT_VFC3"
hexfld.byte 0 " K22 "
hexfld.byte 1 " K23 "
hexfld.byte 2 " K24 "
hexfld.byte 3 " K30 "
;tree.end

;tree "BLT_VFC4"
base ad:0x80130ea0
group 0--3
line.long 0 "BLT_VFC4"
hexfld.byte 0 " K31 "
hexfld.byte 1 " K32 "
hexfld.byte 2 " K33 "
hexfld.byte 3 " K34 "
;tree.end

;tree "BLT_VFC5"
base ad:0x80130ea4
group 0--3
line.long 0 "BLT_VFC5"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

;tree "BLT_VFC6"
base ad:0x80130ea8
group 0--3
line.long 0 "BLT_VFC6"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K50 "
hexfld.byte 2 " K51 "
hexfld.byte 3 " K52 "
;tree.end

;tree "BLT_VFC7"
base ad:0x80130eac
group 0--3
line.long 0 "BLT_VFC7"
hexfld.byte 0 " K53 "
hexfld.byte 1 " K54 "
hexfld.byte 2 " K60 "
hexfld.byte 3 " K61 "
;tree.end

;tree "BLT_VFC8"
base ad:0x80130eb0
group 0--3
line.long 0 "BLT_VFC8"
hexfld.byte 0 " K62 "
hexfld.byte 1 " K63 "
hexfld.byte 2 " K64 "
hexfld.byte 3 " K70 "
;tree.end

;tree "BLT_VFC9"
base ad:0x80130eb4
group 0--3
line.long 0 "BLT_VFC9"
hexfld.byte 0 " K71 "
hexfld.byte 1 " K72 "
hexfld.byte 2 " K73 "
hexfld.byte 3 " K74 "
;tree.end

;tree "BLT_Y_HFC0"
base ad:0x80130d00
group 0--3
line.long 0 "BLT_Y_HFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

;tree "BLT_Y_HFC1"
base ad:0x80130d04
group 0--3
line.long 0 "BLT_Y_HFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K5 "
hexfld.byte 2 " K6 "
hexfld.byte 3 " K7 "
;tree.end

;tree "BLT_Y_HFC2"
base ad:0x80130d08
group 0--3
line.long 0 "BLT_Y_HFC2"
hexfld.byte 0 " K10 "
hexfld.byte 1 " K11 "
hexfld.byte 2 " K12 "
hexfld.byte 3 " K13 "
;tree.end

;tree "BLT_Y_HFC3"
base ad:0x80130d0c
group 0--3
line.long 0 "BLT_Y_HFC3"
hexfld.byte 0 " K14 "
hexfld.byte 1 " K15 "
hexfld.byte 2 " K16 "
hexfld.byte 3 " K17 "
;tree.end

;tree "BLT_Y_HFC4"
base ad:0x80130d10
group 0--3
line.long 0 "BLT_Y_HFC4"
hexfld.byte 0 " K20 "
hexfld.byte 1 " K21 "
hexfld.byte 2 " K22 "
hexfld.byte 3 " K23 "
;tree.end

;tree "BLT_Y_HFC5"
base ad:0x80130d14
group 0--3
line.long 0 "BLT_Y_HFC5"
hexfld.byte 0 " K24 "
hexfld.byte 1 " K25 "
hexfld.byte 2 " K26 "
hexfld.byte 3 " K27 "
;tree.end

;tree "BLT_Y_HFC6"
base ad:0x80130d18
group 0--3
line.long 0 "BLT_Y_HFC6"
hexfld.byte 0 " K30 "
hexfld.byte 1 " K31 "
hexfld.byte 2 " K32 "
hexfld.byte 3 " K33 "
;tree.end

;tree "BLT_Y_HFC7"
base ad:0x80130d1c
group 0--3
line.long 0 "BLT_Y_HFC7"
hexfld.byte 0 " K34 "
hexfld.byte 1 " K35 "
hexfld.byte 2 " K36 "
hexfld.byte 3 " K37 "
;tree.end

;tree "BLT_Y_HFC8"
base ad:0x80130d20
group 0--3
line.long 0 "BLT_Y_HFC8"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

;tree "BLT_Y_HFC9"
base ad:0x80130d24
group 0--3
line.long 0 "BLT_Y_HFC9"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K45 "
hexfld.byte 2 " K46 "
hexfld.byte 3 " K47 "
;tree.end

;tree "BLT_Y_HFC10"
base ad:0x80130d28
group 0--3
line.long 0 "BLT_Y_HFC10"
hexfld.byte 0 " K50 "
hexfld.byte 1 " K51 "
hexfld.byte 2 " K52 "
hexfld.byte 3 " K53 "
;tree.end

;tree "BLT_Y_HFC11"
base ad:0x80130d2c
group 0--3
line.long 0 "BLT_Y_HFC11"
hexfld.byte 0 " K54 "
hexfld.byte 1 " K55 "
hexfld.byte 2 " K56 "
hexfld.byte 3 " K57 "
;tree.end

;tree "BLT_Y_HFC12"
base ad:0x80130d30
group 0--3
line.long 0 "BLT_Y_HFC12"
hexfld.byte 0 " K60 "
hexfld.byte 1 " K61 "
hexfld.byte 2 " K62 "
hexfld.byte 3 " K63 "
;tree.end

;tree "BLT_Y_HFC13"
base ad:0x80130d34
group 0--3
line.long 0 "BLT_Y_HFC13"
hexfld.byte 0 " K64 "
hexfld.byte 1 " K65 "
hexfld.byte 2 " K66 "
hexfld.byte 3 " K67 "
;tree.end

;tree "BLT_Y_HFC14"
base ad:0x80130d38
group 0--3
line.long 0 "BLT_Y_HFC14"
hexfld.byte 0 " K70 "
hexfld.byte 1 " K71 "
hexfld.byte 2 " K72 "
hexfld.byte 3 " K73 "
;tree.end

;tree "BLT_Y_HFC15"
base ad:0x80130d3c
group 0--3
line.long 0 "BLT_Y_HFC15"
hexfld.byte 0 " K74 "
hexfld.byte 1 " K75 "
hexfld.byte 2 " K76 "
hexfld.byte 3 " K77 "
;tree.end

;tree "BLT_Y_VFC0"
base ad:0x80130d90
group 0--3
line.long 0 "BLT_Y_VFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

;tree "BLT_Y_VFC1"
base ad:0x80130d94
group 0--3
line.long 0 "BLT_Y_VFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K10 "
hexfld.byte 2 " K11 "
hexfld.byte 3 " K12 "
;tree.end

;tree "BLT_Y_VFC2"
base ad:0x80130d98
group 0--3
line.long 0 "BLT_Y_VFC2"
hexfld.byte 0 " K13 "
hexfld.byte 1 " K14 "
hexfld.byte 2 " K20 "
hexfld.byte 3 " K21 "
;tree.end

;tree "BLT_Y_VFC3"
base ad:0x80130d9c
group 0--3
line.long 0 "BLT_Y_VFC3"
hexfld.byte 0 " K22 "
hexfld.byte 1 " K23 "
hexfld.byte 2 " K24 "
hexfld.byte 3 " K30 "
;tree.end

;tree "BLT_Y_VFC4"
base ad:0x80130da0
group 0--3
line.long 0 "BLT_Y_VFC4"
hexfld.byte 0 " K31 "
hexfld.byte 1 " K32 "
hexfld.byte 2 " K33 "
hexfld.byte 3 " K34 "
;tree.end

;tree "BLT_Y_VFC5"
base ad:0x80130da4
group 0--3
line.long 0 "BLT_Y_VFC5"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

;tree "BLT_Y_VFC6"
base ad:0x80130da8
group 0--3
line.long 0 "BLT_Y_VFC6"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K50 "
hexfld.byte 2 " K51 "
hexfld.byte 3 " K52 "
;tree.end

;tree "BLT_Y_VFC7"
base ad:0x80130dac
group 0--3
line.long 0 "BLT_Y_VFC7"
hexfld.byte 0 " K53 "
hexfld.byte 1 " K54 "
hexfld.byte 2 " K60 "
hexfld.byte 3 " K61 "
;tree.end

;tree "BLT_Y_VFC8"
base ad:0x80130db0
group 0--3
line.long 0 "BLT_Y_VFC8"
hexfld.byte 0 " K62 "
hexfld.byte 1 " K63 "
hexfld.byte 2 " K64 "
hexfld.byte 3 " K70 "
;tree.end

;tree "BLT_Y_VFC9"
base ad:0x80130db4
group 0--3
line.long 0 "BLT_Y_VFC9"
hexfld.byte 0 " K71 "
hexfld.byte 1 " K72 "
hexfld.byte 2 " K73 "
hexfld.byte 3 " K74 "
;tree.end

endif
tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "B2R2_2"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "BLT_CTL"
base ad:0x800f0a00
group 0--3
line.long 0 "BLT_CTL"
bitfld.long 0 28. " Big_not_little "  "0 ,1 "
bitfld.long 0 29. " Step_By_Step "  "0 ,1 "
bitfld.long 0 31. " GLOBAL_soft_reset "  "0 ,1 "
;tree.end

;tree "BLT_ITS"
base ad:0x800f0a04
group 0--3
line.long 0 "BLT_ITS"
bitfld.long 0 0. " CQ1_completed "  "0 ,1 "
bitfld.long 0 1. " CQ1_retriggered "  "0 ,1 "
bitfld.long 0 2. " CQ1_Node_Notif "  "0 ,1 "
bitfld.long 0 3. " CQ1_Repaced "  "0 ,1 "
bitfld.long 0 4. " CQ2_completed "  "0 ,1 "
bitfld.long 0 5. " CQ2_retriggered "  "0 ,1 "
bitfld.long 0 6. " CQ2_Node_Notif "  "0 ,1 "
bitfld.long 0 7. " CQ2_Repaced "  "0 ,1 "
bitfld.long 0 12. " AQ1_LNA_Reached "  "0 ,1 "
bitfld.long 0 13. " AQ1_Stopped "  "0 ,1 "
bitfld.long 0 14. " AQ1_Node_repeat "  "0 ,1 "
bitfld.long 0 15. " AQ1_Node_Notif "  "0 ,1 "
bitfld.long 0 16. " AQ2_LNA_Reached "  "0 ,1 "
bitfld.long 0 17. " AQ2_Stopped "  "0 ,1 "
bitfld.long 0 18. " AQ2_Node_repeat "  "0 ,1 "
bitfld.long 0 19. " AQ2_Node_Notif "  "0 ,1 "
bitfld.long 0 20. " AQ3_LNA_Reached "  "0 ,1 "
bitfld.long 0 21. " AQ3_Stopped "  "0 ,1 "
bitfld.long 0 22. " AQ3_Node_repeat "  "0 ,1 "
bitfld.long 0 23. " AQ3_Node_Notif "  "0 ,1 "
bitfld.long 0 24. " AQ4_LNA_Reached "  "0 ,1 "
bitfld.long 0 25. " AQ4_Stopped "  "0 ,1 "
bitfld.long 0 26. " AQ4_Node_repeat "  "0 ,1 "
bitfld.long 0 27. " AQ4_Node_Notif "  "0 ,1 "
bitfld.long 0 31. " RLD_ERROR "  "0 ,1 "
;tree.end

;tree "BLT_STA1"
base ad:0x800f0a08
group 0--3
line.long 0 "BLT_STA1"
bitfld.long 0 0. " BDISP_IDLE "  "0 ,1 "
;tree.end

;tree "BLT_SSBA1"
base ad:0x800f0a10
group 0--3
line.long 0 "BLT_SSBA1"
bitfld.long 0 0.--25. " SSBA1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA1_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA2"
base ad:0x800f0a14
group 0--3
line.long 0 "BLT_SSBA2"
bitfld.long 0 0.--25. " SSBA2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA2_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA3"
base ad:0x800f0a18
group 0--3
line.long 0 "BLT_SSBA3"
bitfld.long 0 0.--25. " SSBA3_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA3_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA4"
base ad:0x800f0a1c
group 0--3
line.long 0 "BLT_SSBA4"
bitfld.long 0 0.--25. " SSBA4_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA4_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA5"
base ad:0x800f0a20
group 0--3
line.long 0 "BLT_SSBA5"
bitfld.long 0 0.--25. " SSBA5_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA5_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA6"
base ad:0x800f0a24
group 0--3
line.long 0 "BLT_SSBA6"
bitfld.long 0 0.--25. " SSBA6_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA6_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA7"
base ad:0x800f0a28
group 0--3
line.long 0 "BLT_SSBA7"
bitfld.long 0 0.--25. " SSBA7_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA7_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA8"
base ad:0x800f0a2c
group 0--3
line.long 0 "BLT_SSBA8"
bitfld.long 0 0.--25. " SSBA8_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA8_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA9"
base ad:0x800f0aa0
group 0--3
line.long 0 "BLT_SSBA9"
bitfld.long 0 0.--25. " SSBA9_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA9_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA10"
base ad:0x800f0aa4
group 0--3
line.long 0 "BLT_SSBA10"
bitfld.long 0 0.--25. " SSBA10_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA10_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA11"
base ad:0x800f0aa8
group 0--3
line.long 0 "BLT_SSBA11"
bitfld.long 0 0.--25. " SSBA11_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA11_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA12"
base ad:0x800f0aac
group 0--3
line.long 0 "BLT_SSBA12"
bitfld.long 0 0.--25. " SSBA12_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA12_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA13"
base ad:0x800f0ab0
group 0--3
line.long 0 "BLT_SSBA13"
bitfld.long 0 0.--25. " SSBA13_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA13_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA14"
base ad:0x800f0ab4
group 0--3
line.long 0 "BLT_SSBA14"
bitfld.long 0 0.--25. " SSBA14_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA14_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA15"
base ad:0x800f0ab8
group 0--3
line.long 0 "BLT_SSBA15"
bitfld.long 0 0.--25. " SSBA15_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA15_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA16"
base ad:0x800f0abc
group 0--3
line.long 0 "BLT_SSBA16"
bitfld.long 0 0.--25. " SSBA16_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA16_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA1"
base ad:0x800f0a30
group 0--3
line.long 0 "BLT_STBA1"
bitfld.long 0 0.--25. " STBA1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA1_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA2"
base ad:0x800f0a34
group 0--3
line.long 0 "BLT_STBA2"
bitfld.long 0 0.--25. " STBA2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA2_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA3"
base ad:0x800f0a38
group 0--3
line.long 0 "BLT_STBA3"
bitfld.long 0 0.--25. " STBA3_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA3_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA4"
base ad:0x800f0a3c
group 0--3
line.long 0 "BLT_STBA4"
bitfld.long 0 0.--25. " STBA4_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA4_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_CQ1_TRIG_IP"
base ad:0x800f0a40
group 0--3
line.long 0 "BLT_CQ1_TRIG_IP"
bitfld.long 0 0.--25. " CQ1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " TRIG_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_CQ2_TRIG_IP"
base ad:0x800f0a50
group 0--3
line.long 0 "BLT_CQ2_TRIG_IP"
bitfld.long 0 0.--25. " CQ2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " TRIG_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_CQ1_TRIG_CTL"
base ad:0x800f0a44
group 0--3
line.long 0 "BLT_CQ1_TRIG_CTL"
bitfld.long 0 0.--11. " Trigger_line_num "  " "
bitfld.long 0 12.--15. " Trig_cond "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " Retrig_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

;tree "BLT_CQ2_TRIG_CTL"
base ad:0x800f0a54
group 0--3
line.long 0 "BLT_CQ2_TRIG_CTL"
bitfld.long 0 0.--11. " Trigger_line_num "  " "
bitfld.long 0 12.--15. " Trig_cond "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " Retrig_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

;tree "BLT_CQ1_PACE_CTL"
base ad:0x800f0a48
group 0--3
line.long 0 "BLT_CQ1_PACE_CTL"
bitfld.long 0 0.--11. " Pace_start "  " "
bitfld.long 0 16.--27. " Pace_Count "  " "
bitfld.long 0 31. " Dynamic_Pace "  "0 ,1 "
;tree.end

;tree "BLT_CQ2_PACE_CTL"
base ad:0x800f0a58
group 0--3
line.long 0 "BLT_CQ2_PACE_CTL"
bitfld.long 0 0.--11. " Pace_start "  " "
bitfld.long 0 16.--27. " Pace_Count "  " "
bitfld.long 0 31. " Dynamic_Pace "  "0 ,1 "
;tree.end

;tree "BLT_CQ1_IP"
base ad:0x800f0a4c
rgroup 0--3
line.long 0 "BLT_CQ1_IP"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_CQ2_IP"
base ad:0x800f0a5c
rgroup 0--3
line.long 0 "BLT_CQ2_IP"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ1_CTL"
base ad:0x800f0a60
group 0--3
line.long 0 "BLT_AQ1_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

;tree "BLT_AQ2_CTL"
base ad:0x800f0a70
group 0--3
line.long 0 "BLT_AQ2_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

;tree "BLT_AQ3_CTL"
base ad:0x800f0a80
group 0--3
line.long 0 "BLT_AQ3_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

;tree "BLT_AQ4_CTL"
base ad:0x800f0a90
group 0--3
line.long 0 "BLT_AQ4_CTL"
bitfld.long 0 0.--1. " Priority "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " IRQ_mask "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " Event_behav "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
;tree.end

;tree "BLT_AQ1_IP"
base ad:0x800f0a64
group 0--3
line.long 0 "BLT_AQ1_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ2_IP"
base ad:0x800f0a74
group 0--3
line.long 0 "BLT_AQ2_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ3_IP"
base ad:0x800f0a84
group 0--3
line.long 0 "BLT_AQ3_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ4_IP"
base ad:0x800f0a94
group 0--3
line.long 0 "BLT_AQ4_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ1_LNA"
base ad:0x800f0a68
group 0--3
line.long 0 "BLT_AQ1_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ2_LNA"
base ad:0x800f0a78
group 0--3
line.long 0 "BLT_AQ2_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ3_LNA"
base ad:0x800f0a88
group 0--3
line.long 0 "BLT_AQ3_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ4_LNA"
base ad:0x800f0a98
group 0--3
line.long 0 "BLT_AQ4_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ1_STA"
base ad:0x800f0a6c
rgroup 0--3
line.long 0 "BLT_AQ1_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ2_STA"
base ad:0x800f0a7c
rgroup 0--3
line.long 0 "BLT_AQ2_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ3_STA"
base ad:0x800f0a8c
rgroup 0--3
line.long 0 "BLT_AQ3_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_AQ4_STA"
base ad:0x800f0a9c
rgroup 0--3
line.long 0 "BLT_AQ4_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SGA1"
base ad:0x800f0ac0
group 0--3
line.long 0 "BLT_SGA1"
hexfld.byte 0 " Alpha1 "
hexfld.byte 1 " Alpha2 "
hexfld.byte 2 " Alpha3 "
hexfld.byte 3 " Alpha4 "
;tree.end

;tree "BLT_SGA2"
base ad:0x800f0ac4
group 0--3
line.long 0 "BLT_SGA2"
hexfld.byte 0 " Alpha5 "
hexfld.byte 1 " Alpha6 "
hexfld.byte 2 " Alpha7 "
hexfld.byte 3 " Alpha8 "
;tree.end

;tree "BLT_ITM0"
base ad:0x800f0ad0
group 0--3
line.long 0 "BLT_ITM0"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

;tree "BLT_ITM1"
base ad:0x800f0ad4
group 0--3
line.long 0 "BLT_ITM1"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

;tree "BLT_ITM2"
base ad:0x800f0ad8
group 0--3
line.long 0 "BLT_ITM2"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

;tree "BLT_ITM3"
base ad:0x800f0adc
group 0--3
line.long 0 "BLT_ITM3"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
;tree.end

;tree "BLT_DFV1"
base ad:0x800f0af4
group 0--3
line.long 0 "BLT_DFV1"
bitfld.long 0 0.--11. " DFV1_Line_count "  " "
bitfld.long 0 12. " DFV1_ITM0_IT "  "0 ,1 "
bitfld.long 0 13. " DFV1_ITM1_IT "  "0 ,1 "
bitfld.long 0 14. " DFV1_ITM2_IT "  "0 ,1 "
bitfld.long 0 15. " DFV1_ITM3_IT "  "0 ,1 "
bitfld.long 0 16. " DFV1_AQ1_IT "  "0 ,1 "
bitfld.long 0 17. " DFV1_AQ2_IT "  "0 ,1 "
bitfld.long 0 18. " DFV1_AQ3_IT "  "0 ,1 "
bitfld.long 0 19. " DFV1_AQ4_IT "  "0 ,1 "
bitfld.long 0 20. " DFV1_CQ1_IT "  "0 ,1 "
bitfld.long 0 21. " DFV1_CQ2_IT "  "0 ,1 "
bitfld.long 0 24. " DFV1_GPO "  "0 ,1 "
bitfld.long 0 28. " DFV1_req "  "0 ,1 "
bitfld.long 0 29. " DFV1_ntop_bot "  "0 ,1 "
bitfld.long 0 30. " DFV1_Vsync "  "0 ,1 "
bitfld.long 0 31. " DFV1_Mode_En "  "0 ,1 "
;tree.end

;tree "BLT_DFV2"
base ad:0x800f0af0
group 0--3
line.long 0 "BLT_DFV2"
bitfld.long 0 0.--11. " DFV2_Line_count "  " "
bitfld.long 0 28. " DFV2_req "  "0 ,1 "
bitfld.long 0 29. " DFV2_ntop_bot "  "0 ,1 "
bitfld.long 0 30. " DFV2_Vsync "  "0 ,1 "
bitfld.long 0 31. " DFV2_Mode_En "  "0 ,1 "
;tree.end

;tree "BLT_PRI"
base ad:0x800f0af8
group 0--3
line.long 0 "BLT_PRI"
bitfld.long 0 0.--3. " CQ1_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " CQ2_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " AQ1_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " AQ2_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " AQ3_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " AQ4_prio "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "BLT_SSBA17"
base ad:0x800f0900
group 0--3
line.long 0 "BLT_SSBA17"
bitfld.long 0 0.--25. " SSBA17_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA17_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA18"
base ad:0x800f0904
group 0--3
line.long 0 "BLT_SSBA18"
bitfld.long 0 0.--25. " SSBA18_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA18_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA19"
base ad:0x800f0908
group 0--3
line.long 0 "BLT_SSBA19"
bitfld.long 0 0.--25. " SSBA19_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA19_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA20"
base ad:0x800f090c
group 0--3
line.long 0 "BLT_SSBA20"
bitfld.long 0 0.--25. " SSBA20_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA20_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA21"
base ad:0x800f0910
group 0--3
line.long 0 "BLT_SSBA21"
bitfld.long 0 0.--25. " SSBA21_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA21_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA22"
base ad:0x800f0914
group 0--3
line.long 0 "BLT_SSBA22"
bitfld.long 0 0.--25. " SSBA22_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA22_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA23"
base ad:0x800f0918
group 0--3
line.long 0 "BLT_SSBA23"
bitfld.long 0 0.--25. " SSBA23_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA23_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_SSBA24"
base ad:0x800f091c
group 0--3
line.long 0 "BLT_SSBA24"
bitfld.long 0 0.--25. " SSBA24_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA24_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA5"
base ad:0x800f0940
group 0--3
line.long 0 "BLT_STBA5"
bitfld.long 0 0.--25. " STBA5_Mem_address "  " "
bitfld.long 0 26.--31. " STBA5_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA6"
base ad:0x800f0944
group 0--3
line.long 0 "BLT_STBA6"
bitfld.long 0 0.--25. " STBA6_Mem_address "  " "
bitfld.long 0 26.--31. " STBA6_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA7"
base ad:0x800f0948
group 0--3
line.long 0 "BLT_STBA7"
bitfld.long 0 0.--25. " STBA7_Mem_address "  " "
bitfld.long 0 26.--31. " STBA7_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_STBA8"
base ad:0x800f094c
group 0--3
line.long 0 "BLT_STBA8"
bitfld.long 0 0.--25. " STBA8_Mem_address "  " "
bitfld.long 0 26.--31. " STBA8_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "PLUGS1_OP2"
base ad:0x800f0b04
group 0--3
line.long 0 "PLUGS1_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGS2_OP2"
base ad:0x800f0b24
group 0--3
line.long 0 "PLUGS2_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGS3_OP2"
base ad:0x800f0b44
group 0--3
line.long 0 "PLUGS3_OP2"
bitfld.long 0 0.--2. " Max_opcode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGS1_CHZ"
base ad:0x800f0b08
group 0--3
line.long 0 "PLUGS1_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGS2_CHZ"
base ad:0x800f0b28
group 0--3
line.long 0 "PLUGS2_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGS3_CHZ"
base ad:0x800f0b48
group 0--3
line.long 0 "PLUGS3_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGS1_MSZ"
base ad:0x800f0b0c
group 0--3
line.long 0 "PLUGS1_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " MinSpaceBetweenReq "
;tree.end

;tree "PLUGS2_MSZ"
base ad:0x800f0b2c
group 0--3
line.long 0 "PLUGS2_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " MinSpaceBetweenReq "
;tree.end

;tree "PLUGS3_MSZ"
base ad:0x800f0b4c
group 0--3
line.long 0 "PLUGS3_MSZ"
bitfld.long 0 0.--2. " Message_Size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " MinSpaceBetweenReq "
;tree.end

;tree "PLUGS1_PGZ"
base ad:0x800f0b10
group 0--3
line.long 0 "PLUGS1_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PLUGS2_PGZ"
base ad:0x800f0b30
group 0--3
line.long 0 "PLUGS2_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PLUGS3_PGZ"
base ad:0x800f0b50
group 0--3
line.long 0 "PLUGS3_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PLUGT_OP2"
base ad:0x800f0b84
group 0--3
line.long 0 "PLUGT_OP2"
bitfld.long 0 0.--2. " Max_code "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGT_CHZ"
base ad:0x800f0b88
group 0--3
line.long 0 "PLUGT_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLUGT_MSZ"
base ad:0x800f0b8c
group 0--3
line.long 0 "PLUGT_MSZ"
bitfld.long 0 0.--2. " Message_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " MinSpaceBetweenReq "
;tree.end

;tree "PLUGT_PGZ"
base ad:0x800f0b90
group 0--3
line.long 0 "PLUGT_PGZ"
bitfld.long 0 0.--3. " Page_size "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "BLT_NIP"
base ad:0x800f0c00
group 0--3
line.long 0 "BLT_NIP"
bitfld.long 0 0.--25. " NIP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " NIP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_CIC"
base ad:0x800f0c04
group 0--3
line.long 0 "BLT_CIC"
bitfld.long 0 2. " Group2 "  "0 ,1 "
bitfld.long 0 3. " Group3 "  "0 ,1 "
bitfld.long 0 4. " Group4 "  "0 ,1 "
bitfld.long 0 5. " Group5 "  "0 ,1 "
bitfld.long 0 6. " Group6 "  "0 ,1 "
bitfld.long 0 7. " Group7 "  "0 ,1 "
bitfld.long 0 8. " Group8 "  "0 ,1 "
bitfld.long 0 9. " Group9 "  "0 ,1 "
bitfld.long 0 10. " Group10 "  "0 ,1 "
bitfld.long 0 11. " Group11 "  "0 ,1 "
bitfld.long 0 12. " Group12 "  "0 ,1 "
bitfld.long 0 13. " Group13 "  "0 ,1 "
bitfld.long 0 14. " Group14 "  "0 ,1 "
bitfld.long 0 15. " Group15 "  "0 ,1 "
bitfld.long 0 16. " Group16 "  "0 ,1 "
bitfld.long 0 17. " Group17 "  "0 ,1 "
bitfld.long 0 18. " Group18 "  "0 ,1 "
;tree.end

;tree "BLT_INS"
base ad:0x800f0c08
group 0--3
line.long 0 "BLT_INS"
bitfld.long 0 0.--2. " SOURCE1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--4. " SOURCE2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " SOURCE3 "  "0 ,1 "
bitfld.long 0 6. " IVMX "  "0 ,1 "
bitfld.long 0 7. " CLUTOP "  "0 ,1 "
bitfld.long 0 8. " 2DRESCALE "  "0 ,1 "
bitfld.long 0 9. " FILCK_FILT "  "0 ,1 "
bitfld.long 0 10. " RECT_CLIP "  "0 ,1 "
bitfld.long 0 11. " CKEY "  "0 ,1 "
bitfld.long 0 12. " OVMX "  "0 ,1 "
bitfld.long 0 13. " DEI "  "0 ,1 "
bitfld.long 0 14. " PLANE_MASK "  "0 ,1 "
bitfld.long 0 15. " XYL "  "0 ,1 "
bitfld.long 0 16. " DOT "  "0 ,1 "
bitfld.long 0 17. " VC1R "  "0 ,1 "
bitfld.long 0 18. " ROTATION "  "0 ,1 "
bitfld.long 0 30. " Pace_down "  "0 ,1 "
bitfld.long 0 31. " BlitCompIRQ "  "0 ,1 "
;tree.end

;tree "BLT_ACK"
base ad:0x800f0c0c
group 0--3
line.long 0 "BLT_ACK"
bitfld.long 0 0.--3. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " SWAP_FG_BG "  "0 ,1 "
hexfld.byte 1 " GALPHA_ROPID "
bitfld.long 0 16.--21. " ACK_CKEY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--23. " CKEY_SEL "  "0 ,1 ,2 ,3 "
;tree.end

;tree "BLT_TBA"
base ad:0x800f0c10
group 0--3
line.long 0 "BLT_TBA"
bitfld.long 0 0.--25. " TBA_mem_addr "  " "
bitfld.long 0 26.--31. " TBA_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_TTY"
base ad:0x800f0c14
group 0--3
line.long 0 "BLT_TTY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 26. " RGB_ROUND "  "0 ,1 "
bitfld.long 0 27. " CHROMA_notLUMA "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

;tree "BLT_TXY"
base ad:0x800f0c18
group 0--3
line.long 0 "BLT_TXY"
hexfld.word 0 " XCOORD "
hexfld.word 2 " YCOORD "
;tree.end

;tree "BLT_TSZ"
base ad:0x800f0c1c
group 0--3
line.long 0 "BLT_TSZ"
bitfld.long 0 0.--11. " WIN_WIDTH "  " "
bitfld.long 0 16.--27. " WIN_HEIGHT "  " "
;tree.end

;tree "BLT_S1CF"
base ad:0x800f0c20
group 0--3
line.long 0 "BLT_S1CF"
hexfld.long 0 " SRC1_COLOR_FILL "
;tree.end

;tree "BLT_S2CF"
base ad:0x800f0c24
group 0--3
line.long 0 "BLT_S2CF"
hexfld.long 0 " SRC2_COLOR_FILL "
;tree.end

;tree "BLT_S1BA"
base ad:0x800f0c28
group 0--3
line.long 0 "BLT_S1BA"
bitfld.long 0 0.--25. " S1BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S1BA_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_S1TY"
base ad:0x800f0c2c
group 0--3
line.long 0 "BLT_S1TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 22. " A1_SUBST "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 27. " ROTATION "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 29. " RGB_EXP "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

;tree "BLT_S1XY"
base ad:0x800f0c30
group 0--3
line.long 0 "BLT_S1XY"
hexfld.word 0 " XCOORD "
hexfld.word 2 " YCOORD "
;tree.end

;tree "BLT_S2BA"
base ad:0x800f0c38
group 0--3
line.long 0 "BLT_S2BA"
bitfld.long 0 0.--25. " S2BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S2BA_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_S2TY"
base ad:0x800f0c3c
group 0--3
line.long 0 "BLT_S2TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 22. " A1_SUBST "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 26. " CHROMA_LEFT "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 29. " RGB_EXP "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

;tree "BLT_S2XY"
base ad:0x800f0c40
group 0--3
line.long 0 "BLT_S2XY"
hexfld.word 0 " XCOORD "
hexfld.word 2 " YCOORD "
;tree.end

;tree "BLT_S2SZ"
base ad:0x800f0c44
group 0--3
line.long 0 "BLT_S2SZ"
bitfld.long 0 0.--11. " SRC2_WIN_WIDTH "  " "
bitfld.long 0 16.--27. " SRC2_WIN_HEIGHT "  " "
;tree.end

;tree "BLT_S3BA"
base ad:0x800f0c48
group 0--3
line.long 0 "BLT_S3BA"
bitfld.long 0 0.--25. " S3BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S3BA_bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_S3TY"
base ad:0x800f0c4c
group 0--3
line.long 0 "BLT_S3TY"
hexfld.word 0 " PIXMAP_PITCH "
bitfld.long 0 16.--20. " COLOR_FORM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " VSO "  "0 ,1 "
bitfld.long 0 25. " HSO "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
;tree.end

;tree "BLT_S3XY"
base ad:0x800f0c50
group 0--3
line.long 0 "BLT_S3XY"
hexfld.word 0 " XCOORD "
hexfld.word 2 " YCOORD "
;tree.end

;tree "BLT_S3SZ"
base ad:0x800f0c54
group 0--3
line.long 0 "BLT_S3SZ"
bitfld.long 0 0.--11. " SRC3_WIN_WIDTH "  " "
bitfld.long 0 16.--27. " SRC3_WIN_HEIGHT "  " "
;tree.end

;tree "BLT_CWO"
base ad:0x800f0c58
group 0--3
line.long 0 "BLT_CWO"
bitfld.long 0 0.--14. " XDO "  " "
bitfld.long 0 16.--26. " YDO "  " "
bitfld.long 0 27. " INTNL "  "0 ,1 "
;tree.end

;tree "BLT_CWS"
base ad:0x800f0c5c
group 0--3
line.long 0 "BLT_CWS"
bitfld.long 0 0.--14. " XDS "  " "
bitfld.long 0 16.--26. " YDS "  " "
;tree.end

;tree "BLT_CCO"
base ad:0x800f0c60
group 0--3
line.long 0 "BLT_CCO"
bitfld.long 0 15. " CLUT_NS2_1S1 "  "0 ,1 "
bitfld.long 0 16.--17. " CLUT_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " CLUT_UPDATE "  "0 ,1 "
bitfld.long 0 19.--22. " CLUT_ERRDIFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "BLT_CML"
base ad:0x800f0c64
group 0--3
line.long 0 "BLT_CML"
bitfld.long 0 4.--25. " CML_MEM_ADDR "  " "
bitfld.long 0 26.--31. " CML_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_FCTL"
base ad:0x800f0c68
group 0--3
line.long 0 "BLT_FCTL"
bitfld.long 0 0.--2. " 2DHF_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " 2DVF_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12. " AB_Right "  "0 ,1 "
bitfld.long 0 13. " AB_Left "  "0 ,1 "
bitfld.long 0 14. " AB_BOT "  "0 ,1 "
bitfld.long 0 15. " AB_TOP "  "0 ,1 "
bitfld.long 0 24.--25. " Luma_2Dhf_mode "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " Luma_2Dvf_mode "  "0 ,1 ,2 ,3 "
;tree.end

;tree "BLT_PMK"
base ad:0x800f0c6c
group 0--3
line.long 0 "BLT_PMK"
bitfld.long 0 0. " PLANE_MASK "  "0 ,1 "
;tree.end

;tree "BLT_RSF"
base ad:0x800f0c70
group 0--3
line.long 0 "BLT_RSF"
hexfld.word 0 " HSRC_INC "
hexfld.word 2 " VSRC_INC "
;tree.end

;tree "BLT_RZI"
base ad:0x800f0c74
group 0--3
line.long 0 "BLT_RZI"
bitfld.long 0 0.--9. " HSRC_INIT "  " "
bitfld.long 0 12.--14. " Hnb_repeat "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--25. " VSRC_INIT "  " "
bitfld.long 0 28.--30. " Vnb_repeat "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "BLT_HFP"
base ad:0x800f0c78
group 0--3
line.long 0 "BLT_HFP"
bitfld.long 0 0.--25. " HFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " HFP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_VFP"
base ad:0x800f0c7c
group 0--3
line.long 0 "BLT_VFP"
bitfld.long 0 0.--25. " VFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " VFP_BANK_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_Y_RSF"
base ad:0x800f0c80
group 0--3
line.long 0 "BLT_Y_RSF"
hexfld.word 0 " Luma_HSRC_INC "
hexfld.word 2 " Luma_VSRC_INC "
;tree.end

;tree "BLT_Y_RZI"
base ad:0x800f0c84
group 0--3
line.long 0 "BLT_Y_RZI"
bitfld.long 0 0.--9. " Hsrc_init_luma "  " "
bitfld.long 0 12.--14. " Hnb_repeat_luma "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--25. " Vsrc_init_luma "  " "
bitfld.long 0 28.--30. " Vnb_repeat_Luma "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "BLT_Y_HFP"
base ad:0x800f0c88
group 0--3
line.long 0 "BLT_Y_HFP"
bitfld.long 0 0.--25. " Y_HFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " Y_Hfp_Bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_Y_VFP"
base ad:0x800f0c8c
group 0--3
line.long 0 "BLT_Y_VFP"
bitfld.long 0 0.--25. " Y_VFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " Y_Vfp_Bank_num "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "BLT_KEY1"
base ad:0x800f0ca0
group 0--3
line.long 0 "BLT_KEY1"
hexfld.byte 0 " BLUE_MIN "
hexfld.byte 1 " GREEN_MIN "
hexfld.byte 2 " RED_MIN "
hexfld.byte 3 " ALPHA0 "
;tree.end

;tree "BLT_KEY2"
base ad:0x800f0ca4
group 0--3
line.long 0 "BLT_KEY2"
hexfld.byte 0 " BLUE_MAX "
hexfld.byte 1 " GREEN_MAX "
hexfld.byte 2 " RED_MAX "
hexfld.byte 3 " ALPHA1 "
;tree.end

;tree "BLT_SAR"
base ad:0x800f0cb0
group 0--3
line.long 0 "BLT_SAR"
bitfld.long 0 0.--4. " S1_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " S2_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " S3_SSBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--27. " T_STBA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " A_SGA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "BLT_USR"
base ad:0x800f0cb4
group 0--3
line.long 0 "BLT_USR"
hexfld.long 0 " GENERAL_PURPOSE "
;tree.end

;tree "BLT_IVMX0"
base ad:0x800f0cc0
group 0--3
line.long 0 "BLT_IVMX0"
bitfld.long 0 0.--9. " Coeff13 "  " "
bitfld.long 0 10.--20. " Coeff12 "  " "
bitfld.long 0 21.--31. " Coeff11 "  " "
;tree.end

;tree "BLT_IVMX1"
base ad:0x800f0cc4
group 0--3
line.long 0 "BLT_IVMX1"
bitfld.long 0 0.--9. " Coeff23 "  " "
bitfld.long 0 10.--20. " Coeff22 "  " "
bitfld.long 0 21.--31. " Coeff21 "  " "
;tree.end

;tree "BLT_IVMX2"
base ad:0x800f0cc8
group 0--3
line.long 0 "BLT_IVMX2"
bitfld.long 0 0.--9. " Coeff33 "  " "
bitfld.long 0 10.--20. " Coeff32 "  " "
bitfld.long 0 21.--31. " Coeff31 "  " "
;tree.end

;tree "BLT_IVMX3"
base ad:0x800f0ccc
group 0--3
line.long 0 "BLT_IVMX3"
bitfld.long 0 0.--9. " Offset3 "  " "
bitfld.long 0 10.--19. " Offset2 "  " "
bitfld.long 0 20.--29. " Offset1 "  " "
;tree.end

;tree "BLT_OVMX0"
base ad:0x800f0cd0
group 0--3
line.long 0 "BLT_OVMX0"
bitfld.long 0 0.--9. " Coeff13 "  " "
bitfld.long 0 10.--20. " Coeff12 "  " "
bitfld.long 0 21.--31. " Coeff11 "  " "
;tree.end

;tree "BLT_OVMX1"
base ad:0x800f0cd4
group 0--3
line.long 0 "BLT_OVMX1"
bitfld.long 0 0.--9. " Coeff23 "  " "
bitfld.long 0 10.--20. " Coeff22 "  " "
bitfld.long 0 21.--31. " Coeff21 "  " "
;tree.end

;tree "BLT_OVMX2"
base ad:0x800f0cd8
group 0--3
line.long 0 "BLT_OVMX2"
bitfld.long 0 0.--9. " Coeff33 "  " "
bitfld.long 0 10.--20. " Coeff32 "  " "
bitfld.long 0 21.--31. " Coeff31 "  " "
;tree.end

;tree "BLT_OVMX3"
base ad:0x800f0cdc
group 0--3
line.long 0 "BLT_OVMX3"
bitfld.long 0 0.--9. " Offset3 "  " "
bitfld.long 0 10.--19. " Offset2 "  " "
bitfld.long 0 20.--29. " Offset1 "  " "
;tree.end

;tree "BLT_VC1R"
base ad:0x800f0ce8
group 0--3
line.long 0 "BLT_VC1R"
bitfld.long 0 0.--2. " Luma_coeff "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " Luma_Map "  "0 ,1 "
bitfld.long 0 4.--6. " Chroma_coeff "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " Chroma_map "  "0 ,1 "
;tree.end

;tree "BLT_HFC0"
base ad:0x800f0e00
group 0--3
line.long 0 "BLT_HFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

;tree "BLT_HFC1"
base ad:0x800f0e04
group 0--3
line.long 0 "BLT_HFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K5 "
hexfld.byte 2 " K6 "
hexfld.byte 3 " K7 "
;tree.end

;tree "BLT_HFC2"
base ad:0x800f0e08
group 0--3
line.long 0 "BLT_HFC2"
hexfld.byte 0 " K10 "
hexfld.byte 1 " K11 "
hexfld.byte 2 " K12 "
hexfld.byte 3 " K13 "
;tree.end

;tree "BLT_HFC3"
base ad:0x800f0e0c
group 0--3
line.long 0 "BLT_HFC3"
hexfld.byte 0 " K14 "
hexfld.byte 1 " K15 "
hexfld.byte 2 " K16 "
hexfld.byte 3 " K17 "
;tree.end

;tree "BLT_HFC4"
base ad:0x800f0e10
group 0--3
line.long 0 "BLT_HFC4"
hexfld.byte 0 " K20 "
hexfld.byte 1 " K21 "
hexfld.byte 2 " K22 "
hexfld.byte 3 " K23 "
;tree.end

;tree "BLT_HFC5"
base ad:0x800f0e14
group 0--3
line.long 0 "BLT_HFC5"
hexfld.byte 0 " K24 "
hexfld.byte 1 " K25 "
hexfld.byte 2 " K26 "
hexfld.byte 3 " K27 "
;tree.end

;tree "BLT_HFC6"
base ad:0x800f0e18
group 0--3
line.long 0 "BLT_HFC6"
hexfld.byte 0 " K30 "
hexfld.byte 1 " K31 "
hexfld.byte 2 " K32 "
hexfld.byte 3 " K33 "
;tree.end

;tree "BLT_HFC7"
base ad:0x800f0e1c
group 0--3
line.long 0 "BLT_HFC7"
hexfld.byte 0 " K34 "
hexfld.byte 1 " K35 "
hexfld.byte 2 " K36 "
hexfld.byte 3 " K37 "
;tree.end

;tree "BLT_HFC8"
base ad:0x800f0e20
group 0--3
line.long 0 "BLT_HFC8"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

;tree "BLT_HFC9"
base ad:0x800f0e24
group 0--3
line.long 0 "BLT_HFC9"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K45 "
hexfld.byte 2 " K46 "
hexfld.byte 3 " K47 "
;tree.end

;tree "BLT_HFC10"
base ad:0x800f0e28
group 0--3
line.long 0 "BLT_HFC10"
hexfld.byte 0 " K50 "
hexfld.byte 1 " K51 "
hexfld.byte 2 " K52 "
hexfld.byte 3 " K53 "
;tree.end

;tree "BLT_HFC11"
base ad:0x800f0e2c
group 0--3
line.long 0 "BLT_HFC11"
hexfld.byte 0 " K54 "
hexfld.byte 1 " K55 "
hexfld.byte 2 " K56 "
hexfld.byte 3 " K57 "
;tree.end

;tree "BLT_HFC12"
base ad:0x800f0e30
group 0--3
line.long 0 "BLT_HFC12"
hexfld.byte 0 " K60 "
hexfld.byte 1 " K61 "
hexfld.byte 2 " K62 "
hexfld.byte 3 " K63 "
;tree.end

;tree "BLT_HFC13"
base ad:0x800f0e34
group 0--3
line.long 0 "BLT_HFC13"
hexfld.byte 0 " K64 "
hexfld.byte 1 " K65 "
hexfld.byte 2 " K66 "
hexfld.byte 3 " K67 "
;tree.end

;tree "BLT_HFC14"
base ad:0x800f0e38
group 0--3
line.long 0 "BLT_HFC14"
hexfld.byte 0 " K70 "
hexfld.byte 1 " K71 "
hexfld.byte 2 " K72 "
hexfld.byte 3 " K73 "
;tree.end

;tree "BLT_HFC15"
base ad:0x800f0e3c
group 0--3
line.long 0 "BLT_HFC15"
hexfld.byte 0 " K74 "
hexfld.byte 1 " K75 "
hexfld.byte 2 " K76 "
hexfld.byte 3 " K77 "
;tree.end

;tree "BLT_VFC0"
base ad:0x800f0e90
group 0--3
line.long 0 "BLT_VFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

;tree "BLT_VFC1"
base ad:0x800f0e94
group 0--3
line.long 0 "BLT_VFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K10 "
hexfld.byte 2 " K11 "
hexfld.byte 3 " K12 "
;tree.end

;tree "BLT_VFC2"
base ad:0x800f0e98
group 0--3
line.long 0 "BLT_VFC2"
hexfld.byte 0 " K13 "
hexfld.byte 1 " K14 "
hexfld.byte 2 " K20 "
hexfld.byte 3 " K21 "
;tree.end

;tree "BLT_VFC3"
base ad:0x800f0e9c
group 0--3
line.long 0 "BLT_VFC3"
hexfld.byte 0 " K22 "
hexfld.byte 1 " K23 "
hexfld.byte 2 " K24 "
hexfld.byte 3 " K30 "
;tree.end

;tree "BLT_VFC4"
base ad:0x800f0ea0
group 0--3
line.long 0 "BLT_VFC4"
hexfld.byte 0 " K31 "
hexfld.byte 1 " K32 "
hexfld.byte 2 " K33 "
hexfld.byte 3 " K34 "
;tree.end

;tree "BLT_VFC5"
base ad:0x800f0ea4
group 0--3
line.long 0 "BLT_VFC5"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

;tree "BLT_VFC6"
base ad:0x800f0ea8
group 0--3
line.long 0 "BLT_VFC6"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K50 "
hexfld.byte 2 " K51 "
hexfld.byte 3 " K52 "
;tree.end

;tree "BLT_VFC7"
base ad:0x800f0eac
group 0--3
line.long 0 "BLT_VFC7"
hexfld.byte 0 " K53 "
hexfld.byte 1 " K54 "
hexfld.byte 2 " K60 "
hexfld.byte 3 " K61 "
;tree.end

;tree "BLT_VFC8"
base ad:0x800f0eb0
group 0--3
line.long 0 "BLT_VFC8"
hexfld.byte 0 " K62 "
hexfld.byte 1 " K63 "
hexfld.byte 2 " K64 "
hexfld.byte 3 " K70 "
;tree.end

;tree "BLT_VFC9"
base ad:0x800f0eb4
group 0--3
line.long 0 "BLT_VFC9"
hexfld.byte 0 " K71 "
hexfld.byte 1 " K72 "
hexfld.byte 2 " K73 "
hexfld.byte 3 " K74 "
;tree.end

;tree "BLT_Y_HFC0"
base ad:0x800f0d00
group 0--3
line.long 0 "BLT_Y_HFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

;tree "BLT_Y_HFC1"
base ad:0x800f0d04
group 0--3
line.long 0 "BLT_Y_HFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K5 "
hexfld.byte 2 " K6 "
hexfld.byte 3 " K7 "
;tree.end

;tree "BLT_Y_HFC2"
base ad:0x800f0d08
group 0--3
line.long 0 "BLT_Y_HFC2"
hexfld.byte 0 " K10 "
hexfld.byte 1 " K11 "
hexfld.byte 2 " K12 "
hexfld.byte 3 " K13 "
;tree.end

;tree "BLT_Y_HFC3"
base ad:0x800f0d0c
group 0--3
line.long 0 "BLT_Y_HFC3"
hexfld.byte 0 " K14 "
hexfld.byte 1 " K15 "
hexfld.byte 2 " K16 "
hexfld.byte 3 " K17 "
;tree.end

;tree "BLT_Y_HFC4"
base ad:0x800f0d10
group 0--3
line.long 0 "BLT_Y_HFC4"
hexfld.byte 0 " K20 "
hexfld.byte 1 " K21 "
hexfld.byte 2 " K22 "
hexfld.byte 3 " K23 "
;tree.end

;tree "BLT_Y_HFC5"
base ad:0x800f0d14
group 0--3
line.long 0 "BLT_Y_HFC5"
hexfld.byte 0 " K24 "
hexfld.byte 1 " K25 "
hexfld.byte 2 " K26 "
hexfld.byte 3 " K27 "
;tree.end

;tree "BLT_Y_HFC6"
base ad:0x800f0d18
group 0--3
line.long 0 "BLT_Y_HFC6"
hexfld.byte 0 " K30 "
hexfld.byte 1 " K31 "
hexfld.byte 2 " K32 "
hexfld.byte 3 " K33 "
;tree.end

;tree "BLT_Y_HFC7"
base ad:0x800f0d1c
group 0--3
line.long 0 "BLT_Y_HFC7"
hexfld.byte 0 " K34 "
hexfld.byte 1 " K35 "
hexfld.byte 2 " K36 "
hexfld.byte 3 " K37 "
;tree.end

;tree "BLT_Y_HFC8"
base ad:0x800f0d20
group 0--3
line.long 0 "BLT_Y_HFC8"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

;tree "BLT_Y_HFC9"
base ad:0x800f0d24
group 0--3
line.long 0 "BLT_Y_HFC9"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K45 "
hexfld.byte 2 " K46 "
hexfld.byte 3 " K47 "
;tree.end

;tree "BLT_Y_HFC10"
base ad:0x800f0d28
group 0--3
line.long 0 "BLT_Y_HFC10"
hexfld.byte 0 " K50 "
hexfld.byte 1 " K51 "
hexfld.byte 2 " K52 "
hexfld.byte 3 " K53 "
;tree.end

;tree "BLT_Y_HFC11"
base ad:0x800f0d2c
group 0--3
line.long 0 "BLT_Y_HFC11"
hexfld.byte 0 " K54 "
hexfld.byte 1 " K55 "
hexfld.byte 2 " K56 "
hexfld.byte 3 " K57 "
;tree.end

;tree "BLT_Y_HFC12"
base ad:0x800f0d30
group 0--3
line.long 0 "BLT_Y_HFC12"
hexfld.byte 0 " K60 "
hexfld.byte 1 " K61 "
hexfld.byte 2 " K62 "
hexfld.byte 3 " K63 "
;tree.end

;tree "BLT_Y_HFC13"
base ad:0x800f0d34
group 0--3
line.long 0 "BLT_Y_HFC13"
hexfld.byte 0 " K64 "
hexfld.byte 1 " K65 "
hexfld.byte 2 " K66 "
hexfld.byte 3 " K67 "
;tree.end

;tree "BLT_Y_HFC14"
base ad:0x800f0d38
group 0--3
line.long 0 "BLT_Y_HFC14"
hexfld.byte 0 " K70 "
hexfld.byte 1 " K71 "
hexfld.byte 2 " K72 "
hexfld.byte 3 " K73 "
;tree.end

;tree "BLT_Y_HFC15"
base ad:0x800f0d3c
group 0--3
line.long 0 "BLT_Y_HFC15"
hexfld.byte 0 " K74 "
hexfld.byte 1 " K75 "
hexfld.byte 2 " K76 "
hexfld.byte 3 " K77 "
;tree.end

;tree "BLT_Y_VFC0"
base ad:0x800f0d90
group 0--3
line.long 0 "BLT_Y_VFC0"
hexfld.byte 0 " K0 "
hexfld.byte 1 " K1 "
hexfld.byte 2 " K2 "
hexfld.byte 3 " K3 "
;tree.end

;tree "BLT_Y_VFC1"
base ad:0x800f0d94
group 0--3
line.long 0 "BLT_Y_VFC1"
hexfld.byte 0 " K4 "
hexfld.byte 1 " K10 "
hexfld.byte 2 " K11 "
hexfld.byte 3 " K12 "
;tree.end

;tree "BLT_Y_VFC2"
base ad:0x800f0d98
group 0--3
line.long 0 "BLT_Y_VFC2"
hexfld.byte 0 " K13 "
hexfld.byte 1 " K14 "
hexfld.byte 2 " K20 "
hexfld.byte 3 " K21 "
;tree.end

;tree "BLT_Y_VFC3"
base ad:0x800f0d9c
group 0--3
line.long 0 "BLT_Y_VFC3"
hexfld.byte 0 " K22 "
hexfld.byte 1 " K23 "
hexfld.byte 2 " K24 "
hexfld.byte 3 " K30 "
;tree.end

;tree "BLT_Y_VFC4"
base ad:0x800f0da0
group 0--3
line.long 0 "BLT_Y_VFC4"
hexfld.byte 0 " K31 "
hexfld.byte 1 " K32 "
hexfld.byte 2 " K33 "
hexfld.byte 3 " K34 "
;tree.end

;tree "BLT_Y_VFC5"
base ad:0x800f0da4
group 0--3
line.long 0 "BLT_Y_VFC5"
hexfld.byte 0 " K40 "
hexfld.byte 1 " K41 "
hexfld.byte 2 " K42 "
hexfld.byte 3 " K43 "
;tree.end

;tree "BLT_Y_VFC6"
base ad:0x800f0da8
group 0--3
line.long 0 "BLT_Y_VFC6"
hexfld.byte 0 " K44 "
hexfld.byte 1 " K50 "
hexfld.byte 2 " K51 "
hexfld.byte 3 " K52 "
;tree.end

;tree "BLT_Y_VFC7"
base ad:0x800f0dac
group 0--3
line.long 0 "BLT_Y_VFC7"
hexfld.byte 0 " K53 "
hexfld.byte 1 " K54 "
hexfld.byte 2 " K60 "
hexfld.byte 3 " K61 "
;tree.end

;tree "BLT_Y_VFC8"
base ad:0x800f0db0
group 0--3
line.long 0 "BLT_Y_VFC8"
hexfld.byte 0 " K62 "
hexfld.byte 1 " K63 "
hexfld.byte 2 " K64 "
hexfld.byte 3 " K70 "
;tree.end

;tree "BLT_Y_VFC9"
base ad:0x800f0db4
group 0--3
line.long 0 "BLT_Y_VFC9"
hexfld.byte 0 " K71 "
hexfld.byte 1 " K72 "
hexfld.byte 2 " K73 "
hexfld.byte 3 " K74 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "C2C"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "REVISION"
base ad:0x94000000
rgroup 0--3
line.long 0 "REVISION"
bitfld.long 0 0.--5. " Y_MINOR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--7. " CUSTOM "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--10. " X_MAJOR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11.--15. " R_RTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--27. " FUNC "  " "
bitfld.long 0 28.--29. " Reserved "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " SCHEME "  "0 ,1 ,2 ,3 "
;tree.end

;tree "SYSCONFIG"
base ad:0x94000004
rgroup 0--3
line.long 0 "SYSCONFIG"
hexfld.long 0 " Reserved "
;tree.end

;tree "SYSSTATUS"
base ad:0x94000008
rgroup 0--3
line.long 0 "SYSSTATUS"
hexfld.long 0 " Reserved "
;tree.end

;tree "PORTCONFIG"
base ad:0x9400000c
group 0--3
line.long 0 "PORTCONFIG"
bitfld.long 0 0.--3. " TX_WIDTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " RX_WIDTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--31. " Reserved "  " "
;tree.end

;tree "MIRRORMODE"
base ad:0x94000010
group 0--3
line.long 0 "MIRRORMODE"
bitfld.long 0 0. " MIRRORMODE "  "0 ,1 "
bitfld.long 0 1.--31. " Reserved "  " "
;tree.end

;tree "IRQ_RAW_STATUS_0"
base ad:0x94000014
group 0--3
line.long 0 "IRQ_RAW_STATUS_0"
bitfld.long 0 0. " TX_FREQ_IRQ "  "0 ,1 "
bitfld.long 0 1. " RX_MAX_FREQ_ACK_IRQ "  "0 ,1 "
bitfld.long 0 2. " WAKE_ACK_IRQ "  "0 ,1 "
bitfld.long 0 3. " WAIT_IRQ "  "0 ,1 "
bitfld.long 0 4.--31. " Reserved "  " "
;tree.end

;tree "IRQ_RAW_STATUS_1"
base ad:0x94000018
group 0--3
line.long 0 "IRQ_RAW_STATUS_1"
bitfld.long 0 0. " GENO_IRQ_0 "  "0 ,1 "
bitfld.long 0 1. " GENO_IRQ_1 "  "0 ,1 "
bitfld.long 0 2. " GENO_IRQ_2 "  "0 ,1 "
bitfld.long 0 3. " GENO_IRQ_3 "  "0 ,1 "
bitfld.long 0 4. " GENO_IRQ_4 "  "0 ,1 "
bitfld.long 0 5. " GENO_IRQ_5 "  "0 ,1 "
bitfld.long 0 6. " GENO_IRQ_6 "  "0 ,1 "
bitfld.long 0 7. " GENO_IRQ_7 "  "0 ,1 "
bitfld.long 0 8. " GENO_IRQ_8 "  "0 ,1 "
bitfld.long 0 9. " GENO_IRQ_9 "  "0 ,1 "
bitfld.long 0 10. " GENO_IRQ_10 "  "0 ,1 "
bitfld.long 0 11. " GENO_IRQ_11 "  "0 ,1 "
bitfld.long 0 12. " GENO_IRQ_12 "  "0 ,1 "
bitfld.long 0 13. " GENO_IRQ_13 "  "0 ,1 "
bitfld.long 0 14. " GENO_IRQ_14 "  "0 ,1 "
bitfld.long 0 15. " GENO_IRQ_15 "  "0 ,1 "
bitfld.long 0 16. " GENO_IRQ_16 "  "0 ,1 "
bitfld.long 0 17. " GENO_IRQ_17 "  "0 ,1 "
bitfld.long 0 18. " GENO_IRQ_18 "  "0 ,1 "
bitfld.long 0 19. " GENO_IRQ_19 "  "0 ,1 "
bitfld.long 0 20. " GENO_IRQ_20 "  "0 ,1 "
bitfld.long 0 21. " GENO_IRQ_21 "  "0 ,1 "
bitfld.long 0 22. " GENO_IRQ_22 "  "0 ,1 "
bitfld.long 0 23. " GENO_IRQ_23 "  "0 ,1 "
bitfld.long 0 24. " GENO_IRQ_24 "  "0 ,1 "
bitfld.long 0 25. " GENO_IRQ_25 "  "0 ,1 "
bitfld.long 0 26. " GENO_IRQ_26 "  "0 ,1 "
bitfld.long 0 27. " GENO_IRQ_27 "  "0 ,1 "
bitfld.long 0 28. " GENO_IRQ_28 "  "0 ,1 "
bitfld.long 0 29. " GENO_IRQ_29 "  "0 ,1 "
bitfld.long 0 30. " GENO_IRQ_30 "  "0 ,1 "
bitfld.long 0 31. " GENO_IRQ_31 "  "0 ,1 "
;tree.end

;tree "IRQ_ENABLE_STATUS_0"
base ad:0x9400001c
group 0--3
line.long 0 "IRQ_ENABLE_STATUS_0"
bitfld.long 0 0. " TX_FREQ_IRQ "  "0 ,1 "
bitfld.long 0 1. " RX_MAX_FREQ_ACK_IRQ "  "0 ,1 "
bitfld.long 0 2. " WAKE_ACK_IRQ "  "0 ,1 "
bitfld.long 0 3. " WAIT_IRQ "  "0 ,1 "
bitfld.long 0 4.--31. " Reserved "  " "
;tree.end

;tree "IRQ_ENABLE_STATUS_1"
base ad:0x94000020
group 0--3
line.long 0 "IRQ_ENABLE_STATUS_1"
bitfld.long 0 0. " GENO_IRQ_0 "  "0 ,1 "
bitfld.long 0 1. " GENO_IRQ_1 "  "0 ,1 "
bitfld.long 0 2. " GENO_IRQ_2 "  "0 ,1 "
bitfld.long 0 3. " GENO_IRQ_3 "  "0 ,1 "
bitfld.long 0 4. " GENO_IRQ_4 "  "0 ,1 "
bitfld.long 0 5. " GENO_IRQ_5 "  "0 ,1 "
bitfld.long 0 6. " GENO_IRQ_6 "  "0 ,1 "
bitfld.long 0 7. " GENO_IRQ_7 "  "0 ,1 "
bitfld.long 0 8. " GENO_IRQ_8 "  "0 ,1 "
bitfld.long 0 9. " GENO_IRQ_9 "  "0 ,1 "
bitfld.long 0 10. " GENO_IRQ_10 "  "0 ,1 "
bitfld.long 0 11. " GENO_IRQ_11 "  "0 ,1 "
bitfld.long 0 12. " GENO_IRQ_12 "  "0 ,1 "
bitfld.long 0 13. " GENO_IRQ_13 "  "0 ,1 "
bitfld.long 0 14. " GENO_IRQ_14 "  "0 ,1 "
bitfld.long 0 15. " GENO_IRQ_15 "  "0 ,1 "
bitfld.long 0 16. " GENO_IRQ_16 "  "0 ,1 "
bitfld.long 0 17. " GENO_IRQ_17 "  "0 ,1 "
bitfld.long 0 18. " GENO_IRQ_18 "  "0 ,1 "
bitfld.long 0 19. " GENO_IRQ_19 "  "0 ,1 "
bitfld.long 0 20. " GENO_IRQ_20 "  "0 ,1 "
bitfld.long 0 21. " GENO_IRQ_21 "  "0 ,1 "
bitfld.long 0 22. " GENO_IRQ_22 "  "0 ,1 "
bitfld.long 0 23. " GENO_IRQ_23 "  "0 ,1 "
bitfld.long 0 24. " GENO_IRQ_24 "  "0 ,1 "
bitfld.long 0 25. " GENO_IRQ_25 "  "0 ,1 "
bitfld.long 0 26. " GENO_IRQ_26 "  "0 ,1 "
bitfld.long 0 27. " GENO_IRQ_27 "  "0 ,1 "
bitfld.long 0 28. " GENO_IRQ_28 "  "0 ,1 "
bitfld.long 0 29. " GENO_IRQ_29 "  "0 ,1 "
bitfld.long 0 30. " GENO_IRQ_30 "  "0 ,1 "
bitfld.long 0 31. " GENO_IRQ_31 "  "0 ,1 "
;tree.end

;tree "IRQ_ENABLE_SET_0"
base ad:0x94000024
group 0--3
line.long 0 "IRQ_ENABLE_SET_0"
bitfld.long 0 0. " TX_FREQ_IRQ_EN "  "0 ,1 "
bitfld.long 0 1. " RX_MAX_FREQ_ACK_IRQ_EN "  "0 ,1 "
bitfld.long 0 2. " WAKE_ACK_IRQ_EN "  "0 ,1 "
bitfld.long 0 3. " WAIT_IRQ_EN "  "0 ,1 "
bitfld.long 0 4.--31. " Reserved "  " "
;tree.end

;tree "IRQ_ENABLE_SET_1"
base ad:0x94000028
group 0--3
line.long 0 "IRQ_ENABLE_SET_1"
bitfld.long 0 0. " GENO_IRQ_0_EN "  "0 ,1 "
bitfld.long 0 1. " GENO_IRQ_1_EN "  "0 ,1 "
bitfld.long 0 2. " GENO_IRQ_2_EN "  "0 ,1 "
bitfld.long 0 3. " GENO_IRQ_3_EN "  "0 ,1 "
bitfld.long 0 4. " GENO_IRQ_4_EN "  "0 ,1 "
bitfld.long 0 5. " GENO_IRQ_5_EN "  "0 ,1 "
bitfld.long 0 6. " GENO_IRQ_6_EN "  "0 ,1 "
bitfld.long 0 7. " GENO_IRQ_7_EN "  "0 ,1 "
bitfld.long 0 8. " GENO_IRQ_8_EN "  "0 ,1 "
bitfld.long 0 9. " GENO_IRQ_9_EN "  "0 ,1 "
bitfld.long 0 10. " GENO_IRQ_10_EN "  "0 ,1 "
bitfld.long 0 11. " GENO_IRQ_11_EN "  "0 ,1 "
bitfld.long 0 12. " GENO_IRQ_12_EN "  "0 ,1 "
bitfld.long 0 13. " GENO_IRQ_13_EN "  "0 ,1 "
bitfld.long 0 14. " GENO_IRQ_14_EN "  "0 ,1 "
bitfld.long 0 15. " GENO_IRQ_15_EN "  "0 ,1 "
bitfld.long 0 16. " GENO_IRQ_16_EN "  "0 ,1 "
bitfld.long 0 17. " GENO_IRQ_17_EN "  "0 ,1 "
bitfld.long 0 18. " GENO_IRQ_18_EN "  "0 ,1 "
bitfld.long 0 19. " GENO_IRQ_19_EN "  "0 ,1 "
bitfld.long 0 20. " GENO_IRQ_20_EN "  "0 ,1 "
bitfld.long 0 21. " GENO_IRQ_21_EN "  "0 ,1 "
bitfld.long 0 22. " GENO_IRQ_22_EN "  "0 ,1 "
bitfld.long 0 23. " GENO_IRQ_23_EN "  "0 ,1 "
bitfld.long 0 24. " GENO_IRQ_24_EN "  "0 ,1 "
bitfld.long 0 25. " GENO_IRQ_25_EN "  "0 ,1 "
bitfld.long 0 26. " GENO_IRQ_26_EN "  "0 ,1 "
bitfld.long 0 27. " GENO_IRQ_27_EN "  "0 ,1 "
bitfld.long 0 28. " GENO_IRQ_28_EN "  "0 ,1 "
bitfld.long 0 29. " GENO_IRQ_29_EN "  "0 ,1 "
bitfld.long 0 30. " GENO_IRQ_30_EN "  "0 ,1 "
bitfld.long 0 31. " GENO_IRQ_31_EN "  "0 ,1 "
;tree.end

;tree "IRQ_ENABLE_CLEAR_0"
base ad:0x9400002c
group 0--3
line.long 0 "IRQ_ENABLE_CLEAR_0"
bitfld.long 0 0. " TX_FREQ_IRQ_EN "  "0 ,1 "
bitfld.long 0 1. " RX_MAX_FREQ_ACK_IRQ_EN "  "0 ,1 "
bitfld.long 0 2. " WAKE_ACK_IRQ_EN "  "0 ,1 "
bitfld.long 0 3. " WAIT_IRQ_EN "  "0 ,1 "
bitfld.long 0 4.--31. " Reserved "  " "
;tree.end

;tree "IRQ_ENABLE_CLEAR_1"
base ad:0x94000030
group 0--3
line.long 0 "IRQ_ENABLE_CLEAR_1"
bitfld.long 0 0. " GENO_IRQ_0_EN "  "0 ,1 "
bitfld.long 0 1. " GENO_IRQ_1_EN "  "0 ,1 "
bitfld.long 0 2. " GENO_IRQ_2_EN "  "0 ,1 "
bitfld.long 0 3. " GENO_IRQ_3_EN "  "0 ,1 "
bitfld.long 0 4. " GENO_IRQ_4_EN "  "0 ,1 "
bitfld.long 0 5. " GENO_IRQ_5_EN "  "0 ,1 "
bitfld.long 0 6. " GENO_IRQ_6_EN "  "0 ,1 "
bitfld.long 0 7. " GENO_IRQ_7_EN "  "0 ,1 "
bitfld.long 0 8. " GENO_IRQ_8_EN "  "0 ,1 "
bitfld.long 0 9. " GENO_IRQ_9_EN "  "0 ,1 "
bitfld.long 0 10. " GENO_IRQ_10_EN "  "0 ,1 "
bitfld.long 0 11. " GENO_IRQ_11_EN "  "0 ,1 "
bitfld.long 0 12. " GENO_IRQ_12_EN "  "0 ,1 "
bitfld.long 0 13. " GENO_IRQ_13_EN "  "0 ,1 "
bitfld.long 0 14. " GENO_IRQ_14_EN "  "0 ,1 "
bitfld.long 0 15. " GENO_IRQ_15_EN "  "0 ,1 "
bitfld.long 0 16. " GENO_IRQ_16_EN "  "0 ,1 "
bitfld.long 0 17. " GENO_IRQ_17_EN "  "0 ,1 "
bitfld.long 0 18. " GENO_IRQ_18_EN "  "0 ,1 "
bitfld.long 0 19. " GENO_IRQ_19_EN "  "0 ,1 "
bitfld.long 0 20. " GENO_IRQ_20_EN "  "0 ,1 "
bitfld.long 0 21. " GENO_IRQ_21_EN "  "0 ,1 "
bitfld.long 0 22. " GENO_IRQ_22_EN "  "0 ,1 "
bitfld.long 0 23. " GENO_IRQ_23_EN "  "0 ,1 "
bitfld.long 0 24. " GENO_IRQ_24_EN "  "0 ,1 "
bitfld.long 0 25. " GENO_IRQ_25_EN "  "0 ,1 "
bitfld.long 0 26. " GENO_IRQ_26_EN "  "0 ,1 "
bitfld.long 0 27. " GENO_IRQ_27_EN "  "0 ,1 "
bitfld.long 0 28. " GENO_IRQ_28_EN "  "0 ,1 "
bitfld.long 0 29. " GENO_IRQ_29_EN "  "0 ,1 "
bitfld.long 0 30. " GENO_IRQ_30_EN "  "0 ,1 "
bitfld.long 0 31. " GENO_IRQ_31_EN "  "0 ,1 "
;tree.end

;tree "IRQ_EOI"
base ad:0x94000034
rgroup 0--3
line.long 0 "IRQ_EOI"
bitfld.long 0 0. " EOI_VECTOR "  "0 ,1 "
bitfld.long 0 1.--31. " Reserved "  " "
;tree.end

;tree "FCLK_FREQ"
base ad:0x94000040
group 0--3
line.long 0 "FCLK_FREQ"
bitfld.long 0 0.--9. " FCLK_FREQ "  " "
bitfld.long 0 10.--31. " Reserved "  " "
;tree.end

;tree "RX_MAX_FREQ"
base ad:0x94000044
group 0--3
line.long 0 "RX_MAX_FREQ"
bitfld.long 0 0.--9. " RX_MAX_FREQ "  " "
bitfld.long 0 10.--31. " Reserved "  " "
;tree.end

;tree "TX_MAX_FREQ"
base ad:0x94000048
group 0--3
line.long 0 "TX_MAX_FREQ"
bitfld.long 0 0.--9. " TX_MAX_FREQ "  " "
bitfld.long 0 10.--31. " Reserved "  " "
;tree.end

;tree "RX_MAX_FREQ_ACK"
base ad:0x9400004c
group 0--3
line.long 0 "RX_MAX_FREQ_ACK"
bitfld.long 0 0.--9. " RX_MAX_FREQ_ACK "  " "
bitfld.long 0 10.--31. " Reserved "  " "
;tree.end

;tree "WAKE_REQ"
base ad:0x94000050
group 0--3
line.long 0 "WAKE_REQ"
bitfld.long 0 0. " WAKE_REQ "  "0 ,1 "
bitfld.long 0 1.--31. " Reserved "  " "
;tree.end

;tree "WAKE_ACK"
base ad:0x94000054
group 0--3
line.long 0 "WAKE_ACK"
bitfld.long 0 0. " WAKE_ACK "  "0 ,1 "
bitfld.long 0 1.--31. " Reserved "  " "
;tree.end

;tree "STANDBY"
base ad:0x94000060
group 0--3
line.long 0 "STANDBY"
bitfld.long 0 0. " STANDBY "  "0 ,1 "
bitfld.long 0 1.--31. " Reserved "  " "
;tree.end

;tree "STANDBY_IN"
base ad:0x94000064
group 0--3
line.long 0 "STANDBY_IN"
bitfld.long 0 0. " STANDBY "  "0 ,1 "
bitfld.long 0 1.--31. " Reserved "  " "
;tree.end

;tree "WAIT"
base ad:0x94000068
group 0--3
line.long 0 "WAIT"
bitfld.long 0 0. " WAIT "  "0 ,1 "
bitfld.long 0 1.--31. " Reserved "  " "
;tree.end

;tree "GENI_CONTROL"
base ad:0x94000070
group 0--3
line.long 0 "GENI_CONTROL"
bitfld.long 0 0. " GENI_0 "  "0 ,1 "
bitfld.long 0 1. " GENI_1 "  "0 ,1 "
bitfld.long 0 2. " GENI_2 "  "0 ,1 "
bitfld.long 0 3. " GENI_3 "  "0 ,1 "
bitfld.long 0 4. " GENI_4 "  "0 ,1 "
bitfld.long 0 5. " GENI_5 "  "0 ,1 "
bitfld.long 0 6. " GENI_6 "  "0 ,1 "
bitfld.long 0 7. " GENI_7 "  "0 ,1 "
bitfld.long 0 8. " GENI_8 "  "0 ,1 "
bitfld.long 0 9. " GENI_9 "  "0 ,1 "
bitfld.long 0 10. " GENI_10 "  "0 ,1 "
bitfld.long 0 11. " GENI_11 "  "0 ,1 "
bitfld.long 0 12. " GENI_12 "  "0 ,1 "
bitfld.long 0 13. " GENI_13 "  "0 ,1 "
bitfld.long 0 14. " GENI_14 "  "0 ,1 "
bitfld.long 0 15. " GENI_15 "  "0 ,1 "
bitfld.long 0 16. " GENI_16 "  "0 ,1 "
bitfld.long 0 17. " GENI_17 "  "0 ,1 "
bitfld.long 0 18. " GENI_18 "  "0 ,1 "
bitfld.long 0 19. " GENI_19 "  "0 ,1 "
bitfld.long 0 20. " GENI_20 "  "0 ,1 "
bitfld.long 0 21. " GENI_21 "  "0 ,1 "
bitfld.long 0 22. " GENI_22 "  "0 ,1 "
bitfld.long 0 23. " GENI_23 "  "0 ,1 "
bitfld.long 0 24. " GENI_24 "  "0 ,1 "
bitfld.long 0 25. " GENI_25 "  "0 ,1 "
bitfld.long 0 26. " GENI_26 "  "0 ,1 "
bitfld.long 0 27. " GENI_27 "  "0 ,1 "
bitfld.long 0 28. " GENI_28 "  "0 ,1 "
bitfld.long 0 29. " GENI_29 "  "0 ,1 "
bitfld.long 0 30. " GENI_30 "  "0 ,1 "
bitfld.long 0 31. " GENI_31 "  "0 ,1 "
;tree.end

;tree "GENI_MASK"
base ad:0x94000074
group 0--3
line.long 0 "GENI_MASK"
bitfld.long 0 0. " GENI_MASK_0 "  "0 ,1 "
bitfld.long 0 1. " GENI_MASK_1 "  "0 ,1 "
bitfld.long 0 2. " GENI_MASK_2 "  "0 ,1 "
bitfld.long 0 3. " GENI_MASK_3 "  "0 ,1 "
bitfld.long 0 4. " GENI_MASK_4 "  "0 ,1 "
bitfld.long 0 5. " GENI_MASK_5 "  "0 ,1 "
bitfld.long 0 6. " GENI_MASK_6 "  "0 ,1 "
bitfld.long 0 7. " GENI_MASK_7 "  "0 ,1 "
bitfld.long 0 8. " GENI_MASK_8 "  "0 ,1 "
bitfld.long 0 9. " GENI_MASK_9 "  "0 ,1 "
bitfld.long 0 10. " GENI_MASK_10 "  "0 ,1 "
bitfld.long 0 11. " GENI_MASK_11 "  "0 ,1 "
bitfld.long 0 12. " GENI_MASK_12 "  "0 ,1 "
bitfld.long 0 13. " GENI_MASK_13 "  "0 ,1 "
bitfld.long 0 14. " GENI_MASK_14 "  "0 ,1 "
bitfld.long 0 15. " GENI_MASK_15 "  "0 ,1 "
bitfld.long 0 16. " GENI_MASK_16 "  "0 ,1 "
bitfld.long 0 17. " GENI_MASK_17 "  "0 ,1 "
bitfld.long 0 18. " GENI_MASK_18 "  "0 ,1 "
bitfld.long 0 19. " GENI_MASK_19 "  "0 ,1 "
bitfld.long 0 20. " GENI_MASK_20 "  "0 ,1 "
bitfld.long 0 21. " GENI_MASK_21 "  "0 ,1 "
bitfld.long 0 22. " GENI_MASK_22 "  "0 ,1 "
bitfld.long 0 23. " GENI_MASK_23 "  "0 ,1 "
bitfld.long 0 24. " GENI_MASK_24 "  "0 ,1 "
bitfld.long 0 25. " GENI_MASK_25 "  "0 ,1 "
bitfld.long 0 26. " GENI_MASK_26 "  "0 ,1 "
bitfld.long 0 27. " GENI_MASK_27 "  "0 ,1 "
bitfld.long 0 28. " GENI_MASK_28 "  "0 ,1 "
bitfld.long 0 29. " GENI_MASK_29 "  "0 ,1 "
bitfld.long 0 30. " GENI_MASK_30 "  "0 ,1 "
bitfld.long 0 31. " GENI_MASK_31 "  "0 ,1 "
;tree.end

;tree "GENO_STATUS"
base ad:0x94000080
group 0--3
line.long 0 "GENO_STATUS"
bitfld.long 0 0. " GENO_0 "  "0 ,1 "
bitfld.long 0 1. " GENO_1 "  "0 ,1 "
bitfld.long 0 2. " GENO_2 "  "0 ,1 "
bitfld.long 0 3. " GENO_3 "  "0 ,1 "
bitfld.long 0 4. " GENO_4 "  "0 ,1 "
bitfld.long 0 5. " GENO_5 "  "0 ,1 "
bitfld.long 0 6. " GENO_6 "  "0 ,1 "
bitfld.long 0 7. " GENO_7 "  "0 ,1 "
bitfld.long 0 8. " GENO_8 "  "0 ,1 "
bitfld.long 0 9. " GENO_9 "  "0 ,1 "
bitfld.long 0 10. " GENO_10 "  "0 ,1 "
bitfld.long 0 11. " GENO_11 "  "0 ,1 "
bitfld.long 0 12. " GENO_12 "  "0 ,1 "
bitfld.long 0 13. " GENO_13 "  "0 ,1 "
bitfld.long 0 14. " GENO_14 "  "0 ,1 "
bitfld.long 0 15. " GENO_15 "  "0 ,1 "
bitfld.long 0 16. " GENO_16 "  "0 ,1 "
bitfld.long 0 17. " GENO_17 "  "0 ,1 "
bitfld.long 0 18. " GENO_18 "  "0 ,1 "
bitfld.long 0 19. " GENO_19 "  "0 ,1 "
bitfld.long 0 20. " GENO_20 "  "0 ,1 "
bitfld.long 0 21. " GENO_21 "  "0 ,1 "
bitfld.long 0 22. " GENO_22 "  "0 ,1 "
bitfld.long 0 23. " GENO_23 "  "0 ,1 "
bitfld.long 0 24. " GENO_24 "  "0 ,1 "
bitfld.long 0 25. " GENO_25 "  "0 ,1 "
bitfld.long 0 26. " GENO_26 "  "0 ,1 "
bitfld.long 0 27. " GENO_27 "  "0 ,1 "
bitfld.long 0 28. " GENO_28 "  "0 ,1 "
bitfld.long 0 29. " GENO_29 "  "0 ,1 "
bitfld.long 0 30. " GENO_30 "  "0 ,1 "
bitfld.long 0 31. " GENO_31 "  "0 ,1 "
;tree.end

;tree "GENO_INTERRUPT"
base ad:0x94000084
group 0--3
line.long 0 "GENO_INTERRUPT"
bitfld.long 0 0. " GENO_INT_0 "  "0 ,1 "
bitfld.long 0 1. " GENO_INT_1 "  "0 ,1 "
bitfld.long 0 2. " GENO_INT_2 "  "0 ,1 "
bitfld.long 0 3. " GENO_INT_3 "  "0 ,1 "
bitfld.long 0 4. " GENO_INT_4 "  "0 ,1 "
bitfld.long 0 5. " GENO_INT_5 "  "0 ,1 "
bitfld.long 0 6. " GENO_INT_6 "  "0 ,1 "
bitfld.long 0 7. " GENO_INT_7 "  "0 ,1 "
bitfld.long 0 8. " GENO_INT_8 "  "0 ,1 "
bitfld.long 0 9. " GENO_INT_9 "  "0 ,1 "
bitfld.long 0 10. " GENO_INT_10 "  "0 ,1 "
bitfld.long 0 11. " GENO_INT_11 "  "0 ,1 "
bitfld.long 0 12. " GENO_INT_12 "  "0 ,1 "
bitfld.long 0 13. " GENO_INT_13 "  "0 ,1 "
bitfld.long 0 14. " GENO_INT_14 "  "0 ,1 "
bitfld.long 0 15. " GENO_INT_15 "  "0 ,1 "
bitfld.long 0 16. " GENO_INT_16 "  "0 ,1 "
bitfld.long 0 17. " GENO_INT_17 "  "0 ,1 "
bitfld.long 0 18. " GENO_INT_18 "  "0 ,1 "
bitfld.long 0 19. " GENO_INT_19 "  "0 ,1 "
bitfld.long 0 20. " GENO_INT_20 "  "0 ,1 "
bitfld.long 0 21. " GENO_INT_21 "  "0 ,1 "
bitfld.long 0 22. " GENO_INT_22 "  "0 ,1 "
bitfld.long 0 23. " GENO_INT_23 "  "0 ,1 "
bitfld.long 0 24. " GENO_INT_24 "  "0 ,1 "
bitfld.long 0 25. " GENO_INT_25 "  "0 ,1 "
bitfld.long 0 26. " GENO_INT_26 "  "0 ,1 "
bitfld.long 0 27. " GENO_INT_27 "  "0 ,1 "
bitfld.long 0 28. " GENO_INT_28 "  "0 ,1 "
bitfld.long 0 29. " GENO_INT_29 "  "0 ,1 "
bitfld.long 0 30. " GENO_INT_30 "  "0 ,1 "
bitfld.long 0 31. " GENO_INT_31 "  "0 ,1 "
;tree.end

;tree "GENO_LEVEL"
base ad:0x94000088
group 0--3
line.long 0 "GENO_LEVEL"
bitfld.long 0 0. " GENO_LEVEL_0 "  "0 ,1 "
bitfld.long 0 1. " GENO_LEVEL_1 "  "0 ,1 "
bitfld.long 0 2. " GENO_LEVEL_2 "  "0 ,1 "
bitfld.long 0 3. " GENO_LEVEL_3 "  "0 ,1 "
bitfld.long 0 4. " GENO_LEVEL_4 "  "0 ,1 "
bitfld.long 0 5. " GENO_LEVEL_5 "  "0 ,1 "
bitfld.long 0 6. " GENO_LEVEL_6 "  "0 ,1 "
bitfld.long 0 7. " GENO_LEVEL_7 "  "0 ,1 "
bitfld.long 0 8. " GENO_LEVEL_8 "  "0 ,1 "
bitfld.long 0 9. " GENO_LEVEL_9 "  "0 ,1 "
bitfld.long 0 10. " GENO_LEVEL_10 "  "0 ,1 "
bitfld.long 0 11. " GENO_LEVEL_11 "  "0 ,1 "
bitfld.long 0 12. " GENO_LEVEL_12 "  "0 ,1 "
bitfld.long 0 13. " GENO_LEVEL_13 "  "0 ,1 "
bitfld.long 0 14. " GENO_LEVEL_14 "  "0 ,1 "
bitfld.long 0 15. " GENO_LEVEL_15 "  "0 ,1 "
bitfld.long 0 16. " GENO_LEVEL_16 "  "0 ,1 "
bitfld.long 0 17. " GENO_LEVEL_17 "  "0 ,1 "
bitfld.long 0 18. " GENO_LEVEL_18 "  "0 ,1 "
bitfld.long 0 19. " GENO_LEVEL_19 "  "0 ,1 "
bitfld.long 0 20. " GENO_LEVEL_20 "  "0 ,1 "
bitfld.long 0 21. " GENO_LEVEL_21 "  "0 ,1 "
bitfld.long 0 22. " GENO_LEVEL_22 "  "0 ,1 "
bitfld.long 0 23. " GENO_LEVEL_23 "  "0 ,1 "
bitfld.long 0 24. " GENO_LEVEL_24 "  "0 ,1 "
bitfld.long 0 25. " GENO_LEVEL_25 "  "0 ,1 "
bitfld.long 0 26. " GENO_LEVEL_26 "  "0 ,1 "
bitfld.long 0 27. " GENO_LEVEL_27 "  "0 ,1 "
bitfld.long 0 28. " GENO_LEVEL_28 "  "0 ,1 "
bitfld.long 0 29. " GENO_LEVEL_29 "  "0 ,1 "
bitfld.long 0 30. " GENO_LEVEL_30 "  "0 ,1 "
bitfld.long 0 31. " GENO_LEVEL_31 "  "0 ,1 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "CDITB"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CR"
base ad:0x63e00000
group 0--3
line.long 0 "CR"
bitfld.long 0 0.--1. " channel "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " rst_wrd_ary "  "0 ,1 "
bitfld.long 0 3. " d0_1 "  "0 ,1 "
bitfld.long 0 4. " clknp_1 "  "0 ,1 "
bitfld.long 0 5. " d0_2 "  "0 ,1 "
bitfld.long 0 6. " d1_2 "  "0 ,1 "
bitfld.long 0 7. " clknp_2 "  "0 ,1 "
bitfld.long 0 8. " d0_3 "  "0 ,1 "
bitfld.long 0 9. " d1_3 "  "0 ,1 "
bitfld.long 0 10. " d2_3 "  "0 ,1 "
bitfld.long 0 11. " clknp_3 "  "0 ,1 "
;tree.end

;tree "WRD_0"
base ad:0x63e00004
rgroup 0--3
line.long 0 "WRD_0"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_1"
base ad:0x63e00008
rgroup 0--3
line.long 0 "WRD_1"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_2"
base ad:0x63e0000c
rgroup 0--3
line.long 0 "WRD_2"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_3"
base ad:0x63e00010
rgroup 0--3
line.long 0 "WRD_3"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_4"
base ad:0x63e00014
rgroup 0--3
line.long 0 "WRD_4"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_5"
base ad:0x63e00018
rgroup 0--3
line.long 0 "WRD_5"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_6"
base ad:0x63e0001c
rgroup 0--3
line.long 0 "WRD_6"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_7"
base ad:0x63e00020
rgroup 0--3
line.long 0 "WRD_7"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_8"
base ad:0x63e00024
rgroup 0--3
line.long 0 "WRD_8"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_9"
base ad:0x63e00028
rgroup 0--3
line.long 0 "WRD_9"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_10"
base ad:0x63e0002c
rgroup 0--3
line.long 0 "WRD_10"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_11"
base ad:0x63e00030
rgroup 0--3
line.long 0 "WRD_11"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_12"
base ad:0x63e00034
rgroup 0--3
line.long 0 "WRD_12"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_13"
base ad:0x63e00038
rgroup 0--3
line.long 0 "WRD_13"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_14"
base ad:0x63e0003c
rgroup 0--3
line.long 0 "WRD_14"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_15"
base ad:0x63e00040
rgroup 0--3
line.long 0 "WRD_15"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_16"
base ad:0x63e00044
rgroup 0--3
line.long 0 "WRD_16"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_17"
base ad:0x63e00048
rgroup 0--3
line.long 0 "WRD_17"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_18"
base ad:0x63e0004c
rgroup 0--3
line.long 0 "WRD_18"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_19"
base ad:0x63e00050
rgroup 0--3
line.long 0 "WRD_19"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_20"
base ad:0x63e00054
rgroup 0--3
line.long 0 "WRD_20"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_21"
base ad:0x63e00058
rgroup 0--3
line.long 0 "WRD_21"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_22"
base ad:0x63e0005c
rgroup 0--3
line.long 0 "WRD_22"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_23"
base ad:0x63e00060
rgroup 0--3
line.long 0 "WRD_23"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_24"
base ad:0x63e00064
rgroup 0--3
line.long 0 "WRD_24"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_25"
base ad:0x63e00068
rgroup 0--3
line.long 0 "WRD_25"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_26"
base ad:0x63e0006c
rgroup 0--3
line.long 0 "WRD_26"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_27"
base ad:0x63e00070
rgroup 0--3
line.long 0 "WRD_27"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_28"
base ad:0x63e00074
rgroup 0--3
line.long 0 "WRD_28"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_29"
base ad:0x63e00078
rgroup 0--3
line.long 0 "WRD_29"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_30"
base ad:0x63e0007c
rgroup 0--3
line.long 0 "WRD_30"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_31"
base ad:0x63e00080
rgroup 0--3
line.long 0 "WRD_31"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_32"
base ad:0x63e00084
rgroup 0--3
line.long 0 "WRD_32"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_33"
base ad:0x63e00088
rgroup 0--3
line.long 0 "WRD_33"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_34"
base ad:0x63e0008c
rgroup 0--3
line.long 0 "WRD_34"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_35"
base ad:0x63e00090
rgroup 0--3
line.long 0 "WRD_35"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_36"
base ad:0x63e00094
rgroup 0--3
line.long 0 "WRD_36"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_37"
base ad:0x63e00098
rgroup 0--3
line.long 0 "WRD_37"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_38"
base ad:0x63e0009c
rgroup 0--3
line.long 0 "WRD_38"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_39"
base ad:0x63e000a0
rgroup 0--3
line.long 0 "WRD_39"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_40"
base ad:0x63e000a4
rgroup 0--3
line.long 0 "WRD_40"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_41"
base ad:0x63e000a8
rgroup 0--3
line.long 0 "WRD_41"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_42"
base ad:0x63e000ac
rgroup 0--3
line.long 0 "WRD_42"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_43"
base ad:0x63e000b0
rgroup 0--3
line.long 0 "WRD_43"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_44"
base ad:0x63e000b4
rgroup 0--3
line.long 0 "WRD_44"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_45"
base ad:0x63e000b8
rgroup 0--3
line.long 0 "WRD_45"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_46"
base ad:0x63e000bc
rgroup 0--3
line.long 0 "WRD_46"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_47"
base ad:0x63e000c0
rgroup 0--3
line.long 0 "WRD_47"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_48"
base ad:0x63e000c4
rgroup 0--3
line.long 0 "WRD_48"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_49"
base ad:0x63e000c8
rgroup 0--3
line.long 0 "WRD_49"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_50"
base ad:0x63e000cc
rgroup 0--3
line.long 0 "WRD_50"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_51"
base ad:0x63e000d0
rgroup 0--3
line.long 0 "WRD_51"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_52"
base ad:0x63e000d4
rgroup 0--3
line.long 0 "WRD_52"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_53"
base ad:0x63e000d8
rgroup 0--3
line.long 0 "WRD_53"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_54"
base ad:0x63e000dc
rgroup 0--3
line.long 0 "WRD_54"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_55"
base ad:0x63e000e0
rgroup 0--3
line.long 0 "WRD_55"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_56"
base ad:0x63e000e4
rgroup 0--3
line.long 0 "WRD_56"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_57"
base ad:0x63e000e8
rgroup 0--3
line.long 0 "WRD_57"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_58"
base ad:0x63e000ec
rgroup 0--3
line.long 0 "WRD_58"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_59"
base ad:0x63e000f0
rgroup 0--3
line.long 0 "WRD_59"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_60"
base ad:0x63e000f4
rgroup 0--3
line.long 0 "WRD_60"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_61"
base ad:0x63e000f8
rgroup 0--3
line.long 0 "WRD_61"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_62"
base ad:0x63e000fc
rgroup 0--3
line.long 0 "WRD_62"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_63"
base ad:0x63e00100
rgroup 0--3
line.long 0 "WRD_63"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_64"
base ad:0x63e00104
rgroup 0--3
line.long 0 "WRD_64"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_65"
base ad:0x63e00108
rgroup 0--3
line.long 0 "WRD_65"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_66"
base ad:0x63e0010c
rgroup 0--3
line.long 0 "WRD_66"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_67"
base ad:0x63e00110
rgroup 0--3
line.long 0 "WRD_67"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_68"
base ad:0x63e00114
rgroup 0--3
line.long 0 "WRD_68"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_69"
base ad:0x63e00118
rgroup 0--3
line.long 0 "WRD_69"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_70"
base ad:0x63e0011c
rgroup 0--3
line.long 0 "WRD_70"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_71"
base ad:0x63e00120
rgroup 0--3
line.long 0 "WRD_71"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_72"
base ad:0x63e00124
rgroup 0--3
line.long 0 "WRD_72"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_73"
base ad:0x63e00128
rgroup 0--3
line.long 0 "WRD_73"
hexfld.long 0 " Pixel "
;tree.end

;tree "WRD_74"
base ad:0x63e0012c
rgroup 0--3
line.long 0 "WRD_74"
hexfld.long 0 " Pixel "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "CLK_RST1"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "PRCC_PCKEN"
base ad:0x8012f000
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERCKEN8 "  "0 ,1 "
bitfld.long 0 9. " PERCKEN9 "  "0 ,1 "
bitfld.long 0 10. " PERCKEN10 "  "0 ,1 "
bitfld.long 0 11. " PERCKEN11 "  "0 ,1 "
;tree.end

;tree "PRCC_PCKDIS"
base ad:0x8012f004
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERCKDIS8 "  "0 ,1 "
bitfld.long 0 9. " PERCKDIS9 "  "0 ,1 "
bitfld.long 0 10. " PERCKDIS10 "  "0 ,1 "
bitfld.long 0 11. " PERCKDIS11 "  "0 ,1 "
;tree.end

;tree "PRCC_KCKEN"
base ad:0x8012f008
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
bitfld.long 0 8. " PERKCKEN8 "  "0 ,1 "
bitfld.long 0 9. " PERKCKEN9 "  "0 ,1 "
bitfld.long 0 10. " PERKCKEN10 "  "0 ,1 "
;tree.end

;tree "PRCC_KCKDIS"
base ad:0x8012f00c
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
bitfld.long 0 8. " PERKCKDIS8 "  "0 ,1 "
bitfld.long 0 9. " PERKCKDIS9 "  "0 ,1 "
bitfld.long 0 10. " PERKCKDIS10 "  "0 ,1 "
;tree.end

;tree "PRCC_PCKSR"
base ad:0x8012f010
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERCKSR8 "  "0 ,1 "
bitfld.long 0 9. " PERCKSR9 "  "0 ,1 "
bitfld.long 0 10. " PERCKSR10 "  "0 ,1 "
bitfld.long 0 11. " PERCKSR11 "  "0 ,1 "
;tree.end

;tree "PRCC_PKCKSR"
base ad:0x8012f014
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
bitfld.long 0 8. " PERKCKSR8 "  "0 ,1 "
bitfld.long 0 9. " PERKCKSR9 "  "0 ,1 "
bitfld.long 0 10. " PERKCKSR10 "  "0 ,1 "
;tree.end

;tree "PRCC_K_SOFTRST_SET"
base ad:0x8012f018
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 0. " K_SOFTRST_SET0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTRST_SET1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_SET2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_SET3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_SET4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_SET5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_SET6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_SET7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTRST_SET8 "  "0 ,1 "
bitfld.long 0 9. " K_SOFTRST_SET9 "  "0 ,1 "
bitfld.long 0 10. " K_SOFTRST_SET10 "  "0 ,1 "
bitfld.long 0 11. " K_SOFTRST_SET11 "  "0 ,1 "
bitfld.long 0 12. " K_SOFTRST_SET12 "  "0 ,1 "
bitfld.long 0 13. " K_SOFTRST_SET13 "  "0 ,1 "
bitfld.long 0 14. " K_SOFTRST_SET14 "  "0 ,1 "
;tree.end

;tree "PRCC_K_SOFTRST_CLR"
base ad:0x8012f01c
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 0. " K_SOFTRST_CLR0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTRST_CLR1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_CLR2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_CLR3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_CLR4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_CLR5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_CLR6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_CLR7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTRST_CLR8 "  "0 ,1 "
bitfld.long 0 9. " K_SOFTRST_CLR9 "  "0 ,1 "
bitfld.long 0 10. " K_SOFTRST_CLR10 "  "0 ,1 "
bitfld.long 0 11. " K_SOFTRST_CLR11 "  "0 ,1 "
bitfld.long 0 12. " K_SOFTRST_CLR12 "  "0 ,1 "
bitfld.long 0 13. " K_SOFTRST_CLR13 "  "0 ,1 "
bitfld.long 0 14. " K_SOFTRST_CLR14 "  "0 ,1 "
;tree.end

;tree "PRCC_K_RST_STATUS"
base ad:0x8012f020
group 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 0. " K_RST_STATUS0 "  "0 ,1 "
bitfld.long 0 1. " K_RST_STATUS1 "  "0 ,1 "
bitfld.long 0 2. " K_RST_STATUS2 "  "0 ,1 "
bitfld.long 0 3. " K_RST_STATUS3 "  "0 ,1 "
bitfld.long 0 4. " K_RST_STATUS4 "  "0 ,1 "
bitfld.long 0 5. " K_RST_STATUS5 "  "0 ,1 "
bitfld.long 0 6. " K_RST_STATUS6 "  "0 ,1 "
bitfld.long 0 7. " K_RST_STATUS7 "  "0 ,1 "
bitfld.long 0 8. " K_RST_STATUS8 "  "0 ,1 "
bitfld.long 0 9. " K_RST_STATUS9 "  "0 ,1 "
bitfld.long 0 10. " K_RST_STATUS10 "  "0 ,1 "
bitfld.long 0 11. " K_RST_STATUS11 "  "0 ,1 "
bitfld.long 0 12. " K_RST_STATUS12 "  "0 ,1 "
bitfld.long 0 13. " K_RST_STATUS13 "  "0 ,1 "
;tree.end

;tree "PRCCPeriphID0"
base ad:0x8012ffe0
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PRCCPeriphID1"
base ad:0x8012ffe4
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCCPeriphID2"
base ad:0x8012ffe8
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCCPeriphID3"
base ad:0x8012ffec
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PRCCPCellID0"
base ad:0x8012fff0
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

;tree "PRCCPCellID1"
base ad:0x8012fff4
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

;tree "PRCCPCellID2"
base ad:0x8012fff8
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

;tree "PRCCPCellID3"
base ad:0x8012fffc
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "CLK_RST2"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "PRCC_PCKEN"
base ad:0x8011f000
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERCKEN8 "  "0 ,1 "
bitfld.long 0 9. " PERCKEN9 "  "0 ,1 "
bitfld.long 0 10. " PERCKEN10 "  "0 ,1 "
bitfld.long 0 11. " PERCKEN11 "  "0 ,1 "
;tree.end

;tree "PRCC_PCKDIS"
base ad:0x8011f004
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERCKDIS8 "  "0 ,1 "
bitfld.long 0 9. " PERCKDIS9 "  "0 ,1 "
bitfld.long 0 10. " PERCKDIS10 "  "0 ,1 "
bitfld.long 0 11. " PERCKDIS11 "  "0 ,1 "
;tree.end

;tree "PRCC_KCKEN"
base ad:0x8011f008
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKEN7 "  "0 ,1 "
;tree.end

;tree "PRCC_KCKDIS"
base ad:0x8011f00c
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKDIS7 "  "0 ,1 "
;tree.end

;tree "PRCC_PCKSR"
base ad:0x8011f010
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERCKSR8 "  "0 ,1 "
bitfld.long 0 9. " PERCKSR9 "  "0 ,1 "
bitfld.long 0 10. " PERCKSR10 "  "0 ,1 "
bitfld.long 0 11. " PERCKSR11 "  "0 ,1 "
;tree.end

;tree "PRCC_PKCKSR"
base ad:0x8011f014
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKSR7 "  "0 ,1 "
;tree.end

;tree "PRCC_K_SOFTRST_SET"
base ad:0x8011f018
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 0. " K_SOFTRST_SET0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTRST_SET1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_SET2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_SET3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_SET4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_SET5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_SET6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_SET7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTRST_SET8 "  "0 ,1 "
bitfld.long 0 9. " K_SOFTRST_SET9 "  "0 ,1 "
bitfld.long 0 10. " K_SOFTRST_SET10 "  "0 ,1 "
;tree.end

;tree "PRCC_K_SOFTRST_CLR"
base ad:0x8011f01c
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 0. " K_SOFTRST_CLR0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTRST_CLR1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_CLR2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_CLR3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_CLR4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_CLR5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_CLR6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_CLR7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTRST_CLR8 "  "0 ,1 "
bitfld.long 0 9. " K_SOFTRST_CLR9 "  "0 ,1 "
bitfld.long 0 10. " K_SOFTRST_CLR10 "  "0 ,1 "
;tree.end

;tree "PRCC_K_RST_STATUS"
base ad:0x8011f020
group 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 0. " K_RST_STATUS0 "  "0 ,1 "
bitfld.long 0 1. " K_RST_STATUS1 "  "0 ,1 "
bitfld.long 0 2. " K_RST_STATUS2 "  "0 ,1 "
bitfld.long 0 3. " K_RST_STATUS3 "  "0 ,1 "
bitfld.long 0 4. " K_RST_STATUS4 "  "0 ,1 "
bitfld.long 0 5. " K_RST_STATUS5 "  "0 ,1 "
bitfld.long 0 6. " K_RST_STATUS6 "  "0 ,1 "
bitfld.long 0 7. " K_RST_STATUS7 "  "0 ,1 "
bitfld.long 0 8. " K_RST_STATUS8 "  "0 ,1 "
;tree.end

;tree "PRCCPeriphID0"
base ad:0x8011ffe0
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PRCCPeriphID1"
base ad:0x8011ffe4
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCCPeriphID2"
base ad:0x8011ffe8
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCCPeriphID3"
base ad:0x8011ffec
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PRCCPCellID0"
base ad:0x8011fff0
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

;tree "PRCCPCellID1"
base ad:0x8011fff4
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

;tree "PRCCPCellID2"
base ad:0x8011fff8
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

;tree "PRCCPCellID3"
base ad:0x8011fffc
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "CLK_RST3"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "PRCC_PCKEN"
base ad:0x8000f000
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERCKEN8 "  "0 ,1 "
;tree.end

;tree "PRCC_PCKDIS"
base ad:0x8000f004
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERCKDIS8 "  "0 ,1 "
;tree.end

;tree "PRCC_KCKEN"
base ad:0x8000f008
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKEN7 "  "0 ,1 "
;tree.end

;tree "PRCC_KCKDIS"
base ad:0x8000f00c
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKDIS7 "  "0 ,1 "
;tree.end

;tree "PRCC_PCKSR"
base ad:0x8000f010
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERCKSR8 "  "0 ,1 "
;tree.end

;tree "PRCC_PKCKSR"
base ad:0x8000f014
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKSR7 "  "0 ,1 "
;tree.end

;tree "PRCC_K_SOFTRST_SET"
base ad:0x8000f018
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 1. " K_SOFTRST_SET1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_SET2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_SET3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_SET4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_SET5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_SET6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_SET7 "  "0 ,1 "
;tree.end

;tree "PRCC_K_SOFTRST_CLR"
base ad:0x8000f01c
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 1. " K_SOFTRST_CLR1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_CLR2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_CLR3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_CLR4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_CLR5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_CLR6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_CLR7 "  "0 ,1 "
;tree.end

;tree "PRCC_K_RST_STATUS"
base ad:0x8000f020
group 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 1. " K_RST_STATUS1 "  "0 ,1 "
bitfld.long 0 2. " K_RST_STATUS2 "  "0 ,1 "
bitfld.long 0 3. " K_RST_STATUS3 "  "0 ,1 "
bitfld.long 0 4. " K_RST_STATUS4 "  "0 ,1 "
bitfld.long 0 5. " K_RST_STATUS5 "  "0 ,1 "
bitfld.long 0 6. " K_RST_STATUS6 "  "0 ,1 "
bitfld.long 0 7. " K_RST_STATUS7 "  "0 ,1 "
;tree.end

;tree "PRCCPeriphID0"
base ad:0x8000ffe0
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PRCCPeriphID1"
base ad:0x8000ffe4
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCCPeriphID2"
base ad:0x8000ffe8
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCCPeriphID3"
base ad:0x8000ffec
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PRCCPCellID0"
base ad:0x8000fff0
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

;tree "PRCCPCellID1"
base ad:0x8000fff4
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

;tree "PRCCPCellID2"
base ad:0x8000fff8
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

;tree "PRCCPCellID3"
base ad:0x8000fffc
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "CLK_RST5"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "PRCC_PCKEN"
base ad:0xa03ff000
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
;tree.end

;tree "PRCC_PCKDIS"
base ad:0xa03ff004
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
;tree.end

;tree "PRCC_PCKSR"
base ad:0xa03ff010
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
;tree.end

;tree "PRCCPeriphID0"
base ad:0xa03fffe0
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PRCCPeriphID1"
base ad:0xa03fffe4
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCCPeriphID2"
base ad:0xa03fffe8
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCCPeriphID3"
base ad:0xa03fffec
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PRCCPCellID0"
base ad:0xa03ffff0
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

;tree "PRCCPCellID1"
base ad:0xa03ffff4
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

;tree "PRCCPCellID2"
base ad:0xa03ffff8
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

;tree "PRCCPCellID3"
base ad:0xa03ffffc
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "CLK_RST6"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "PRCC_PCKEN"
base ad:0xa03cf000
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
;tree.end

;tree "PRCC_PCKDIS"
base ad:0xa03cf004
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
;tree.end

;tree "PRCC_KCKEN"
base ad:0xa03cf008
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
;tree.end

;tree "PRCC_KCKDIS"
base ad:0xa03cf00c
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
;tree.end

;tree "PRCC_PCKSR"
base ad:0xa03cf010
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
;tree.end

;tree "PRCC_PKCKSR"
base ad:0xa03cf014
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
;tree.end

;tree "PRCC_K_SOFTRST_SET"
base ad:0xa03cf018
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 0. " K_SOFTRST_SET0 "  "0 ,1 "
;tree.end

;tree "PRCC_K_SOFTRST_CLR"
base ad:0xa03cf01c
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 0. " K_SOFTRST_CLR0 "  "0 ,1 "
;tree.end

;tree "PRCC_K_RST_STATUS"
base ad:0xa03cf020
group 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 0. " K_RST_STATUS0 "  "0 ,1 "
;tree.end

;tree "PRCCPeriphID0"
base ad:0xa03cffe0
rgroup 0--3
line.long 0 "PRCCPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PRCCPeriphID1"
base ad:0xa03cffe4
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCCPeriphID2"
base ad:0xa03cffe8
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCCPeriphID3"
base ad:0xa03cffec
rgroup 0--3
line.long 0 "PRCCPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PRCCPCellID0"
base ad:0xa03cfff0
rgroup 0--3
line.long 0 "PRCCPCellID0"
hexfld.byte 0 " PRCCPCellID0 "
;tree.end

;tree "PRCCPCellID1"
base ad:0xa03cfff4
rgroup 0--3
line.long 0 "PRCCPCellID1"
hexfld.byte 0 " PRCCPCellID1 "
;tree.end

;tree "PRCCPCellID2"
base ad:0xa03cfff8
rgroup 0--3
line.long 0 "PRCCPCellID2"
hexfld.byte 0 " PRCCPCellID2 "
;tree.end

;tree "PRCCPCellID3"
base ad:0xa03cfffc
rgroup 0--3
line.long 0 "PRCCPCellID3"
hexfld.byte 0 " PRCCPCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "CPUTW"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CPUTW_TLR"
base ad:0xa0410600
group 0--3
line.long 0 "CPUTW_TLR"
hexfld.long 0 " TLD "
;tree.end

;tree "CPUTW_TCOUNTERR"
base ad:0xa0410604
group 0--3
line.long 0 "CPUTW_TCOUNTERR"
hexfld.long 0 " TCD "
;tree.end

;tree "CPUTW_TCONTROLR"
base ad:0xa0410608
group 0--3
line.long 0 "CPUTW_TCONTROLR"
bitfld.long 0 0. " CPUTWTCONTROLRTE "  "0 ,1 "
bitfld.long 0 1. " CPUTWTCONTROLRAR "  "0 ,1 "
bitfld.long 0 2. " CPUTWTCONTROLRITE "  "0 ,1 "
hexfld.byte 1 " CPUTWTCONTROLRPRESCALER "
;tree.end

;tree "CPUTW_TISR"
base ad:0xa041060c
group 0--3
line.long 0 "CPUTW_TISR"
bitfld.long 0 0. " CPUTWTISREF "  "0 ,1 "
;tree.end

;tree "CPUTW_WLR"
base ad:0xa0410620
group 0--3
line.long 0 "CPUTW_WLR"
hexfld.long 0 " WLD "
;tree.end

;tree "CPUTW_WCOUNTERR"
base ad:0xa0410624
group 0--3
line.long 0 "CPUTW_WCOUNTERR"
hexfld.long 0 " WCD "
;tree.end

;tree "CPUTW_WCONTROLR"
base ad:0xa0410628
group 0--3
line.long 0 "CPUTW_WCONTROLR"
bitfld.long 0 0. " CPUTWWCONTROLRWE "  "0 ,1 "
bitfld.long 0 1. " CPUTWWCONTROLRAR "  "0 ,1 "
bitfld.long 0 2. " CPUTWWCONTROLRITE "  "0 ,1 "
bitfld.long 0 3. " CPUTWWCONTROLRWDM "  "0 ,1 "
hexfld.byte 1 " CPUTWTCONTROLRPRESCALER "
;tree.end

;tree "CPUTW_WISR"
base ad:0xa041062c
group 0--3
line.long 0 "CPUTW_WISR"
bitfld.long 0 0. " CPUTWWISREF "  "0 ,1 "
;tree.end

;tree "CPUTW_WRSR"
base ad:0xa0410630
group 0--3
line.long 0 "CPUTW_WRSR"
bitfld.long 0 0. " CPUTWWRSRRF "  "0 ,1 "
;tree.end

;tree "CPUTW_WDR"
base ad:0xa0410634
wgroup 0--3
line.long 0 "CPUTW_WDR"
hexfld.long 0 " WDD "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "CR"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CR_REG0"
base ad:0xa03c8000
group 0--3
line.long 0 "CR_REG0"
bitfld.long 0 0.--2. " VPIPWM8MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " MSP0WR "  "0 ,1 "
bitfld.long 0 4.--6. " SPARE0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7. " MSSINTMSK "  "0 ,1 "
bitfld.long 0 8.--12. " MDMTPDATSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " MDMTPCTL "  "0 ,1 "
bitfld.long 0 16. " SXAGPIO "  "0 ,1 "
bitfld.long 0 18.--21. " SBAGD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 22.--25. " SBAGT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 26. " HTIMEN "  "0 ,1 "
bitfld.long 0 28.--31. " MSSHOSTADDROFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CR_REG1"
base ad:0xa03c8004
group 0--3
line.long 0 "CR_REG1"
bitfld.long 0 0. " ICN_DEC_ERROR_ITMASK "  "0 ,1 "
bitfld.long 0 1. " ICN_DEC_ERROR_ITCLR "  "0 ,1 "
bitfld.long 0 10. " PRODTESTUICC_DP_OUT "  "0 ,1 "
bitfld.long 0 11. " PRODTESTUICC_DM_OUT "  "0 ,1 "
bitfld.long 0 12. " PRODTESTUICC_IOCTRL_OUT "  "0 ,1 "
bitfld.long 0 15. " MSP4ACTIVE "  "0 ,1 "
hexfld.word 2 " SPARE "
;tree.end

;tree "CR_REG2"
base ad:0xa03c8008
group 0--3
line.long 0 "CR_REG2"
bitfld.long 0 0.--3. " KPSKA0MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " KPSKA1MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " KPSKA2MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " KPSKB0MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " KPSKB1MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " KPSKB2MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " KP08MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 27.--29. " KP09MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "CR_REG3"
base ad:0xa03c800c
group 0--3
line.long 0 "CR_REG3"
bitfld.long 0 0.--1. " SVADMACH0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " SVADMACH1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--8. " SVADMACH2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 9.--13. " SVADMACH3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 14. " SVASMSP2SLIMINT "  "0 ,1 "
bitfld.long 0 16.--17. " SIADMACH0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " SIADMACH1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--24. " SIADMACH2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--29. " SIADMACH3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 30. " SIASMSP2SLIMINT "  "0 ,1 "
bitfld.long 0 31. " FSMCFBCLK "  "0 ,1 "
;tree.end

;tree "CR_REG5"
base ad:0xa03c8014
group 0--3
line.long 0 "CR_REG5"
bitfld.long 0 0.--9. " HSISLIM0RX "  " "
bitfld.long 0 10.--19. " HSISLIM0TX "  " "
bitfld.long 0 30. " MSP0SLIM0RX "  "0 ,1 "
bitfld.long 0 31. " MSP0SLIM0TX "  "0 ,1 "
;tree.end

;tree "SLIM_CFG"
base ad:0xa03c8018
group 0--3
line.long 0 "SLIM_CFG"
bitfld.long 0 0.--1. " CLK_LOADREG "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " CLK_BUSKEEP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--8. " CLK_VSAFEBUSKEEP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 9. " CLK_SLIMBUSMODE "  "0 ,1 "
bitfld.long 0 10.--11. " DATA_LOADREG "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " DATA_BUSKEEP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 15.--18. " DATA_VSAFEBUSKEEP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 19. " DATA_SLIMBUSMODE "  "0 ,1 "
bitfld.long 0 20.--26. " CALREQUEST "  " "
;tree.end

;tree "MCSBAG_CLKEN_CR"
base ad:0xa03c801c
group 0--3
line.long 0 "MCSBAG_CLKEN_CR"
bitfld.long 0 0. " PI_CLKGATE_EN "  "0 ,1 "
bitfld.long 0 1. " WPS_CLKGATE_EN "  "0 ,1 "
bitfld.long 0 2.--15. " TMS_CLKGATE_EN "  " "
;tree.end

;tree "CR_XDBG"
base ad:0xa03c8020
group 0--3
line.long 0 "CR_XDBG"
bitfld.long 0 0. " XDBGEN "  "0 ,1 "
bitfld.long 0 1. " EXTBRKEn "  "0 ,1 "
bitfld.long 0 2.--3. " XDBGMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--11. " XDBGSRC "  " "
bitfld.long 0 12.--19. " XDBGSTA "  " "
;tree.end

;tree "CR_XDBG_BRKINEN"
base ad:0xa03c8024
group 0--3
line.long 0 "CR_XDBG_BRKINEN"
hexfld.byte 0 " BRKINEN "
;tree.end

;tree "MCSBAG_CLKEN_TMS_STATUS"
base ad:0xa03c8028
rgroup 0--3
line.long 0 "MCSBAG_CLKEN_TMS_STATUS"
bitfld.long 0 0.--13. " CLKEN_TMS_STATUS "  " "
;tree.end

;tree "CR_USB"
base ad:0xa03c802c
group 0--3
line.long 0 "CR_USB"
bitfld.long 0 0. " XGATE "  "0 ,1 "
;tree.end

;tree "CR_REG6"
base ad:0xa03c8030
group 0--3
line.long 0 "CR_REG6"
bitfld.long 0 0. " SBAG_MUX_SIA_M "  "0 ,1 "
bitfld.long 0 1. " SBAG_MUX_SIA_DMAO "  "0 ,1 "
bitfld.long 0 2.--3. " SBAG_MUX_SVA_DMAE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " SBAG_MUX_SVA_DMAO "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " SBAG_MUX_DISPLAY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8. " SBAG_MUX_DMA1 "  "0 ,1 "
;tree.end

;tree "CRPeriphID0"
base ad:0xa03c8fe0
rgroup 0--3
line.long 0 "CRPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "CRPeriphID1"
base ad:0xa03c8fe4
rgroup 0--3
line.long 0 "CRPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CRPeriphID2"
base ad:0xa03c8fe8
rgroup 0--3
line.long 0 "CRPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CRPeriphID3"
base ad:0xa03c8fec
rgroup 0--3
line.long 0 "CRPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "CRPCellID0"
base ad:0xa03c8ff0
rgroup 0--3
line.long 0 "CRPCellID0"
hexfld.byte 0 " CRPCellID0 "
;tree.end

;tree "CRPCellID1"
base ad:0xa03c8ff4
rgroup 0--3
line.long 0 "CRPCellID1"
hexfld.byte 0 " CRPCellID1 "
;tree.end

;tree "CRPCellID2"
base ad:0xa03c8ff8
rgroup 0--3
line.long 0 "CRPCellID2"
hexfld.byte 0 " CRPCellID2 "
;tree.end

;tree "CRPCellID3"
base ad:0xa03c8ffc
rgroup 0--3
line.long 0 "CRPCellID3"
hexfld.byte 0 " CRPCellID3 "
;tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "CRYP (2 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "CRYP-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0CR"
base ad:0xa03ca000
group 0--3
line.long 0 "CR"
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGODIR "  "0 ,1 "
bitfld.long 0 3.--5. " ALGOMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--7. " DATATYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " KEYSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " KEYRDEN "  "0 ,1 "
bitfld.long 0 11. " KSE "  "0 ,1 "
bitfld.long 0 12. " START "  "0 ,1 "
bitfld.long 0 13. " INIT "  "0 ,1 "
bitfld.long 0 14. " FFLUSH "  "0 ,1 "
bitfld.long 0 15. " CRYPEN "  "0 ,1 "
bitfld.long 0 16. " SECONDLAST "  "0 ,1 "
bitfld.long 0 20. " ENS "  "0 ,1 "
bitfld.long 0 24. " KEYLOCK "  "0 ,1 "
;tree.end

;tree "0SR"
base ad:0xa03ca004
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " IFEM "  "0 ,1 "
bitfld.long 0 1. " IFNF "  "0 ,1 "
bitfld.long 0 2. " OFNE "  "0 ,1 "
bitfld.long 0 3. " OFFU "  "0 ,1 "
bitfld.long 0 4. " BUSY "  "0 ,1 "
;tree.end

;tree "0DIN"
base ad:0xa03ca008
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
;tree.end

;tree "0DINSIZE"
base ad:0xa03ca00c
group 0--3
line.long 0 "DINSIZE"
bitfld.long 0 0.--3. " DINSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0DOUT"
base ad:0xa03ca010
rgroup 0--3
line.long 0 "DOUT"
hexfld.long 0 " DATA "
;tree.end

;tree "0DOUTSIZE"
base ad:0xa03ca014
rgroup 0--3
line.long 0 "DOUTSIZE"
bitfld.long 0 0.--3. " DOUTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0DMACR"
base ad:0xa03ca018
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " DMAINEN "  "0 ,1 "
bitfld.long 0 1. " DMAOUTEN "  "0 ,1 "
;tree.end

;tree "0IMSC"
base ad:0xa03ca01c
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " INIM "  "0 ,1 "
bitfld.long 0 1. " OUTIM "  "0 ,1 "
;tree.end

;tree "0RIS"
base ad:0xa03ca020
group 0--3
line.long 0 "RIS"
bitfld.long 0 0. " INRIS "  "0 ,1 "
bitfld.long 0 1. " OUTRIS "  "0 ,1 "
;tree.end

;tree "0MIS"
base ad:0xa03ca024
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " INMIS "  "0 ,1 "
bitfld.long 0 1. " OUTMIS "  "0 ,1 "
;tree.end

;tree "0K1L"
base ad:0xa03ca028
group 0--3
line.long 0 "K1L"
bitfld.long 0 0. " K31 "  "0 ,1 "
bitfld.long 0 1. " K30 "  "0 ,1 "
bitfld.long 0 2. " K29 "  "0 ,1 "
bitfld.long 0 3. " K28 "  "0 ,1 "
bitfld.long 0 4. " K27 "  "0 ,1 "
bitfld.long 0 5. " K26 "  "0 ,1 "
bitfld.long 0 6. " K25 "  "0 ,1 "
bitfld.long 0 7. " K24 "  "0 ,1 "
bitfld.long 0 8. " K23 "  "0 ,1 "
bitfld.long 0 9. " K22 "  "0 ,1 "
bitfld.long 0 10. " K21 "  "0 ,1 "
bitfld.long 0 11. " K20 "  "0 ,1 "
bitfld.long 0 12. " K19 "  "0 ,1 "
bitfld.long 0 13. " K18 "  "0 ,1 "
bitfld.long 0 14. " K17 "  "0 ,1 "
bitfld.long 0 15. " K16 "  "0 ,1 "
bitfld.long 0 16. " K15 "  "0 ,1 "
bitfld.long 0 17. " K14 "  "0 ,1 "
bitfld.long 0 18. " K13 "  "0 ,1 "
bitfld.long 0 19. " K12 "  "0 ,1 "
bitfld.long 0 20. " K11 "  "0 ,1 "
bitfld.long 0 21. " K10 "  "0 ,1 "
bitfld.long 0 22. " K9 "  "0 ,1 "
bitfld.long 0 23. " K8 "  "0 ,1 "
bitfld.long 0 24. " K7 "  "0 ,1 "
bitfld.long 0 25. " K6 "  "0 ,1 "
bitfld.long 0 26. " K5 "  "0 ,1 "
bitfld.long 0 27. " K4 "  "0 ,1 "
bitfld.long 0 28. " K3 "  "0 ,1 "
bitfld.long 0 29. " K2 "  "0 ,1 "
bitfld.long 0 30. " K1 "  "0 ,1 "
bitfld.long 0 31. " K0 "  "0 ,1 "
;tree.end

;tree "0K1R"
base ad:0xa03ca02c
group 0--3
line.long 0 "K1R"
bitfld.long 0 0. " K63 "  "0 ,1 "
bitfld.long 0 1. " K62 "  "0 ,1 "
bitfld.long 0 2. " K61 "  "0 ,1 "
bitfld.long 0 3. " K60 "  "0 ,1 "
bitfld.long 0 4. " K59 "  "0 ,1 "
bitfld.long 0 5. " K58 "  "0 ,1 "
bitfld.long 0 6. " K57 "  "0 ,1 "
bitfld.long 0 7. " K56 "  "0 ,1 "
bitfld.long 0 8. " K55 "  "0 ,1 "
bitfld.long 0 9. " K54 "  "0 ,1 "
bitfld.long 0 10. " K53 "  "0 ,1 "
bitfld.long 0 11. " K52 "  "0 ,1 "
bitfld.long 0 12. " K51 "  "0 ,1 "
bitfld.long 0 13. " K50 "  "0 ,1 "
bitfld.long 0 14. " K49 "  "0 ,1 "
bitfld.long 0 15. " K48 "  "0 ,1 "
bitfld.long 0 16. " K47 "  "0 ,1 "
bitfld.long 0 17. " K46 "  "0 ,1 "
bitfld.long 0 18. " K45 "  "0 ,1 "
bitfld.long 0 19. " K44 "  "0 ,1 "
bitfld.long 0 20. " K43 "  "0 ,1 "
bitfld.long 0 21. " K42 "  "0 ,1 "
bitfld.long 0 22. " K41 "  "0 ,1 "
bitfld.long 0 23. " K40 "  "0 ,1 "
bitfld.long 0 24. " K39 "  "0 ,1 "
bitfld.long 0 25. " K38 "  "0 ,1 "
bitfld.long 0 26. " K37 "  "0 ,1 "
bitfld.long 0 27. " K36 "  "0 ,1 "
bitfld.long 0 28. " K35 "  "0 ,1 "
bitfld.long 0 29. " K34 "  "0 ,1 "
bitfld.long 0 30. " K33 "  "0 ,1 "
bitfld.long 0 31. " K32 "  "0 ,1 "
;tree.end

;tree "0K2L"
base ad:0xa03ca030
group 0--3
line.long 0 "K2L"
bitfld.long 0 0. " K95 "  "0 ,1 "
bitfld.long 0 1. " K94 "  "0 ,1 "
bitfld.long 0 2. " K93 "  "0 ,1 "
bitfld.long 0 3. " K92 "  "0 ,1 "
bitfld.long 0 4. " K91 "  "0 ,1 "
bitfld.long 0 5. " K90 "  "0 ,1 "
bitfld.long 0 6. " K89 "  "0 ,1 "
bitfld.long 0 7. " K88 "  "0 ,1 "
bitfld.long 0 8. " K87 "  "0 ,1 "
bitfld.long 0 9. " K86 "  "0 ,1 "
bitfld.long 0 10. " K85 "  "0 ,1 "
bitfld.long 0 11. " K84 "  "0 ,1 "
bitfld.long 0 12. " K83 "  "0 ,1 "
bitfld.long 0 13. " K82 "  "0 ,1 "
bitfld.long 0 14. " K81 "  "0 ,1 "
bitfld.long 0 15. " K80 "  "0 ,1 "
bitfld.long 0 16. " K79 "  "0 ,1 "
bitfld.long 0 17. " K78 "  "0 ,1 "
bitfld.long 0 18. " K77 "  "0 ,1 "
bitfld.long 0 19. " K76 "  "0 ,1 "
bitfld.long 0 20. " K75 "  "0 ,1 "
bitfld.long 0 21. " K74 "  "0 ,1 "
bitfld.long 0 22. " K73 "  "0 ,1 "
bitfld.long 0 23. " K72 "  "0 ,1 "
bitfld.long 0 24. " K71 "  "0 ,1 "
bitfld.long 0 25. " K70 "  "0 ,1 "
bitfld.long 0 26. " K69 "  "0 ,1 "
bitfld.long 0 27. " K68 "  "0 ,1 "
bitfld.long 0 28. " K67 "  "0 ,1 "
bitfld.long 0 29. " K66 "  "0 ,1 "
bitfld.long 0 30. " K65 "  "0 ,1 "
bitfld.long 0 31. " K64 "  "0 ,1 "
;tree.end

;tree "0K2R"
base ad:0xa03ca034
group 0--3
line.long 0 "K2R"
bitfld.long 0 0. " K127 "  "0 ,1 "
bitfld.long 0 1. " K126 "  "0 ,1 "
bitfld.long 0 2. " K125 "  "0 ,1 "
bitfld.long 0 3. " K124 "  "0 ,1 "
bitfld.long 0 4. " K123 "  "0 ,1 "
bitfld.long 0 5. " K122 "  "0 ,1 "
bitfld.long 0 6. " K121 "  "0 ,1 "
bitfld.long 0 7. " K120 "  "0 ,1 "
bitfld.long 0 8. " K119 "  "0 ,1 "
bitfld.long 0 9. " K118 "  "0 ,1 "
bitfld.long 0 10. " K117 "  "0 ,1 "
bitfld.long 0 11. " K116 "  "0 ,1 "
bitfld.long 0 12. " K115 "  "0 ,1 "
bitfld.long 0 13. " K114 "  "0 ,1 "
bitfld.long 0 14. " K113 "  "0 ,1 "
bitfld.long 0 15. " K112 "  "0 ,1 "
bitfld.long 0 16. " K111 "  "0 ,1 "
bitfld.long 0 17. " K110 "  "0 ,1 "
bitfld.long 0 18. " K109 "  "0 ,1 "
bitfld.long 0 19. " K108 "  "0 ,1 "
bitfld.long 0 20. " K107 "  "0 ,1 "
bitfld.long 0 21. " K106 "  "0 ,1 "
bitfld.long 0 22. " K105 "  "0 ,1 "
bitfld.long 0 23. " K104 "  "0 ,1 "
bitfld.long 0 24. " K103 "  "0 ,1 "
bitfld.long 0 25. " K102 "  "0 ,1 "
bitfld.long 0 26. " K101 "  "0 ,1 "
bitfld.long 0 27. " K100 "  "0 ,1 "
bitfld.long 0 28. " K99 "  "0 ,1 "
bitfld.long 0 29. " K98 "  "0 ,1 "
bitfld.long 0 30. " K97 "  "0 ,1 "
bitfld.long 0 31. " K96 "  "0 ,1 "
;tree.end

;tree "0K3L"
base ad:0xa03ca038
group 0--3
line.long 0 "K3L"
bitfld.long 0 0. " K159 "  "0 ,1 "
bitfld.long 0 1. " K158 "  "0 ,1 "
bitfld.long 0 2. " K157 "  "0 ,1 "
bitfld.long 0 3. " K156 "  "0 ,1 "
bitfld.long 0 4. " K155 "  "0 ,1 "
bitfld.long 0 5. " K154 "  "0 ,1 "
bitfld.long 0 6. " K153 "  "0 ,1 "
bitfld.long 0 7. " K152 "  "0 ,1 "
bitfld.long 0 8. " K151 "  "0 ,1 "
bitfld.long 0 9. " K150 "  "0 ,1 "
bitfld.long 0 10. " K149 "  "0 ,1 "
bitfld.long 0 11. " K148 "  "0 ,1 "
bitfld.long 0 12. " K147 "  "0 ,1 "
bitfld.long 0 13. " K146 "  "0 ,1 "
bitfld.long 0 14. " K145 "  "0 ,1 "
bitfld.long 0 15. " K144 "  "0 ,1 "
bitfld.long 0 16. " K143 "  "0 ,1 "
bitfld.long 0 17. " K142 "  "0 ,1 "
bitfld.long 0 18. " K141 "  "0 ,1 "
bitfld.long 0 19. " K140 "  "0 ,1 "
bitfld.long 0 20. " K139 "  "0 ,1 "
bitfld.long 0 21. " K138 "  "0 ,1 "
bitfld.long 0 22. " K137 "  "0 ,1 "
bitfld.long 0 23. " K136 "  "0 ,1 "
bitfld.long 0 24. " K135 "  "0 ,1 "
bitfld.long 0 25. " K134 "  "0 ,1 "
bitfld.long 0 26. " K133 "  "0 ,1 "
bitfld.long 0 27. " K132 "  "0 ,1 "
bitfld.long 0 28. " K131 "  "0 ,1 "
bitfld.long 0 29. " K130 "  "0 ,1 "
bitfld.long 0 30. " K129 "  "0 ,1 "
bitfld.long 0 31. " K128 "  "0 ,1 "
;tree.end

;tree "0K3R"
base ad:0xa03ca03c
group 0--3
line.long 0 "K3R"
bitfld.long 0 0. " K191 "  "0 ,1 "
bitfld.long 0 1. " K190 "  "0 ,1 "
bitfld.long 0 2. " K189 "  "0 ,1 "
bitfld.long 0 3. " K188 "  "0 ,1 "
bitfld.long 0 4. " K187 "  "0 ,1 "
bitfld.long 0 5. " K186 "  "0 ,1 "
bitfld.long 0 6. " K185 "  "0 ,1 "
bitfld.long 0 7. " K184 "  "0 ,1 "
bitfld.long 0 8. " K183 "  "0 ,1 "
bitfld.long 0 9. " K182 "  "0 ,1 "
bitfld.long 0 10. " K181 "  "0 ,1 "
bitfld.long 0 11. " K180 "  "0 ,1 "
bitfld.long 0 12. " K179 "  "0 ,1 "
bitfld.long 0 13. " K178 "  "0 ,1 "
bitfld.long 0 14. " K177 "  "0 ,1 "
bitfld.long 0 15. " K176 "  "0 ,1 "
bitfld.long 0 16. " K175 "  "0 ,1 "
bitfld.long 0 17. " K174 "  "0 ,1 "
bitfld.long 0 18. " K173 "  "0 ,1 "
bitfld.long 0 19. " K172 "  "0 ,1 "
bitfld.long 0 20. " K171 "  "0 ,1 "
bitfld.long 0 21. " K170 "  "0 ,1 "
bitfld.long 0 22. " K169 "  "0 ,1 "
bitfld.long 0 23. " K168 "  "0 ,1 "
bitfld.long 0 24. " K167 "  "0 ,1 "
bitfld.long 0 25. " K166 "  "0 ,1 "
bitfld.long 0 26. " K165 "  "0 ,1 "
bitfld.long 0 27. " K164 "  "0 ,1 "
bitfld.long 0 28. " K163 "  "0 ,1 "
bitfld.long 0 29. " K162 "  "0 ,1 "
bitfld.long 0 30. " K161 "  "0 ,1 "
bitfld.long 0 31. " K160 "  "0 ,1 "
;tree.end

;tree "0K4L"
base ad:0xa03ca040
group 0--3
line.long 0 "K4L"
bitfld.long 0 0. " K223 "  "0 ,1 "
bitfld.long 0 1. " K222 "  "0 ,1 "
bitfld.long 0 2. " K221 "  "0 ,1 "
bitfld.long 0 3. " K220 "  "0 ,1 "
bitfld.long 0 4. " K219 "  "0 ,1 "
bitfld.long 0 5. " K218 "  "0 ,1 "
bitfld.long 0 6. " K217 "  "0 ,1 "
bitfld.long 0 7. " K216 "  "0 ,1 "
bitfld.long 0 8. " K215 "  "0 ,1 "
bitfld.long 0 9. " K214 "  "0 ,1 "
bitfld.long 0 10. " K213 "  "0 ,1 "
bitfld.long 0 11. " K212 "  "0 ,1 "
bitfld.long 0 12. " K211 "  "0 ,1 "
bitfld.long 0 13. " K210 "  "0 ,1 "
bitfld.long 0 14. " K209 "  "0 ,1 "
bitfld.long 0 15. " K208 "  "0 ,1 "
bitfld.long 0 16. " K207 "  "0 ,1 "
bitfld.long 0 17. " K206 "  "0 ,1 "
bitfld.long 0 18. " K205 "  "0 ,1 "
bitfld.long 0 19. " K204 "  "0 ,1 "
bitfld.long 0 20. " K203 "  "0 ,1 "
bitfld.long 0 21. " K202 "  "0 ,1 "
bitfld.long 0 22. " K201 "  "0 ,1 "
bitfld.long 0 23. " K200 "  "0 ,1 "
bitfld.long 0 24. " K199 "  "0 ,1 "
bitfld.long 0 25. " K198 "  "0 ,1 "
bitfld.long 0 26. " K197 "  "0 ,1 "
bitfld.long 0 27. " K196 "  "0 ,1 "
bitfld.long 0 28. " K195 "  "0 ,1 "
bitfld.long 0 29. " K194 "  "0 ,1 "
bitfld.long 0 30. " K193 "  "0 ,1 "
bitfld.long 0 31. " K192 "  "0 ,1 "
;tree.end

;tree "0K4R"
base ad:0xa03ca044
group 0--3
line.long 0 "K4R"
bitfld.long 0 0. " K255 "  "0 ,1 "
bitfld.long 0 1. " K254 "  "0 ,1 "
bitfld.long 0 2. " K253 "  "0 ,1 "
bitfld.long 0 3. " K252 "  "0 ,1 "
bitfld.long 0 4. " K251 "  "0 ,1 "
bitfld.long 0 5. " K250 "  "0 ,1 "
bitfld.long 0 6. " K249 "  "0 ,1 "
bitfld.long 0 7. " K248 "  "0 ,1 "
bitfld.long 0 8. " K247 "  "0 ,1 "
bitfld.long 0 9. " K246 "  "0 ,1 "
bitfld.long 0 10. " K245 "  "0 ,1 "
bitfld.long 0 11. " K244 "  "0 ,1 "
bitfld.long 0 12. " K243 "  "0 ,1 "
bitfld.long 0 13. " K242 "  "0 ,1 "
bitfld.long 0 14. " K241 "  "0 ,1 "
bitfld.long 0 15. " K240 "  "0 ,1 "
bitfld.long 0 16. " K239 "  "0 ,1 "
bitfld.long 0 17. " K238 "  "0 ,1 "
bitfld.long 0 18. " K237 "  "0 ,1 "
bitfld.long 0 19. " K236 "  "0 ,1 "
bitfld.long 0 20. " K235 "  "0 ,1 "
bitfld.long 0 21. " K234 "  "0 ,1 "
bitfld.long 0 22. " K233 "  "0 ,1 "
bitfld.long 0 23. " K232 "  "0 ,1 "
bitfld.long 0 24. " K231 "  "0 ,1 "
bitfld.long 0 25. " K230 "  "0 ,1 "
bitfld.long 0 26. " K229 "  "0 ,1 "
bitfld.long 0 27. " K228 "  "0 ,1 "
bitfld.long 0 28. " K227 "  "0 ,1 "
bitfld.long 0 29. " K226 "  "0 ,1 "
bitfld.long 0 30. " K225 "  "0 ,1 "
bitfld.long 0 31. " K224 "  "0 ,1 "
;tree.end

;tree "0IV0L"
base ad:0xa03ca048
group 0--3
line.long 0 "IV0L"
bitfld.long 0 0. " IV32 "  "0 ,1 "
bitfld.long 0 1. " IV31 "  "0 ,1 "
bitfld.long 0 2. " IV30 "  "0 ,1 "
bitfld.long 0 3. " IV29 "  "0 ,1 "
bitfld.long 0 4. " IV28 "  "0 ,1 "
bitfld.long 0 5. " IV27 "  "0 ,1 "
bitfld.long 0 6. " IV26 "  "0 ,1 "
bitfld.long 0 7. " IV25 "  "0 ,1 "
bitfld.long 0 8. " IV24 "  "0 ,1 "
bitfld.long 0 9. " IV23 "  "0 ,1 "
bitfld.long 0 10. " IV22 "  "0 ,1 "
bitfld.long 0 11. " IV21 "  "0 ,1 "
bitfld.long 0 12. " IV20 "  "0 ,1 "
bitfld.long 0 13. " IV19 "  "0 ,1 "
bitfld.long 0 14. " IV18 "  "0 ,1 "
bitfld.long 0 15. " IV17 "  "0 ,1 "
bitfld.long 0 16. " IV16 "  "0 ,1 "
bitfld.long 0 17. " IV15 "  "0 ,1 "
bitfld.long 0 18. " IV14 "  "0 ,1 "
bitfld.long 0 19. " IV13 "  "0 ,1 "
bitfld.long 0 20. " IV12 "  "0 ,1 "
bitfld.long 0 21. " IV11 "  "0 ,1 "
bitfld.long 0 22. " IV10 "  "0 ,1 "
bitfld.long 0 23. " IV9 "  "0 ,1 "
bitfld.long 0 24. " IV8 "  "0 ,1 "
bitfld.long 0 25. " IV7 "  "0 ,1 "
bitfld.long 0 26. " IV6 "  "0 ,1 "
bitfld.long 0 27. " IV5 "  "0 ,1 "
bitfld.long 0 28. " IV4 "  "0 ,1 "
bitfld.long 0 29. " IV3 "  "0 ,1 "
bitfld.long 0 30. " IV2 "  "0 ,1 "
bitfld.long 0 31. " IV1 "  "0 ,1 "
;tree.end

;tree "0IV0R"
base ad:0xa03ca04c
group 0--3
line.long 0 "IV0R"
bitfld.long 0 0. " IV64 "  "0 ,1 "
bitfld.long 0 1. " IV63 "  "0 ,1 "
bitfld.long 0 2. " IV62 "  "0 ,1 "
bitfld.long 0 3. " IV61 "  "0 ,1 "
bitfld.long 0 4. " IV60 "  "0 ,1 "
bitfld.long 0 5. " IV59 "  "0 ,1 "
bitfld.long 0 6. " IV58 "  "0 ,1 "
bitfld.long 0 7. " IV57 "  "0 ,1 "
bitfld.long 0 8. " IV56 "  "0 ,1 "
bitfld.long 0 9. " IV55 "  "0 ,1 "
bitfld.long 0 10. " IV54 "  "0 ,1 "
bitfld.long 0 11. " IV53 "  "0 ,1 "
bitfld.long 0 12. " IV52 "  "0 ,1 "
bitfld.long 0 13. " IV51 "  "0 ,1 "
bitfld.long 0 14. " IV50 "  "0 ,1 "
bitfld.long 0 15. " IV49 "  "0 ,1 "
bitfld.long 0 16. " IV48 "  "0 ,1 "
bitfld.long 0 17. " IV47 "  "0 ,1 "
bitfld.long 0 18. " IV46 "  "0 ,1 "
bitfld.long 0 19. " IV45 "  "0 ,1 "
bitfld.long 0 20. " IV44 "  "0 ,1 "
bitfld.long 0 21. " IV43 "  "0 ,1 "
bitfld.long 0 22. " IV42 "  "0 ,1 "
bitfld.long 0 23. " IV41 "  "0 ,1 "
bitfld.long 0 24. " IV40 "  "0 ,1 "
bitfld.long 0 25. " IV39 "  "0 ,1 "
bitfld.long 0 26. " IV38 "  "0 ,1 "
bitfld.long 0 27. " IV37 "  "0 ,1 "
bitfld.long 0 28. " IV36 "  "0 ,1 "
bitfld.long 0 29. " IV35 "  "0 ,1 "
bitfld.long 0 30. " IV34 "  "0 ,1 "
bitfld.long 0 31. " IV33 "  "0 ,1 "
;tree.end

;tree "0IV1L"
base ad:0xa03ca050
group 0--3
line.long 0 "IV1L"
bitfld.long 0 0. " IV96 "  "0 ,1 "
bitfld.long 0 1. " IV95 "  "0 ,1 "
bitfld.long 0 2. " IV94 "  "0 ,1 "
bitfld.long 0 3. " IV93 "  "0 ,1 "
bitfld.long 0 4. " IV92 "  "0 ,1 "
bitfld.long 0 5. " IV91 "  "0 ,1 "
bitfld.long 0 6. " IV90 "  "0 ,1 "
bitfld.long 0 7. " IV89 "  "0 ,1 "
bitfld.long 0 8. " IV88 "  "0 ,1 "
bitfld.long 0 9. " IV87 "  "0 ,1 "
bitfld.long 0 10. " IV86 "  "0 ,1 "
bitfld.long 0 11. " IV85 "  "0 ,1 "
bitfld.long 0 12. " IV84 "  "0 ,1 "
bitfld.long 0 13. " IV83 "  "0 ,1 "
bitfld.long 0 14. " IV82 "  "0 ,1 "
bitfld.long 0 15. " IV81 "  "0 ,1 "
bitfld.long 0 16. " IV80 "  "0 ,1 "
bitfld.long 0 17. " IV79 "  "0 ,1 "
bitfld.long 0 18. " IV78 "  "0 ,1 "
bitfld.long 0 19. " IV77 "  "0 ,1 "
bitfld.long 0 20. " IV76 "  "0 ,1 "
bitfld.long 0 21. " IV75 "  "0 ,1 "
bitfld.long 0 22. " IV74 "  "0 ,1 "
bitfld.long 0 23. " IV73 "  "0 ,1 "
bitfld.long 0 24. " IV72 "  "0 ,1 "
bitfld.long 0 25. " IV71 "  "0 ,1 "
bitfld.long 0 26. " IV70 "  "0 ,1 "
bitfld.long 0 27. " IV69 "  "0 ,1 "
bitfld.long 0 28. " IV68 "  "0 ,1 "
bitfld.long 0 29. " IV67 "  "0 ,1 "
bitfld.long 0 30. " IV66 "  "0 ,1 "
bitfld.long 0 31. " IV65 "  "0 ,1 "
;tree.end

;tree "0IV1R"
base ad:0xa03ca054
group 0--3
line.long 0 "IV1R"
bitfld.long 0 0. " IV128 "  "0 ,1 "
bitfld.long 0 1. " IV127 "  "0 ,1 "
bitfld.long 0 2. " IV126 "  "0 ,1 "
bitfld.long 0 3. " IV125 "  "0 ,1 "
bitfld.long 0 4. " IV124 "  "0 ,1 "
bitfld.long 0 5. " IV123 "  "0 ,1 "
bitfld.long 0 6. " IV122 "  "0 ,1 "
bitfld.long 0 7. " IV121 "  "0 ,1 "
bitfld.long 0 8. " IV120 "  "0 ,1 "
bitfld.long 0 9. " IV119 "  "0 ,1 "
bitfld.long 0 10. " IV118 "  "0 ,1 "
bitfld.long 0 11. " IV117 "  "0 ,1 "
bitfld.long 0 12. " IV116 "  "0 ,1 "
bitfld.long 0 13. " IV115 "  "0 ,1 "
bitfld.long 0 14. " IV114 "  "0 ,1 "
bitfld.long 0 15. " IV113 "  "0 ,1 "
bitfld.long 0 16. " IV112 "  "0 ,1 "
bitfld.long 0 17. " IV111 "  "0 ,1 "
bitfld.long 0 18. " IV110 "  "0 ,1 "
bitfld.long 0 19. " IV109 "  "0 ,1 "
bitfld.long 0 20. " IV108 "  "0 ,1 "
bitfld.long 0 21. " IV107 "  "0 ,1 "
bitfld.long 0 22. " IV106 "  "0 ,1 "
bitfld.long 0 23. " IV105 "  "0 ,1 "
bitfld.long 0 24. " IV104 "  "0 ,1 "
bitfld.long 0 25. " IV103 "  "0 ,1 "
bitfld.long 0 26. " IV102 "  "0 ,1 "
bitfld.long 0 27. " IV101 "  "0 ,1 "
bitfld.long 0 28. " IV100 "  "0 ,1 "
bitfld.long 0 29. " IV99 "  "0 ,1 "
bitfld.long 0 30. " IV98 "  "0 ,1 "
bitfld.long 0 31. " IV97 "  "0 ,1 "
;tree.end

;tree "0ITCR"
base ad:0xa03ca080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "0ITIP"
base ad:0xa03ca084
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMAIUTC "  "0 ,1 "
bitfld.long 0 1. " DMAOUTC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
;tree.end

;tree "0ITOP"
base ad:0xa03ca088
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMAINBREQ "  "0 ,1 "
bitfld.long 0 1. " DMAOUTBREQ "  "0 ,1 "
bitfld.long 0 2. " DMAOUTSREQ "  "0 ,1 "
bitfld.long 0 3. " ININTR "  "0 ,1 "
bitfld.long 0 4. " OUTINTR "  "0 ,1 "
;tree.end

;tree "0CRYPPeriphID0"
base ad:0xa03cafe0
rgroup 0--3
line.long 0 "CRYPPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "0CRYPPeriphID1"
base ad:0xa03cafe4
rgroup 0--3
line.long 0 "CRYPPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0CRYPPeriphID2"
base ad:0xa03cafe8
rgroup 0--3
line.long 0 "CRYPPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0CRYPPeriphID3"
base ad:0xa03cafec
rgroup 0--3
line.long 0 "CRYPPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "0CRYPPCellID0"
base ad:0xa03caff0
rgroup 0--3
line.long 0 "CRYPPCellID0"
hexfld.byte 0 " CRYPPCellID0 "
;tree.end

;tree "0CRYPPCellID1"
base ad:0xa03caff4
rgroup 0--3
line.long 0 "CRYPPCellID1"
hexfld.byte 0 " CRYPPCellID1 "
;tree.end

;tree "0CRYPPCellID2"
base ad:0xa03caff8
rgroup 0--3
line.long 0 "CRYPPCellID2"
hexfld.byte 0 " CRYPPCellID2 "
;tree.end

;tree "0CRYPPCellID3"
base ad:0xa03caffc
rgroup 0--3
line.long 0 "CRYPPCellID3"
hexfld.byte 0 " CRYPPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "CRYP-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1CR"
base ad:0xa03cb000
group 0--3
line.long 0 "CR"
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGODIR "  "0 ,1 "
bitfld.long 0 3.--5. " ALGOMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--7. " DATATYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " KEYSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " KEYRDEN "  "0 ,1 "
bitfld.long 0 11. " KSE "  "0 ,1 "
bitfld.long 0 12. " START "  "0 ,1 "
bitfld.long 0 13. " INIT "  "0 ,1 "
bitfld.long 0 14. " FFLUSH "  "0 ,1 "
bitfld.long 0 15. " CRYPEN "  "0 ,1 "
bitfld.long 0 16. " SECONDLAST "  "0 ,1 "
bitfld.long 0 20. " ENS "  "0 ,1 "
bitfld.long 0 24. " KEYLOCK "  "0 ,1 "
;tree.end

;tree "1SR"
base ad:0xa03cb004
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " IFEM "  "0 ,1 "
bitfld.long 0 1. " IFNF "  "0 ,1 "
bitfld.long 0 2. " OFNE "  "0 ,1 "
bitfld.long 0 3. " OFFU "  "0 ,1 "
bitfld.long 0 4. " BUSY "  "0 ,1 "
;tree.end

;tree "1DIN"
base ad:0xa03cb008
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
;tree.end

;tree "1DINSIZE"
base ad:0xa03cb00c
group 0--3
line.long 0 "DINSIZE"
bitfld.long 0 0.--3. " DINSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1DOUT"
base ad:0xa03cb010
rgroup 0--3
line.long 0 "DOUT"
hexfld.long 0 " DATA "
;tree.end

;tree "1DOUTSIZE"
base ad:0xa03cb014
rgroup 0--3
line.long 0 "DOUTSIZE"
bitfld.long 0 0.--3. " DOUTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1DMACR"
base ad:0xa03cb018
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " DMAINEN "  "0 ,1 "
bitfld.long 0 1. " DMAOUTEN "  "0 ,1 "
;tree.end

;tree "1IMSC"
base ad:0xa03cb01c
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " INIM "  "0 ,1 "
bitfld.long 0 1. " OUTIM "  "0 ,1 "
;tree.end

;tree "1RIS"
base ad:0xa03cb020
group 0--3
line.long 0 "RIS"
bitfld.long 0 0. " INRIS "  "0 ,1 "
bitfld.long 0 1. " OUTRIS "  "0 ,1 "
;tree.end

;tree "1MIS"
base ad:0xa03cb024
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " INMIS "  "0 ,1 "
bitfld.long 0 1. " OUTMIS "  "0 ,1 "
;tree.end

;tree "1K1L"
base ad:0xa03cb028
group 0--3
line.long 0 "K1L"
bitfld.long 0 0. " K31 "  "0 ,1 "
bitfld.long 0 1. " K30 "  "0 ,1 "
bitfld.long 0 2. " K29 "  "0 ,1 "
bitfld.long 0 3. " K28 "  "0 ,1 "
bitfld.long 0 4. " K27 "  "0 ,1 "
bitfld.long 0 5. " K26 "  "0 ,1 "
bitfld.long 0 6. " K25 "  "0 ,1 "
bitfld.long 0 7. " K24 "  "0 ,1 "
bitfld.long 0 8. " K23 "  "0 ,1 "
bitfld.long 0 9. " K22 "  "0 ,1 "
bitfld.long 0 10. " K21 "  "0 ,1 "
bitfld.long 0 11. " K20 "  "0 ,1 "
bitfld.long 0 12. " K19 "  "0 ,1 "
bitfld.long 0 13. " K18 "  "0 ,1 "
bitfld.long 0 14. " K17 "  "0 ,1 "
bitfld.long 0 15. " K16 "  "0 ,1 "
bitfld.long 0 16. " K15 "  "0 ,1 "
bitfld.long 0 17. " K14 "  "0 ,1 "
bitfld.long 0 18. " K13 "  "0 ,1 "
bitfld.long 0 19. " K12 "  "0 ,1 "
bitfld.long 0 20. " K11 "  "0 ,1 "
bitfld.long 0 21. " K10 "  "0 ,1 "
bitfld.long 0 22. " K9 "  "0 ,1 "
bitfld.long 0 23. " K8 "  "0 ,1 "
bitfld.long 0 24. " K7 "  "0 ,1 "
bitfld.long 0 25. " K6 "  "0 ,1 "
bitfld.long 0 26. " K5 "  "0 ,1 "
bitfld.long 0 27. " K4 "  "0 ,1 "
bitfld.long 0 28. " K3 "  "0 ,1 "
bitfld.long 0 29. " K2 "  "0 ,1 "
bitfld.long 0 30. " K1 "  "0 ,1 "
bitfld.long 0 31. " K0 "  "0 ,1 "
;tree.end

;tree "1K1R"
base ad:0xa03cb02c
group 0--3
line.long 0 "K1R"
bitfld.long 0 0. " K63 "  "0 ,1 "
bitfld.long 0 1. " K62 "  "0 ,1 "
bitfld.long 0 2. " K61 "  "0 ,1 "
bitfld.long 0 3. " K60 "  "0 ,1 "
bitfld.long 0 4. " K59 "  "0 ,1 "
bitfld.long 0 5. " K58 "  "0 ,1 "
bitfld.long 0 6. " K57 "  "0 ,1 "
bitfld.long 0 7. " K56 "  "0 ,1 "
bitfld.long 0 8. " K55 "  "0 ,1 "
bitfld.long 0 9. " K54 "  "0 ,1 "
bitfld.long 0 10. " K53 "  "0 ,1 "
bitfld.long 0 11. " K52 "  "0 ,1 "
bitfld.long 0 12. " K51 "  "0 ,1 "
bitfld.long 0 13. " K50 "  "0 ,1 "
bitfld.long 0 14. " K49 "  "0 ,1 "
bitfld.long 0 15. " K48 "  "0 ,1 "
bitfld.long 0 16. " K47 "  "0 ,1 "
bitfld.long 0 17. " K46 "  "0 ,1 "
bitfld.long 0 18. " K45 "  "0 ,1 "
bitfld.long 0 19. " K44 "  "0 ,1 "
bitfld.long 0 20. " K43 "  "0 ,1 "
bitfld.long 0 21. " K42 "  "0 ,1 "
bitfld.long 0 22. " K41 "  "0 ,1 "
bitfld.long 0 23. " K40 "  "0 ,1 "
bitfld.long 0 24. " K39 "  "0 ,1 "
bitfld.long 0 25. " K38 "  "0 ,1 "
bitfld.long 0 26. " K37 "  "0 ,1 "
bitfld.long 0 27. " K36 "  "0 ,1 "
bitfld.long 0 28. " K35 "  "0 ,1 "
bitfld.long 0 29. " K34 "  "0 ,1 "
bitfld.long 0 30. " K33 "  "0 ,1 "
bitfld.long 0 31. " K32 "  "0 ,1 "
;tree.end

;tree "1K2L"
base ad:0xa03cb030
group 0--3
line.long 0 "K2L"
bitfld.long 0 0. " K95 "  "0 ,1 "
bitfld.long 0 1. " K94 "  "0 ,1 "
bitfld.long 0 2. " K93 "  "0 ,1 "
bitfld.long 0 3. " K92 "  "0 ,1 "
bitfld.long 0 4. " K91 "  "0 ,1 "
bitfld.long 0 5. " K90 "  "0 ,1 "
bitfld.long 0 6. " K89 "  "0 ,1 "
bitfld.long 0 7. " K88 "  "0 ,1 "
bitfld.long 0 8. " K87 "  "0 ,1 "
bitfld.long 0 9. " K86 "  "0 ,1 "
bitfld.long 0 10. " K85 "  "0 ,1 "
bitfld.long 0 11. " K84 "  "0 ,1 "
bitfld.long 0 12. " K83 "  "0 ,1 "
bitfld.long 0 13. " K82 "  "0 ,1 "
bitfld.long 0 14. " K81 "  "0 ,1 "
bitfld.long 0 15. " K80 "  "0 ,1 "
bitfld.long 0 16. " K79 "  "0 ,1 "
bitfld.long 0 17. " K78 "  "0 ,1 "
bitfld.long 0 18. " K77 "  "0 ,1 "
bitfld.long 0 19. " K76 "  "0 ,1 "
bitfld.long 0 20. " K75 "  "0 ,1 "
bitfld.long 0 21. " K74 "  "0 ,1 "
bitfld.long 0 22. " K73 "  "0 ,1 "
bitfld.long 0 23. " K72 "  "0 ,1 "
bitfld.long 0 24. " K71 "  "0 ,1 "
bitfld.long 0 25. " K70 "  "0 ,1 "
bitfld.long 0 26. " K69 "  "0 ,1 "
bitfld.long 0 27. " K68 "  "0 ,1 "
bitfld.long 0 28. " K67 "  "0 ,1 "
bitfld.long 0 29. " K66 "  "0 ,1 "
bitfld.long 0 30. " K65 "  "0 ,1 "
bitfld.long 0 31. " K64 "  "0 ,1 "
;tree.end

;tree "1K2R"
base ad:0xa03cb034
group 0--3
line.long 0 "K2R"
bitfld.long 0 0. " K127 "  "0 ,1 "
bitfld.long 0 1. " K126 "  "0 ,1 "
bitfld.long 0 2. " K125 "  "0 ,1 "
bitfld.long 0 3. " K124 "  "0 ,1 "
bitfld.long 0 4. " K123 "  "0 ,1 "
bitfld.long 0 5. " K122 "  "0 ,1 "
bitfld.long 0 6. " K121 "  "0 ,1 "
bitfld.long 0 7. " K120 "  "0 ,1 "
bitfld.long 0 8. " K119 "  "0 ,1 "
bitfld.long 0 9. " K118 "  "0 ,1 "
bitfld.long 0 10. " K117 "  "0 ,1 "
bitfld.long 0 11. " K116 "  "0 ,1 "
bitfld.long 0 12. " K115 "  "0 ,1 "
bitfld.long 0 13. " K114 "  "0 ,1 "
bitfld.long 0 14. " K113 "  "0 ,1 "
bitfld.long 0 15. " K112 "  "0 ,1 "
bitfld.long 0 16. " K111 "  "0 ,1 "
bitfld.long 0 17. " K110 "  "0 ,1 "
bitfld.long 0 18. " K109 "  "0 ,1 "
bitfld.long 0 19. " K108 "  "0 ,1 "
bitfld.long 0 20. " K107 "  "0 ,1 "
bitfld.long 0 21. " K106 "  "0 ,1 "
bitfld.long 0 22. " K105 "  "0 ,1 "
bitfld.long 0 23. " K104 "  "0 ,1 "
bitfld.long 0 24. " K103 "  "0 ,1 "
bitfld.long 0 25. " K102 "  "0 ,1 "
bitfld.long 0 26. " K101 "  "0 ,1 "
bitfld.long 0 27. " K100 "  "0 ,1 "
bitfld.long 0 28. " K99 "  "0 ,1 "
bitfld.long 0 29. " K98 "  "0 ,1 "
bitfld.long 0 30. " K97 "  "0 ,1 "
bitfld.long 0 31. " K96 "  "0 ,1 "
;tree.end

;tree "1K3L"
base ad:0xa03cb038
group 0--3
line.long 0 "K3L"
bitfld.long 0 0. " K159 "  "0 ,1 "
bitfld.long 0 1. " K158 "  "0 ,1 "
bitfld.long 0 2. " K157 "  "0 ,1 "
bitfld.long 0 3. " K156 "  "0 ,1 "
bitfld.long 0 4. " K155 "  "0 ,1 "
bitfld.long 0 5. " K154 "  "0 ,1 "
bitfld.long 0 6. " K153 "  "0 ,1 "
bitfld.long 0 7. " K152 "  "0 ,1 "
bitfld.long 0 8. " K151 "  "0 ,1 "
bitfld.long 0 9. " K150 "  "0 ,1 "
bitfld.long 0 10. " K149 "  "0 ,1 "
bitfld.long 0 11. " K148 "  "0 ,1 "
bitfld.long 0 12. " K147 "  "0 ,1 "
bitfld.long 0 13. " K146 "  "0 ,1 "
bitfld.long 0 14. " K145 "  "0 ,1 "
bitfld.long 0 15. " K144 "  "0 ,1 "
bitfld.long 0 16. " K143 "  "0 ,1 "
bitfld.long 0 17. " K142 "  "0 ,1 "
bitfld.long 0 18. " K141 "  "0 ,1 "
bitfld.long 0 19. " K140 "  "0 ,1 "
bitfld.long 0 20. " K139 "  "0 ,1 "
bitfld.long 0 21. " K138 "  "0 ,1 "
bitfld.long 0 22. " K137 "  "0 ,1 "
bitfld.long 0 23. " K136 "  "0 ,1 "
bitfld.long 0 24. " K135 "  "0 ,1 "
bitfld.long 0 25. " K134 "  "0 ,1 "
bitfld.long 0 26. " K133 "  "0 ,1 "
bitfld.long 0 27. " K132 "  "0 ,1 "
bitfld.long 0 28. " K131 "  "0 ,1 "
bitfld.long 0 29. " K130 "  "0 ,1 "
bitfld.long 0 30. " K129 "  "0 ,1 "
bitfld.long 0 31. " K128 "  "0 ,1 "
;tree.end

;tree "1K3R"
base ad:0xa03cb03c
group 0--3
line.long 0 "K3R"
bitfld.long 0 0. " K191 "  "0 ,1 "
bitfld.long 0 1. " K190 "  "0 ,1 "
bitfld.long 0 2. " K189 "  "0 ,1 "
bitfld.long 0 3. " K188 "  "0 ,1 "
bitfld.long 0 4. " K187 "  "0 ,1 "
bitfld.long 0 5. " K186 "  "0 ,1 "
bitfld.long 0 6. " K185 "  "0 ,1 "
bitfld.long 0 7. " K184 "  "0 ,1 "
bitfld.long 0 8. " K183 "  "0 ,1 "
bitfld.long 0 9. " K182 "  "0 ,1 "
bitfld.long 0 10. " K181 "  "0 ,1 "
bitfld.long 0 11. " K180 "  "0 ,1 "
bitfld.long 0 12. " K179 "  "0 ,1 "
bitfld.long 0 13. " K178 "  "0 ,1 "
bitfld.long 0 14. " K177 "  "0 ,1 "
bitfld.long 0 15. " K176 "  "0 ,1 "
bitfld.long 0 16. " K175 "  "0 ,1 "
bitfld.long 0 17. " K174 "  "0 ,1 "
bitfld.long 0 18. " K173 "  "0 ,1 "
bitfld.long 0 19. " K172 "  "0 ,1 "
bitfld.long 0 20. " K171 "  "0 ,1 "
bitfld.long 0 21. " K170 "  "0 ,1 "
bitfld.long 0 22. " K169 "  "0 ,1 "
bitfld.long 0 23. " K168 "  "0 ,1 "
bitfld.long 0 24. " K167 "  "0 ,1 "
bitfld.long 0 25. " K166 "  "0 ,1 "
bitfld.long 0 26. " K165 "  "0 ,1 "
bitfld.long 0 27. " K164 "  "0 ,1 "
bitfld.long 0 28. " K163 "  "0 ,1 "
bitfld.long 0 29. " K162 "  "0 ,1 "
bitfld.long 0 30. " K161 "  "0 ,1 "
bitfld.long 0 31. " K160 "  "0 ,1 "
;tree.end

;tree "1K4L"
base ad:0xa03cb040
group 0--3
line.long 0 "K4L"
bitfld.long 0 0. " K223 "  "0 ,1 "
bitfld.long 0 1. " K222 "  "0 ,1 "
bitfld.long 0 2. " K221 "  "0 ,1 "
bitfld.long 0 3. " K220 "  "0 ,1 "
bitfld.long 0 4. " K219 "  "0 ,1 "
bitfld.long 0 5. " K218 "  "0 ,1 "
bitfld.long 0 6. " K217 "  "0 ,1 "
bitfld.long 0 7. " K216 "  "0 ,1 "
bitfld.long 0 8. " K215 "  "0 ,1 "
bitfld.long 0 9. " K214 "  "0 ,1 "
bitfld.long 0 10. " K213 "  "0 ,1 "
bitfld.long 0 11. " K212 "  "0 ,1 "
bitfld.long 0 12. " K211 "  "0 ,1 "
bitfld.long 0 13. " K210 "  "0 ,1 "
bitfld.long 0 14. " K209 "  "0 ,1 "
bitfld.long 0 15. " K208 "  "0 ,1 "
bitfld.long 0 16. " K207 "  "0 ,1 "
bitfld.long 0 17. " K206 "  "0 ,1 "
bitfld.long 0 18. " K205 "  "0 ,1 "
bitfld.long 0 19. " K204 "  "0 ,1 "
bitfld.long 0 20. " K203 "  "0 ,1 "
bitfld.long 0 21. " K202 "  "0 ,1 "
bitfld.long 0 22. " K201 "  "0 ,1 "
bitfld.long 0 23. " K200 "  "0 ,1 "
bitfld.long 0 24. " K199 "  "0 ,1 "
bitfld.long 0 25. " K198 "  "0 ,1 "
bitfld.long 0 26. " K197 "  "0 ,1 "
bitfld.long 0 27. " K196 "  "0 ,1 "
bitfld.long 0 28. " K195 "  "0 ,1 "
bitfld.long 0 29. " K194 "  "0 ,1 "
bitfld.long 0 30. " K193 "  "0 ,1 "
bitfld.long 0 31. " K192 "  "0 ,1 "
;tree.end

;tree "1K4R"
base ad:0xa03cb044
group 0--3
line.long 0 "K4R"
bitfld.long 0 0. " K255 "  "0 ,1 "
bitfld.long 0 1. " K254 "  "0 ,1 "
bitfld.long 0 2. " K253 "  "0 ,1 "
bitfld.long 0 3. " K252 "  "0 ,1 "
bitfld.long 0 4. " K251 "  "0 ,1 "
bitfld.long 0 5. " K250 "  "0 ,1 "
bitfld.long 0 6. " K249 "  "0 ,1 "
bitfld.long 0 7. " K248 "  "0 ,1 "
bitfld.long 0 8. " K247 "  "0 ,1 "
bitfld.long 0 9. " K246 "  "0 ,1 "
bitfld.long 0 10. " K245 "  "0 ,1 "
bitfld.long 0 11. " K244 "  "0 ,1 "
bitfld.long 0 12. " K243 "  "0 ,1 "
bitfld.long 0 13. " K242 "  "0 ,1 "
bitfld.long 0 14. " K241 "  "0 ,1 "
bitfld.long 0 15. " K240 "  "0 ,1 "
bitfld.long 0 16. " K239 "  "0 ,1 "
bitfld.long 0 17. " K238 "  "0 ,1 "
bitfld.long 0 18. " K237 "  "0 ,1 "
bitfld.long 0 19. " K236 "  "0 ,1 "
bitfld.long 0 20. " K235 "  "0 ,1 "
bitfld.long 0 21. " K234 "  "0 ,1 "
bitfld.long 0 22. " K233 "  "0 ,1 "
bitfld.long 0 23. " K232 "  "0 ,1 "
bitfld.long 0 24. " K231 "  "0 ,1 "
bitfld.long 0 25. " K230 "  "0 ,1 "
bitfld.long 0 26. " K229 "  "0 ,1 "
bitfld.long 0 27. " K228 "  "0 ,1 "
bitfld.long 0 28. " K227 "  "0 ,1 "
bitfld.long 0 29. " K226 "  "0 ,1 "
bitfld.long 0 30. " K225 "  "0 ,1 "
bitfld.long 0 31. " K224 "  "0 ,1 "
;tree.end

;tree "1IV0L"
base ad:0xa03cb048
group 0--3
line.long 0 "IV0L"
bitfld.long 0 0. " IV32 "  "0 ,1 "
bitfld.long 0 1. " IV31 "  "0 ,1 "
bitfld.long 0 2. " IV30 "  "0 ,1 "
bitfld.long 0 3. " IV29 "  "0 ,1 "
bitfld.long 0 4. " IV28 "  "0 ,1 "
bitfld.long 0 5. " IV27 "  "0 ,1 "
bitfld.long 0 6. " IV26 "  "0 ,1 "
bitfld.long 0 7. " IV25 "  "0 ,1 "
bitfld.long 0 8. " IV24 "  "0 ,1 "
bitfld.long 0 9. " IV23 "  "0 ,1 "
bitfld.long 0 10. " IV22 "  "0 ,1 "
bitfld.long 0 11. " IV21 "  "0 ,1 "
bitfld.long 0 12. " IV20 "  "0 ,1 "
bitfld.long 0 13. " IV19 "  "0 ,1 "
bitfld.long 0 14. " IV18 "  "0 ,1 "
bitfld.long 0 15. " IV17 "  "0 ,1 "
bitfld.long 0 16. " IV16 "  "0 ,1 "
bitfld.long 0 17. " IV15 "  "0 ,1 "
bitfld.long 0 18. " IV14 "  "0 ,1 "
bitfld.long 0 19. " IV13 "  "0 ,1 "
bitfld.long 0 20. " IV12 "  "0 ,1 "
bitfld.long 0 21. " IV11 "  "0 ,1 "
bitfld.long 0 22. " IV10 "  "0 ,1 "
bitfld.long 0 23. " IV9 "  "0 ,1 "
bitfld.long 0 24. " IV8 "  "0 ,1 "
bitfld.long 0 25. " IV7 "  "0 ,1 "
bitfld.long 0 26. " IV6 "  "0 ,1 "
bitfld.long 0 27. " IV5 "  "0 ,1 "
bitfld.long 0 28. " IV4 "  "0 ,1 "
bitfld.long 0 29. " IV3 "  "0 ,1 "
bitfld.long 0 30. " IV2 "  "0 ,1 "
bitfld.long 0 31. " IV1 "  "0 ,1 "
;tree.end

;tree "1IV0R"
base ad:0xa03cb04c
group 0--3
line.long 0 "IV0R"
bitfld.long 0 0. " IV64 "  "0 ,1 "
bitfld.long 0 1. " IV63 "  "0 ,1 "
bitfld.long 0 2. " IV62 "  "0 ,1 "
bitfld.long 0 3. " IV61 "  "0 ,1 "
bitfld.long 0 4. " IV60 "  "0 ,1 "
bitfld.long 0 5. " IV59 "  "0 ,1 "
bitfld.long 0 6. " IV58 "  "0 ,1 "
bitfld.long 0 7. " IV57 "  "0 ,1 "
bitfld.long 0 8. " IV56 "  "0 ,1 "
bitfld.long 0 9. " IV55 "  "0 ,1 "
bitfld.long 0 10. " IV54 "  "0 ,1 "
bitfld.long 0 11. " IV53 "  "0 ,1 "
bitfld.long 0 12. " IV52 "  "0 ,1 "
bitfld.long 0 13. " IV51 "  "0 ,1 "
bitfld.long 0 14. " IV50 "  "0 ,1 "
bitfld.long 0 15. " IV49 "  "0 ,1 "
bitfld.long 0 16. " IV48 "  "0 ,1 "
bitfld.long 0 17. " IV47 "  "0 ,1 "
bitfld.long 0 18. " IV46 "  "0 ,1 "
bitfld.long 0 19. " IV45 "  "0 ,1 "
bitfld.long 0 20. " IV44 "  "0 ,1 "
bitfld.long 0 21. " IV43 "  "0 ,1 "
bitfld.long 0 22. " IV42 "  "0 ,1 "
bitfld.long 0 23. " IV41 "  "0 ,1 "
bitfld.long 0 24. " IV40 "  "0 ,1 "
bitfld.long 0 25. " IV39 "  "0 ,1 "
bitfld.long 0 26. " IV38 "  "0 ,1 "
bitfld.long 0 27. " IV37 "  "0 ,1 "
bitfld.long 0 28. " IV36 "  "0 ,1 "
bitfld.long 0 29. " IV35 "  "0 ,1 "
bitfld.long 0 30. " IV34 "  "0 ,1 "
bitfld.long 0 31. " IV33 "  "0 ,1 "
;tree.end

;tree "1IV1L"
base ad:0xa03cb050
group 0--3
line.long 0 "IV1L"
bitfld.long 0 0. " IV96 "  "0 ,1 "
bitfld.long 0 1. " IV95 "  "0 ,1 "
bitfld.long 0 2. " IV94 "  "0 ,1 "
bitfld.long 0 3. " IV93 "  "0 ,1 "
bitfld.long 0 4. " IV92 "  "0 ,1 "
bitfld.long 0 5. " IV91 "  "0 ,1 "
bitfld.long 0 6. " IV90 "  "0 ,1 "
bitfld.long 0 7. " IV89 "  "0 ,1 "
bitfld.long 0 8. " IV88 "  "0 ,1 "
bitfld.long 0 9. " IV87 "  "0 ,1 "
bitfld.long 0 10. " IV86 "  "0 ,1 "
bitfld.long 0 11. " IV85 "  "0 ,1 "
bitfld.long 0 12. " IV84 "  "0 ,1 "
bitfld.long 0 13. " IV83 "  "0 ,1 "
bitfld.long 0 14. " IV82 "  "0 ,1 "
bitfld.long 0 15. " IV81 "  "0 ,1 "
bitfld.long 0 16. " IV80 "  "0 ,1 "
bitfld.long 0 17. " IV79 "  "0 ,1 "
bitfld.long 0 18. " IV78 "  "0 ,1 "
bitfld.long 0 19. " IV77 "  "0 ,1 "
bitfld.long 0 20. " IV76 "  "0 ,1 "
bitfld.long 0 21. " IV75 "  "0 ,1 "
bitfld.long 0 22. " IV74 "  "0 ,1 "
bitfld.long 0 23. " IV73 "  "0 ,1 "
bitfld.long 0 24. " IV72 "  "0 ,1 "
bitfld.long 0 25. " IV71 "  "0 ,1 "
bitfld.long 0 26. " IV70 "  "0 ,1 "
bitfld.long 0 27. " IV69 "  "0 ,1 "
bitfld.long 0 28. " IV68 "  "0 ,1 "
bitfld.long 0 29. " IV67 "  "0 ,1 "
bitfld.long 0 30. " IV66 "  "0 ,1 "
bitfld.long 0 31. " IV65 "  "0 ,1 "
;tree.end

;tree "1IV1R"
base ad:0xa03cb054
group 0--3
line.long 0 "IV1R"
bitfld.long 0 0. " IV128 "  "0 ,1 "
bitfld.long 0 1. " IV127 "  "0 ,1 "
bitfld.long 0 2. " IV126 "  "0 ,1 "
bitfld.long 0 3. " IV125 "  "0 ,1 "
bitfld.long 0 4. " IV124 "  "0 ,1 "
bitfld.long 0 5. " IV123 "  "0 ,1 "
bitfld.long 0 6. " IV122 "  "0 ,1 "
bitfld.long 0 7. " IV121 "  "0 ,1 "
bitfld.long 0 8. " IV120 "  "0 ,1 "
bitfld.long 0 9. " IV119 "  "0 ,1 "
bitfld.long 0 10. " IV118 "  "0 ,1 "
bitfld.long 0 11. " IV117 "  "0 ,1 "
bitfld.long 0 12. " IV116 "  "0 ,1 "
bitfld.long 0 13. " IV115 "  "0 ,1 "
bitfld.long 0 14. " IV114 "  "0 ,1 "
bitfld.long 0 15. " IV113 "  "0 ,1 "
bitfld.long 0 16. " IV112 "  "0 ,1 "
bitfld.long 0 17. " IV111 "  "0 ,1 "
bitfld.long 0 18. " IV110 "  "0 ,1 "
bitfld.long 0 19. " IV109 "  "0 ,1 "
bitfld.long 0 20. " IV108 "  "0 ,1 "
bitfld.long 0 21. " IV107 "  "0 ,1 "
bitfld.long 0 22. " IV106 "  "0 ,1 "
bitfld.long 0 23. " IV105 "  "0 ,1 "
bitfld.long 0 24. " IV104 "  "0 ,1 "
bitfld.long 0 25. " IV103 "  "0 ,1 "
bitfld.long 0 26. " IV102 "  "0 ,1 "
bitfld.long 0 27. " IV101 "  "0 ,1 "
bitfld.long 0 28. " IV100 "  "0 ,1 "
bitfld.long 0 29. " IV99 "  "0 ,1 "
bitfld.long 0 30. " IV98 "  "0 ,1 "
bitfld.long 0 31. " IV97 "  "0 ,1 "
;tree.end

;tree "1ITCR"
base ad:0xa03cb080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "1ITIP"
base ad:0xa03cb084
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMAIUTC "  "0 ,1 "
bitfld.long 0 1. " DMAOUTC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
;tree.end

;tree "1ITOP"
base ad:0xa03cb088
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMAINBREQ "  "0 ,1 "
bitfld.long 0 1. " DMAOUTBREQ "  "0 ,1 "
bitfld.long 0 2. " DMAOUTSREQ "  "0 ,1 "
bitfld.long 0 3. " ININTR "  "0 ,1 "
bitfld.long 0 4. " OUTINTR "  "0 ,1 "
;tree.end

;tree "1CRYPPeriphID0"
base ad:0xa03cbfe0
rgroup 0--3
line.long 0 "CRYPPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "1CRYPPeriphID1"
base ad:0xa03cbfe4
rgroup 0--3
line.long 0 "CRYPPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CRYPPeriphID2"
base ad:0xa03cbfe8
rgroup 0--3
line.long 0 "CRYPPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1CRYPPeriphID3"
base ad:0xa03cbfec
rgroup 0--3
line.long 0 "CRYPPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "1CRYPPCellID0"
base ad:0xa03cbff0
rgroup 0--3
line.long 0 "CRYPPCellID0"
hexfld.byte 0 " CRYPPCellID0 "
;tree.end

;tree "1CRYPPCellID1"
base ad:0xa03cbff4
rgroup 0--3
line.long 0 "CRYPPCellID1"
hexfld.byte 0 " CRYPPCellID1 "
;tree.end

;tree "1CRYPPCellID2"
base ad:0xa03cbff8
rgroup 0--3
line.long 0 "CRYPPCellID2"
hexfld.byte 0 " CRYPPCellID2 "
;tree.end

;tree "1CRYPPCellID3"
base ad:0xa03cbffc
rgroup 0--3
line.long 0 "CRYPPCellID3"
hexfld.byte 0 " CRYPPCellID3 "
;tree.end

tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "CTI"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CTICONTROL"
base eapb:0x80180000
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
;tree.end

;tree "CTIINTACK"
base eapb:0x80180010
wgroup 0--3
line.long 0 "CTIINTACK"
hexfld.byte 0 " INTACK "
;tree.end

;tree "CTIAPPSET"
base eapb:0x80180014
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIAPPCLEAR"
base eapb:0x80180018
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIAPPPULSE"
base eapb:0x8018001c
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIINEN0"
base eapb:0x80180020
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIINEN1"
base eapb:0x80180024
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIINEN2"
base eapb:0x80180028
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIINEN3"
base eapb:0x8018002c
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIINEN4"
base eapb:0x80180030
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIINEN5"
base eapb:0x80180034
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIINEN6"
base eapb:0x80180038
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIINEN7"
base eapb:0x8018003c
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIOUTEN0"
base eapb:0x801800a0
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIOUTEN1"
base eapb:0x801800a4
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIOUTEN2"
base eapb:0x801800a8
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIOUTEN3"
base eapb:0x801800ac
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIOUTEN4"
base eapb:0x801800b0
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIOUTEN5"
base eapb:0x801800b4
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIOUTEN6"
base eapb:0x801800b8
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIOUTEN7"
base eapb:0x801800bc
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTITRIGINSTATUS"
base eapb:0x80180130
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
hexfld.byte 0 " TRIGINSTATUS "
;tree.end

;tree "CTITRIGOUTSTATUS"
base eapb:0x80180134
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
hexfld.byte 0 " TRIGOUTSTATUS "
;tree.end

;tree "CTICHINSTATUS"
base eapb:0x80180138
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTICHOUTSTATUS"
base eapb:0x8018013c
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTIGATE"
base eapb:0x80180140
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
;tree.end

;tree "ASICCTL"
base eapb:0x80180144
group 0--3
line.long 0 "ASICCTL"
hexfld.byte 0 " ASICCTL "
;tree.end

;tree "ITCHINACK"
base eapb:0x80180edc
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "ITTRIGINACK"
base eapb:0x80180ee0
wgroup 0--3
line.long 0 "ITTRIGINACK"
hexfld.byte 0 " CTTRIGINACK "
;tree.end

;tree "ITCHOUT"
base eapb:0x80180ee4
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "ITTRFLIN"
base eapb:0x80180ee8
wgroup 0--3
line.long 0 "ITTRFLIN"
hexfld.byte 0 " CTTRIGOUT "
;tree.end

;tree "ITCHOUTACK"
base eapb:0x80180eec
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "ITTRIGOUTACK"
base eapb:0x80180ef0
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
hexfld.byte 0 " CTTRIGOUTACK "
;tree.end

;tree "ITCHIN"
base eapb:0x80180ef4
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "ITRIGIN"
base eapb:0x80180ef8
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
;tree.end

;tree "ITCTRL"
base eapb:0x80180f00
group 0--3
line.long 0 "ITCTRL"
bitfld.long 0 0. " ITCTRL "  "0 ,1 "
;tree.end

;tree "CTSR"
base eapb:0x80180fa0
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTCR"
base eapb:0x80180fa4
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "LAR"
base eapb:0x80180fb0
wgroup 0--3
line.long 0 "LAR"
hexfld.long 0 " LAR "
;tree.end

;tree "LSR"
base eapb:0x80180fb4
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ASR"
base eapb:0x80180fb8
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DID"
base eapb:0x80180fc8
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
;tree.end

;tree "DTIR"
base eapb:0x80180fcc
rgroup 0--3
line.long 0 "DTIR"
hexfld.byte 0 " DTIR "
;tree.end

;tree "PERIPHERAL_ID4"
base eapb:0x80180fd0
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
hexfld.byte 0 " PERIPHERAL_ID4 "
;tree.end

;tree "PERIPHERAL_ID5"
base eapb:0x80180fd4
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

;tree "PERIPHERAL_ID6"
base eapb:0x80180fd8
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

;tree "PERIPHERAL_ID7"
base eapb:0x80180fdc
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

;tree "PERIPHERAL_ID0"
base eapb:0x80180fe0
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
hexfld.byte 0 " PERIPHERAL_ID0 "
;tree.end

;tree "PERIPHERAL_ID1"
base eapb:0x80180fe4
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
hexfld.byte 0 " PERIPHERAL_ID1 "
;tree.end

;tree "PERIPHERAL_ID2"
base eapb:0x80180fe8
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
hexfld.byte 0 " PERIPHERAL_ID2 "
;tree.end

;tree "PERIPHERAL_ID3"
base eapb:0x80180fec
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
hexfld.byte 0 " PERIPHERAL_ID3 "
;tree.end

;tree "COMPONENT_ID0"
base eapb:0x80180ff0
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

;tree "COMPONENT_ID1"
base eapb:0x80180ff4
rgroup 0--3
line.long 0 "COMPONENT_ID1"
hexfld.byte 0 " COMPONENT_ID1 "
;tree.end

;tree "COMPONENT_ID2"
base eapb:0x80180ff8
rgroup 0--3
line.long 0 "COMPONENT_ID2"
hexfld.byte 0 " COMPONENT_ID2 "
;tree.end

;tree "COMPONENT_ID3"
base eapb:0x80180ffc
rgroup 0--3
line.long 0 "COMPONENT_ID3"
hexfld.byte 0 " COMPONENT_ID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "DBAHN"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "DENALI_CTL_00"
base ad:0x80156000
group 0--3
line.long 0 "DENALI_CTL_00"
bitfld.long 0 0. " ACTIVE_AGING "  "0 ,1 "
bitfld.long 0 8. " ADDR_CMP_EN "  "0 ,1 "
bitfld.long 0 16. " AP "  "0 ,1 "
bitfld.long 0 24. " AREFRESH "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_01"
base ad:0x80156004
group 0--3
line.long 0 "DENALI_CTL_01"
bitfld.long 0 0. " AUTO_REFRESH_MODE "  "0 ,1 "
bitfld.long 0 8. " AXI0_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 16. " AXI1_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 24. " AXI2_BDW_OVFLOW "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_02"
base ad:0x80156008
group 0--3
line.long 0 "DENALI_CTL_02"
bitfld.long 0 0. " AXI3_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 8. " BANK_SPLIT_EN "  "0 ,1 "
bitfld.long 0 16. " CONCURRENTAP "  "0 ,1 "
bitfld.long 0 24. " DLLLOCKREG "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_03"
base ad:0x8015600c
group 0--3
line.long 0 "DENALI_CTL_03"
bitfld.long 0 0. " DLL_BYPASS_MODE "  "0 ,1 "
bitfld.long 0 8. " DRIVE_DQ_DQ "  "0 ,1 "
bitfld.long 0 16. " ENABLE_QUICK_SREFRESH "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_04"
base ad:0x80156010
group 0--3
line.long 0 "DENALI_CTL_04"
bitfld.long 0 0. " FAST_WRITE "  "0 ,1 "
bitfld.long 0 8. " INTRPTAPBURST "  "0 ,1 "
bitfld.long 0 16. " INTRPTREADA "  "0 ,1 "
bitfld.long 0 24. " INTRPTWRITEA "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_05"
base ad:0x80156014
group 0--3
line.long 0 "DENALI_CTL_05"
bitfld.long 0 0. " NO_CMD_INIT "  "0 ,1 "
bitfld.long 0 8. " PLACEMENT_EN "  "0 ,1 "
bitfld.long 0 16. " POWER_DOWN "  "0 ,1 "
bitfld.long 0 24. " PRIORITY_EN "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_06"
base ad:0x80156018
group 0--3
line.long 0 "DENALI_CTL_06"
bitfld.long 0 0. " PWRUP_SREFRESH_EXIT "  "0 ,1 "
bitfld.long 0 8. " RD2RD_TURN "  "0 ,1 "
bitfld.long 0 16. " REDUC "  "0 ,1 "
bitfld.long 0 24. " REG_DIMM_ENABLE "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_07"
base ad:0x8015601c
group 0--3
line.long 0 "DENALI_CTL_07"
bitfld.long 0 0. " RW_SAME_EN "  "0 ,1 "
bitfld.long 0 8. " SREFRESH "  "0 ,1 "
bitfld.long 0 16. " START "  "0 ,1 "
bitfld.long 0 24. " SWAP_EN "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_08"
base ad:0x80156020
group 0--3
line.long 0 "DENALI_CTL_08"
bitfld.long 0 0. " TRAS_LOCKOUT "  "0 ,1 "
bitfld.long 0 8. " TREF_ENABLE "  "0 ,1 "
bitfld.long 0 16. " WRITEINTERP "  "0 ,1 "
bitfld.long 0 24. " WRITE_MODEREG "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_09"
base ad:0x80156024
group 0--3
line.long 0 "DENALI_CTL_09"
bitfld.long 0 0. " WRLAT "  "0 ,1 "
bitfld.long 0 8.--9. " AXI0_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI0_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI0_W_PRIORITY "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DENALI_CTL_10"
base ad:0x80156028
group 0--3
line.long 0 "DENALI_CTL_10"
bitfld.long 0 0.--1. " AXI1_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI1_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI1_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI2_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DENALI_CTL_11"
base ad:0x8015602c
group 0--3
line.long 0 "DENALI_CTL_11"
bitfld.long 0 0.--1. " AXI2_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI2_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI3_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI3_R_PRIORITY "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DENALI_CTL_12"
base ad:0x80156030
group 0--3
line.long 0 "DENALI_CTL_12"
bitfld.long 0 0.--1. " AXI3_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " CS_MAP "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " LOWPOWER_REFRESH_ENABLE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DENALI_CTL_13"
base ad:0x80156034
group 0--3
line.long 0 "DENALI_CTL_13"
bitfld.long 0 0.--1. " MAX_CS_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TEMRS "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " WRTPRCT_ENABLE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DENALI_CTL_14"
base ad:0x80156038
group 0--3
line.long 0 "DENALI_CTL_14"
bitfld.long 0 0.--2. " ARB_CMD_Q_THRESHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " BSTLEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " CASLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " CKE_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DENALI_CTL_15"
base ad:0x8015603c
group 0--3
line.long 0 "DENALI_CTL_15"
bitfld.long 0 8.--10. " PORT_DATA_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " Q_FULLNESS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TCKE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DENALI_CTL_16"
base ad:0x80156040
group 0--3
line.long 0 "DENALI_CTL_16"
bitfld.long 0 0.--2. " TDFI_CTRL_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDFI_DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " TDFI_DRAM_CLK_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TRRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DENALI_CTL_17"
base ad:0x80156044
group 0--3
line.long 0 "DENALI_CTL_17"
bitfld.long 0 0.--3. " TWTR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--28. " CASLAT_LIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DENALI_CTL_18"
base ad:0x80156048
group 0--3
line.long 0 "DENALI_CTL_18"
bitfld.long 0 0.--3. " CASLAT_LIN_GATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " COMMAND_AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " INITAREF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAX_COL_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DENALI_CTL_19"
base ad:0x8015604c
group 0--3
line.long 0 "DENALI_CTL_19"
bitfld.long 0 0.--3. " MAX_ROW_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " PORT_CMD_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_CTRLUPD_MIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DENALI_CTL_20"
base ad:0x80156050
group 0--3
line.long 0 "DENALI_CTL_20"
bitfld.long 0 0.--3. " TDFI_PHY_RDLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TDFI_PHY_WRLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDFI_PHY_WRLAT_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_RDDATA_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DENALI_CTL_21"
base ad:0x80156054
group 0--3
line.long 0 "DENALI_CTL_21"
bitfld.long 0 0.--4. " TDFI_RDDATA_EN_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " TRP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " TWR_INT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--30. " DLL_LOCK "  " "
;tree.end

;tree "DENALI_CTL_22"
base ad:0x80156058
group 0--3
line.long 0 "DENALI_CTL_22"
bitfld.long 0 0.--4. " LOWPOWER_AUTO_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " LOWPOWER_CONTROL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--21. " OUT_OF_RANGE_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24.--28. " TMRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DENALI_CTL_23"
base ad:0x8015605c
group 0--3
line.long 0 "DENALI_CTL_23"
bitfld.long 0 0.--5. " TRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8.--14. " AXI0_BDW "  " "
bitfld.long 0 16.--22. " AXI0_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI1_BDW "  " "
;tree.end

;tree "DENALI_CTL_24"
base ad:0x80156060
group 0--3
line.long 0 "DENALI_CTL_24"
bitfld.long 0 0.--6. " AXI1_CURRENT_BDW "  " "
bitfld.long 0 8.--14. " AXI2_BDW "  " "
bitfld.long 0 16.--22. " AXI2_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI3_BDW "  " "
;tree.end

;tree "DENALI_CTL_25"
base ad:0x80156064
rgroup 0--3
line.long 0 "DENALI_CTL_25"
bitfld.long 0 0.--6. " AXI3_CURRENT_BDW "  " "
bitfld.long 0 16.--22. " OUT_OF_RANGE_LENGTH "  " "
bitfld.long 0 24.--30. " WRTPRCT_ERROR_LENGTH "  " "
;tree.end

;tree "DENALI_CTL_26"
base ad:0x80156068
group 0--3
line.long 0 "DENALI_CTL_26"
hexfld.byte 2 " TRAS_MIN "
hexfld.byte 3 " TRCD_INT "
;tree.end

;tree "DENALI_CTL_27"
base ad:0x8015606c
group 0--3
line.long 0 "DENALI_CTL_27"
hexfld.byte 0 " TRFC "
bitfld.long 0 8.--17. " OUT_OF_RANGE_SOURCE_ID "  " "
;tree.end

;tree "DENALI_CTL_28"
base ad:0x80156070
rgroup 0--3
line.long 0 "DENALI_CTL_28"
bitfld.long 0 0.--11. " PORT_CMD_ERROR_ID "  " "
bitfld.long 0 16.--27. " PORT_DATA_ERROR_ID "  " "
;tree.end

;tree "DENALI_CTL_29"
base ad:0x80156074
rgroup 0--3
line.long 0 "DENALI_CTL_29"
hexfld.word 0 " TDFI_CTRLUPD_MAX "
hexfld.word 2 " TDFI_PHYUPD_RESP "
;tree.end

;tree "DENALI_CTL_30"
base ad:0x80156078
group 0--3
line.long 0 "DENALI_CTL_30"
hexfld.word 0 " TDFI_PHYUPD_TYPE0 "
hexfld.word 2 " TREF "
;tree.end

;tree "DENALI_CTL_31"
base ad:0x8015607c
rgroup 0--3
line.long 0 "DENALI_CTL_31"
;tree.end

;tree "DENALI_CTL_32"
base ad:0x80156080
group 0--3
line.long 0 "DENALI_CTL_32"
hexfld.word 2 " AXI0_EN_SIZE_LT_WIDTH_INSTR "
;tree.end

;tree "DENALI_CTL_33"
base ad:0x80156084
group 0--3
line.long 0 "DENALI_CTL_33"
hexfld.word 0 " AXI1_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 2 " AXI2_EN_SIZE_LT_WIDTH_INSTR "
;tree.end

;tree "DENALI_CTL_34"
base ad:0x80156088
group 0--3
line.long 0 "DENALI_CTL_34"
hexfld.word 0 " AXI3_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 2 " LOWPOWER_EXTERNAL_CNT "
;tree.end

;tree "DENALI_CTL_35"
base ad:0x8015608c
group 0--3
line.long 0 "DENALI_CTL_35"
hexfld.word 0 " LOWPOWER_INTERNAL_CNT "
hexfld.word 2 " LOWPOWER_POWER_DOWN_CNT "
;tree.end

;tree "DENALI_CTL_36"
base ad:0x80156090
group 0--3
line.long 0 "DENALI_CTL_36"
hexfld.word 0 " LOWPOWER_REFRESH_HOLD "
hexfld.word 2 " LOWPOWER_SELF_REFRESH_CNT "
;tree.end

;tree "DENALI_CTL_37"
base ad:0x80156094
group 0--3
line.long 0 "DENALI_CTL_37"
hexfld.word 0 " TDLL "
hexfld.word 2 " TPDEX "
;tree.end

;tree "DENALI_CTL_38"
base ad:0x80156098
group 0--3
line.long 0 "DENALI_CTL_38"
hexfld.word 0 " TRAS_MAX "
hexfld.word 2 " TXSNR "
;tree.end

;tree "DENALI_CTL_39"
base ad:0x8015609c
group 0--3
line.long 0 "DENALI_CTL_39"
hexfld.word 0 " TXSR "
hexfld.word 2 " VERSION "
;tree.end

;tree "DENALI_CTL_40"
base ad:0x801560a0
group 0--3
line.long 0 "DENALI_CTL_40"
bitfld.long 0 0.--23. " TINIT "  " "
;tree.end

;tree "DENALI_CTL_41"
base ad:0x801560a4
rgroup 0--3
line.long 0 "DENALI_CTL_41"
hexfld.long 0 " OUT_OF_RANGE_ADDR "
;tree.end

;tree "DENALI_CTL_42"
base ad:0x801560a8
rgroup 0--3
line.long 0 "DENALI_CTL_42"
hexfld.long 0 " PORT_CMD_ERROR_ADDR "
;tree.end

;tree "DENALI_CTL_43"
base ad:0x801560ac
rgroup 0--3
line.long 0 "DENALI_CTL_43"
hexfld.long 0 " WRTPRCT_ERROR_ADDRESS "
;tree.end

;tree "DENALI_CTL_44"
base ad:0x801560b0
group 0--3
line.long 0 "DENALI_CTL_44"
hexfld.long 0 " WRTPRCT_LOWER_ADDRESS_0 "
;tree.end

;tree "DENALI_CTL_45"
base ad:0x801560b4
group 0--3
line.long 0 "DENALI_CTL_45"
hexfld.long 0 " WRTPRCT_LOWER_ADDRESS_1 "
;tree.end

;tree "DENALI_CTL_46"
base ad:0x801560b8
group 0--3
line.long 0 "DENALI_CTL_46"
hexfld.long 0 " WRTPRCT_UPPER_ADDRESS_0 "
;tree.end

;tree "DENALI_CTL_47"
base ad:0x801560bc
group 0--3
line.long 0 "DENALI_CTL_47"
hexfld.long 0 " WRTPRCT_UPPER_ADDRESS_1 "
;tree.end

;tree "DENALI_CTL_59"
base ad:0x801560ec
group 0--3
line.long 0 "DENALI_CTL_59"
hexfld.long 0 " PHY_ADD "
;tree.end

;tree "DENALI_CTL_60"
base ad:0x801560f0
group 0--3
line.long 0 "DENALI_CTL_60"
hexfld.long 0 " PHY_CFG "
;tree.end

;tree "DENALI_CTL_61"
base ad:0x801560f4
rgroup 0--3
line.long 0 "DENALI_CTL_61"
hexfld.long 0 " PHY_STS "
;tree.end

;tree "DENALI_CTL_62"
base ad:0x801560f8
rgroup 0--3
line.long 0 "DENALI_CTL_62"
;tree.end

;tree "DENALI_CTL_63"
base ad:0x801560fc
group 0--3
line.long 0 "DENALI_CTL_63"
bitfld.long 0 0.--2. " WRLAT_ADJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " W2R_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " W2R_SAMECS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--27. " DRAM_CLASS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DENALI_CTL_64"
base ad:0x80156100
group 0--3
line.long 0 "DENALI_CTL_64"
bitfld.long 0 0.--4. " RDLAT_ADJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.byte 1 " DLL_RST_ADJ_DLY "
hexfld.byte 2 " TMOD "
;tree.end

;tree "DENALI_CTL_65"
base ad:0x80156104
group 0--3
line.long 0 "DENALI_CTL_65"
;tree.end

;tree "DENALI_CTL_66"
base ad:0x80156108
group 0--3
line.long 0 "DENALI_CTL_66"
;tree.end

;tree "DENALI_CTL_67"
base ad:0x8015610c
group 0--3
line.long 0 "DENALI_CTL_67"
hexfld.word 0 " DLL_RST_DELAY "
;tree.end

;tree "DENALI_CTL_72"
base ad:0x80156120
group 0--3
line.long 0 "DENALI_CTL_72"
hexfld.long 0 " USER_DEF_REG_2 "
;tree.end

;tree "DENALI_CTL_73"
base ad:0x80156124
group 0--3
line.long 0 "DENALI_CTL_73"
bitfld.long 0 26. " DEBUG_DFI_TRIGGER_IS_WRITE "  "0 ,1 "
bitfld.long 0 27. " DENALI_JTAG_CONTROL_ENABLE "  "0 ,1 "
bitfld.long 0 28. " DENALI_JTAG_TRSTN "  "0 ,1 "
bitfld.long 0 29. " DENALI_JTAG_TCK "  "0 ,1 "
bitfld.long 0 30. " DENALI_JTAG_TMS "  "0 ,1 "
bitfld.long 0 31. " DENALI_JTAG_TDI "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_74"
base ad:0x80156128
group 0--3
line.long 0 "DENALI_CTL_74"
hexfld.long 0 " USER_DEF_REG_RO_2 "
;tree.end

;tree "DENALI_CTL_75"
base ad:0x8015612c
rgroup 0--3
line.long 0 "DENALI_CTL_75"
bitfld.long 0 30. " DFI_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 31. " DENALI_JTAG_TDO "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_76"
base ad:0x80156130
rgroup 0--3
line.long 0 "DENALI_CTL_76"
bitfld.long 0 8. " DQS_N_EN "  "0 ,1 "
bitfld.long 0 24. " LPDDR2_S4 "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_77"
base ad:0x80156134
group 0--3
line.long 0 "DENALI_CTL_77"
bitfld.long 0 0.--1. " TDQSCK_MAX "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TDQSCK_MIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--26. " R2R_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DENALI_CTL_78"
base ad:0x80156138
group 0--3
line.long 0 "DENALI_CTL_78"
bitfld.long 0 0.--1. " TDQSCK_MAX "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TDQSCK_MIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--28. " TCCD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DENALI_CTL_79"
base ad:0x8015613c
group 0--3
line.long 0 "DENALI_CTL_79"
bitfld.long 0 0.--2. " TRTP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " W2W_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " W2W_SAMECS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--28. " TMRR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DENALI_CTL_80"
base ad:0x80156140
group 0--3
line.long 0 "DENALI_CTL_80"
bitfld.long 0 8.--11. " ZQ_ON_SREF_EXIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " ZQ_REQ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--29. " TFAW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "DENALI_CTL_81"
base ad:0x80156144
group 0--3
line.long 0 "DENALI_CTL_81"
hexfld.byte 0 " REFRESH_PER_ZQ "
bitfld.long 0 8.--17. " INT_MASK "  " "
;tree.end

;tree "DENALI_CTL_82"
base ad:0x80156148
group 0--3
line.long 0 "DENALI_CTL_82"
bitfld.long 0 0.--9. " INT_STATUS "  " "
bitfld.long 0 16.--27. " ZQCL "  " "
;tree.end

;tree "DENALI_CTL_83"
base ad:0x8015614c
group 0--3
line.long 0 "DENALI_CTL_83"
bitfld.long 0 0.--11. " ZQCS "  " "
bitfld.long 0 16.--27. " ZQINIT "  " "
;tree.end

;tree "DENALI_CTL_84"
base ad:0x80156150
group 0--3
line.long 0 "DENALI_CTL_84"
bitfld.long 0 0.--11. " ZQRESET "  " "
bitfld.long 0 16.--30. " MR0_DATA_0 "  " "
;tree.end

;tree "DENALI_CTL_85"
base ad:0x80156154
group 0--3
line.long 0 "DENALI_CTL_85"
bitfld.long 0 0.--14. " MR0_DATA_1 "  " "
bitfld.long 0 16.--30. " MR16_DATA_0 "  " "
;tree.end

;tree "DENALI_CTL_86"
base ad:0x80156158
group 0--3
line.long 0 "DENALI_CTL_86"
bitfld.long 0 0.--14. " MR16_DATA_1 "  " "
bitfld.long 0 16.--30. " MR17_DATA_0 "  " "
;tree.end

;tree "DENALI_CTL_87"
base ad:0x8015615c
group 0--3
line.long 0 "DENALI_CTL_87"
bitfld.long 0 0.--14. " MR17_DATA_1 "  " "
bitfld.long 0 16.--30. " MR1_DATA_0 "  " "
;tree.end

;tree "DENALI_CTL_88"
base ad:0x80156160
group 0--3
line.long 0 "DENALI_CTL_88"
bitfld.long 0 0.--14. " MR1_DATA_1 "  " "
bitfld.long 0 16.--30. " MR2_DATA_0 "  " "
;tree.end

;tree "DENALI_CTL_89"
base ad:0x80156164
group 0--3
line.long 0 "DENALI_CTL_89"
bitfld.long 0 0.--14. " MR2_DATA_1 "  " "
bitfld.long 0 16.--30. " MR3_DATA_0 "  " "
;tree.end

;tree "DENALI_CTL_90"
base ad:0x80156168
group 0--3
line.long 0 "DENALI_CTL_90"
bitfld.long 0 0.--14. " MR3_DATA_1 "  " "
hexfld.word 2 " PERIPHERAL_MRR_DATA "
;tree.end

;tree "DENALI_CTL_91"
base ad:0x8015616c
group 0--3
line.long 0 "DENALI_CTL_91"
bitfld.long 0 0.--16. " READ_MODEREG "  " "
;tree.end

;tree "DENALI_CTL_92"
base ad:0x80156170
group 0--3
line.long 0 "DENALI_CTL_92"
bitfld.long 0 0.--23. " TINIT3 "  " "
;tree.end

;tree "DENALI_CTL_93"
base ad:0x80156174
group 0--3
line.long 0 "DENALI_CTL_93"
bitfld.long 0 0.--23. " TINIT4 "  " "
;tree.end

;tree "DENALI_CTL_94"
base ad:0x80156178
group 0--3
line.long 0 "DENALI_CTL_94"
bitfld.long 0 0.--23. " TINIT5 "  " "
bitfld.long 0 24. " CONCURRENTAP_WR_ONLY "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_95"
base ad:0x8015617c
group 0--3
line.long 0 "DENALI_CTL_95"
bitfld.long 0 0. " CONFIG_ERROR "  "0 ,1 "
bitfld.long 0 8. " EIGHT_BANK_MODE_0 "  "0 ,1 "
bitfld.long 0 16. " EIGHT_BANK_MODE_1 "  "0 ,1 "
bitfld.long 0 24. " RESYNC_DLL "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_96"
base ad:0x80156180
group 0--3
line.long 0 "DENALI_CTL_96"
bitfld.long 0 0. " RESYNC_DLL_PER_AREF_EN "  "0 ,1 "
bitfld.long 0 8. " ZQCS_ROTATE "  "0 ,1 "
bitfld.long 0 16. " ZQ_IN_PROGRESS "  "0 ,1 "
bitfld.long 0 24.--26. " ADDR_PINS_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DENALI_CTL_97"
base ad:0x80156184
group 0--3
line.long 0 "DENALI_CTL_97"
bitfld.long 0 0.--2. " ADDR_PINS_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " COLUMN_SIZE_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " COLUMN_SIZE_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--27. " APREBIT_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DENALI_CTL_98"
base ad:0x80156188
group 0--3
line.long 0 "DENALI_CTL_98"
bitfld.long 0 0.--3. " APREBIT_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--12. " TRP_AB_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " TRP_AB_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DENALI_CTL_99"
base ad:0x8015618c
group 0--3
line.long 0 "DENALI_CTL_99"
bitfld.long 0 0.--8. " INT_ACK "  " "
hexfld.word 2 " CS_MSK_0 "
;tree.end

;tree "DENALI_CTL_100"
base ad:0x80156190
group 0--3
line.long 0 "DENALI_CTL_100"
hexfld.word 0 " CS_MSK_1 "
hexfld.word 2 " CS_VAL_0 "
;tree.end

;tree "DENALI_CTL_101"
base ad:0x80156194
group 0--3
line.long 0 "DENALI_CTL_101"
hexfld.word 0 " CS_VAL_1 "
bitfld.long 0 16.--18. " TBST_INT_INTERVAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--27. " CKSRE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DENALI_CTL_102"
base ad:0x80156198
group 0--3
line.long 0 "DENALI_CTL_102"
bitfld.long 0 0.--3. " CKSRX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--12. " TCKESR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--29. " TREF_INTERVAL "  " "
;tree.end

;tree "DENALI_CTL_103"
base ad:0x8015619c
group 0--3
line.long 0 "DENALI_CTL_103"
hexfld.word 0 " TDFI_PHYUPD_TYPE1 "
hexfld.word 2 " TDFI_PHYUPD_TYPE2 "
;tree.end

;tree "DENALI_CTL_104"
base ad:0x801561a0
group 0--3
line.long 0 "DENALI_CTL_104"
hexfld.word 0 " TDFI_PHYUPD_TYPE3 "
;tree.end

;tree "DENALI_CTL_105"
base ad:0x801561a4
group 0--3
line.long 0 "DENALI_CTL_105"
hexfld.long 0 " USER_DEF_REG_10 "
;tree.end

;tree "DENALI_CTL_106"
base ad:0x801561a8
group 0--3
line.long 0 "DENALI_CTL_106"
hexfld.long 0 " USER_DEF_REG_11 "
;tree.end

;tree "DENALI_CTL_107"
base ad:0x801561ac
group 0--3
line.long 0 "DENALI_CTL_107"
hexfld.long 0 " USER_DEF_REG_12 "
;tree.end

;tree "DENALI_CTL_108"
base ad:0x801561b0
group 0--3
line.long 0 "DENALI_CTL_108"
hexfld.long 0 " USER_DEF_REG_13 "
;tree.end

;tree "DENALI_CTL_109"
base ad:0x801561b4
group 0--3
line.long 0 "DENALI_CTL_109"
hexfld.long 0 " USER_DEF_REG_14 "
;tree.end

;tree "DENALI_CTL_110"
base ad:0x801561b8
group 0--3
line.long 0 "DENALI_CTL_110"
hexfld.long 0 " USER_DEF_REG_15 "
;tree.end

;tree "DENALI_CTL_111"
base ad:0x801561bc
group 0--3
line.long 0 "DENALI_CTL_111"
hexfld.long 0 " USER_DEF_REG_16 "
;tree.end

;tree "DENALI_CTL_112"
base ad:0x801561c0
group 0--3
line.long 0 "DENALI_CTL_112"
hexfld.long 0 " USER_DEF_REG_17 "
;tree.end

;tree "DENALI_CTL_113"
base ad:0x801561c4
group 0--3
line.long 0 "DENALI_CTL_113"
hexfld.long 0 " USER_DEF_REG_18 "
;tree.end

;tree "DENALI_CTL_114"
base ad:0x801561c8
group 0--3
line.long 0 "DENALI_CTL_114"
hexfld.long 0 " USER_DEF_REG_19 "
;tree.end

;tree "DENALI_CTL_115"
base ad:0x801561cc
group 0--3
line.long 0 "DENALI_CTL_115"
hexfld.long 0 " USER_DEF_REG_20 "
;tree.end

;tree "DENALI_CTL_116"
base ad:0x801561d0
group 0--3
line.long 0 "DENALI_CTL_116"
hexfld.long 0 " USER_DEF_REG_21 "
;tree.end

;tree "DENALI_CTL_117"
base ad:0x801561d4
group 0--3
line.long 0 "DENALI_CTL_117"
hexfld.long 0 " USER_DEF_REG_22 "
;tree.end

;tree "DENALI_CTL_118"
base ad:0x801561d8
group 0--3
line.long 0 "DENALI_CTL_118"
hexfld.long 0 " USER_DEF_REG_23 "
;tree.end

;tree "DENALI_CTL_119"
base ad:0x801561dc
group 0--3
line.long 0 "DENALI_CTL_119"
hexfld.long 0 " USER_DEF_REG_24 "
;tree.end

;tree "DENALI_CTL_120"
base ad:0x801561e0
group 0--3
line.long 0 "DENALI_CTL_120"
hexfld.long 0 " USER_DEF_REG_25 "
;tree.end

;tree "DENALI_CTL_121"
base ad:0x801561e4
group 0--3
line.long 0 "DENALI_CTL_121"
hexfld.long 0 " USER_DEF_REG_26 "
;tree.end

;tree "DENALI_CTL_122"
base ad:0x801561e8
group 0--3
line.long 0 "DENALI_CTL_122"
hexfld.long 0 " USER_DEF_REG_27 "
;tree.end

;tree "DENALI_CTL_123"
base ad:0x801561ec
group 0--3
line.long 0 "DENALI_CTL_123"
hexfld.long 0 " USER_DEF_REG_28 "
;tree.end

;tree "DENALI_CTL_124"
base ad:0x801561f0
group 0--3
line.long 0 "DENALI_CTL_124"
hexfld.long 0 " USER_DEF_REG_29 "
;tree.end

;tree "DENALI_CTL_125"
base ad:0x801561f4
group 0--3
line.long 0 "DENALI_CTL_125"
hexfld.long 0 " USER_DEF_REG_30 "
;tree.end

;tree "DENALI_CTL_126"
base ad:0x801561f8
group 0--3
line.long 0 "DENALI_CTL_126"
hexfld.long 0 " USER_DEF_REG_31 "
;tree.end

;tree "DENALI_CTL_127"
base ad:0x801561fc
group 0--3
line.long 0 "DENALI_CTL_127"
hexfld.long 0 " USER_DEF_REG_4 "
;tree.end

;tree "DENALI_CTL_128"
base ad:0x80156200
group 0--3
line.long 0 "DENALI_CTL_128"
hexfld.long 0 " USER_DEF_REG_5 "
;tree.end

;tree "DENALI_CTL_129"
base ad:0x80156204
group 0--3
line.long 0 "DENALI_CTL_129"
hexfld.long 0 " USER_DEF_REG_6 "
;tree.end

;tree "DENALI_CTL_130"
base ad:0x80156208
group 0--3
line.long 0 "DENALI_CTL_130"
hexfld.long 0 " USER_DEF_REG_7 "
;tree.end

;tree "DENALI_CTL_131"
base ad:0x8015620c
group 0--3
line.long 0 "DENALI_CTL_131"
hexfld.long 0 " USER_DEF_REG_8 "
;tree.end

;tree "DENALI_CTL_132"
base ad:0x80156210
group 0--3
line.long 0 "DENALI_CTL_132"
hexfld.long 0 " USER_DEF_REG_9 "
;tree.end

;tree "DENALI_CTL_145"
base ad:0x80156244
rgroup 0--3
line.long 0 "DENALI_CTL_145"
bitfld.long 0 0. " SECERR_INT_ACK "  "0 ,1 "
bitfld.long 0 4.--5. " SECERR_INT_MASK "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " SECERR_INT_STATUS "  "0 ,1 ,2 ,3 "
hexfld.word 2 " SECERR_COUNTER "
;tree.end

;tree "DENALI_CTL_146"
base ad:0x80156248
rgroup 0--3
line.long 0 "DENALI_CTL_146"
hexfld.long 0 " SECERR_ADDRESS "
;tree.end

;tree "DENALI_CTL_147"
base ad:0x8015624c
rgroup 0--3
line.long 0 "DENALI_CTL_147"
bitfld.long 0 0.--9. " SECERR_ID "  " "
bitfld.long 0 10.--11. " SECERR_PORT "  "0 ,1 ,2 ,3 "
bitfld.long 0 16. " SECERR_TYPE "  "0 ,1 "
hexfld.byte 3 " SECERR_LENGTH "
;tree.end

;tree "DENALI_CTL_148"
base ad:0x80156250
group 0--3
line.long 0 "DENALI_CTL_148"
hexfld.long 0 " USER_DEF_REG_10 "
;tree.end

;tree "DENALI_CTL_149"
base ad:0x80156254
group 0--3
line.long 0 "DENALI_CTL_149"
hexfld.long 0 " USER_DEF_REG_11 "
;tree.end

;tree "DENALI_CTL_150"
base ad:0x80156258
group 0--3
line.long 0 "DENALI_CTL_150"
hexfld.long 0 " USER_DEF_REG_12 "
;tree.end

;tree "DENALI_CTL_151"
base ad:0x8015625c
group 0--3
line.long 0 "DENALI_CTL_151"
hexfld.long 0 " USER_DEF_REG_13 "
;tree.end

;tree "DENALI_CTL_152"
base ad:0x80156260
group 0--3
line.long 0 "DENALI_CTL_152"
hexfld.long 0 " USER_DEF_REG_14 "
;tree.end

;tree "DENALI_CTL_153"
base ad:0x80156264
group 0--3
line.long 0 "DENALI_CTL_153"
hexfld.long 0 " USER_DEF_REG_15 "
;tree.end

;tree "DENALI_CTL_154"
base ad:0x80156268
group 0--3
line.long 0 "DENALI_CTL_154"
hexfld.long 0 " USER_DEF_REG_16 "
;tree.end

;tree "DENALI_CTL_155"
base ad:0x8015626c
group 0--3
line.long 0 "DENALI_CTL_155"
hexfld.long 0 " USER_DEF_REG_17 "
;tree.end

;tree "DENALI_CTL_156"
base ad:0x80156270
group 0--3
line.long 0 "DENALI_CTL_156"
hexfld.long 0 " USER_DEF_REG_18 "
;tree.end

;tree "DENALI_CTL_157"
base ad:0x80156274
group 0--3
line.long 0 "DENALI_CTL_157"
hexfld.long 0 " USER_DEF_REG_19 "
;tree.end

;tree "DENALI_CTL_158"
base ad:0x80156278
group 0--3
line.long 0 "DENALI_CTL_158"
hexfld.long 0 " USER_DEF_REG_20 "
;tree.end

;tree "DENALI_CTL_159"
base ad:0x8015627c
group 0--3
line.long 0 "DENALI_CTL_159"
hexfld.long 0 " USER_DEF_REG_21 "
;tree.end

;tree "DENALI_CTL_160"
base ad:0x80156280
group 0--3
line.long 0 "DENALI_CTL_160"
hexfld.long 0 " USER_DEF_REG_22 "
;tree.end

;tree "DENALI_CTL_161"
base ad:0x80156284
group 0--3
line.long 0 "DENALI_CTL_161"
hexfld.long 0 " USER_DEF_REG_23 "
;tree.end

;tree "DENALI_CTL_162"
base ad:0x80156288
group 0--3
line.long 0 "DENALI_CTL_162"
hexfld.long 0 " USER_DEF_REG_24 "
;tree.end

;tree "DENALI_CTL_163"
base ad:0x8015628c
group 0--3
line.long 0 "DENALI_CTL_163"
hexfld.long 0 " USER_DEF_REG_25 "
;tree.end

;tree "DENALI_CTL_164"
base ad:0x80156290
group 0--3
line.long 0 "DENALI_CTL_164"
hexfld.long 0 " USER_DEF_REG_26 "
;tree.end

;tree "DENALI_CTL_165"
base ad:0x80156294
group 0--3
line.long 0 "DENALI_CTL_165"
hexfld.long 0 " USER_DEF_REG_27 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "DBAHN_GFX"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "DENALI_CTL_00"
base ad:0x8015a000
group 0--3
line.long 0 "DENALI_CTL_00"
bitfld.long 0 0. " ACTIVE_AGING "  "0 ,1 "
bitfld.long 0 8. " ADDR_CMP_EN "  "0 ,1 "
bitfld.long 0 16. " AP "  "0 ,1 "
bitfld.long 0 24. " AREFRESH "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_01"
base ad:0x8015a004
group 0--3
line.long 0 "DENALI_CTL_01"
bitfld.long 0 0. " AUTO_REFRESH_MODE "  "0 ,1 "
bitfld.long 0 8. " AXI0_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 16. " AXI1_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 24. " AXI2_BDW_OVFLOW "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_02"
base ad:0x8015a008
group 0--3
line.long 0 "DENALI_CTL_02"
bitfld.long 0 0. " AXI3_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 8. " BANK_SPLIT_EN "  "0 ,1 "
bitfld.long 0 16. " CONCURRENTAP "  "0 ,1 "
bitfld.long 0 24. " DLLLOCKREG "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_03"
base ad:0x8015a00c
group 0--3
line.long 0 "DENALI_CTL_03"
bitfld.long 0 0. " DLL_BYPASS_MODE "  "0 ,1 "
bitfld.long 0 8. " DRIVE_DQ_DQ "  "0 ,1 "
bitfld.long 0 16. " ENABLE_QUICK_SREFRESH "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_04"
base ad:0x8015a010
group 0--3
line.long 0 "DENALI_CTL_04"
bitfld.long 0 0. " FAST_WRITE "  "0 ,1 "
bitfld.long 0 8. " INTRPTAPBURST "  "0 ,1 "
bitfld.long 0 16. " INTRPTREADA "  "0 ,1 "
bitfld.long 0 24. " INTRPTWRITEA "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_05"
base ad:0x8015a014
group 0--3
line.long 0 "DENALI_CTL_05"
bitfld.long 0 0. " NO_CMD_INIT "  "0 ,1 "
bitfld.long 0 8. " PLACEMENT_EN "  "0 ,1 "
bitfld.long 0 16. " POWER_DOWN "  "0 ,1 "
bitfld.long 0 24. " PRIORITY_EN "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_06"
base ad:0x8015a018
group 0--3
line.long 0 "DENALI_CTL_06"
bitfld.long 0 0. " PWRUP_SREFRESH_EXIT "  "0 ,1 "
bitfld.long 0 8. " RD2RD_TURN "  "0 ,1 "
bitfld.long 0 16. " REDUC "  "0 ,1 "
bitfld.long 0 24. " REG_DIMM_ENABLE "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_07"
base ad:0x8015a01c
group 0--3
line.long 0 "DENALI_CTL_07"
bitfld.long 0 0. " RW_SAME_EN "  "0 ,1 "
bitfld.long 0 8. " SREFRESH "  "0 ,1 "
bitfld.long 0 16. " START "  "0 ,1 "
bitfld.long 0 24. " SWAP_EN "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_08"
base ad:0x8015a020
group 0--3
line.long 0 "DENALI_CTL_08"
bitfld.long 0 0. " TRAS_LOCKOUT "  "0 ,1 "
bitfld.long 0 8. " TREF_ENABLE "  "0 ,1 "
bitfld.long 0 16. " WRITEINTERP "  "0 ,1 "
bitfld.long 0 24. " WRITE_MODEREG "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_09"
base ad:0x8015a024
group 0--3
line.long 0 "DENALI_CTL_09"
bitfld.long 0 0. " WRLAT "  "0 ,1 "
bitfld.long 0 8.--9. " AXI0_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI0_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI0_W_PRIORITY "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DENALI_CTL_10"
base ad:0x8015a028
group 0--3
line.long 0 "DENALI_CTL_10"
bitfld.long 0 0.--1. " AXI1_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI1_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI1_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI2_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DENALI_CTL_11"
base ad:0x8015a02c
group 0--3
line.long 0 "DENALI_CTL_11"
bitfld.long 0 0.--1. " AXI2_R_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " AXI2_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " AXI3_FIFO_TYPE_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " AXI3_R_PRIORITY "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DENALI_CTL_12"
base ad:0x8015a030
group 0--3
line.long 0 "DENALI_CTL_12"
bitfld.long 0 0.--1. " AXI3_W_PRIORITY "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " CS_MAP "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " LOWPOWER_REFRESH_ENABLE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DENALI_CTL_13"
base ad:0x8015a034
group 0--3
line.long 0 "DENALI_CTL_13"
bitfld.long 0 0.--1. " MAX_CS_REG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TEMRS "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " WRTPRCT_ENABLE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DENALI_CTL_14"
base ad:0x8015a038
group 0--3
line.long 0 "DENALI_CTL_14"
bitfld.long 0 0.--2. " ARB_CMD_Q_THRESHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " BSTLEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " CASLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " CKE_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DENALI_CTL_15"
base ad:0x8015a03c
group 0--3
line.long 0 "DENALI_CTL_15"
bitfld.long 0 8.--10. " PORT_DATA_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " Q_FULLNESS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TCKE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DENALI_CTL_16"
base ad:0x8015a040
group 0--3
line.long 0 "DENALI_CTL_16"
bitfld.long 0 0.--2. " TDFI_CTRL_DELAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDFI_DRAM_CLK_DISABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " TDFI_DRAM_CLK_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " TRRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DENALI_CTL_17"
base ad:0x8015a044
group 0--3
line.long 0 "DENALI_CTL_17"
bitfld.long 0 0.--3. " TWTR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--28. " CASLAT_LIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DENALI_CTL_18"
base ad:0x8015a048
group 0--3
line.long 0 "DENALI_CTL_18"
bitfld.long 0 0.--3. " CASLAT_LIN_GATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " COMMAND_AGE_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " INITAREF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAX_COL_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DENALI_CTL_19"
base ad:0x8015a04c
group 0--3
line.long 0 "DENALI_CTL_19"
bitfld.long 0 0.--3. " MAX_ROW_REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " PORT_CMD_ERROR_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_CTRLUPD_MIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DENALI_CTL_20"
base ad:0x8015a050
group 0--3
line.long 0 "DENALI_CTL_20"
bitfld.long 0 0.--3. " TDFI_PHY_RDLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TDFI_PHY_WRLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " TDFI_PHY_WRLAT_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " TDFI_RDDATA_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DENALI_CTL_21"
base ad:0x8015a054
group 0--3
line.long 0 "DENALI_CTL_21"
bitfld.long 0 0.--4. " TDFI_RDDATA_EN_BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " TRP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " TWR_INT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--30. " DLL_LOCK "  " "
;tree.end

;tree "DENALI_CTL_22"
base ad:0x8015a058
group 0--3
line.long 0 "DENALI_CTL_22"
bitfld.long 0 0.--4. " LOWPOWER_AUTO_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " LOWPOWER_CONTROL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--21. " OUT_OF_RANGE_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 24.--28. " TMRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DENALI_CTL_23"
base ad:0x8015a05c
group 0--3
line.long 0 "DENALI_CTL_23"
bitfld.long 0 0.--5. " TRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8.--14. " AXI0_BDW "  " "
bitfld.long 0 16.--22. " AXI0_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI1_BDW "  " "
;tree.end

;tree "DENALI_CTL_24"
base ad:0x8015a060
group 0--3
line.long 0 "DENALI_CTL_24"
bitfld.long 0 0.--6. " AXI1_CURRENT_BDW "  " "
bitfld.long 0 8.--14. " AXI2_BDW "  " "
bitfld.long 0 16.--22. " AXI2_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI3_BDW "  " "
;tree.end

;tree "DENALI_CTL_25"
base ad:0x8015a064
rgroup 0--3
line.long 0 "DENALI_CTL_25"
bitfld.long 0 0.--6. " AXI3_CURRENT_BDW "  " "
bitfld.long 0 16.--22. " OUT_OF_RANGE_LENGTH "  " "
bitfld.long 0 24.--30. " WRTPRCT_ERROR_LENGTH "  " "
;tree.end

;tree "DENALI_CTL_26"
base ad:0x8015a068
group 0--3
line.long 0 "DENALI_CTL_26"
hexfld.byte 2 " TRAS_MIN "
hexfld.byte 3 " TRCD_INT "
;tree.end

;tree "DENALI_CTL_27"
base ad:0x8015a06c
group 0--3
line.long 0 "DENALI_CTL_27"
hexfld.byte 0 " TRFC "
bitfld.long 0 8.--17. " OUT_OF_RANGE_SOURCE_ID "  " "
;tree.end

;tree "DENALI_CTL_28"
base ad:0x8015a070
rgroup 0--3
line.long 0 "DENALI_CTL_28"
bitfld.long 0 0.--11. " PORT_CMD_ERROR_ID "  " "
bitfld.long 0 16.--27. " PORT_DATA_ERROR_ID "  " "
;tree.end

;tree "DENALI_CTL_29"
base ad:0x8015a074
rgroup 0--3
line.long 0 "DENALI_CTL_29"
hexfld.word 0 " TDFI_CTRLUPD_MAX "
hexfld.word 2 " TDFI_PHYUPD_RESP "
;tree.end

;tree "DENALI_CTL_30"
base ad:0x8015a078
group 0--3
line.long 0 "DENALI_CTL_30"
hexfld.word 0 " TDFI_PHYUPD_TYPE0 "
hexfld.word 2 " TREF "
;tree.end

;tree "DENALI_CTL_31"
base ad:0x8015a07c
rgroup 0--3
line.long 0 "DENALI_CTL_31"
;tree.end

;tree "DENALI_CTL_32"
base ad:0x8015a080
group 0--3
line.long 0 "DENALI_CTL_32"
hexfld.word 2 " AXI0_EN_SIZE_LT_WIDTH_INSTR "
;tree.end

;tree "DENALI_CTL_33"
base ad:0x8015a084
group 0--3
line.long 0 "DENALI_CTL_33"
hexfld.word 0 " AXI1_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 2 " AXI2_EN_SIZE_LT_WIDTH_INSTR "
;tree.end

;tree "DENALI_CTL_34"
base ad:0x8015a088
group 0--3
line.long 0 "DENALI_CTL_34"
hexfld.word 0 " AXI3_EN_SIZE_LT_WIDTH_INSTR "
hexfld.word 2 " LOWPOWER_EXTERNAL_CNT "
;tree.end

;tree "DENALI_CTL_35"
base ad:0x8015a08c
group 0--3
line.long 0 "DENALI_CTL_35"
hexfld.word 0 " LOWPOWER_INTERNAL_CNT "
hexfld.word 2 " LOWPOWER_POWER_DOWN_CNT "
;tree.end

;tree "DENALI_CTL_36"
base ad:0x8015a090
group 0--3
line.long 0 "DENALI_CTL_36"
hexfld.word 0 " LOWPOWER_REFRESH_HOLD "
hexfld.word 2 " LOWPOWER_SELF_REFRESH_CNT "
;tree.end

;tree "DENALI_CTL_37"
base ad:0x8015a094
group 0--3
line.long 0 "DENALI_CTL_37"
hexfld.word 0 " TDLL "
hexfld.word 2 " TPDEX "
;tree.end

;tree "DENALI_CTL_38"
base ad:0x8015a098
group 0--3
line.long 0 "DENALI_CTL_38"
hexfld.word 0 " TRAS_MAX "
hexfld.word 2 " TXSNR "
;tree.end

;tree "DENALI_CTL_39"
base ad:0x8015a09c
group 0--3
line.long 0 "DENALI_CTL_39"
hexfld.word 0 " TXSR "
hexfld.word 2 " VERSION "
;tree.end

;tree "DENALI_CTL_40"
base ad:0x8015a0a0
group 0--3
line.long 0 "DENALI_CTL_40"
bitfld.long 0 0.--23. " TINIT "  " "
;tree.end

;tree "DENALI_CTL_41"
base ad:0x8015a0a4
rgroup 0--3
line.long 0 "DENALI_CTL_41"
hexfld.long 0 " OUT_OF_RANGE_ADDR "
;tree.end

;tree "DENALI_CTL_42"
base ad:0x8015a0a8
rgroup 0--3
line.long 0 "DENALI_CTL_42"
hexfld.long 0 " PORT_CMD_ERROR_ADDR "
;tree.end

;tree "DENALI_CTL_43"
base ad:0x8015a0ac
rgroup 0--3
line.long 0 "DENALI_CTL_43"
hexfld.long 0 " WRTPRCT_ERROR_ADDRESS "
;tree.end

;tree "DENALI_CTL_44"
base ad:0x8015a0b0
group 0--3
line.long 0 "DENALI_CTL_44"
hexfld.long 0 " WRTPRCT_LOWER_ADDRESS_0 "
;tree.end

;tree "DENALI_CTL_45"
base ad:0x8015a0b4
group 0--3
line.long 0 "DENALI_CTL_45"
hexfld.long 0 " WRTPRCT_LOWER_ADDRESS_1 "
;tree.end

;tree "DENALI_CTL_46"
base ad:0x8015a0b8
group 0--3
line.long 0 "DENALI_CTL_46"
hexfld.long 0 " WRTPRCT_UPPER_ADDRESS_0 "
;tree.end

;tree "DENALI_CTL_47"
base ad:0x8015a0bc
group 0--3
line.long 0 "DENALI_CTL_47"
hexfld.long 0 " WRTPRCT_UPPER_ADDRESS_1 "
;tree.end

;tree "DENALI_CTL_59"
base ad:0x8015a0ec
group 0--3
line.long 0 "DENALI_CTL_59"
hexfld.long 0 " PHY_ADD "
;tree.end

;tree "DENALI_CTL_60"
base ad:0x8015a0f0
group 0--3
line.long 0 "DENALI_CTL_60"
hexfld.long 0 " PHY_CFG "
;tree.end

;tree "DENALI_CTL_61"
base ad:0x8015a0f4
rgroup 0--3
line.long 0 "DENALI_CTL_61"
hexfld.long 0 " PHY_STS "
;tree.end

;tree "DENALI_CTL_62"
base ad:0x8015a0f8
rgroup 0--3
line.long 0 "DENALI_CTL_62"
;tree.end

;tree "DENALI_CTL_63"
base ad:0x8015a0fc
group 0--3
line.long 0 "DENALI_CTL_63"
bitfld.long 0 0.--2. " WRLAT_ADJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " W2R_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " W2R_SAMECS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--27. " DRAM_CLASS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DENALI_CTL_64"
base ad:0x8015a100
group 0--3
line.long 0 "DENALI_CTL_64"
bitfld.long 0 0.--4. " RDLAT_ADJ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
hexfld.byte 1 " DLL_RST_ADJ_DLY "
hexfld.byte 2 " TMOD "
;tree.end

;tree "DENALI_CTL_65"
base ad:0x8015a104
group 0--3
line.long 0 "DENALI_CTL_65"
;tree.end

;tree "DENALI_CTL_66"
base ad:0x8015a108
group 0--3
line.long 0 "DENALI_CTL_66"
;tree.end

;tree "DENALI_CTL_67"
base ad:0x8015a10c
group 0--3
line.long 0 "DENALI_CTL_67"
hexfld.word 0 " DLL_RST_DELAY "
;tree.end

;tree "DENALI_CTL_72"
base ad:0x8015a120
group 0--3
line.long 0 "DENALI_CTL_72"
hexfld.long 0 " USER_DEF_REG_2 "
;tree.end

;tree "DENALI_CTL_73"
base ad:0x8015a124
group 0--3
line.long 0 "DENALI_CTL_73"
bitfld.long 0 26. " DEBUG_DFI_TRIGGER_IS_WRITE "  "0 ,1 "
bitfld.long 0 27. " DENALI_JTAG_CONTROL_ENABLE "  "0 ,1 "
bitfld.long 0 28. " DENALI_JTAG_TRSTN "  "0 ,1 "
bitfld.long 0 29. " DENALI_JTAG_TCK "  "0 ,1 "
bitfld.long 0 30. " DENALI_JTAG_TMS "  "0 ,1 "
bitfld.long 0 31. " DENALI_JTAG_TDI "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_74"
base ad:0x8015a128
group 0--3
line.long 0 "DENALI_CTL_74"
hexfld.long 0 " USER_DEF_REG_RO_2 "
;tree.end

;tree "DENALI_CTL_75"
base ad:0x8015a12c
rgroup 0--3
line.long 0 "DENALI_CTL_75"
bitfld.long 0 30. " DFI_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 31. " DENALI_JTAG_TDO "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_76"
base ad:0x8015a130
rgroup 0--3
line.long 0 "DENALI_CTL_76"
bitfld.long 0 8. " DQS_N_EN "  "0 ,1 "
bitfld.long 0 24. " LPDDR2_S4 "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_77"
base ad:0x8015a134
group 0--3
line.long 0 "DENALI_CTL_77"
bitfld.long 0 0.--1. " TDQSCK_MAX "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TDQSCK_MIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--26. " R2R_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DENALI_CTL_78"
base ad:0x8015a138
group 0--3
line.long 0 "DENALI_CTL_78"
bitfld.long 0 0.--1. " TDQSCK_MAX "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " TDQSCK_MIN "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--28. " TCCD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DENALI_CTL_79"
base ad:0x8015a13c
group 0--3
line.long 0 "DENALI_CTL_79"
bitfld.long 0 0.--2. " TRTP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " W2W_DIFFCS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " W2W_SAMECS_DLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--28. " TMRR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DENALI_CTL_80"
base ad:0x8015a140
group 0--3
line.long 0 "DENALI_CTL_80"
bitfld.long 0 8.--11. " ZQ_ON_SREF_EXIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " ZQ_REQ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--29. " TFAW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "DENALI_CTL_81"
base ad:0x8015a144
group 0--3
line.long 0 "DENALI_CTL_81"
hexfld.byte 0 " REFRESH_PER_ZQ "
bitfld.long 0 8.--17. " INT_MASK "  " "
;tree.end

;tree "DENALI_CTL_82"
base ad:0x8015a148
group 0--3
line.long 0 "DENALI_CTL_82"
bitfld.long 0 0.--9. " INT_STATUS "  " "
bitfld.long 0 16.--27. " ZQCL "  " "
;tree.end

;tree "DENALI_CTL_83"
base ad:0x8015a14c
group 0--3
line.long 0 "DENALI_CTL_83"
bitfld.long 0 0.--11. " ZQCS "  " "
bitfld.long 0 16.--27. " ZQINIT "  " "
;tree.end

;tree "DENALI_CTL_84"
base ad:0x8015a150
group 0--3
line.long 0 "DENALI_CTL_84"
bitfld.long 0 0.--11. " ZQRESET "  " "
bitfld.long 0 16.--30. " MR0_DATA_0 "  " "
;tree.end

;tree "DENALI_CTL_85"
base ad:0x8015a154
group 0--3
line.long 0 "DENALI_CTL_85"
bitfld.long 0 0.--14. " MR0_DATA_1 "  " "
bitfld.long 0 16.--30. " MR16_DATA_0 "  " "
;tree.end

;tree "DENALI_CTL_86"
base ad:0x8015a158
group 0--3
line.long 0 "DENALI_CTL_86"
bitfld.long 0 0.--14. " MR16_DATA_1 "  " "
bitfld.long 0 16.--30. " MR17_DATA_0 "  " "
;tree.end

;tree "DENALI_CTL_87"
base ad:0x8015a15c
group 0--3
line.long 0 "DENALI_CTL_87"
bitfld.long 0 0.--14. " MR17_DATA_1 "  " "
bitfld.long 0 16.--30. " MR1_DATA_0 "  " "
;tree.end

;tree "DENALI_CTL_88"
base ad:0x8015a160
group 0--3
line.long 0 "DENALI_CTL_88"
bitfld.long 0 0.--14. " MR1_DATA_1 "  " "
bitfld.long 0 16.--30. " MR2_DATA_0 "  " "
;tree.end

;tree "DENALI_CTL_89"
base ad:0x8015a164
group 0--3
line.long 0 "DENALI_CTL_89"
bitfld.long 0 0.--14. " MR2_DATA_1 "  " "
bitfld.long 0 16.--30. " MR3_DATA_0 "  " "
;tree.end

;tree "DENALI_CTL_90"
base ad:0x8015a168
group 0--3
line.long 0 "DENALI_CTL_90"
bitfld.long 0 0.--14. " MR3_DATA_1 "  " "
hexfld.word 2 " PERIPHERAL_MRR_DATA "
;tree.end

;tree "DENALI_CTL_91"
base ad:0x8015a16c
group 0--3
line.long 0 "DENALI_CTL_91"
bitfld.long 0 0.--16. " READ_MODEREG "  " "
;tree.end

;tree "DENALI_CTL_92"
base ad:0x8015a170
group 0--3
line.long 0 "DENALI_CTL_92"
bitfld.long 0 0.--23. " TINIT3 "  " "
;tree.end

;tree "DENALI_CTL_93"
base ad:0x8015a174
group 0--3
line.long 0 "DENALI_CTL_93"
bitfld.long 0 0.--23. " TINIT4 "  " "
;tree.end

;tree "DENALI_CTL_94"
base ad:0x8015a178
group 0--3
line.long 0 "DENALI_CTL_94"
bitfld.long 0 0.--23. " TINIT5 "  " "
bitfld.long 0 24. " CONCURRENTAP_WR_ONLY "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_95"
base ad:0x8015a17c
group 0--3
line.long 0 "DENALI_CTL_95"
bitfld.long 0 0. " CONFIG_ERROR "  "0 ,1 "
bitfld.long 0 8. " EIGHT_BANK_MODE_0 "  "0 ,1 "
bitfld.long 0 16. " EIGHT_BANK_MODE_1 "  "0 ,1 "
bitfld.long 0 24. " RESYNC_DLL "  "0 ,1 "
;tree.end

;tree "DENALI_CTL_96"
base ad:0x8015a180
group 0--3
line.long 0 "DENALI_CTL_96"
bitfld.long 0 0. " RESYNC_DLL_PER_AREF_EN "  "0 ,1 "
bitfld.long 0 8. " ZQCS_ROTATE "  "0 ,1 "
bitfld.long 0 16. " ZQ_IN_PROGRESS "  "0 ,1 "
bitfld.long 0 24.--26. " ADDR_PINS_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DENALI_CTL_97"
base ad:0x8015a184
group 0--3
line.long 0 "DENALI_CTL_97"
bitfld.long 0 0.--2. " ADDR_PINS_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " COLUMN_SIZE_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " COLUMN_SIZE_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--27. " APREBIT_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DENALI_CTL_98"
base ad:0x8015a188
group 0--3
line.long 0 "DENALI_CTL_98"
bitfld.long 0 0.--3. " APREBIT_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--12. " TRP_AB_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " TRP_AB_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DENALI_CTL_99"
base ad:0x8015a18c
group 0--3
line.long 0 "DENALI_CTL_99"
bitfld.long 0 0.--8. " INT_ACK "  " "
hexfld.word 2 " CS_MSK_0 "
;tree.end

;tree "DENALI_CTL_100"
base ad:0x8015a190
group 0--3
line.long 0 "DENALI_CTL_100"
hexfld.word 0 " CS_MSK_1 "
hexfld.word 2 " CS_VAL_0 "
;tree.end

;tree "DENALI_CTL_101"
base ad:0x8015a194
group 0--3
line.long 0 "DENALI_CTL_101"
hexfld.word 0 " CS_VAL_1 "
bitfld.long 0 16.--18. " TBST_INT_INTERVAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--27. " CKSRE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DENALI_CTL_102"
base ad:0x8015a198
group 0--3
line.long 0 "DENALI_CTL_102"
bitfld.long 0 0.--3. " CKSRX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--12. " TCKESR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--29. " TREF_INTERVAL "  " "
;tree.end

;tree "DENALI_CTL_103"
base ad:0x8015a19c
group 0--3
line.long 0 "DENALI_CTL_103"
hexfld.word 0 " TDFI_PHYUPD_TYPE1 "
hexfld.word 2 " TDFI_PHYUPD_TYPE2 "
;tree.end

;tree "DENALI_CTL_104"
base ad:0x8015a1a0
group 0--3
line.long 0 "DENALI_CTL_104"
hexfld.word 0 " TDFI_PHYUPD_TYPE3 "
;tree.end

;tree "DENALI_CTL_105"
base ad:0x8015a1a4
group 0--3
line.long 0 "DENALI_CTL_105"
hexfld.long 0 " USER_DEF_REG_10 "
;tree.end

;tree "DENALI_CTL_106"
base ad:0x8015a1a8
group 0--3
line.long 0 "DENALI_CTL_106"
hexfld.long 0 " USER_DEF_REG_11 "
;tree.end

;tree "DENALI_CTL_107"
base ad:0x8015a1ac
group 0--3
line.long 0 "DENALI_CTL_107"
hexfld.long 0 " USER_DEF_REG_12 "
;tree.end

;tree "DENALI_CTL_108"
base ad:0x8015a1b0
group 0--3
line.long 0 "DENALI_CTL_108"
hexfld.long 0 " USER_DEF_REG_13 "
;tree.end

;tree "DENALI_CTL_109"
base ad:0x8015a1b4
group 0--3
line.long 0 "DENALI_CTL_109"
hexfld.long 0 " USER_DEF_REG_14 "
;tree.end

;tree "DENALI_CTL_110"
base ad:0x8015a1b8
group 0--3
line.long 0 "DENALI_CTL_110"
hexfld.long 0 " USER_DEF_REG_15 "
;tree.end

;tree "DENALI_CTL_111"
base ad:0x8015a1bc
group 0--3
line.long 0 "DENALI_CTL_111"
hexfld.long 0 " USER_DEF_REG_16 "
;tree.end

;tree "DENALI_CTL_112"
base ad:0x8015a1c0
group 0--3
line.long 0 "DENALI_CTL_112"
hexfld.long 0 " USER_DEF_REG_17 "
;tree.end

;tree "DENALI_CTL_113"
base ad:0x8015a1c4
group 0--3
line.long 0 "DENALI_CTL_113"
hexfld.long 0 " USER_DEF_REG_18 "
;tree.end

;tree "DENALI_CTL_114"
base ad:0x8015a1c8
group 0--3
line.long 0 "DENALI_CTL_114"
hexfld.long 0 " USER_DEF_REG_19 "
;tree.end

;tree "DENALI_CTL_115"
base ad:0x8015a1cc
group 0--3
line.long 0 "DENALI_CTL_115"
hexfld.long 0 " USER_DEF_REG_20 "
;tree.end

;tree "DENALI_CTL_116"
base ad:0x8015a1d0
group 0--3
line.long 0 "DENALI_CTL_116"
hexfld.long 0 " USER_DEF_REG_21 "
;tree.end

;tree "DENALI_CTL_117"
base ad:0x8015a1d4
group 0--3
line.long 0 "DENALI_CTL_117"
hexfld.long 0 " USER_DEF_REG_22 "
;tree.end

;tree "DENALI_CTL_118"
base ad:0x8015a1d8
group 0--3
line.long 0 "DENALI_CTL_118"
hexfld.long 0 " USER_DEF_REG_23 "
;tree.end

;tree "DENALI_CTL_119"
base ad:0x8015a1dc
group 0--3
line.long 0 "DENALI_CTL_119"
hexfld.long 0 " USER_DEF_REG_24 "
;tree.end

;tree "DENALI_CTL_120"
base ad:0x8015a1e0
group 0--3
line.long 0 "DENALI_CTL_120"
hexfld.long 0 " USER_DEF_REG_25 "
;tree.end

;tree "DENALI_CTL_121"
base ad:0x8015a1e4
group 0--3
line.long 0 "DENALI_CTL_121"
hexfld.long 0 " USER_DEF_REG_26 "
;tree.end

;tree "DENALI_CTL_122"
base ad:0x8015a1e8
group 0--3
line.long 0 "DENALI_CTL_122"
hexfld.long 0 " USER_DEF_REG_27 "
;tree.end

;tree "DENALI_CTL_123"
base ad:0x8015a1ec
group 0--3
line.long 0 "DENALI_CTL_123"
hexfld.long 0 " USER_DEF_REG_28 "
;tree.end

;tree "DENALI_CTL_124"
base ad:0x8015a1f0
group 0--3
line.long 0 "DENALI_CTL_124"
hexfld.long 0 " USER_DEF_REG_29 "
;tree.end

;tree "DENALI_CTL_125"
base ad:0x8015a1f4
group 0--3
line.long 0 "DENALI_CTL_125"
hexfld.long 0 " USER_DEF_REG_30 "
;tree.end

;tree "DENALI_CTL_126"
base ad:0x8015a1f8
group 0--3
line.long 0 "DENALI_CTL_126"
hexfld.long 0 " USER_DEF_REG_31 "
;tree.end

;tree "DENALI_CTL_127"
base ad:0x8015a1fc
group 0--3
line.long 0 "DENALI_CTL_127"
hexfld.long 0 " USER_DEF_REG_4 "
;tree.end

;tree "DENALI_CTL_128"
base ad:0x8015a200
group 0--3
line.long 0 "DENALI_CTL_128"
hexfld.long 0 " USER_DEF_REG_5 "
;tree.end

;tree "DENALI_CTL_129"
base ad:0x8015a204
group 0--3
line.long 0 "DENALI_CTL_129"
hexfld.long 0 " USER_DEF_REG_6 "
;tree.end

;tree "DENALI_CTL_130"
base ad:0x8015a208
group 0--3
line.long 0 "DENALI_CTL_130"
hexfld.long 0 " USER_DEF_REG_7 "
;tree.end

;tree "DENALI_CTL_131"
base ad:0x8015a20c
group 0--3
line.long 0 "DENALI_CTL_131"
hexfld.long 0 " USER_DEF_REG_8 "
;tree.end

;tree "DENALI_CTL_132"
base ad:0x8015a210
group 0--3
line.long 0 "DENALI_CTL_132"
hexfld.long 0 " USER_DEF_REG_9 "
;tree.end

;tree "DENALI_CTL_145"
base ad:0x8015a244
rgroup 0--3
line.long 0 "DENALI_CTL_145"
bitfld.long 0 0. " SECERR_INT_ACK "  "0 ,1 "
bitfld.long 0 4.--5. " SECERR_INT_MASK "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " SECERR_INT_STATUS "  "0 ,1 ,2 ,3 "
hexfld.word 2 " SECERR_COUNTER "
;tree.end

;tree "DENALI_CTL_146"
base ad:0x8015a248
rgroup 0--3
line.long 0 "DENALI_CTL_146"
hexfld.long 0 " SECERR_ADDRESS "
;tree.end

;tree "DENALI_CTL_147"
base ad:0x8015a24c
rgroup 0--3
line.long 0 "DENALI_CTL_147"
bitfld.long 0 0.--9. " SECERR_ID "  " "
bitfld.long 0 10.--11. " SECERR_PORT "  "0 ,1 ,2 ,3 "
bitfld.long 0 16. " SECERR_TYPE "  "0 ,1 "
hexfld.byte 3 " SECERR_LENGTH "
;tree.end

;tree "DENALI_CTL_148"
base ad:0x8015a250
group 0--3
line.long 0 "DENALI_CTL_148"
hexfld.long 0 " USER_DEF_REG_10 "
;tree.end

;tree "DENALI_CTL_149"
base ad:0x8015a254
group 0--3
line.long 0 "DENALI_CTL_149"
hexfld.long 0 " USER_DEF_REG_11 "
;tree.end

;tree "DENALI_CTL_150"
base ad:0x8015a258
group 0--3
line.long 0 "DENALI_CTL_150"
hexfld.long 0 " USER_DEF_REG_12 "
;tree.end

;tree "DENALI_CTL_151"
base ad:0x8015a25c
group 0--3
line.long 0 "DENALI_CTL_151"
hexfld.long 0 " USER_DEF_REG_13 "
;tree.end

;tree "DENALI_CTL_152"
base ad:0x8015a260
group 0--3
line.long 0 "DENALI_CTL_152"
hexfld.long 0 " USER_DEF_REG_14 "
;tree.end

;tree "DENALI_CTL_153"
base ad:0x8015a264
group 0--3
line.long 0 "DENALI_CTL_153"
hexfld.long 0 " USER_DEF_REG_15 "
;tree.end

;tree "DENALI_CTL_154"
base ad:0x8015a268
group 0--3
line.long 0 "DENALI_CTL_154"
hexfld.long 0 " USER_DEF_REG_16 "
;tree.end

;tree "DENALI_CTL_155"
base ad:0x8015a26c
group 0--3
line.long 0 "DENALI_CTL_155"
hexfld.long 0 " USER_DEF_REG_17 "
;tree.end

;tree "DENALI_CTL_156"
base ad:0x8015a270
group 0--3
line.long 0 "DENALI_CTL_156"
hexfld.long 0 " USER_DEF_REG_18 "
;tree.end

;tree "DENALI_CTL_157"
base ad:0x8015a274
group 0--3
line.long 0 "DENALI_CTL_157"
hexfld.long 0 " USER_DEF_REG_19 "
;tree.end

;tree "DENALI_CTL_158"
base ad:0x8015a278
group 0--3
line.long 0 "DENALI_CTL_158"
hexfld.long 0 " USER_DEF_REG_20 "
;tree.end

;tree "DENALI_CTL_159"
base ad:0x8015a27c
group 0--3
line.long 0 "DENALI_CTL_159"
hexfld.long 0 " USER_DEF_REG_21 "
;tree.end

;tree "DENALI_CTL_160"
base ad:0x8015a280
group 0--3
line.long 0 "DENALI_CTL_160"
hexfld.long 0 " USER_DEF_REG_22 "
;tree.end

;tree "DENALI_CTL_161"
base ad:0x8015a284
group 0--3
line.long 0 "DENALI_CTL_161"
hexfld.long 0 " USER_DEF_REG_23 "
;tree.end

;tree "DENALI_CTL_162"
base ad:0x8015a288
group 0--3
line.long 0 "DENALI_CTL_162"
hexfld.long 0 " USER_DEF_REG_24 "
;tree.end

;tree "DENALI_CTL_163"
base ad:0x8015a28c
group 0--3
line.long 0 "DENALI_CTL_163"
hexfld.long 0 " USER_DEF_REG_25 "
;tree.end

;tree "DENALI_CTL_164"
base ad:0x8015a290
group 0--3
line.long 0 "DENALI_CTL_164"
hexfld.long 0 " USER_DEF_REG_26 "
;tree.end

;tree "DENALI_CTL_165"
base ad:0x8015a294
group 0--3
line.long 0 "DENALI_CTL_165"
hexfld.long 0 " USER_DEF_REG_27 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "DMA"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "GCC"
base ad:0x801c0000
group 0--3
line.long 0 "GCC"
bitfld.long 0 0. " ENA "  "0 ,1 "
bitfld.long 0 1. " STAT "  "0 ,1 "
bitfld.long 0 8. " SE0 "  "0 ,1 "
bitfld.long 0 9. " DE0 "  "0 ,1 "
bitfld.long 0 10. " SE1 "  "0 ,1 "
bitfld.long 0 11. " DE1 "  "0 ,1 "
bitfld.long 0 12. " SE2 "  "0 ,1 "
bitfld.long 0 13. " DE2 "  "0 ,1 "
bitfld.long 0 14. " SE3 "  "0 ,1 "
bitfld.long 0 15. " DE3 "  "0 ,1 "
;tree.end

;tree "PRTYP"
base ad:0x801c0004
group 0--3
line.long 0 "PRTYP"
bitfld.long 0 0.--1. " CP0TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " CP1TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " CP2TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " CP3TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " CP4TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " CP5TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " CP6TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " CP7TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " CP8TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " CP9TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " CP10TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " CP11TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " CP12TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " CP13TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " CP14TYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " CP15TYP "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRSME"
base ad:0x801c0008
group 0--3
line.long 0 "PRSME"
bitfld.long 0 0.--1. " PR0SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR2SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR4SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR6SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR8SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR10SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR12SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR14SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR16SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR18SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR20SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR22SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR24SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR26SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR28SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR30SEC "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRSMO"
base ad:0x801c000c
group 0--3
line.long 0 "PRSMO"
bitfld.long 0 0.--1. " PR1SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR3SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR5SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR7SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR9SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR11SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR13SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR15SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR17SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR19SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR21SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR23SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR25SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR27SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR29SEC "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR31SEC "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRMSE"
base ad:0x801c0010
group 0--3
line.long 0 "PRMSE"
bitfld.long 0 0.--1. " PR0MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR2MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR4MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR6MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR8MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR10MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR12MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR14MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR16MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR18MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR20MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR22MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR24MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR26MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR28MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR30MOD "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRMSO"
base ad:0x801c0014
group 0--3
line.long 0 "PRMSO"
bitfld.long 0 0.--1. " PR1MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR3MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR5MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR7MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR9MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR11MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR13MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR15MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR17MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR19MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR21MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR23MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR25MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR27MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR29MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR31MOD "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRMOE"
base ad:0x801c0018
group 0--3
line.long 0 "PRMOE"
bitfld.long 0 0.--1. " PR0OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR2OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR4OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR6OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR8OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR10OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR12OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR14OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR16OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR18OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR20OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR22OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR24OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR26OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR28OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR30OPT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRMOO"
base ad:0x801c001c
group 0--3
line.long 0 "PRMOO"
bitfld.long 0 0.--1. " PR1OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR3OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR5OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR7OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR9OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR11OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR13OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR15OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR17OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR19OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR21OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR23OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR25OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR27OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR29OPT "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR31OPT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "LCPA"
base ad:0x801c0020
group 0--3
line.long 0 "LCPA"
bitfld.long 0 11.--31. " LCPA "  " "
;tree.end

;tree "LCLA"
base ad:0x801c0024
group 0--3
line.long 0 "LCLA"
bitfld.long 0 18.--31. " LCLA "  " "
;tree.end

;tree "SLCPA"
base ad:0x801c0028
group 0--3
line.long 0 "SLCPA"
bitfld.long 0 11.--31. " SLCPA "  " "
;tree.end

;tree "SLCLA"
base ad:0x801c002c
group 0--3
line.long 0 "SLCLA"
bitfld.long 0 18.--31. " SLCLA "  " "
;tree.end

;tree "SSEG1"
base ad:0x801c0030
group 0--3
line.long 0 "SSEG1"
hexfld.word 0 " SSSEL "
hexfld.word 2 " SSDEL "
;tree.end

;tree "SSEG2"
base ad:0x801c0034
group 0--3
line.long 0 "SSEG2"
hexfld.word 0 " SSSEL "
hexfld.word 2 " SSDEL "
;tree.end

;tree "SSEG3"
base ad:0x801c0038
group 0--3
line.long 0 "SSEG3"
hexfld.word 0 " SSSEL "
hexfld.word 2 " SSDEL "
;tree.end

;tree "SSEG4"
base ad:0x801c003c
group 0--3
line.long 0 "SSEG4"
hexfld.word 0 " SSSEL "
hexfld.word 2 " SSDEL "
;tree.end

;tree "SCEG1"
base ad:0x801c0040
group 0--3
line.long 0 "SCEG1"
hexfld.word 0 " SCSEL "
hexfld.word 2 " SCDEL "
;tree.end

;tree "SCEG2"
base ad:0x801c0044
group 0--3
line.long 0 "SCEG2"
hexfld.word 0 " SCSEL "
hexfld.word 2 " SCDEL "
;tree.end

;tree "SCEG3"
base ad:0x801c0048
group 0--3
line.long 0 "SCEG3"
hexfld.word 0 " SCSEL "
hexfld.word 2 " SCDEL "
;tree.end

;tree "SCEG4"
base ad:0x801c004c
group 0--3
line.long 0 "SCEG4"
hexfld.word 0 " SCSEL "
hexfld.word 2 " SCDEL "
;tree.end

;tree "ACTIVE"
base ad:0x801c0050
group 0--3
line.long 0 "ACTIVE"
bitfld.long 0 0.--1. " PR0AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR2AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR4AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR6AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR8AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR10AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR12AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR14AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR16AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR18AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR20AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR22AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR24AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR26AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR28AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR30AS "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ACTIVO"
base ad:0x801c0054
group 0--3
line.long 0 "ACTIVO"
bitfld.long 0 0.--1. " PR1AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " PR3AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " PR5AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " PR7AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PR9AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PR11AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " PR13AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PR15AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " PR17AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " PR19AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " PR21AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " PR23AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " PR25AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " PR27AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " PR29AS "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " PR31AS "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PCMIS"
base ad:0x801c0060
group 0--3
line.long 0 "PCMIS"
hexfld.long 0 " PCMIS "
;tree.end

;tree "PCICR"
base ad:0x801c0064
wgroup 0--3
line.long 0 "PCICR"
hexfld.long 0 " PCICR "
;tree.end

;tree "PCTIS"
base ad:0x801c0068
group 0--3
line.long 0 "PCTIS"
hexfld.long 0 " PCTIS "
;tree.end

;tree "PCEIS"
base ad:0x801c006c
group 0--3
line.long 0 "PCEIS"
hexfld.long 0 " PCEIS "
;tree.end

;tree "SPCMIS"
base ad:0x801c0070
group 0--3
line.long 0 "SPCMIS"
hexfld.long 0 " SPCMIS "
;tree.end

;tree "SPCICR"
base ad:0x801c0074
wgroup 0--3
line.long 0 "SPCICR"
hexfld.long 0 " PCICR "
;tree.end

;tree "SPCTIS"
base ad:0x801c0078
group 0--3
line.long 0 "SPCTIS"
hexfld.long 0 " SPCTIS "
;tree.end

;tree "SPCEIS"
base ad:0x801c007c
group 0--3
line.long 0 "SPCEIS"
hexfld.long 0 " SPCEIS "
;tree.end

;tree "LCMIS1"
base ad:0x801c0080
group 0--3
line.long 0 "LCMIS1"
hexfld.long 0 " LCMIS "
;tree.end

;tree "LCMIS2"
base ad:0x801c0084
group 0--3
line.long 0 "LCMIS2"
hexfld.long 0 " LCMIS "
;tree.end

;tree "LCMIS3"
base ad:0x801c0088
group 0--3
line.long 0 "LCMIS3"
hexfld.long 0 " LCMIS "
;tree.end

;tree "LCMIS4"
base ad:0x801c008c
group 0--3
line.long 0 "LCMIS4"
hexfld.long 0 " LCMIS "
;tree.end

;tree "LCICR1"
base ad:0x801c0090
wgroup 0--3
line.long 0 "LCICR1"
hexfld.long 0 " LCICR "
;tree.end

;tree "LCICR2"
base ad:0x801c0094
wgroup 0--3
line.long 0 "LCICR2"
hexfld.long 0 " LCICR "
;tree.end

;tree "LCICR3"
base ad:0x801c0098
wgroup 0--3
line.long 0 "LCICR3"
hexfld.long 0 " LCICR "
;tree.end

;tree "LCICR4"
base ad:0x801c009c
wgroup 0--3
line.long 0 "LCICR4"
hexfld.long 0 " LCICR "
;tree.end

;tree "LCTIS1"
base ad:0x801c00a0
group 0--3
line.long 0 "LCTIS1"
hexfld.long 0 " LCTIS "
;tree.end

;tree "LCTIS2"
base ad:0x801c00a4
group 0--3
line.long 0 "LCTIS2"
hexfld.long 0 " LCTIS "
;tree.end

;tree "LCTIS3"
base ad:0x801c00a8
group 0--3
line.long 0 "LCTIS3"
hexfld.long 0 " LCTIS "
;tree.end

;tree "LCTIS4"
base ad:0x801c00ac
group 0--3
line.long 0 "LCTIS4"
hexfld.long 0 " LCTIS "
;tree.end

;tree "LCEIS1"
base ad:0x801c00b0
group 0--3
line.long 0 "LCEIS1"
hexfld.long 0 " LCEIS "
;tree.end

;tree "LCEIS2"
base ad:0x801c00b4
group 0--3
line.long 0 "LCEIS2"
hexfld.long 0 " LCEIS "
;tree.end

;tree "LCEIS3"
base ad:0x801c00b8
group 0--3
line.long 0 "LCEIS3"
hexfld.long 0 " LCEIS "
;tree.end

;tree "LCEIS4"
base ad:0x801c00bc
group 0--3
line.long 0 "LCEIS4"
hexfld.long 0 " LCEIS "
;tree.end

;tree "SLCMIS1"
base ad:0x801c00c0
group 0--3
line.long 0 "SLCMIS1"
hexfld.long 0 " SLCMIS "
;tree.end

;tree "SLCMIS2"
base ad:0x801c00c4
group 0--3
line.long 0 "SLCMIS2"
hexfld.long 0 " SLCMIS "
;tree.end

;tree "SLCMIS3"
base ad:0x801c00c8
group 0--3
line.long 0 "SLCMIS3"
hexfld.long 0 " SLCMIS "
;tree.end

;tree "SLCMIS4"
base ad:0x801c00cc
group 0--3
line.long 0 "SLCMIS4"
hexfld.long 0 " SLCMIS "
;tree.end

;tree "SLCICR1"
base ad:0x801c00d0
wgroup 0--3
line.long 0 "SLCICR1"
hexfld.long 0 " SLCICR "
;tree.end

;tree "SLCICR2"
base ad:0x801c00d4
wgroup 0--3
line.long 0 "SLCICR2"
hexfld.long 0 " SLCICR "
;tree.end

;tree "SLCICR3"
base ad:0x801c00d8
wgroup 0--3
line.long 0 "SLCICR3"
hexfld.long 0 " SLCICR "
;tree.end

;tree "SLCICR4"
base ad:0x801c00dc
wgroup 0--3
line.long 0 "SLCICR4"
hexfld.long 0 " SLCICR "
;tree.end

;tree "SLCTIS1"
base ad:0x801c00e0
group 0--3
line.long 0 "SLCTIS1"
hexfld.long 0 " SLCTIS "
;tree.end

;tree "SLCTIS2"
base ad:0x801c00e4
group 0--3
line.long 0 "SLCTIS2"
hexfld.long 0 " SLCTIS "
;tree.end

;tree "SLCTIS3"
base ad:0x801c00e8
group 0--3
line.long 0 "SLCTIS3"
hexfld.long 0 " SLCTIS "
;tree.end

;tree "SLCTIS4"
base ad:0x801c00ec
group 0--3
line.long 0 "SLCTIS4"
hexfld.long 0 " SLCTIS "
;tree.end

;tree "SLCEIS1"
base ad:0x801c00f0
group 0--3
line.long 0 "SLCEIS1"
hexfld.long 0 " SLCEIS "
;tree.end

;tree "SLCEIS2"
base ad:0x801c00f4
group 0--3
line.long 0 "SLCEIS2"
hexfld.long 0 " SLCEIS "
;tree.end

;tree "SLCEIS3"
base ad:0x801c00f8
group 0--3
line.long 0 "SLCEIS3"
hexfld.long 0 " SLCEIS "
;tree.end

;tree "SLCEIS4"
base ad:0x801c00fc
group 0--3
line.long 0 "SLCEIS4"
hexfld.long 0 " SLCEIS "
;tree.end

;tree "FSESS1"
base ad:0x801c0100
group 0--3
line.long 0 "FSESS1"
hexfld.long 0 " FSESS1 "
;tree.end

;tree "FSESS2"
base ad:0x801c0104
group 0--3
line.long 0 "FSESS2"
hexfld.long 0 " FSESS2 "
;tree.end

;tree "FSEBS1"
base ad:0x801c0108
group 0--3
line.long 0 "FSEBS1"
hexfld.long 0 " FSEBS1 "
;tree.end

;tree "FSEBS2"
base ad:0x801c010c
group 0--3
line.long 0 "FSEBS2"
hexfld.long 0 " FSEBS2 "
;tree.end

;tree "PSEG1"
base ad:0x801c0110
group 0--3
line.long 0 "PSEG1"
hexfld.word 0 " PSSEL1 "
hexfld.word 2 " PSDEL1 "
;tree.end

;tree "PSEG2"
base ad:0x801c0114
group 0--3
line.long 0 "PSEG2"
hexfld.word 0 " PSSEL2 "
hexfld.word 2 " PSDEL2 "
;tree.end

;tree "PSEG3"
base ad:0x801c0118
group 0--3
line.long 0 "PSEG3"
hexfld.word 0 " PSSEL3 "
hexfld.word 2 " PSDEL3 "
;tree.end

;tree "PSEG4"
base ad:0x801c011c
group 0--3
line.long 0 "PSEG4"
hexfld.word 0 " PSSEL4 "
hexfld.word 2 " PSDEL4 "
;tree.end

;tree "PCEG1"
base ad:0x801c0120
group 0--3
line.long 0 "PCEG1"
hexfld.word 0 " PCSEL1 "
hexfld.word 2 " PCDEL1 "
;tree.end

;tree "PCEG2"
base ad:0x801c0124
group 0--3
line.long 0 "PCEG2"
hexfld.word 0 " PCSEL2 "
hexfld.word 2 " PCDEL2 "
;tree.end

;tree "PCEG3"
base ad:0x801c0128
group 0--3
line.long 0 "PCEG3"
hexfld.word 0 " PCSEL3 "
hexfld.word 2 " PCDEL3 "
;tree.end

;tree "PCEG4"
base ad:0x801c012c
group 0--3
line.long 0 "PCEG4"
hexfld.word 0 " PCSEL4 "
hexfld.word 2 " PCDEL4 "
;tree.end

;tree "RSEG1"
base ad:0x801c0130
group 0--3
line.long 0 "RSEG1"
hexfld.word 0 " RSSEL1 "
hexfld.word 2 " RSDEL1 "
;tree.end

;tree "RSEG2"
base ad:0x801c0134
group 0--3
line.long 0 "RSEG2"
hexfld.word 0 " RSSEL2 "
hexfld.word 2 " RSDEL2 "
;tree.end

;tree "RSEG3"
base ad:0x801c0138
group 0--3
line.long 0 "RSEG3"
hexfld.word 0 " RSSEL3 "
hexfld.word 2 " RSDEL3 "
;tree.end

;tree "RSEG4"
base ad:0x801c013c
group 0--3
line.long 0 "RSEG4"
hexfld.word 0 " RSSEL4 "
hexfld.word 2 " RSDEL4 "
;tree.end

;tree "RCEG1"
base ad:0x801c0140
group 0--3
line.long 0 "RCEG1"
hexfld.word 0 " RCSEL1 "
hexfld.word 2 " RCDEL1 "
;tree.end

;tree "RCEG2"
base ad:0x801c0144
group 0--3
line.long 0 "RCEG2"
hexfld.word 0 " RCSEL2 "
hexfld.word 2 " RCDEL2 "
;tree.end

;tree "RCEG3"
base ad:0x801c0148
group 0--3
line.long 0 "RCEG3"
hexfld.word 0 " RCSEL3 "
hexfld.word 2 " RCDEL3 "
;tree.end

;tree "RCEG4"
base ad:0x801c014c
group 0--3
line.long 0 "RCEG4"
hexfld.word 0 " RCSEL4 "
hexfld.word 2 " RCDEL4 "
;tree.end

;tree "STTC"
base ad:0x801c0fc4
group 0--3
line.long 0 "STTC"
hexfld.long 0 " STTC1 "
;tree.end

;tree "STFU"
base ad:0x801c0fc8
group 0--3
line.long 0 "STFU"
hexfld.word 0 " RESULT "
bitfld.long 0 16.--19. " LCELNB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20. " SD "  "0 ,1 "
bitfld.long 0 21.--25. " PRSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 26.--27. " MSTSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--30. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " ENA "  "0 ,1 "
;tree.end

;tree "ICFG"
base ad:0x801c0fcc
rgroup 0--3
line.long 0 "ICFG"
bitfld.long 0 0.--2. " SCHNB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--4. " MNB "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " DBUFSZ "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " CPSZ "  "0 ,1 "
bitfld.long 0 8. " M1SZ "  "0 ,1 "
bitfld.long 0 9. " M2SZ "  "0 ,1 "
bitfld.long 0 10. " M3SZ "  "0 ,1 "
bitfld.long 0 11. " M4SZ "  "0 ,1 "
bitfld.long 0 12. " PTYP "  "0 ,1 "
bitfld.long 0 16.--19. " MODEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "MPLUG0"
base ad:0x801c0fd0
rgroup 0--3
line.long 0 "MPLUG0"
hexfld.long 0 " MPLUG0 "
;tree.end

;tree "MPLUG1"
base ad:0x801c0fd4
rgroup 0--3
line.long 0 "MPLUG1"
hexfld.long 0 " MPLUG1 "
;tree.end

;tree "MPLUG2"
base ad:0x801c0fd8
rgroup 0--3
line.long 0 "MPLUG2"
hexfld.long 0 " MPLUG2 "
;tree.end

;tree "MPLUG3"
base ad:0x801c0fdc
rgroup 0--3
line.long 0 "MPLUG3"
hexfld.long 0 " MPLUG3 "
;tree.end

;tree "PeriphID0"
base ad:0x801c0fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PTNUM "
;tree.end

;tree "PeriphID1"
base ad:0x801c0fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PTNUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " DES0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0x801c0fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " DES1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0x801c0fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " CONFIG "
;tree.end

;tree "CellID0"
base ad:0x801c0ff0
rgroup 0--3
line.long 0 "CellID0"
hexfld.byte 0 " ID0 "
;tree.end

;tree "CellID1"
base ad:0x801c0ff4
rgroup 0--3
line.long 0 "CellID1"
hexfld.byte 0 " ID1 "
;tree.end

;tree "CellID2"
base ad:0x801c0ff8
rgroup 0--3
line.long 0 "CellID2"
hexfld.byte 0 " ID2 "
;tree.end

;tree "CellID3"
base ad:0x801c0ffc
rgroup 0--3
line.long 0 "CellID3"
hexfld.byte 0 " ID3 "
;tree.end

;tree "SSCFG0"
base ad:0x801c0400
group 0--3
line.long 0 "SSCFG0"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SDCFG0"
base ad:0x801c0410
group 0--3
line.long 0 "SDCFG0"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SSELT0"
base ad:0x801c0404
group 0--3
line.long 0 "SSELT0"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SDELT0"
base ad:0x801c0414
group 0--3
line.long 0 "SDELT0"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SSPTR0"
base ad:0x801c0408
group 0--3
line.long 0 "SSPTR0"
hexfld.long 0 " PTR "
;tree.end

;tree "SDPTR0"
base ad:0x801c0418
group 0--3
line.long 0 "SDPTR0"
hexfld.long 0 " PTR "
;tree.end

;tree "SSLNK0"
base ad:0x801c040c
group 0--3
line.long 0 "SSLNK0"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SDLNK0"
base ad:0x801c041c
group 0--3
line.long 0 "SDLNK0"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SSCFG1"
base ad:0x801c0420
group 0--3
line.long 0 "SSCFG1"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SDCFG1"
base ad:0x801c0430
group 0--3
line.long 0 "SDCFG1"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SSELT1"
base ad:0x801c0424
group 0--3
line.long 0 "SSELT1"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SDELT1"
base ad:0x801c0434
group 0--3
line.long 0 "SDELT1"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SSPTR1"
base ad:0x801c0428
group 0--3
line.long 0 "SSPTR1"
hexfld.long 0 " PTR "
;tree.end

;tree "SDPTR1"
base ad:0x801c0438
group 0--3
line.long 0 "SDPTR1"
hexfld.long 0 " PTR "
;tree.end

;tree "SSLNK1"
base ad:0x801c042c
group 0--3
line.long 0 "SSLNK1"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SDLNK1"
base ad:0x801c043c
group 0--3
line.long 0 "SDLNK1"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SSCFG2"
base ad:0x801c0440
group 0--3
line.long 0 "SSCFG2"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SDCFG2"
base ad:0x801c0450
group 0--3
line.long 0 "SDCFG2"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SSELT2"
base ad:0x801c0444
group 0--3
line.long 0 "SSELT2"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SDELT2"
base ad:0x801c0454
group 0--3
line.long 0 "SDELT2"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SSPTR2"
base ad:0x801c0448
group 0--3
line.long 0 "SSPTR2"
hexfld.long 0 " PTR "
;tree.end

;tree "SDPTR2"
base ad:0x801c0458
group 0--3
line.long 0 "SDPTR2"
hexfld.long 0 " PTR "
;tree.end

;tree "SSLNK2"
base ad:0x801c044c
group 0--3
line.long 0 "SSLNK2"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SDLNK2"
base ad:0x801c045c
group 0--3
line.long 0 "SDLNK2"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SSCFG3"
base ad:0x801c0460
group 0--3
line.long 0 "SSCFG3"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SDCFG3"
base ad:0x801c0470
group 0--3
line.long 0 "SDCFG3"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SSELT3"
base ad:0x801c0464
group 0--3
line.long 0 "SSELT3"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SDELT3"
base ad:0x801c0474
group 0--3
line.long 0 "SDELT3"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SSPTR3"
base ad:0x801c0468
group 0--3
line.long 0 "SSPTR3"
hexfld.long 0 " PTR "
;tree.end

;tree "SDPTR3"
base ad:0x801c0478
group 0--3
line.long 0 "SDPTR3"
hexfld.long 0 " PTR "
;tree.end

;tree "SSLNK3"
base ad:0x801c046c
group 0--3
line.long 0 "SSLNK3"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SDLNK3"
base ad:0x801c047c
group 0--3
line.long 0 "SDLNK3"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SSCFG4"
base ad:0x801c0480
group 0--3
line.long 0 "SSCFG4"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SDCFG4"
base ad:0x801c0490
group 0--3
line.long 0 "SDCFG4"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SSELT4"
base ad:0x801c0484
group 0--3
line.long 0 "SSELT4"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SDELT4"
base ad:0x801c0494
group 0--3
line.long 0 "SDELT4"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SSPTR4"
base ad:0x801c0488
group 0--3
line.long 0 "SSPTR4"
hexfld.long 0 " PTR "
;tree.end

;tree "SDPTR4"
base ad:0x801c0498
group 0--3
line.long 0 "SDPTR4"
hexfld.long 0 " PTR "
;tree.end

;tree "SSLNK4"
base ad:0x801c048c
group 0--3
line.long 0 "SSLNK4"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SDLNK4"
base ad:0x801c049c
group 0--3
line.long 0 "SDLNK4"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SSCFG5"
base ad:0x801c04a0
group 0--3
line.long 0 "SSCFG5"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SDCFG5"
base ad:0x801c04b0
group 0--3
line.long 0 "SDCFG5"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SSELT5"
base ad:0x801c04a4
group 0--3
line.long 0 "SSELT5"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SDELT5"
base ad:0x801c04b4
group 0--3
line.long 0 "SDELT5"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SSPTR5"
base ad:0x801c04a8
group 0--3
line.long 0 "SSPTR5"
hexfld.long 0 " PTR "
;tree.end

;tree "SDPTR5"
base ad:0x801c04b8
group 0--3
line.long 0 "SDPTR5"
hexfld.long 0 " PTR "
;tree.end

;tree "SSLNK5"
base ad:0x801c04ac
group 0--3
line.long 0 "SSLNK5"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SDLNK5"
base ad:0x801c04bc
group 0--3
line.long 0 "SDLNK5"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SSCFG6"
base ad:0x801c04c0
group 0--3
line.long 0 "SSCFG6"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SDCFG6"
base ad:0x801c04d0
group 0--3
line.long 0 "SDCFG6"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SSELT6"
base ad:0x801c04c4
group 0--3
line.long 0 "SSELT6"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SDELT6"
base ad:0x801c04d4
group 0--3
line.long 0 "SDELT6"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SSPTR6"
base ad:0x801c04c8
group 0--3
line.long 0 "SSPTR6"
hexfld.long 0 " PTR "
;tree.end

;tree "SDPTR6"
base ad:0x801c04d8
group 0--3
line.long 0 "SDPTR6"
hexfld.long 0 " PTR "
;tree.end

;tree "SSLNK6"
base ad:0x801c04cc
group 0--3
line.long 0 "SSLNK6"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SDLNK6"
base ad:0x801c04dc
group 0--3
line.long 0 "SDLNK6"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SSCFG7"
base ad:0x801c04e0
group 0--3
line.long 0 "SSCFG7"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SDCFG7"
base ad:0x801c04f0
group 0--3
line.long 0 "SDCFG7"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "SSELT7"
base ad:0x801c04e4
group 0--3
line.long 0 "SSELT7"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SDELT7"
base ad:0x801c04f4
group 0--3
line.long 0 "SDELT7"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "SSPTR7"
base ad:0x801c04e8
group 0--3
line.long 0 "SSPTR7"
hexfld.long 0 " PTR "
;tree.end

;tree "SDPTR7"
base ad:0x801c04f8
group 0--3
line.long 0 "SDPTR7"
hexfld.long 0 " PTR "
;tree.end

;tree "SSLNK7"
base ad:0x801c04ec
group 0--3
line.long 0 "SSLNK7"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "SDLNK7"
base ad:0x801c04fc
group 0--3
line.long 0 "SDLNK7"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
;tree.end

;tree "ESCFG0"
base ad:0x801c0800
group 0--3
line.long 0 "ESCFG0"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "EDCFG0"
base ad:0x801c0820
group 0--3
line.long 0 "EDCFG0"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "ESELT0"
base ad:0x801c0804
group 0--3
line.long 0 "ESELT0"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "EDELT0"
base ad:0x801c0824
group 0--3
line.long 0 "EDELT0"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "ESPTR0"
base ad:0x801c0808
group 0--3
line.long 0 "ESPTR0"
hexfld.long 0 " PTR "
;tree.end

;tree "EDPTR0"
base ad:0x801c0828
group 0--3
line.long 0 "EDPTR0"
hexfld.long 0 " PTR "
;tree.end

;tree "ESLNK0"
base ad:0x801c080c
group 0--3
line.long 0 "ESLNK0"
hexfld.long 0 " EXC "
;tree.end

;tree "EDLNK0"
base ad:0x801c082c
group 0--3
line.long 0 "EDLNK0"
hexfld.long 0 " EXC "
;tree.end

;tree "ESEXC0"
base ad:0x801c0810
group 0--3
line.long 0 "ESEXC0"
hexfld.word 0 " EXC "
;tree.end

;tree "EDEXC0"
base ad:0x801c0830
group 0--3
line.long 0 "EDEXC0"
hexfld.word 0 " EXC "
;tree.end

;tree "ESFRM0"
base ad:0x801c0814
group 0--3
line.long 0 "ESFRM0"
hexfld.word 0 " FIDX "
hexfld.word 2 " FCNT "
;tree.end

;tree "EDFRM0"
base ad:0x801c0834
group 0--3
line.long 0 "EDFRM0"
hexfld.word 0 " FIDX "
hexfld.word 2 " FCNT "
;tree.end

;tree "ESRLD0"
base ad:0x801c0818
group 0--3
line.long 0 "ESRLD0"
hexfld.word 0 " FRLD "
hexfld.word 2 " ERLD "
;tree.end

;tree "EDRLD0"
base ad:0x801c0838
group 0--3
line.long 0 "EDRLD0"
hexfld.word 0 " FRLD "
hexfld.word 2 " ERLD "
;tree.end

;tree "ESBLK0"
base ad:0x801c081c
group 0--3
line.long 0 "ESBLK0"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

;tree "EDBLK0"
base ad:0x801c083c
group 0--3
line.long 0 "EDBLK0"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

;tree "ESCFG1"
base ad:0x801c0840
group 0--3
line.long 0 "ESCFG1"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "EDCFG1"
base ad:0x801c0860
group 0--3
line.long 0 "EDCFG1"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "ESELT1"
base ad:0x801c0844
group 0--3
line.long 0 "ESELT1"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "EDELT1"
base ad:0x801c0864
group 0--3
line.long 0 "EDELT1"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "ESPTR1"
base ad:0x801c0848
group 0--3
line.long 0 "ESPTR1"
hexfld.long 0 " PTR "
;tree.end

;tree "EDPTR1"
base ad:0x801c0868
group 0--3
line.long 0 "EDPTR1"
hexfld.long 0 " PTR "
;tree.end

;tree "ESLNK1"
base ad:0x801c084c
group 0--3
line.long 0 "ESLNK1"
hexfld.long 0 " EXC "
;tree.end

;tree "EDLNK1"
base ad:0x801c086c
group 0--3
line.long 0 "EDLNK1"
hexfld.long 0 " EXC "
;tree.end

;tree "ESEXC1"
base ad:0x801c0850
group 0--3
line.long 0 "ESEXC1"
hexfld.word 0 " EXC "
;tree.end

;tree "EDEXC1"
base ad:0x801c0870
group 0--3
line.long 0 "EDEXC1"
hexfld.word 0 " EXC "
;tree.end

;tree "ESFRM1"
base ad:0x801c0854
group 0--3
line.long 0 "ESFRM1"
hexfld.word 0 " FIDX "
hexfld.word 2 " FCNT "
;tree.end

;tree "EDFRM1"
base ad:0x801c0874
group 0--3
line.long 0 "EDFRM1"
hexfld.word 0 " FIDX "
hexfld.word 2 " FCNT "
;tree.end

;tree "ESRLD1"
base ad:0x801c0858
group 0--3
line.long 0 "ESRLD1"
hexfld.word 0 " FRLD "
hexfld.word 2 " ERLD "
;tree.end

;tree "EDRLD1"
base ad:0x801c0878
group 0--3
line.long 0 "EDRLD1"
hexfld.word 0 " FRLD "
hexfld.word 2 " ERLD "
;tree.end

;tree "ESBLK1"
base ad:0x801c085c
group 0--3
line.long 0 "ESBLK1"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

;tree "EDBLK1"
base ad:0x801c087c
group 0--3
line.long 0 "EDBLK1"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

;tree "ESCFG2"
base ad:0x801c0880
group 0--3
line.long 0 "ESCFG2"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "EDCFG2"
base ad:0x801c08a0
group 0--3
line.long 0 "EDCFG2"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "ESELT2"
base ad:0x801c0884
group 0--3
line.long 0 "ESELT2"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "EDELT2"
base ad:0x801c08a4
group 0--3
line.long 0 "EDELT2"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "ESPTR2"
base ad:0x801c0888
group 0--3
line.long 0 "ESPTR2"
hexfld.long 0 " PTR "
;tree.end

;tree "EDPTR2"
base ad:0x801c08a8
group 0--3
line.long 0 "EDPTR2"
hexfld.long 0 " PTR "
;tree.end

;tree "ESLNK2"
base ad:0x801c088c
group 0--3
line.long 0 "ESLNK2"
hexfld.long 0 " EXC "
;tree.end

;tree "EDLNK2"
base ad:0x801c08ac
group 0--3
line.long 0 "EDLNK2"
hexfld.long 0 " EXC "
;tree.end

;tree "ESEXC2"
base ad:0x801c0890
group 0--3
line.long 0 "ESEXC2"
hexfld.word 0 " EXC "
;tree.end

;tree "EDEXC2"
base ad:0x801c08b0
group 0--3
line.long 0 "EDEXC2"
hexfld.word 0 " EXC "
;tree.end

;tree "ESFRM2"
base ad:0x801c0894
group 0--3
line.long 0 "ESFRM2"
hexfld.word 0 " FIDX "
hexfld.word 2 " FCNT "
;tree.end

;tree "EDFRM2"
base ad:0x801c08b4
group 0--3
line.long 0 "EDFRM2"
hexfld.word 0 " FIDX "
hexfld.word 2 " FCNT "
;tree.end

;tree "ESRLD2"
base ad:0x801c0898
group 0--3
line.long 0 "ESRLD2"
hexfld.word 0 " FRLD "
hexfld.word 2 " ERLD "
;tree.end

;tree "EDRLD2"
base ad:0x801c08b8
group 0--3
line.long 0 "EDRLD2"
hexfld.word 0 " FRLD "
hexfld.word 2 " ERLD "
;tree.end

;tree "ESBLK2"
base ad:0x801c089c
group 0--3
line.long 0 "ESBLK2"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

;tree "EDBLK2"
base ad:0x801c08bc
group 0--3
line.long 0 "EDBLK2"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

;tree "ESCFG3"
base ad:0x801c08c0
group 0--3
line.long 0 "ESCFG3"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "EDCFG3"
base ad:0x801c08e0
group 0--3
line.long 0 "EDCFG3"
bitfld.long 0 0.--3. " EVTL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--5. " TM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " PSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
;tree.end

;tree "ESELT3"
base ad:0x801c08c4
group 0--3
line.long 0 "ESELT3"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "EDELT3"
base ad:0x801c08e4
group 0--3
line.long 0 "EDELT3"
hexfld.word 0 " EIDX "
hexfld.word 2 " ECNT "
;tree.end

;tree "ESPTR3"
base ad:0x801c08c8
group 0--3
line.long 0 "ESPTR3"
hexfld.long 0 " PTR "
;tree.end

;tree "EDPTR3"
base ad:0x801c08e8
group 0--3
line.long 0 "EDPTR3"
hexfld.long 0 " PTR "
;tree.end

;tree "ESLNK3"
base ad:0x801c08cc
group 0--3
line.long 0 "ESLNK3"
hexfld.long 0 " EXC "
;tree.end

;tree "EDLNK3"
base ad:0x801c08ec
group 0--3
line.long 0 "EDLNK3"
hexfld.long 0 " EXC "
;tree.end

;tree "ESEXC3"
base ad:0x801c08d0
group 0--3
line.long 0 "ESEXC3"
hexfld.word 0 " EXC "
;tree.end

;tree "EDEXC3"
base ad:0x801c08f0
group 0--3
line.long 0 "EDEXC3"
hexfld.word 0 " EXC "
;tree.end

;tree "ESFRM3"
base ad:0x801c08d4
group 0--3
line.long 0 "ESFRM3"
hexfld.word 0 " FIDX "
hexfld.word 2 " FCNT "
;tree.end

;tree "EDFRM3"
base ad:0x801c08f4
group 0--3
line.long 0 "EDFRM3"
hexfld.word 0 " FIDX "
hexfld.word 2 " FCNT "
;tree.end

;tree "ESRLD3"
base ad:0x801c08d8
group 0--3
line.long 0 "ESRLD3"
hexfld.word 0 " FRLD "
hexfld.word 2 " ERLD "
;tree.end

;tree "EDRLD3"
base ad:0x801c08f8
group 0--3
line.long 0 "EDRLD3"
hexfld.word 0 " FRLD "
hexfld.word 2 " ERLD "
;tree.end

;tree "ESBLK3"
base ad:0x801c08dc
group 0--3
line.long 0 "ESBLK3"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

;tree "EDBLK3"
base ad:0x801c08fc
group 0--3
line.long 0 "EDBLK3"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
;tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "DSI (2 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
if (((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x8015741c)&0x100000)!=0x100000)||((data.long(ad:0x801571ec)&0x4)!=0x4)||((data.long(ad:0x80157428)&0x400)!=0x0))
base ad:0x0
hgroup 0--3
TEXTLINE " DSI is not acessible. Please activate its clock or release its reset"
endif

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "DSI-2"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
if (((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x8015741c)&0x100000)!=0x100000)||((data.long(ad:0x801571ec)&0x4)!=0x4)||((data.long(ad:0x80157428)&0x400)!=0x0))
base ad:0x0
hgroup 0--3
TEXTLINE " Instance DSI is not acessible. Please activate its clock or release its reset"
else
;tree "2MCTL_INTEGRATION_MODE"
base ad:0xa0353000
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
;tree.end

;tree "2MCTL_MAIN_DATA_CTL"
base ad:0xa0353004
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF1_MODE "  "0 ,1 "
bitfld.long 0 2. " VID_EN "  "0 ,1 "
bitfld.long 0 3. " TVG_SEL "  "0 ,1 "
bitfld.long 0 4. " TBG_SEL "  "0 ,1 "
bitfld.long 0 5. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 6. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 7. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 8. " READ_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_EN "  "0 ,1 "
bitfld.long 0 10. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 11. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 12. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 13. " DISP_EOT_GEN "  "0 ,1 "
;tree.end

;tree "2MCTL_MAIN_PHY_CTL"
base ad:0xa0353008
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 2. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 3. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 6.--9. " WAIT_BURST_TIME "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10. " CLK_FORCE_STOP "  "0 ,1 "
;tree.end

;tree "2MCTL_PLL_CTL"
base ad:0xa035300c
group 0--3
line.long 0 "MCTL_PLL_CTL"
hexfld.byte 0 " PLL_MULT "
bitfld.long 0 8.--13. " PLL_OUT_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--16. " PLL_IN_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17. " PLL_SEL_DIV2 "  "0 ,1 "
bitfld.long 0 18. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 31. " PLL_MASTER "  "0 ,1 "
;tree.end

;tree "2MCTL_LANE_STS"
base ad:0xa0353010
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " DATLANE1_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " DATLANE2_STATE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "2MCTL_DPHY_TIMEOUT"
base ad:0xa0353014
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT"
bitfld.long 0 0.--3. " CLK_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--17. " HSTX_TO_VAL "  " "
bitfld.long 0 18.--31. " LPRX_TO_VAL "  " "
;tree.end

;tree "2MCTL_ULPOUT_TIME"
base ad:0xa0353018
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
;tree.end

;tree "2MCTL_DPHY_STATIC"
base ad:0xa035301c
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6.--11. " UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "2MCTL_MAIN_EN"
base ad:0xa0353020
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 7. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 8. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " IF1_EN "  "0 ,1 "
bitfld.long 0 10. " IF2_EN "  "0 ,1 "
;tree.end

;tree "2MCTL_MAIN_STS"
base ad:0xa0353024
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK "  "0 ,1 "
;tree.end

;tree "2MCTL_DPHY_ERR"
base ad:0xa0353028
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2 "  "0 ,1 "
;tree.end

;tree "2INT_VID_RDDATA"
base ad:0xa0353030
group 0--3
line.long 0 "INT_VID_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

;tree "2INT_VID_GNT"
base ad:0xa0353034
group 0--3
line.long 0 "INT_VID_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

;tree "2INT_CMD_RDDATA"
base ad:0xa0353038
group 0--3
line.long 0 "INT_CMD_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

;tree "2INT_CMD_GNT"
base ad:0xa035303c
group 0--3
line.long 0 "INT_CMD_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

;tree "2INT_INTERRUPT_CTL"
base ad:0xa0353040
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
;tree.end

;tree "2CMD_MODE_CTL"
base ad:0xa0353050
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " IF2_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 5. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 6. " ARB_MODE "  "0 ,1 "
bitfld.long 0 7. " ARB_PRI "  "0 ,1 "
hexfld.byte 1 " FIL_VALUE "
bitfld.long 0 16.--25. " TE_TIMEOUT "  " "
;tree.end

;tree "2CMD_MODE_STS"
base ad:0xa0353054
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING "  "0 ,1 "
;tree.end

;tree "2DIRECT_CMD_SEND"
base ad:0xa0353060
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
;tree.end

;tree "2DIRECT_CMD_MAIN_SETTINGS"
base ad:0xa0353064
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--15. " CMD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--20. " CMD_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 24.--27. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2DIRECT_CMD_STS"
base ad:0xa0353068
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 2 " ACK_VAL "
;tree.end

;tree "2DIRECT_CMD_RD_INIT"
base ad:0xa035306c
group 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
hexfld.word 0 " CMD_RD_INIT "
;tree.end

;tree "2DIRECT_CMD_WRDAT0"
base ad:0xa0353070
group 0--3
line.long 0 "DIRECT_CMD_WRDAT0"
hexfld.byte 0 " WRDAT0 "
hexfld.byte 1 " WRDAT1 "
hexfld.byte 2 " WRDAT2 "
hexfld.byte 3 " WRDAT3 "
;tree.end

;tree "2DIRECT_CMD_WRDAT1"
base ad:0xa0353074
group 0--3
line.long 0 "DIRECT_CMD_WRDAT1"
hexfld.byte 0 " WRDAT4 "
hexfld.byte 1 " WRDAT5 "
hexfld.byte 2 " WRDAT6 "
hexfld.byte 3 " WRDAT7 "
;tree.end

;tree "2DIRECT_CMD_WRDAT2"
base ad:0xa0353078
group 0--3
line.long 0 "DIRECT_CMD_WRDAT2"
hexfld.byte 0 " WRDAT8 "
hexfld.byte 1 " WRDAT9 "
hexfld.byte 2 " WRDAT10 "
hexfld.byte 3 " WRDAT11 "
;tree.end

;tree "2DIRECT_CMD_WRDAT3"
base ad:0xa035307c
group 0--3
line.long 0 "DIRECT_CMD_WRDAT3"
hexfld.byte 0 " WRDAT12 "
hexfld.byte 1 " WRDAT13 "
hexfld.byte 2 " WRDAT14 "
hexfld.byte 3 " WRDAT15 "
;tree.end

;tree "2DIRECT_CMD_RDDAT"
base ad:0xa0353080
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
hexfld.byte 0 " RDDAT0 "
hexfld.byte 1 " RDDAT1 "
hexfld.byte 2 " RDDAT2 "
hexfld.byte 3 " RDDAT3 "
;tree.end

;tree "2DIRECT_CMD_RD_PROPERTY"
base ad:0xa0353084
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
hexfld.word 0 " RD_SIZE "
bitfld.long 0 16.--17. " RD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
;tree.end

;tree "2DIRECT_CMD_RD_STS"
base ad:0xa0353088
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
;tree.end

;tree "2VID_MAIN_CTL"
base ad:0xa0353090
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STOP_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " VID_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--11. " HEADER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--13. " VID_PIXEL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " BURST_MODE "  "0 ,1 "
bitfld.long 0 15. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 16. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 17.--18. " REG_BLKLINE_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 19.--20. " REG_BLKEOL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--22. " RECOVERY_MODE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "2VID_VSIZE"
base ad:0xa0353094
group 0--3
line.long 0 "VID_VSIZE"
bitfld.long 0 0.--5. " VSA_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " VBP_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--19. " VFP_LENGTH "  " "
bitfld.long 0 20.--30. " VACT_LENGTH "  " "
;tree.end

;tree "2VID_HSIZE1"
base ad:0xa0353098
group 0--3
line.long 0 "VID_HSIZE1"
bitfld.long 0 0.--9. " HSA_LENGTH "  " "
bitfld.long 0 10.--19. " HBP_LENGTH "  " "
bitfld.long 0 20.--30. " HFP_LENGTH "  " "
;tree.end

;tree "2VID_HSIZE2"
base ad:0xa035309c
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--12. " RGB_SIZE "  " "
;tree.end

;tree "2VID_BLKSIZE1"
base ad:0xa03530a0
group 0--3
line.long 0 "VID_BLKSIZE1"
bitfld.long 0 0.--12. " BLKLINE_EVENT_PCK "  " "
bitfld.long 0 13.--25. " BLKEOL_PCK "  " "
;tree.end

;tree "2VID_BLKSIZE2"
base ad:0xa03530a4
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
;tree.end

;tree "2VID_PCK_TIME"
base ad:0xa03530a8
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
;tree.end

;tree "2VID_DPHY_TIME"
base ad:0xa03530ac
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
;tree.end

;tree "2VID_ERR_COLOR"
base ad:0xa03530b0
group 0--3
line.long 0 "VID_ERR_COLOR"
hexfld.byte 0 " COL_RED "
hexfld.byte 1 " COL_GREEN "
hexfld.byte 2 " COL_BLUE "
hexfld.byte 3 " PAD_VAL "
;tree.end

;tree "2VID_VPOS"
base ad:0xa03530b4
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--12. " LINE_VAL "  " "
;tree.end

;tree "2VID_HPOS"
base ad:0xa03530b8
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
;tree.end

;tree "2VID_MODE_STS"
base ad:0xa03530bc
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY "  "0 ,1 "
;tree.end

;tree "2VID_VCA_SETTING1"
base ad:0xa03530c0
group 0--3
line.long 0 "VID_VCA_SETTING1"
hexfld.word 0 " MAX_BURST_LIMIT "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
;tree.end

;tree "2VID_VCA_SETTING2"
base ad:0xa03530c4
group 0--3
line.long 0 "VID_VCA_SETTING2"
hexfld.word 0 " EXACT_BURST_LIMIT "
hexfld.word 2 " MAX_LINE_LIMIT "
;tree.end

;tree "2TVG_CTL"
base ad:0xa03530c8
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " TVG_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "2TVG_IMG_SIZE"
base ad:0xa03530cc
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--12. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--26. " TVG_NBLINE "  " "
;tree.end

;tree "2TVG_COLOR1"
base ad:0xa03530d0
group 0--3
line.long 0 "TVG_COLOR1"
hexfld.byte 0 " COL1_RED "
hexfld.byte 1 " COL1_GREEN "
hexfld.byte 2 " COL1_BLUE "
;tree.end

;tree "2TVG_COLOR2"
base ad:0xa03530d4
group 0--3
line.long 0 "TVG_COLOR2"
hexfld.byte 0 " COL2_RED "
hexfld.byte 1 " COL2_GREEN "
hexfld.byte 2 " COL2_BLUE "
;tree.end

;tree "2TVG_STS"
base ad:0xa03530d8
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
;tree.end

;tree "2TBG_CTL"
base ad:0xa03530e0
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "2TBG_SETTING"
base ad:0xa03530e4
group 0--3
line.long 0 "TBG_SETTING"
hexfld.word 0 " TBG_DATA "
bitfld.long 0 16.--27. " TBG_CPT "  " "
;tree.end

;tree "2TBG_STS"
base ad:0xa03530e8
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
;tree.end

;tree "2MCTL_MAIN_STS_CTL"
base ad:0xa03530f0
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 21. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " CRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " VRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
;tree.end

;tree "2CMD_MODE_STS_CTL"
base ad:0xa03530f4
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SDI1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SDI2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 21. " CSM_RUNNING_EDGE "  "0 ,1 "
;tree.end

;tree "2DIRECT_CMD_STS_CTL"
base ad:0xa03530f8
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

;tree "2DIRECT_CMD_RD_STS_CTL"
base ad:0xa03530fc
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

;tree "2VID_MODE_STS_CTL"
base ad:0xa0353100
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGTH_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 26. " VSG_RECOVERY_EDGE "  "0 ,1 "
;tree.end

;tree "2TG_STS_CTL"
base ad:0xa0353104
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
;tree.end

;tree "2MCTL_DPHY_ERR_CTL"
base ad:0xa0353108
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL"
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 22. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 26. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 27. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 28. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 29. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 30. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 31. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
;tree.end

;tree "2MCTL_MAIN_STS_CLR"
base ad:0xa0353110
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
;tree.end

;tree "2CMD_MODE_STS_CLR"
base ad:0xa0353114
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_CLR "  "0 ,1 "
;tree.end

;tree "2DIRECT_CMD_STS_CLR"
base ad:0xa0353118
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
;tree.end

;tree "2DIRECT_CMD_RD_STS_CLR"
base ad:0xa035311c
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
;tree.end

;tree "2VID_MODE_STS_CLR"
base ad:0xa0353120
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_CLR "  "0 ,1 "
;tree.end

;tree "2TG_STS_CLR"
base ad:0xa0353124
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
;tree.end

;tree "2MCTL_DPHY_ERR_CLR"
base ad:0xa0353128
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
;tree.end

;tree "2MCTL_MAIN_STS_FLAG"
base ad:0xa0353130
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
;tree.end

;tree "2CMD_MODE_STS_FLAG"
base ad:0xa0353134
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_FLAG "  "0 ,1 "
;tree.end

;tree "2DIRECT_CMD_STS_FLAG"
base ad:0xa0353138
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

;tree "2DIRECT_CMD_RD_STS_FLAG"
base ad:0xa035313c
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

;tree "2VID_MODE_STS_FLAG"
base ad:0xa0353140
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 10. " FLAG_VSG_RECOVERY "  "0 ,1 "
;tree.end

;tree "2TG_STS_FLAG"
base ad:0xa0353144
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
;tree.end

;tree "2MCTL_DPHY_ERR_FLAG"
base ad:0xa0353148
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
;tree.end

;tree "2DPHY_LANES_TRIM"
base ad:0xa0353150
group 0--3
line.long 0 "DPHY_LANES_TRIM"
bitfld.long 0 0.--1. " DPHY_SKEW_DAT1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DPHY_CD_OFF_DAT1 "  "0 ,1 "
bitfld.long 0 3. " DPHY_HSTX_SLEWRATE_DOWN_DAT1 "  "0 ,1 "
bitfld.long 0 4. " DPHY_HSTX_SLEWRATE_UP_DAT1 "  "0 ,1 "
bitfld.long 0 5. " DPHY_TEST_RESERVED_1_DAT1 "  "0 ,1 "
bitfld.long 0 6.--7. " DPHY_SKEW_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " DPHY_LP_RX_VIL_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " DPHY_LP_TX_SLEWRATE_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " DPHY_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 13. " DPHY_HSTX_SLEWRATE_DOWN_CLK "  "0 ,1 "
bitfld.long 0 14. " DPHY_HSTX_SLEWRATE_UP_CLK "  "0 ,1 "
bitfld.long 0 15. " DPHY_TEST_RESERVED_1_CLK "  "0 ,1 "
bitfld.long 0 16.--17. " DPHY_SKEW_DAT2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " DPHY_HSTX_SLEWRATE_DOWN_DAT2 "  "0 ,1 "
bitfld.long 0 19. " DPHY_HSTX_SLEWRATE_UP_DAT2 "  "0 ,1 "
bitfld.long 0 20. " DPHY_TEST_RESERVED_1_DAT2 "  "0 ,1 "
;tree.end

;tree "2ID_REG"
base ad:0xa0353ff0
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " H "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--19. " PRODUCT_ID "  " "
bitfld.long 0 20.--31. " VENDOR_ID "  " "
;tree.end

;tree "2IP_CONF"
base ad:0xa0353ff4
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " FIFO_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

endif
tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "DSI-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
if (((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x8015741c)&0x100000)!=0x100000)||((data.long(ad:0x801571ec)&0x4)!=0x4)||((data.long(ad:0x80157428)&0x400)!=0x0))
base ad:0x0
hgroup 0--3
TEXTLINE " Instance DSI is not acessible. Please activate its clock or release its reset"
else
;tree "0MCTL_INTEGRATION_MODE"
base ad:0xa0351000
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
;tree.end

;tree "0MCTL_MAIN_DATA_CTL"
base ad:0xa0351004
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF1_MODE "  "0 ,1 "
bitfld.long 0 2. " VID_EN "  "0 ,1 "
bitfld.long 0 3. " TVG_SEL "  "0 ,1 "
bitfld.long 0 4. " TBG_SEL "  "0 ,1 "
bitfld.long 0 5. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 6. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 7. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 8. " READ_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_EN "  "0 ,1 "
bitfld.long 0 10. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 11. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 12. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 13. " DISP_EOT_GEN "  "0 ,1 "
;tree.end

;tree "0MCTL_MAIN_PHY_CTL"
base ad:0xa0351008
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 2. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 3. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 6.--9. " WAIT_BURST_TIME "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10. " CLK_FORCE_STOP "  "0 ,1 "
;tree.end

;tree "0MCTL_PLL_CTL"
base ad:0xa035100c
group 0--3
line.long 0 "MCTL_PLL_CTL"
hexfld.byte 0 " PLL_MULT "
bitfld.long 0 8.--13. " PLL_OUT_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--16. " PLL_IN_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17. " PLL_SEL_DIV2 "  "0 ,1 "
bitfld.long 0 18. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 31. " PLL_MASTER "  "0 ,1 "
;tree.end

;tree "0MCTL_LANE_STS"
base ad:0xa0351010
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " DATLANE1_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " DATLANE2_STATE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "0MCTL_DPHY_TIMEOUT"
base ad:0xa0351014
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT"
bitfld.long 0 0.--3. " CLK_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--17. " HSTX_TO_VAL "  " "
bitfld.long 0 18.--31. " LPRX_TO_VAL "  " "
;tree.end

;tree "0MCTL_ULPOUT_TIME"
base ad:0xa0351018
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
;tree.end

;tree "0MCTL_DPHY_STATIC"
base ad:0xa035101c
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6.--11. " UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "0MCTL_MAIN_EN"
base ad:0xa0351020
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 7. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 8. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " IF1_EN "  "0 ,1 "
bitfld.long 0 10. " IF2_EN "  "0 ,1 "
;tree.end

;tree "0MCTL_MAIN_STS"
base ad:0xa0351024
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK "  "0 ,1 "
;tree.end

;tree "0MCTL_DPHY_ERR"
base ad:0xa0351028
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2 "  "0 ,1 "
;tree.end

;tree "0INT_VID_RDDATA"
base ad:0xa0351030
group 0--3
line.long 0 "INT_VID_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

;tree "0INT_VID_GNT"
base ad:0xa0351034
group 0--3
line.long 0 "INT_VID_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

;tree "0INT_CMD_RDDATA"
base ad:0xa0351038
group 0--3
line.long 0 "INT_CMD_RDDATA"
hexfld.word 0 " IF_DATA "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

;tree "0INT_CMD_GNT"
base ad:0xa035103c
group 0--3
line.long 0 "INT_CMD_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

;tree "0INT_INTERRUPT_CTL"
base ad:0xa0351040
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
;tree.end

;tree "0CMD_MODE_CTL"
base ad:0xa0351050
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " IF2_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 5. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 6. " ARB_MODE "  "0 ,1 "
bitfld.long 0 7. " ARB_PRI "  "0 ,1 "
hexfld.byte 1 " FIL_VALUE "
bitfld.long 0 16.--25. " TE_TIMEOUT "  " "
;tree.end

;tree "0CMD_MODE_STS"
base ad:0xa0351054
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING "  "0 ,1 "
;tree.end

;tree "0DIRECT_CMD_SEND"
base ad:0xa0351060
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
;tree.end

;tree "0DIRECT_CMD_MAIN_SETTINGS"
base ad:0xa0351064
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--15. " CMD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--20. " CMD_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 24.--27. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0DIRECT_CMD_STS"
base ad:0xa0351068
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 2 " ACK_VAL "
;tree.end

;tree "0DIRECT_CMD_RD_INIT"
base ad:0xa035106c
group 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
hexfld.word 0 " CMD_RD_INIT "
;tree.end

;tree "0DIRECT_CMD_WRDAT0"
base ad:0xa0351070
group 0--3
line.long 0 "DIRECT_CMD_WRDAT0"
hexfld.byte 0 " WRDAT0 "
hexfld.byte 1 " WRDAT1 "
hexfld.byte 2 " WRDAT2 "
hexfld.byte 3 " WRDAT3 "
;tree.end

;tree "0DIRECT_CMD_WRDAT1"
base ad:0xa0351074
group 0--3
line.long 0 "DIRECT_CMD_WRDAT1"
hexfld.byte 0 " WRDAT4 "
hexfld.byte 1 " WRDAT5 "
hexfld.byte 2 " WRDAT6 "
hexfld.byte 3 " WRDAT7 "
;tree.end

;tree "0DIRECT_CMD_WRDAT2"
base ad:0xa0351078
group 0--3
line.long 0 "DIRECT_CMD_WRDAT2"
hexfld.byte 0 " WRDAT8 "
hexfld.byte 1 " WRDAT9 "
hexfld.byte 2 " WRDAT10 "
hexfld.byte 3 " WRDAT11 "
;tree.end

;tree "0DIRECT_CMD_WRDAT3"
base ad:0xa035107c
group 0--3
line.long 0 "DIRECT_CMD_WRDAT3"
hexfld.byte 0 " WRDAT12 "
hexfld.byte 1 " WRDAT13 "
hexfld.byte 2 " WRDAT14 "
hexfld.byte 3 " WRDAT15 "
;tree.end

;tree "0DIRECT_CMD_RDDAT"
base ad:0xa0351080
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
hexfld.byte 0 " RDDAT0 "
hexfld.byte 1 " RDDAT1 "
hexfld.byte 2 " RDDAT2 "
hexfld.byte 3 " RDDAT3 "
;tree.end

;tree "0DIRECT_CMD_RD_PROPERTY"
base ad:0xa0351084
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
hexfld.word 0 " RD_SIZE "
bitfld.long 0 16.--17. " RD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
;tree.end

;tree "0DIRECT_CMD_RD_STS"
base ad:0xa0351088
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
;tree.end

;tree "0VID_MAIN_CTL"
base ad:0xa0351090
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STOP_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " VID_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--11. " HEADER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--13. " VID_PIXEL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " BURST_MODE "  "0 ,1 "
bitfld.long 0 15. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 16. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 17.--18. " REG_BLKLINE_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 19.--20. " REG_BLKEOL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--22. " RECOVERY_MODE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "0VID_VSIZE"
base ad:0xa0351094
group 0--3
line.long 0 "VID_VSIZE"
bitfld.long 0 0.--5. " VSA_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " VBP_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--19. " VFP_LENGTH "  " "
bitfld.long 0 20.--30. " VACT_LENGTH "  " "
;tree.end

;tree "0VID_HSIZE1"
base ad:0xa0351098
group 0--3
line.long 0 "VID_HSIZE1"
bitfld.long 0 0.--9. " HSA_LENGTH "  " "
bitfld.long 0 10.--19. " HBP_LENGTH "  " "
bitfld.long 0 20.--30. " HFP_LENGTH "  " "
;tree.end

;tree "0VID_HSIZE2"
base ad:0xa035109c
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--12. " RGB_SIZE "  " "
;tree.end

;tree "0VID_BLKSIZE1"
base ad:0xa03510a0
group 0--3
line.long 0 "VID_BLKSIZE1"
bitfld.long 0 0.--12. " BLKLINE_EVENT_PCK "  " "
bitfld.long 0 13.--25. " BLKEOL_PCK "  " "
;tree.end

;tree "0VID_BLKSIZE2"
base ad:0xa03510a4
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
;tree.end

;tree "0VID_PCK_TIME"
base ad:0xa03510a8
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
;tree.end

;tree "0VID_DPHY_TIME"
base ad:0xa03510ac
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
;tree.end

;tree "0VID_ERR_COLOR"
base ad:0xa03510b0
group 0--3
line.long 0 "VID_ERR_COLOR"
hexfld.byte 0 " COL_RED "
hexfld.byte 1 " COL_GREEN "
hexfld.byte 2 " COL_BLUE "
hexfld.byte 3 " PAD_VAL "
;tree.end

;tree "0VID_VPOS"
base ad:0xa03510b4
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--12. " LINE_VAL "  " "
;tree.end

;tree "0VID_HPOS"
base ad:0xa03510b8
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
;tree.end

;tree "0VID_MODE_STS"
base ad:0xa03510bc
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY "  "0 ,1 "
;tree.end

;tree "0VID_VCA_SETTING1"
base ad:0xa03510c0
group 0--3
line.long 0 "VID_VCA_SETTING1"
hexfld.word 0 " MAX_BURST_LIMIT "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
;tree.end

;tree "0VID_VCA_SETTING2"
base ad:0xa03510c4
group 0--3
line.long 0 "VID_VCA_SETTING2"
hexfld.word 0 " EXACT_BURST_LIMIT "
hexfld.word 2 " MAX_LINE_LIMIT "
;tree.end

;tree "0TVG_CTL"
base ad:0xa03510c8
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " TVG_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "0TVG_IMG_SIZE"
base ad:0xa03510cc
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--12. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--26. " TVG_NBLINE "  " "
;tree.end

;tree "0TVG_COLOR1"
base ad:0xa03510d0
group 0--3
line.long 0 "TVG_COLOR1"
hexfld.byte 0 " COL1_RED "
hexfld.byte 1 " COL1_GREEN "
hexfld.byte 2 " COL1_BLUE "
;tree.end

;tree "0TVG_COLOR2"
base ad:0xa03510d4
group 0--3
line.long 0 "TVG_COLOR2"
hexfld.byte 0 " COL2_RED "
hexfld.byte 1 " COL2_GREEN "
hexfld.byte 2 " COL2_BLUE "
;tree.end

;tree "0TVG_STS"
base ad:0xa03510d8
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
;tree.end

;tree "0TBG_CTL"
base ad:0xa03510e0
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "0TBG_SETTING"
base ad:0xa03510e4
group 0--3
line.long 0 "TBG_SETTING"
hexfld.word 0 " TBG_DATA "
bitfld.long 0 16.--27. " TBG_CPT "  " "
;tree.end

;tree "0TBG_STS"
base ad:0xa03510e8
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
;tree.end

;tree "0MCTL_MAIN_STS_CTL"
base ad:0xa03510f0
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 21. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " CRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " VRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
;tree.end

;tree "0CMD_MODE_STS_CTL"
base ad:0xa03510f4
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SDI1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SDI2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 21. " CSM_RUNNING_EDGE "  "0 ,1 "
;tree.end

;tree "0DIRECT_CMD_STS_CTL"
base ad:0xa03510f8
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

;tree "0DIRECT_CMD_RD_STS_CTL"
base ad:0xa03510fc
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

;tree "0VID_MODE_STS_CTL"
base ad:0xa0351100
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGTH_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 26. " VSG_RECOVERY_EDGE "  "0 ,1 "
;tree.end

;tree "0TG_STS_CTL"
base ad:0xa0351104
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
;tree.end

;tree "0MCTL_DPHY_ERR_CTL"
base ad:0xa0351108
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL"
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 22. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 26. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 27. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 28. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 29. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 30. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 31. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
;tree.end

;tree "0MCTL_MAIN_STS_CLR"
base ad:0xa0351110
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
;tree.end

;tree "0CMD_MODE_STS_CLR"
base ad:0xa0351114
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_CLR "  "0 ,1 "
;tree.end

;tree "0DIRECT_CMD_STS_CLR"
base ad:0xa0351118
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
;tree.end

;tree "0DIRECT_CMD_RD_STS_CLR"
base ad:0xa035111c
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
;tree.end

;tree "0VID_MODE_STS_CLR"
base ad:0xa0351120
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_CLR "  "0 ,1 "
;tree.end

;tree "0TG_STS_CLR"
base ad:0xa0351124
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
;tree.end

;tree "0MCTL_DPHY_ERR_CLR"
base ad:0xa0351128
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
;tree.end

;tree "0MCTL_MAIN_STS_FLAG"
base ad:0xa0351130
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
;tree.end

;tree "0CMD_MODE_STS_FLAG"
base ad:0xa0351134
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_FLAG "  "0 ,1 "
;tree.end

;tree "0DIRECT_CMD_STS_FLAG"
base ad:0xa0351138
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

;tree "0DIRECT_CMD_RD_STS_FLAG"
base ad:0xa035113c
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

;tree "0VID_MODE_STS_FLAG"
base ad:0xa0351140
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 10. " FLAG_VSG_RECOVERY "  "0 ,1 "
;tree.end

;tree "0TG_STS_FLAG"
base ad:0xa0351144
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
;tree.end

;tree "0MCTL_DPHY_ERR_FLAG"
base ad:0xa0351148
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
;tree.end

;tree "0DPHY_LANES_TRIM"
base ad:0xa0351150
group 0--3
line.long 0 "DPHY_LANES_TRIM"
bitfld.long 0 0.--1. " DPHY_SKEW_DAT1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DPHY_CD_OFF_DAT1 "  "0 ,1 "
bitfld.long 0 3. " DPHY_HSTX_SLEWRATE_DOWN_DAT1 "  "0 ,1 "
bitfld.long 0 4. " DPHY_HSTX_SLEWRATE_UP_DAT1 "  "0 ,1 "
bitfld.long 0 5. " DPHY_TEST_RESERVED_1_DAT1 "  "0 ,1 "
bitfld.long 0 6.--7. " DPHY_SKEW_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " DPHY_LP_RX_VIL_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " DPHY_LP_TX_SLEWRATE_CLK "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " DPHY_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 13. " DPHY_HSTX_SLEWRATE_DOWN_CLK "  "0 ,1 "
bitfld.long 0 14. " DPHY_HSTX_SLEWRATE_UP_CLK "  "0 ,1 "
bitfld.long 0 15. " DPHY_TEST_RESERVED_1_CLK "  "0 ,1 "
bitfld.long 0 16.--17. " DPHY_SKEW_DAT2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " DPHY_HSTX_SLEWRATE_DOWN_DAT2 "  "0 ,1 "
bitfld.long 0 19. " DPHY_HSTX_SLEWRATE_UP_DAT2 "  "0 ,1 "
bitfld.long 0 20. " DPHY_TEST_RESERVED_1_DAT2 "  "0 ,1 "
;tree.end

;tree "0ID_REG"
base ad:0xa0351ff0
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " H "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--19. " PRODUCT_ID "  " "
bitfld.long 0 20.--31. " VENDOR_ID "  " "
;tree.end

;tree "0IP_CONF"
base ad:0xa0351ff4
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " FIFO_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

endif
tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "DSI3"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
if (((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x8015741c)&0x100000)!=0x100000)||((data.long(ad:0x801571ec)&0x4)!=0x4)||((data.long(ad:0x80157428)&0x400)!=0x0))
base ad:0x0
hgroup 0--3
TEXTLINE "DSI3 is not acessible. Please activate its clock or release its reset"
else
;tree "MCTL_INTEGRATION_MODE"
base ad:0xa0352000
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
;tree.end

;tree "MCTL_MAIN_DATA_CTL"
base ad:0xa0352004
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF_VID_MODE "  "0 ,1 "
bitfld.long 0 2.--3. " IF_VID_SELECT "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " VID_EN "  "0 ,1 "
bitfld.long 0 6. " TVG_SEL "  "0 ,1 "
bitfld.long 0 7. " TBG_SEL "  "0 ,1 "
bitfld.long 0 8. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 9. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 10. " IF3_TE_EN "  "0 ,1 "
bitfld.long 0 11. " IF4_TE_EN "  "0 ,1 "
bitfld.long 0 12. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 13. " READ_EN "  "0 ,1 "
bitfld.long 0 14. " BTA_EN "  "0 ,1 "
bitfld.long 0 15. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 16. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 17. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 18. " DISP_EOT_GEN "  "0 ,1 "
bitfld.long 0 24. " TE_HW_POLLING_EN "  "0 ,1 "
bitfld.long 0 25. " TE_MIPI_POLLING_EN "  "0 ,1 "
bitfld.long 0 26. " IF1_INTERLACED_EN "  "0 ,1 "
bitfld.long 0 27. " IF2_INTERLACED_EN "  "0 ,1 "
bitfld.long 0 28. " IF3_INTERLACED_EN "  "0 ,1 "
bitfld.long 0 29. " IF4_INTERLACED_EN "  "0 ,1 "
;tree.end

;tree "MCTL_MAIN_PHY_CTL"
base ad:0xa0352008
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " LANE3_EN "  "0 ,1 "
bitfld.long 0 2. " LANE4_EN "  "0 ,1 "
bitfld.long 0 3. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 4. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 5. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 6. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 7. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 8. " DAT3_ULPM_EN "  "0 ,1 "
bitfld.long 0 9. " DAT4_ULPM_EN "  "0 ,1 "
bitfld.long 0 10.--13. " WAIT_BURST_TIME "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14. " CLK_FORCE_STOP "  "0 ,1 "
;tree.end

;tree "MCTL_PLL_CTL"
base ad:0xa035200c
group 0--3
line.long 0 "MCTL_PLL_CTL"
bitfld.long 0 0.--29. " PLL_GPO "  " "
bitfld.long 0 30. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 31. " PLL_MASTER "  "0 ,1 "
;tree.end

;tree "MCTL_LANE_STS"
base ad:0xa0352010
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " DATLANE1_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " DATLANE2_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 7.--8. " DATLANE3_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--10. " DATLANE4_STATE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "MCTL_DPHY_TIMEOUT1"
base ad:0xa0352014
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT1"
bitfld.long 0 0.--3. " CLK_DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--21. " HSTX_TO_VAL "  " "
;tree.end

;tree "MCTL_DPHY_TIMEOUT2"
base ad:0xa0352018
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT2"
bitfld.long 0 0.--13. " LPRX_TO_VAL "  " "
;tree.end

;tree "MCTL_ULPOUT_TIME"
base ad:0xa035201c
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
;tree.end

;tree "MCTL_DPHY_STATIC"
base ad:0xa0352020
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6. " SWAP_PINS_DAT3 "  "0 ,1 "
bitfld.long 0 7. " HS_INVERT_DAT3 "  "0 ,1 "
bitfld.long 0 8. " SWAP_PINS_DAT4 "  "0 ,1 "
bitfld.long 0 9. " HS_INVERT_DAT4 "  "0 ,1 "
bitfld.long 0 10.--15. " UI_X4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "MCTL_MAIN_EN"
base ad:0xa0352024
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " DAT3_EN "  "0 ,1 "
bitfld.long 0 7. " DAT4_EN "  "0 ,1 "
bitfld.long 0 8. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 10. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 11. " DAT3_ULPM_REQ "  "0 ,1 "
bitfld.long 0 12. " DAT4_ULPM_REQ "  "0 ,1 "
bitfld.long 0 13. " IF1_EN "  "0 ,1 "
bitfld.long 0 14. " IF2_EN "  "0 ,1 "
bitfld.long 0 15. " IF3_EN "  "0 ,1 "
bitfld.long 0 16. " IF4_EN "  "0 ,1 "
;tree.end

;tree "MCTL_MAIN_STS"
base ad:0xa0352028
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " DAT3_READY "  "0 ,1 "
bitfld.long 0 5. " DAT4_READY "  "0 ,1 "
bitfld.long 0 6. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 7. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 8. " IF1_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 9. " IF2_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 10. " IF3_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 11. " IF4_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 12. " LANE_MAP_ERR "  "0 ,1 "
;tree.end

;tree "MCTL_DPHY_ERR"
base ad:0xa035202c
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_ESC_3 "  "0 ,1 "
bitfld.long 0 9. " ERR_ESC_4 "  "0 ,1 "
bitfld.long 0 10. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_SYNCESC_3 "  "0 ,1 "
bitfld.long 0 13. " ERR_SYNCESC_4 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 16. " ERR_CONTROL_3 "  "0 ,1 "
bitfld.long 0 17. " ERR_CONTROL_4 "  "0 ,1 "
bitfld.long 0 18. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 19. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 20. " ERR_CONT_LP0_3 "  "0 ,1 "
bitfld.long 0 21. " ERR_CONT_LP0_4 "  "0 ,1 "
bitfld.long 0 22. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 23. " ERR_CONT_LP1_2 "  "0 ,1 "
bitfld.long 0 24. " ERR_CONT_LP1_3 "  "0 ,1 "
bitfld.long 0 25. " ERR_CONT_LP1_4 "  "0 ,1 "
;tree.end

;tree "INT_IF1_RDDATA"
base ad:0xa0352030
group 0--3
line.long 0 "INT_IF1_RDDATA"
hexfld.long 0 " IF_DATA "
;tree.end

;tree "INT_IF1_RDDATA2"
base ad:0xa0352034
group 0--3
line.long 0 "INT_IF1_RDDATA2"
bitfld.long 0 0. " IF_VALID "  "0 ,1 "
bitfld.long 0 1. " IF_START "  "0 ,1 "
bitfld.long 0 2. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

;tree "INT_IF1_GNT"
base ad:0xa0352038
group 0--3
line.long 0 "INT_IF1_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

;tree "INT_IF2_RDDATA"
base ad:0xa035203c
group 0--3
line.long 0 "INT_IF2_RDDATA"
hexfld.long 0 " IF_DATA "
;tree.end

;tree "INT_IF2_RDDATA2"
base ad:0xa0352040
group 0--3
line.long 0 "INT_IF2_RDDATA2"
bitfld.long 0 0. " IF_VALID "  "0 ,1 "
bitfld.long 0 1. " IF_START "  "0 ,1 "
bitfld.long 0 2. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

;tree "INT_IF2_GNT"
base ad:0xa0352044
group 0--3
line.long 0 "INT_IF2_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

;tree "INT_IF3_RDDATA"
base ad:0xa0352048
group 0--3
line.long 0 "INT_IF3_RDDATA"
hexfld.long 0 " IF_DATA "
;tree.end

;tree "INT_IF3_RDDATA2"
base ad:0xa035204c
group 0--3
line.long 0 "INT_IF3_RDDATA2"
bitfld.long 0 0. " IF_VALID "  "0 ,1 "
bitfld.long 0 1. " IF_START "  "0 ,1 "
bitfld.long 0 2. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

;tree "INT_IF3_GNT"
base ad:0xa0352050
group 0--3
line.long 0 "INT_IF3_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

;tree "INT_IF4_RDDATA"
base ad:0xa0352054
group 0--3
line.long 0 "INT_IF4_RDDATA"
hexfld.long 0 " IF_DATA "
;tree.end

;tree "INT_IF4_RDDATA2"
base ad:0xa0352058
group 0--3
line.long 0 "INT_IF4_RDDATA2"
bitfld.long 0 0. " IF_VALID "  "0 ,1 "
bitfld.long 0 1. " IF_START "  "0 ,1 "
bitfld.long 0 2. " IF_FRAME_SYNC "  "0 ,1 "
;tree.end

;tree "INT_IF4_GNT"
base ad:0xa035205c
group 0--3
line.long 0 "INT_IF4_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
;tree.end

;tree "INT_INTERRUPT_CTL"
base ad:0xa0352060
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
;tree.end

;tree "CMD_MODE_CTL"
base ad:0xa0352070
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " IF2_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " IF3_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " IF4_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 8. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 9. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 10. " IF3_LP_EN "  "0 ,1 "
bitfld.long 0 11. " IF4_LP_EN "  "0 ,1 "
;tree.end

;tree "CMD_MODE_CTL2"
base ad:0xa0352074
group 0--3
line.long 0 "CMD_MODE_CTL2"
bitfld.long 0 0. " ARB_MODE "  "0 ,1 "
bitfld.long 0 1. " ARB_PRI "  "0 ,1 "
bitfld.long 0 2.--9. " FIL_VALUE "  " "
bitfld.long 0 10.--19. " TE_TIMEOUT "  " "
;tree.end

;tree "CMD_MODE_STS"
base ad:0xa0352078
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_IF1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_IF2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_IF3_UNDERRUN "  "0 ,1 "
bitfld.long 0 5. " ERR_IF4_UNDERRUN "  "0 ,1 "
bitfld.long 0 6. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 7. " CSM_RUNNING "  "0 ,1 "
;tree.end

;tree "DIRECT_CMD_SEND"
base ad:0xa0352080
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
;tree.end

;tree "DIRECT_CMD_MAIN_SETTINGS"
base ad:0xa0352084
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--15. " CMD_ID "  "0 ,1 ,2 ,3 "
hexfld.byte 2 " CMD_SIZE "
bitfld.long 0 24. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 27.--30. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DIRECT_CMD_STS"
base ad:0xa0352088
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 2 " ACK_VAL "
;tree.end

;tree "DIRECT_CMD_RD_INIT"
base ad:0xa035208c
group 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
hexfld.word 0 " CMD_RD_INIT "
;tree.end

;tree "DIRECT_CMD_WRDAT"
base ad:0xa0352090
group 0--3
line.long 0 "DIRECT_CMD_WRDAT"
hexfld.byte 0 " WRDAT0 "
hexfld.byte 1 " WRDAT1 "
hexfld.byte 2 " WRDAT2 "
hexfld.byte 3 " WRDAT3 "
;tree.end

;tree "DIRECT_CMD_FIFO_RST"
base ad:0xa0352094
wgroup 0--3
line.long 0 "DIRECT_CMD_FIFO_RST"
bitfld.long 0 0. " DIRECT_CMD_FIFO_RST "  "0 ,1 "
;tree.end

;tree "DIRECT_CMD_RDDAT"
base ad:0xa03520a0
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
hexfld.byte 0 " RDDAT0 "
hexfld.byte 1 " RDDAT1 "
hexfld.byte 2 " RDDAT2 "
hexfld.byte 3 " RDDAT3 "
;tree.end

;tree "DIRECT_CMD_RD_PROPERTY"
base ad:0xa03520a4
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
hexfld.word 0 " RD_SIZE "
bitfld.long 0 16.--17. " RD_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
;tree.end

;tree "DIRECT_CMD_RD_STS"
base ad:0xa03520a8
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
;tree.end

;tree "VID_MAIN_CTL"
base ad:0xa03520b0
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STOP_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " VID_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " VID_ID_SDFD "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--13. " HEADER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14.--17. " VID_PIXEL_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 18. " BURST_MODE "  "0 ,1 "
bitfld.long 0 19. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 20. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 21.--22. " REG_BLKLINE_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 23.--24. " REG_BLKEOL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 25.--26. " RECOVERY_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 27. " VID_INTERLACED_EN "  "0 ,1 "
bitfld.long 0 28. " VID_FIELD_SW "  "0 ,1 "
;tree.end

;tree "VID_VSIZE1"
base ad:0xa03520b4
group 0--3
line.long 0 "VID_VSIZE1"
bitfld.long 0 0.--5. " VSA_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " VBP_LENGTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--19. " VFP_LENGTH "  " "
bitfld.long 0 20.--30. " VACT_LENGTH "  " "
;tree.end

;tree "VID_VSIZE2"
base ad:0xa03520b8
group 0--3
line.long 0 "VID_VSIZE2"
bitfld.long 0 0.--12. " VACT_LENGTH "  " "
;tree.end

;tree "VID_HSIZE1"
base ad:0xa03520c0
group 0--3
line.long 0 "VID_HSIZE1"
bitfld.long 0 0.--9. " HSA_LENGTH "  " "
bitfld.long 0 10.--19. " HBP_LENGTH "  " "
bitfld.long 0 20.--30. " HFP_LENGTH "  " "
;tree.end

;tree "VID_HSIZE2"
base ad:0xa03520c4
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--14. " RGB_SIZE "  " "
;tree.end

;tree "VID_BLKSIZE2"
base ad:0xa03520d0
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
;tree.end

;tree "VID_PCK_TIME"
base ad:0xa03520d8
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
;tree.end

;tree "VID_DPHY_TIME"
base ad:0xa03520dc
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
;tree.end

;tree "VID_ERR_COLOR1"
base ad:0xa03520e0
group 0--3
line.long 0 "VID_ERR_COLOR1"
bitfld.long 0 0.--11. " COL_RED "  " "
bitfld.long 0 12.--23. " COL_GREEN "  " "
;tree.end

;tree "VID_ERR_COLOR2"
base ad:0xa03520e4
group 0--3
line.long 0 "VID_ERR_COLOR2"
bitfld.long 0 0.--11. " COL_BLUE "  " "
bitfld.long 0 12.--23. " PAD_VAL "  " "
;tree.end

;tree "VID_VPOS"
base ad:0xa03520e8
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--14. " LINE_VAL "  " "
;tree.end

;tree "VID_HPOS"
base ad:0xa03520ec
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
;tree.end

;tree "VID_MODE_STS"
base ad:0xa03520f0
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY "  "0 ,1 "
;tree.end

;tree "VID_VCA_SETTING1"
base ad:0xa03520f4
group 0--3
line.long 0 "VID_VCA_SETTING1"
hexfld.word 0 " MAX_BURST_LIMIT "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
;tree.end

;tree "VID_VCA_SETTING2"
base ad:0xa03520f8
group 0--3
line.long 0 "VID_VCA_SETTING2"
hexfld.word 0 " EXACT_BURST_LIMIT "
hexfld.word 2 " MAX_LINE_LIMIT "
;tree.end

;tree "TVG_CTL"
base ad:0xa03520fc
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " TVG_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "TVG_IMG_SIZE"
base ad:0xa0352100
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--14. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--28. " TVG_NBLINE "  " "
;tree.end

;tree "TVG_COLOR1"
base ad:0xa0352104
group 0--3
line.long 0 "TVG_COLOR1"
bitfld.long 0 0.--11. " COL_RED "  " "
bitfld.long 0 12.--23. " COL_GREEN "  " "
;tree.end

;tree "TVG_COLOR1_BIS"
base ad:0xa0352108
group 0--3
line.long 0 "TVG_COLOR1_BIS"
bitfld.long 0 0.--11. " COL1_BLUE "  " "
;tree.end

;tree "TVG_COLOR2"
base ad:0xa035210c
group 0--3
line.long 0 "TVG_COLOR2"
bitfld.long 0 0.--11. " COL2_RED "  " "
bitfld.long 0 12.--23. " COL2_GREEN "  " "
;tree.end

;tree "TVG_COLOR2_BIS"
base ad:0xa0352110
group 0--3
line.long 0 "TVG_COLOR2_BIS"
bitfld.long 0 0.--11. " COL2_BLUE "  " "
;tree.end

;tree "TVG_STS"
base ad:0xa0352114
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
;tree.end

;tree "TBG_CTL"
base ad:0xa0352118
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "TBG_SETTING1"
base ad:0xa035211c
group 0--3
line.long 0 "TBG_SETTING1"
hexfld.long 0 " TTBG_DATA "
;tree.end

;tree "TBG_SETTING2"
base ad:0xa0352120
group 0--3
line.long 0 "TBG_SETTING2"
bitfld.long 0 0.--11. " TBG_CPT "  " "
;tree.end

;tree "TBG_STS"
base ad:0xa0352124
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
;tree.end

;tree "MCTL_MAIN_STS_CTL"
base ad:0xa0352130
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " DAT3_READY_EN "  "0 ,1 "
bitfld.long 0 5. " DAT4_READY_EN "  "0 ,1 "
bitfld.long 0 6. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 8. " IF1_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 9. " IF2_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 10. " IF3_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 11. " IF4_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 12. " LANE_MAP_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " DAT3_READY_EDGE "  "0 ,1 "
bitfld.long 0 21. " DAT4_READY_EDGE "  "0 ,1 "
bitfld.long 0 22. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 24. " IF1_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 25. " IF2_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 26. " IF3_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 27. " IF4_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 28. " LANE_MAP_ERR_EDGE "  "0 ,1 "
;tree.end

;tree "CMD_MODE_STS_CTL"
base ad:0xa0352134
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_IF1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_IF2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_IF3_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_IF4_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 7. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_IF1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_IF2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_IF3_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_IF4_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 23. " CSM_RUNNING_EDGE "  "0 ,1 "
;tree.end

;tree "DIRECT_CMD_STS_CTL"
base ad:0xa0352138
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

;tree "DIRECT_CMD_RD_STS_CTL"
base ad:0xa035213c
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
;tree.end

;tree "VID_MODE_STS_CTL"
base ad:0xa0352140
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGHT_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGHT_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 26. " VSG_RECOVERY_EDGE "  "0 ,1 "
;tree.end

;tree "TG_STS_CTL"
base ad:0xa0352144
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
;tree.end

;tree "MCTL_DPHY_ERR_CTL1"
base ad:0xa0352148
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL1"
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_ESC_3_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_ESC_4_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_SYNCESC_3_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_SYNCESC_4_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_CONTROL_3_EN "  "0 ,1 "
bitfld.long 0 17. " ERR_CONTROL_4_EN "  "0 ,1 "
bitfld.long 0 18. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 19. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 20. " ERR_CONT_LP0_3_EN "  "0 ,1 "
bitfld.long 0 21. " ERR_CONT_LP0_4_EN "  "0 ,1 "
bitfld.long 0 22. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 23. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 24. " ERR_CONT_LP1_3_EN "  "0 ,1 "
bitfld.long 0 25. " ERR_CONT_LP1_4_EN "  "0 ,1 "
;tree.end

;tree "MCTL_DPHY_ERR_CTL2"
base ad:0xa035214c
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL2"
bitfld.long 0 0. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 1. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 2. " ERR_ESC_3_EDGE "  "0 ,1 "
bitfld.long 0 3. " ERR_ESC_4_EDGE "  "0 ,1 "
bitfld.long 0 4. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 5. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 6. " ERR_SYNCESC_3_EDGE "  "0 ,1 "
bitfld.long 0 7. " ERR_SYNCESC_4_EDGE "  "0 ,1 "
bitfld.long 0 8. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 9. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_3_EDGE "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_4_EDGE "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP0_3_EDGE "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP0_4_EDGE "  "0 ,1 "
bitfld.long 0 16. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CONT_LP1_3_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_CONT_LP1_4_EDGE "  "0 ,1 "
;tree.end

;tree "MCTL_MAIN_STS_CLR"
base ad:0xa0352150
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " DAT3_READY_CLR "  "0 ,1 "
bitfld.long 0 5. " DAT4_READY_CLR "  "0 ,1 "
bitfld.long 0 6. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 8. " IF1_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 9. " IF2_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 10. " IF3_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 11. " IF4_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 12. " LANE_MAP_ERR_CLR "  "0 ,1 "
;tree.end

;tree "CMD_MODE_STS_CLR"
base ad:0xa0352154
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_IF1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_IF2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_IF3_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_IF4_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 7. " CSM_RUNNING_CLR "  "0 ,1 "
;tree.end

;tree "DIRECT_CMD_STS_CLR"
base ad:0xa0352158
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
;tree.end

;tree "DIRECT_CMD_RD_STS_CLR"
base ad:0xa035215c
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
;tree.end

;tree "VID_MODE_STS_CLR"
base ad:0xa0352160
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_CLR "  "0 ,1 "
;tree.end

;tree "TG_STS_CLR"
base ad:0xa0352164
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
;tree.end

;tree "MCTL_DPHY_ERR_CLR"
base ad:0xa0352168
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_ESC_3_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_ESC_4_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_SYNCESC_3_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_SYNCESC_4_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 16. " ERR_CONTROL_3_CLR "  "0 ,1 "
bitfld.long 0 17. " ERR_CONTROL_4_CLR "  "0 ,1 "
bitfld.long 0 18. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 19. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 20. " ERR_CONT_LP0_3_CLR "  "0 ,1 "
bitfld.long 0 21. " ERR_CONT_LP0_4_CLR "  "0 ,1 "
bitfld.long 0 22. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 23. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
bitfld.long 0 24. " ERR_CONT_LP1_3_CLR "  "0 ,1 "
bitfld.long 0 25. " ERR_CONT_LP1_4_CLR "  "0 ,1 "
;tree.end

;tree "MCTL_MAIN_STS_FLAG"
base ad:0xa0352170
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " DAT3_READY_FLAG "  "0 ,1 "
bitfld.long 0 5. " DAT4_READY_FLAG "  "0 ,1 "
bitfld.long 0 6. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 8. " IF1_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 9. " IF2_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 10. " IF3_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 11. " IF4_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
;tree.end

;tree "CMD_MODE_STS_FLAG"
base ad:0xa0352174
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_IF1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_IF2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_IF3_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_IF4_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 7. " CSM_RUNNING_FLAG "  "0 ,1 "
;tree.end

;tree "DIRECT_CMD_STS_FLAG"
base ad:0xa0352178
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

;tree "DIRECT_CMD_RD_STS_FLAG"
base ad:0xa035217c
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
;tree.end

;tree "VID_MODE_STS_FLAG"
base ad:0xa0352180
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 10. " FLAG_VSG_RECOVERY "  "0 ,1 "
;tree.end

;tree "TG_STS_FLAG"
base ad:0xa0352184
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
;tree.end

;tree "MCTL_DPHY_ERR_FLAG"
base ad:0xa0352188
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_ESC_3_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_ESC_4_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_SYNCESC_3_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_SYNCESC_4_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 16. " ERR_CONTROL_3_FLAG "  "0 ,1 "
bitfld.long 0 17. " ERR_CONTROL_4_FLAG "  "0 ,1 "
bitfld.long 0 18. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 19. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 20. " ERR_CONT_LP0_3_FLAG "  "0 ,1 "
bitfld.long 0 21. " ERR_CONT_LP0_4_FLAG "  "0 ,1 "
bitfld.long 0 22. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 23. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
bitfld.long 0 24. " ERR_CONT_LP1_3_FLAG "  "0 ,1 "
bitfld.long 0 25. " ERR_CONT_LP1_4_FLAG "  "0 ,1 "
;tree.end

;tree "DPHY_LANES_MAP"
base ad:0xa0352198
group 0--3
line.long 0 "DPHY_LANES_MAP"
bitfld.long 0 0.--1. " DAT1_REMAP_CFG "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " DAT2_REMAP_CFG "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " DAT3_REMAP_CFG "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " DAT4_REMAP_CFG "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DPHY_LANES_TRIM1"
base ad:0xa0352200
group 0--3
line.long 0 "DPHY_LANES_TRIM1"
bitfld.long 0 0.--1. " SKEW_CL "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " CTRL_4DL "  "0 ,1 "
bitfld.long 0 3. " SPEC81 "  "0 ,1 "
bitfld.long 0 4.--5. " LPTX_SLEWRATE_CL "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " TEST_RESERVED_1_CL "  "0 ,1 "
bitfld.long 0 7.--8. " HSTX_ZOS_ADJUST_CL "  "0 ,1 ,2 ,3 "
bitfld.long 0 9. " HSTX_BLEEDER_ON_CL "  "0 ,1 "
bitfld.long 0 10.--12. " HSTX_SLEWRATE_CL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13. " TIMER_SELECT_CL "  "0 ,1 "
bitfld.long 0 14.--16. " TCLKZERO_TIMER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17.--19. " TCLKPREP_TIMER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DPHY_LANES_TRIM2"
base ad:0xa0352208
group 0--3
line.long 0 "DPHY_LANES_TRIM2"
bitfld.long 0 0.--2. " SKEW_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " SPEC81 "  "0 ,1 "
bitfld.long 0 4.--5. " LPTX_SLEWRATE_DL1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " TEST_RESERVED_1_DL1 "  "0 ,1 "
bitfld.long 0 7.--8. " HSTX_ZOS_ADJUST_DL1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 9. " HSTX_BLEEDER_ON_DL1 "  "0 ,1 "
bitfld.long 0 10.--12. " HSTX_SLEWRATE_DL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DPHY_LANES_TRIM3"
base ad:0xa0352210
group 0--3
line.long 0 "DPHY_LANES_TRIM3"
bitfld.long 0 0.--2. " SKEW_DL2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " SPEC81 "  "0 ,1 "
bitfld.long 0 4.--5. " LPTX_SLEWRATE_DL2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " TEST_RESERVED_1_DL2 "  "0 ,1 "
bitfld.long 0 7.--8. " HSTX_ZOS_ADJUST_DL2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 9. " HSTX_BLEEDER_ON_DL2 "  "0 ,1 "
bitfld.long 0 10.--12. " HSTX_SLEWRATE_DL2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DPHY_LANES_TRIM4"
base ad:0xa0352218
group 0--3
line.long 0 "DPHY_LANES_TRIM4"
bitfld.long 0 0.--2. " SKEW_DL3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " SPEC81 "  "0 ,1 "
bitfld.long 0 4.--5. " LPTX_SLEWRATE_DL3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " TEST_RESERVED_1_DL3 "  "0 ,1 "
bitfld.long 0 7.--8. " HSTX_ZOS_ADJUST_DL3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 9. " HSTX_BLEEDER_ON_DL3 "  "0 ,1 "
bitfld.long 0 10.--12. " HSTX_SLEWRATE_DL3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DPHY_LANES_TRIM5"
base ad:0xa0352220
group 0--3
line.long 0 "DPHY_LANES_TRIM5"
bitfld.long 0 0.--2. " SKEW_DL4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " SPEC81 "  "0 ,1 "
bitfld.long 0 4.--5. " LPTX_SLEWRATE_DL4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " TEST_RESERVED_1_DL4 "  "0 ,1 "
bitfld.long 0 7.--8. " HSTX_ZOS_ADJUST_DL4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 9. " HSTX_BLEEDER_ON_DL4 "  "0 ,1 "
bitfld.long 0 10.--12. " HSTX_SLEWRATE_DL4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "ID_REG"
base ad:0xa0352ff0
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " H "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--19. " PRODUCT_ID "  " "
bitfld.long 0 20.--31. " VENDOR_ID "  " "
;tree.end

;tree "IP_CONF"
base ad:0xa0352ff4
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " RX_FIFO_DEPTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--7. " MAX_LANE_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " NB_IF "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " DATAPATH_SIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " IF_DATASIZE "  "0 ,1 "
bitfld.long 0 13.--15. " DIRECT_CMD_FIFO_DEPTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--20. " VRS_FIFO_DEPTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21.--25. " CRS_FIFO_DEPTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

endif
tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "DSITB (3 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "DSITB-2"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "2DPHY_RX_CFG_C"
base ad:0x63b00000
group 0--3
line.long 0 "DPHY_RX_CFG_C"
bitfld.long 0 0. " c_swap_pins "  "0 ,1 "
bitfld.long 0 1. " c_hs_invert "  "0 ,1 "
bitfld.long 0 2. " c_enable "  "0 ,1 "
bitfld.long 0 3.--8. " c_ui_x4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 9. " spec_90_81b "  "0 ,1 "
;tree.end

;tree "2DPHY_RX_CFG_D1"
base ad:0x63b00004
group 0--3
line.long 0 "DPHY_RX_CFG_D1"
bitfld.long 0 0. " d1_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d1_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d1_enable "  "0 ,1 "
bitfld.long 0 3. " d1_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d1_force_rx_mode "  "0 ,1 "
;tree.end

;tree "2DPHY_RX_CFG_D2"
base ad:0x63b00008
group 0--3
line.long 0 "DPHY_RX_CFG_D2"
bitfld.long 0 0. " d2_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d2_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d2_enable "  "0 ,1 "
bitfld.long 0 3. " d2_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d2_force_rx_mode "  "0 ,1 "
;tree.end

;tree "2DPHY_RX_CFG_D3"
base ad:0x63b0000c
group 0--3
line.long 0 "DPHY_RX_CFG_D3"
bitfld.long 0 0. " d3_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d3_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d3_enable "  "0 ,1 "
bitfld.long 0 3. " d3_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d3_force_rx_mode "  "0 ,1 "
;tree.end

;tree "2DPHY_RX_CFG_D4"
base ad:0x63b00010
group 0--3
line.long 0 "DPHY_RX_CFG_D4"
bitfld.long 0 0. " d4_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d4_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d4_enable "  "0 ,1 "
bitfld.long 0 3. " d4_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d4_force_rx_mode "  "0 ,1 "
;tree.end

;tree "2DPHY_RX_ERR_D1"
base ad:0x63b00014
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D1"
bitfld.long 0 0. " d1_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d1_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d1_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d1_err_esc "  "0 ,1 "
bitfld.long 0 4. " d1_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d1_err_control "  "0 ,1 "
bitfld.long 0 6. " d1_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d1_err_contention_lp1 "  "0 ,1 "
;tree.end

;tree "2DPHY_RX_ERR_D2"
base ad:0x63b00018
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D2"
bitfld.long 0 0. " d2_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d2_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d2_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d2_err_esc "  "0 ,1 "
bitfld.long 0 4. " d2_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d2_err_control "  "0 ,1 "
bitfld.long 0 6. " d2_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d2_err_contention_lp1 "  "0 ,1 "
;tree.end

;tree "2DPHY_RX_ERR_D3"
base ad:0x63b0001c
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D3"
bitfld.long 0 0. " d3_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d3_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d3_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d3_err_esc "  "0 ,1 "
bitfld.long 0 4. " d3_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d3_err_control "  "0 ,1 "
bitfld.long 0 6. " d3_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d3_err_contention_lp1 "  "0 ,1 "
;tree.end

;tree "2DPHY_RX_ERR_D4"
base ad:0x63b00020
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D4"
bitfld.long 0 0. " d4_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d4_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d4_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d4_err_esc "  "0 ,1 "
bitfld.long 0 4. " d4_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d4_err_control "  "0 ,1 "
bitfld.long 0 6. " d4_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d4_err_contention_lp1 "  "0 ,1 "
;tree.end

;tree "2ADDR_BANK_1_MSB"
base ad:0x63b00024
group 0--3
line.long 0 "ADDR_BANK_1_MSB"
hexfld.word 0 " addr_bank_1_msb "
;tree.end

;tree "2ADDR_BANK_1_LSB"
base ad:0x63b00028
group 0--3
line.long 0 "ADDR_BANK_1_LSB"
hexfld.word 0 " addr_bank_1_lsb "
;tree.end

;tree "2ADDR_BANK_2_MSB"
base ad:0x63b0002c
group 0--3
line.long 0 "ADDR_BANK_2_MSB"
hexfld.word 0 " addr_bank_2_msb "
;tree.end

;tree "2ADDR_BANK_2_LSB"
base ad:0x63b00030
group 0--3
line.long 0 "ADDR_BANK_2_LSB"
hexfld.word 0 " addr_bank_2_lsb "
;tree.end

;tree "2ADDR_BANK_3_MSB"
base ad:0x63b00034
group 0--3
line.long 0 "ADDR_BANK_3_MSB"
hexfld.word 0 " addr_bank_3_msb "
;tree.end

;tree "2ADDR_BANK_3_LSB"
base ad:0x63b00038
group 0--3
line.long 0 "ADDR_BANK_3_LSB"
hexfld.word 0 " addr_bank_3_lsb "
;tree.end

;tree "2ADDR_BANK_4_MSB"
base ad:0x63b0003c
group 0--3
line.long 0 "ADDR_BANK_4_MSB"
hexfld.word 0 " addr_bank_4_msb "
;tree.end

;tree "2ADDR_BANK_4_LSB"
base ad:0x63b00040
group 0--3
line.long 0 "ADDR_BANK_4_LSB"
hexfld.word 0 " addr_bank_4_lsb "
;tree.end

;tree "2ADDR_BANK_5_MSB"
base ad:0x63b00044
group 0--3
line.long 0 "ADDR_BANK_5_MSB"
hexfld.word 0 " addr_bank_5_msb "
;tree.end

;tree "2ADDR_BANK_5_LSB"
base ad:0x63b00048
group 0--3
line.long 0 "ADDR_BANK_5_LSB"
hexfld.word 0 " addr_bank_5_lsb "
;tree.end

;tree "2LM_CFG"
base ad:0x63b0004c
group 0--3
line.long 0 "LM_CFG"
bitfld.long 0 0. " lane2_en "  "0 ,1 "
bitfld.long 0 1. " lane3_en "  "0 ,1 "
bitfld.long 0 2. " lane4_en "  "0 ,1 "
;tree.end

;tree "2RTM_CFG_1"
base ad:0x63b00050
group 0--3
line.long 0 "RTM_CFG_1"
bitfld.long 0 0. " ack_with_error "  "0 ,1 "
bitfld.long 0 1.--4. " trigger_value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2RTM_CFG_2"
base ad:0x63b00054
group 0--3
line.long 0 "RTM_CFG_2"
hexfld.byte 0 " read_data "
bitfld.long 0 8.--12. " data_number "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "2RTM_CFG_3"
base ad:0x63b00058
group 0--3
line.long 0 "RTM_CFG_3"
hexfld.word 0 " error_report "
;tree.end

;tree "2TESTER_CFG"
base ad:0x63b0005c
group 0--3
line.long 0 "TESTER_CFG"
bitfld.long 0 0. " soft_rst_n "  "0 ,1 "
bitfld.long 0 1. " isolate_tester "  "0 ,1 "
;tree.end

;tree "2EXT_MEM"
base ad:0x63b00400
group 0--3
line.long 0 "EXT_MEM"
bitfld.long 0 0. " EXT_MEM "  "0 ,1 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "DSITB-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0DPHY_RX_CFG_C"
base ad:0x63b80000
group 0--3
line.long 0 "DPHY_RX_CFG_C"
bitfld.long 0 0. " c_swap_pins "  "0 ,1 "
bitfld.long 0 1. " c_hs_invert "  "0 ,1 "
bitfld.long 0 2. " c_enable "  "0 ,1 "
bitfld.long 0 3.--8. " c_ui_x4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 9. " spec_90_81b "  "0 ,1 "
;tree.end

;tree "0DPHY_RX_CFG_D1"
base ad:0x63b80004
group 0--3
line.long 0 "DPHY_RX_CFG_D1"
bitfld.long 0 0. " d1_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d1_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d1_enable "  "0 ,1 "
bitfld.long 0 3. " d1_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d1_force_rx_mode "  "0 ,1 "
;tree.end

;tree "0DPHY_RX_CFG_D2"
base ad:0x63b80008
group 0--3
line.long 0 "DPHY_RX_CFG_D2"
bitfld.long 0 0. " d2_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d2_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d2_enable "  "0 ,1 "
bitfld.long 0 3. " d2_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d2_force_rx_mode "  "0 ,1 "
;tree.end

;tree "0DPHY_RX_CFG_D3"
base ad:0x63b8000c
group 0--3
line.long 0 "DPHY_RX_CFG_D3"
bitfld.long 0 0. " d3_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d3_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d3_enable "  "0 ,1 "
bitfld.long 0 3. " d3_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d3_force_rx_mode "  "0 ,1 "
;tree.end

;tree "0DPHY_RX_CFG_D4"
base ad:0x63b80010
group 0--3
line.long 0 "DPHY_RX_CFG_D4"
bitfld.long 0 0. " d4_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d4_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d4_enable "  "0 ,1 "
bitfld.long 0 3. " d4_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d4_force_rx_mode "  "0 ,1 "
;tree.end

;tree "0DPHY_RX_ERR_D1"
base ad:0x63b80014
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D1"
bitfld.long 0 0. " d1_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d1_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d1_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d1_err_esc "  "0 ,1 "
bitfld.long 0 4. " d1_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d1_err_control "  "0 ,1 "
bitfld.long 0 6. " d1_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d1_err_contention_lp1 "  "0 ,1 "
;tree.end

;tree "0DPHY_RX_ERR_D2"
base ad:0x63b80018
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D2"
bitfld.long 0 0. " d2_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d2_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d2_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d2_err_esc "  "0 ,1 "
bitfld.long 0 4. " d2_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d2_err_control "  "0 ,1 "
bitfld.long 0 6. " d2_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d2_err_contention_lp1 "  "0 ,1 "
;tree.end

;tree "0DPHY_RX_ERR_D3"
base ad:0x63b8001c
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D3"
bitfld.long 0 0. " d3_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d3_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d3_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d3_err_esc "  "0 ,1 "
bitfld.long 0 4. " d3_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d3_err_control "  "0 ,1 "
bitfld.long 0 6. " d3_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d3_err_contention_lp1 "  "0 ,1 "
;tree.end

;tree "0DPHY_RX_ERR_D4"
base ad:0x63b80020
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D4"
bitfld.long 0 0. " d4_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d4_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d4_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d4_err_esc "  "0 ,1 "
bitfld.long 0 4. " d4_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d4_err_control "  "0 ,1 "
bitfld.long 0 6. " d4_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d4_err_contention_lp1 "  "0 ,1 "
;tree.end

;tree "0ADDR_BANK_1_MSB"
base ad:0x63b80024
group 0--3
line.long 0 "ADDR_BANK_1_MSB"
hexfld.word 0 " addr_bank_1_msb "
;tree.end

;tree "0ADDR_BANK_1_LSB"
base ad:0x63b80028
group 0--3
line.long 0 "ADDR_BANK_1_LSB"
hexfld.word 0 " addr_bank_1_lsb "
;tree.end

;tree "0ADDR_BANK_2_MSB"
base ad:0x63b8002c
group 0--3
line.long 0 "ADDR_BANK_2_MSB"
hexfld.word 0 " addr_bank_2_msb "
;tree.end

;tree "0ADDR_BANK_2_LSB"
base ad:0x63b80030
group 0--3
line.long 0 "ADDR_BANK_2_LSB"
hexfld.word 0 " addr_bank_2_lsb "
;tree.end

;tree "0ADDR_BANK_3_MSB"
base ad:0x63b80034
group 0--3
line.long 0 "ADDR_BANK_3_MSB"
hexfld.word 0 " addr_bank_3_msb "
;tree.end

;tree "0ADDR_BANK_3_LSB"
base ad:0x63b80038
group 0--3
line.long 0 "ADDR_BANK_3_LSB"
hexfld.word 0 " addr_bank_3_lsb "
;tree.end

;tree "0ADDR_BANK_4_MSB"
base ad:0x63b8003c
group 0--3
line.long 0 "ADDR_BANK_4_MSB"
hexfld.word 0 " addr_bank_4_msb "
;tree.end

;tree "0ADDR_BANK_4_LSB"
base ad:0x63b80040
group 0--3
line.long 0 "ADDR_BANK_4_LSB"
hexfld.word 0 " addr_bank_4_lsb "
;tree.end

;tree "0ADDR_BANK_5_MSB"
base ad:0x63b80044
group 0--3
line.long 0 "ADDR_BANK_5_MSB"
hexfld.word 0 " addr_bank_5_msb "
;tree.end

;tree "0ADDR_BANK_5_LSB"
base ad:0x63b80048
group 0--3
line.long 0 "ADDR_BANK_5_LSB"
hexfld.word 0 " addr_bank_5_lsb "
;tree.end

;tree "0LM_CFG"
base ad:0x63b8004c
group 0--3
line.long 0 "LM_CFG"
bitfld.long 0 0. " lane2_en "  "0 ,1 "
bitfld.long 0 1. " lane3_en "  "0 ,1 "
bitfld.long 0 2. " lane4_en "  "0 ,1 "
;tree.end

;tree "0RTM_CFG_1"
base ad:0x63b80050
group 0--3
line.long 0 "RTM_CFG_1"
bitfld.long 0 0. " ack_with_error "  "0 ,1 "
bitfld.long 0 1.--4. " trigger_value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0RTM_CFG_2"
base ad:0x63b80054
group 0--3
line.long 0 "RTM_CFG_2"
hexfld.byte 0 " read_data "
bitfld.long 0 8.--12. " data_number "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "0RTM_CFG_3"
base ad:0x63b80058
group 0--3
line.long 0 "RTM_CFG_3"
hexfld.word 0 " error_report "
;tree.end

;tree "0TESTER_CFG"
base ad:0x63b8005c
group 0--3
line.long 0 "TESTER_CFG"
bitfld.long 0 0. " soft_rst_n "  "0 ,1 "
bitfld.long 0 1. " isolate_tester "  "0 ,1 "
;tree.end

;tree "0EXT_MEM"
base ad:0x63b80400
group 0--3
line.long 0 "EXT_MEM"
bitfld.long 0 0. " EXT_MEM "  "0 ,1 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "DSITB-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1DPHY_RX_CFG_C"
base ad:0x63b80000
group 0--3
line.long 0 "DPHY_RX_CFG_C"
bitfld.long 0 0. " c_swap_pins "  "0 ,1 "
bitfld.long 0 1. " c_hs_invert "  "0 ,1 "
bitfld.long 0 2. " c_enable "  "0 ,1 "
bitfld.long 0 3.--8. " c_ui_x4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 9. " spec_90_81b "  "0 ,1 "
;tree.end

;tree "1DPHY_RX_CFG_D1"
base ad:0x63b80004
group 0--3
line.long 0 "DPHY_RX_CFG_D1"
bitfld.long 0 0. " d1_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d1_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d1_enable "  "0 ,1 "
bitfld.long 0 3. " d1_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d1_force_rx_mode "  "0 ,1 "
;tree.end

;tree "1DPHY_RX_CFG_D2"
base ad:0x63b80008
group 0--3
line.long 0 "DPHY_RX_CFG_D2"
bitfld.long 0 0. " d2_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d2_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d2_enable "  "0 ,1 "
bitfld.long 0 3. " d2_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d2_force_rx_mode "  "0 ,1 "
;tree.end

;tree "1DPHY_RX_CFG_D3"
base ad:0x63b8000c
group 0--3
line.long 0 "DPHY_RX_CFG_D3"
bitfld.long 0 0. " d3_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d3_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d3_enable "  "0 ,1 "
bitfld.long 0 3. " d3_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d3_force_rx_mode "  "0 ,1 "
;tree.end

;tree "1DPHY_RX_CFG_D4"
base ad:0x63b80010
group 0--3
line.long 0 "DPHY_RX_CFG_D4"
bitfld.long 0 0. " d4_swap_pins "  "0 ,1 "
bitfld.long 0 1. " d4_hs_invert "  "0 ,1 "
bitfld.long 0 2. " d4_enable "  "0 ,1 "
bitfld.long 0 3. " d4_eot_bypass "  "0 ,1 "
bitfld.long 0 4. " d4_force_rx_mode "  "0 ,1 "
;tree.end

;tree "1DPHY_RX_ERR_D1"
base ad:0x63b80014
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D1"
bitfld.long 0 0. " d1_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d1_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d1_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d1_err_esc "  "0 ,1 "
bitfld.long 0 4. " d1_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d1_err_control "  "0 ,1 "
bitfld.long 0 6. " d1_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d1_err_contention_lp1 "  "0 ,1 "
;tree.end

;tree "1DPHY_RX_ERR_D2"
base ad:0x63b80018
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D2"
bitfld.long 0 0. " d2_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d2_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d2_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d2_err_esc "  "0 ,1 "
bitfld.long 0 4. " d2_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d2_err_control "  "0 ,1 "
bitfld.long 0 6. " d2_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d2_err_contention_lp1 "  "0 ,1 "
;tree.end

;tree "1DPHY_RX_ERR_D3"
base ad:0x63b8001c
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D3"
bitfld.long 0 0. " d3_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d3_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d3_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d3_err_esc "  "0 ,1 "
bitfld.long 0 4. " d3_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d3_err_control "  "0 ,1 "
bitfld.long 0 6. " d3_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d3_err_contention_lp1 "  "0 ,1 "
;tree.end

;tree "1DPHY_RX_ERR_D4"
base ad:0x63b80020
rgroup 0--3
line.long 0 "DPHY_RX_ERR_D4"
bitfld.long 0 0. " d4_err_sot_hs "  "0 ,1 "
bitfld.long 0 1. " d4_err_sot_sync_hs "  "0 ,1 "
bitfld.long 0 2. " d4_err_eot_sync_hs "  "0 ,1 "
bitfld.long 0 3. " d4_err_esc "  "0 ,1 "
bitfld.long 0 4. " d4_err_sync_esc "  "0 ,1 "
bitfld.long 0 5. " d4_err_control "  "0 ,1 "
bitfld.long 0 6. " d4_err_contention_lp0 "  "0 ,1 "
bitfld.long 0 7. " d4_err_contention_lp1 "  "0 ,1 "
;tree.end

;tree "1ADDR_BANK_1_MSB"
base ad:0x63b80024
group 0--3
line.long 0 "ADDR_BANK_1_MSB"
hexfld.word 0 " addr_bank_1_msb "
;tree.end

;tree "1ADDR_BANK_1_LSB"
base ad:0x63b80028
group 0--3
line.long 0 "ADDR_BANK_1_LSB"
hexfld.word 0 " addr_bank_1_lsb "
;tree.end

;tree "1ADDR_BANK_2_MSB"
base ad:0x63b8002c
group 0--3
line.long 0 "ADDR_BANK_2_MSB"
hexfld.word 0 " addr_bank_2_msb "
;tree.end

;tree "1ADDR_BANK_2_LSB"
base ad:0x63b80030
group 0--3
line.long 0 "ADDR_BANK_2_LSB"
hexfld.word 0 " addr_bank_2_lsb "
;tree.end

;tree "1ADDR_BANK_3_MSB"
base ad:0x63b80034
group 0--3
line.long 0 "ADDR_BANK_3_MSB"
hexfld.word 0 " addr_bank_3_msb "
;tree.end

;tree "1ADDR_BANK_3_LSB"
base ad:0x63b80038
group 0--3
line.long 0 "ADDR_BANK_3_LSB"
hexfld.word 0 " addr_bank_3_lsb "
;tree.end

;tree "1ADDR_BANK_4_MSB"
base ad:0x63b8003c
group 0--3
line.long 0 "ADDR_BANK_4_MSB"
hexfld.word 0 " addr_bank_4_msb "
;tree.end

;tree "1ADDR_BANK_4_LSB"
base ad:0x63b80040
group 0--3
line.long 0 "ADDR_BANK_4_LSB"
hexfld.word 0 " addr_bank_4_lsb "
;tree.end

;tree "1ADDR_BANK_5_MSB"
base ad:0x63b80044
group 0--3
line.long 0 "ADDR_BANK_5_MSB"
hexfld.word 0 " addr_bank_5_msb "
;tree.end

;tree "1ADDR_BANK_5_LSB"
base ad:0x63b80048
group 0--3
line.long 0 "ADDR_BANK_5_LSB"
hexfld.word 0 " addr_bank_5_lsb "
;tree.end

;tree "1LM_CFG"
base ad:0x63b8004c
group 0--3
line.long 0 "LM_CFG"
bitfld.long 0 0. " lane2_en "  "0 ,1 "
bitfld.long 0 1. " lane3_en "  "0 ,1 "
bitfld.long 0 2. " lane4_en "  "0 ,1 "
;tree.end

;tree "1RTM_CFG_1"
base ad:0x63b80050
group 0--3
line.long 0 "RTM_CFG_1"
bitfld.long 0 0. " ack_with_error "  "0 ,1 "
bitfld.long 0 1.--4. " trigger_value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1RTM_CFG_2"
base ad:0x63b80054
group 0--3
line.long 0 "RTM_CFG_2"
hexfld.byte 0 " read_data "
bitfld.long 0 8.--12. " data_number "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "1RTM_CFG_3"
base ad:0x63b80058
group 0--3
line.long 0 "RTM_CFG_3"
hexfld.word 0 " error_report "
;tree.end

;tree "1TESTER_CFG"
base ad:0x63b8005c
group 0--3
line.long 0 "TESTER_CFG"
bitfld.long 0 0. " soft_rst_n "  "0 ,1 "
bitfld.long 0 1. " isolate_tester "  "0 ,1 "
;tree.end

;tree "1EXT_MEM"
base ad:0x63b80400
group 0--3
line.long 0 "EXT_MEM"
bitfld.long 0 0. " EXT_MEM "  "0 ,1 "
;tree.end

tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "ETB11"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "RAM_Depth"
base eapb:0x801b4004
rgroup 0--3
line.long 0 "RAM_Depth"
hexfld.long 0 " RDP "
;tree.end

;tree "Status"
base eapb:0x801b400c
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " FULL "  "0 ,1 "
bitfld.long 0 1. " TRIGGERED "  "0 ,1 "
bitfld.long 0 2. " ACQCOMP "  "0 ,1 "
bitfld.long 0 3. " FTEMPTY "  "0 ,1 "
;tree.end

;tree "RAM_Data"
base eapb:0x801b4010
group 0--3
line.long 0 "RAM_Data"
hexfld.long 0 " RAM_READ_DATA "
;tree.end

;tree "RAM_Read_Pointer"
base eapb:0x801b4014
group 0--3
line.long 0 "RAM_Read_Pointer"
bitfld.long 0 0.--1. " RAM_Read_Pointer "  "0 ,1 ,2 ,3 "
;tree.end

;tree "RAM_Write_Pointer"
base eapb:0x801b4018
group 0--3
line.long 0 "RAM_Write_Pointer"
bitfld.long 0 0.--1. " RAM_Write_Pointer "  "0 ,1 ,2 ,3 "
;tree.end

;tree "Trigger_Counter"
base eapb:0x801b401c
group 0--3
line.long 0 "Trigger_Counter"
bitfld.long 0 0.--1. " Trigger_Counter "  "0 ,1 ,2 ,3 "
;tree.end

;tree "Control"
base eapb:0x801b4020
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " TRACECAPTEN "  "0 ,1 "
;tree.end

;tree "RAM_WRITE"
base eapb:0x801b4024
wgroup 0--3
line.long 0 "RAM_WRITE"
hexfld.long 0 " RAM_WRITE_DATA "
;tree.end

;tree "FFSR"
base eapb:0x801b4300
rgroup 0--3
line.long 0 "FFSR"
bitfld.long 0 0. " FLINPROG "  "0 ,1 "
bitfld.long 0 1. " FTSTOPPED "  "0 ,1 "
;tree.end

;tree "DESCRIPTION"
base eapb:0x801b4304
group 0--3
line.long 0 "DESCRIPTION"
bitfld.long 0 0. " ENFTC "  "0 ,1 "
bitfld.long 0 1. " ENFCONT "  "0 ,1 "
bitfld.long 0 4. " FONFLIN "  "0 ,1 "
bitfld.long 0 5. " FONTRIG "  "0 ,1 "
bitfld.long 0 6. " FONMAN "  "0 ,1 "
bitfld.long 0 8. " TRIGIN "  "0 ,1 "
bitfld.long 0 9. " TRIGEVT "  "0 ,1 "
bitfld.long 0 10. " TRGFL "  "0 ,1 "
bitfld.long 0 12. " STOPFL "  "0 ,1 "
bitfld.long 0 13. " STOPTRIG "  "0 ,1 "
;tree.end

;tree "ITMISCOP0"
base eapb:0x801b4ee0
group 0--3
line.long 0 "ITMISCOP0"
bitfld.long 0 0. " ACQCOMP "  "0 ,1 "
bitfld.long 0 1. " FULL "  "0 ,1 "
;tree.end

;tree "ITTRFLINACK"
base eapb:0x801b4ee4
group 0--3
line.long 0 "ITTRFLINACK"
bitfld.long 0 0. " TRIGNACK "  "0 ,1 "
bitfld.long 0 1. " FLUSHINACK "  "0 ,1 "
;tree.end

;tree "ITTRFLIN"
base eapb:0x801b4ee8
group 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0. " TRIGIN "  "0 ,1 "
bitfld.long 0 1. " FLUSHIN "  "0 ,1 "
;tree.end

;tree "ITATBDATA0"
base eapb:0x801b4eec
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0.--4. " ATDATA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "ITATBCTR2"
base eapb:0x801b4ef0
group 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ATREADYS "  "0 ,1 "
bitfld.long 0 1. " AFVALIDS "  "0 ,1 "
;tree.end

;tree "ITATBCTR1"
base eapb:0x801b4ef4
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0.--6. " ATID "  " "
;tree.end

;tree "ITATBCTR0"
base eapb:0x801b4ef8
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ATVALID "  "0 ,1 "
bitfld.long 0 1. " AFREADY "  "0 ,1 "
bitfld.long 0 8.--9. " ATBYTES "  "0 ,1 ,2 ,3 "
;tree.end

;tree "IMCR"
base eapb:0x801b4f00
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " IMCR "  "0 ,1 "
;tree.end

;tree "CTSR"
base eapb:0x801b4fa0
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0. " CTSR "  "0 ,1 "
;tree.end

;tree "CTCR"
base eapb:0x801b4fa4
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0. " CTCR "  "0 ,1 "
;tree.end

;tree "LAR"
base eapb:0x801b4fb0
group 0--3
line.long 0 "LAR"
bitfld.long 0 0. " LAR "  "0 ,1 "
;tree.end

;tree "LSR"
base eapb:0x801b4fb4
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0. " LSR "  "0 ,1 "
;tree.end

;tree "ASR"
base eapb:0x801b4fb8
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0. " ASR "  "0 ,1 "
;tree.end

;tree "DID"
base eapb:0x801b4fc8
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0. " DID "  "0 ,1 "
;tree.end

;tree "DTIR"
base eapb:0x801b4fcc
rgroup 0--3
line.long 0 "DTIR"
bitfld.long 0 0. " DTIR "  "0 ,1 "
;tree.end

;tree "PERIPHERAL_ID4"
base eapb:0x801b4fd0
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0. " PERIPHERAL_ID4 "  "0 ,1 "
;tree.end

;tree "PERIPHERAL_ID5"
base eapb:0x801b4fd4
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
;tree.end

;tree "PERIPHERAL_ID6"
base eapb:0x801b4fd8
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
;tree.end

;tree "PERIPHERAL_ID7"
base eapb:0x801b4fdc
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
;tree.end

;tree "PERIPHERAL_ID0"
base eapb:0x801b4fe0
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0. " PERIPHERAL_ID0 "  "0 ,1 "
;tree.end

;tree "PERIPHERAL_ID1"
base eapb:0x801b4fe4
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0. " PERIPHERAL_ID1 "  "0 ,1 "
;tree.end

;tree "PERIPHERAL_ID2"
base eapb:0x801b4fe8
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0. " PERIPHERAL_ID2 "  "0 ,1 "
;tree.end

;tree "PERIPHERAL_ID3"
base eapb:0x801b4fec
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0. " PERIPHERAL_ID3 "  "0 ,1 "
;tree.end

;tree "COMPONENT_ID0"
base eapb:0x801b4ff0
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
;tree.end

;tree "COMPONENT_ID1"
base eapb:0x801b4ff4
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0. " COMPONENT_ID1 "  "0 ,1 "
;tree.end

;tree "COMPONENT_ID2"
base eapb:0x801b4ff8
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0. " COMPONENT_ID2 "  "0 ,1 "
;tree.end

;tree "COMPONENT_ID3"
base eapb:0x801b4ffc
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0. " COMPONENT_ID3 "  "0 ,1 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "FSMC"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "FSMC_BCR0"
base ad:0x80000000
group 0--3
line.long 0 "FSMC_BCR0"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
;tree.end

;tree "FSMC_BCR1"
base ad:0x80000008
group 0--3
line.long 0 "FSMC_BCR1"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
;tree.end

;tree "FSMC_BCR2"
base ad:0x80000010
group 0--3
line.long 0 "FSMC_BCR2"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
;tree.end

;tree "FSMC_BCR3"
base ad:0x80000018
group 0--3
line.long 0 "FSMC_BCR3"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " MWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
;tree.end

;tree "FSMC_BTR0"
base ad:0x80000004
group 0--3
line.long 0 "FSMC_BTR0"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

;tree "FSMC_BTR1"
base ad:0x8000000c
group 0--3
line.long 0 "FSMC_BTR1"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

;tree "FSMC_BTR2"
base ad:0x80000014
group 0--3
line.long 0 "FSMC_BTR2"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

;tree "FSMC_BTR3"
base ad:0x8000001c
group 0--3
line.long 0 "FSMC_BTR3"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

;tree "FSMC_PCR0"
base ad:0x80000040
group 0--3
line.long 0 "FSMC_PCR0"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "FSMC_PCR1"
base ad:0x80000060
group 0--3
line.long 0 "FSMC_PCR1"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "FSMC_PCR2"
base ad:0x80000080
group 0--3
line.long 0 "FSMC_PCR2"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "FSMC_PCR3"
base ad:0x800000a0
group 0--3
line.long 0 "FSMC_PCR3"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 13.--16. " TAR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " ECCPS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "FSMC_SR0"
base ad:0x80000044
group 0--3
line.long 0 "FSMC_SR0"
bitfld.long 0 6. " FEMPT "  "0 ,1 "
;tree.end

;tree "FSMC_SR1"
base ad:0x80000064
group 0--3
line.long 0 "FSMC_SR1"
bitfld.long 0 6. " FEMPT "  "0 ,1 "
;tree.end

;tree "FSMC_PMEM0"
base ad:0x80000048
group 0--3
line.long 0 "FSMC_PMEM0"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

;tree "FSMC_PMEM1"
base ad:0x80000068
group 0--3
line.long 0 "FSMC_PMEM1"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

;tree "FSMC_PMEM2"
base ad:0x80000088
group 0--3
line.long 0 "FSMC_PMEM2"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

;tree "FSMC_PMEM3"
base ad:0x800000a8
group 0--3
line.long 0 "FSMC_PMEM3"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

;tree "FSMC_PATT0"
base ad:0x8000004c
group 0--3
line.long 0 "FSMC_PATT0"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

;tree "FSMC_PATT1"
base ad:0x8000006c
group 0--3
line.long 0 "FSMC_PATT1"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

;tree "FSMC_PATT2"
base ad:0x8000008c
group 0--3
line.long 0 "FSMC_PATT2"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

;tree "FSMC_PATT3"
base ad:0x800000ac
group 0--3
line.long 0 "FSMC_PATT3"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

;tree "FSMC_PIO0"
base ad:0x80000050
group 0--3
line.long 0 "FSMC_PIO0"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

;tree "FSMC_PIO1"
base ad:0x80000070
group 0--3
line.long 0 "FSMC_PIO1"
hexfld.byte 0 " SET "
hexfld.byte 1 " WAIT "
hexfld.byte 2 " HOLD "
hexfld.byte 3 " HIZ "
;tree.end

;tree "FSMC_ECCR0"
base ad:0x80000054
group 0--3
line.long 0 "FSMC_ECCR0"
bitfld.long 0 0.--23. " ECC "  " "
;tree.end

;tree "FSMC_ECCR1"
base ad:0x80000074
group 0--3
line.long 0 "FSMC_ECCR1"
bitfld.long 0 0.--23. " ECC "  " "
;tree.end

;tree "FSMC_ITCR"
base ad:0x800000c0
group 0--3
line.long 0 "FSMC_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "FSMC_ITIP0"
base ad:0x800000c4
group 0--3
line.long 0 "FSMC_ITIP0"
hexfld.long 0 " PCDAI "
;tree.end

;tree "FSMC_ITIP1"
base ad:0x800000c8
group 0--3
line.long 0 "FSMC_ITIP1"
bitfld.long 0 0. " SMFBCLK "  "0 ,1 "
bitfld.long 0 1. " SMWAITn "  "0 ,1 "
bitfld.long 0 2.--3. " SMPCIRQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SMPIOIS16n "  "0 ,1 "
bitfld.long 0 7.--8. " SMPCD "  "0 ,1 ,2 ,3 "
bitfld.long 0 11.--12. " ExtDefWidth "  "0 ,1 ,2 ,3 "
;tree.end

;tree "FSMC_ITOP0"
base ad:0x800000cc
group 0--3
line.long 0 "FSMC_ITOP0"
hexfld.long 0 " PCDAO "
;tree.end

;tree "FSMC_ITOP1"
base ad:0x800000d0
group 0--3
line.long 0 "FSMC_ITOP1"
bitfld.long 0 0.--25. " SMAD "  " "
bitfld.long 0 26. " PC0INTR "  "0 ,1 "
bitfld.long 0 27. " PC1INTR "  "0 ,1 "
bitfld.long 0 30. " SMOEN "  "0 ,1 "
bitfld.long 0 31. " SWWEN "  "0 ,1 "
;tree.end

;tree "FSMC_ITOP2"
base ad:0x800000d4
group 0--3
line.long 0 "FSMC_ITOP2"
bitfld.long 0 0. " SMPREGN "  "0 ,1 "
bitfld.long 0 1. " SMPRST0N "  "0 ,1 "
bitfld.long 0 2. " SMPRST1N "  "0 ,1 "
bitfld.long 0 5. " SMPCDIRN "  "0 ,1 "
bitfld.long 0 6. " SMPC1EN "  "0 ,1 "
bitfld.long 0 7. " SMPC2EN "  "0 ,1 "
bitfld.long 0 8. " SMPIORN "  "0 ,1 "
bitfld.long 0 9. " SMPIOWN "  "0 ,1 "
bitfld.long 0 10. " SMADVN "  "0 ,1 "
bitfld.long 0 11. " SMCKO "  "0 ,1 "
bitfld.long 0 12. " SMBE0n "  "0 ,1 "
bitfld.long 0 13. " SMBE1n "  "0 ,1 "
bitfld.long 0 14. " SMBE2n "  "0 ,1 "
bitfld.long 0 15. " SMBE3n "  "0 ,1 "
bitfld.long 0 16. " SMPS0N "  "0 ,1 "
bitfld.long 0 17. " SMPS1N "  "0 ,1 "
;tree.end

;tree "FSMC_ITOP3"
base ad:0x800000d8
group 0--3
line.long 0 "FSMC_ITOP3"
bitfld.long 0 0. " SMCS0N "  "0 ,1 "
bitfld.long 0 1. " SMCS1N "  "0 ,1 "
bitfld.long 0 2. " SMCS2N "  "0 ,1 "
bitfld.long 0 3. " SMCS3N "  "0 ,1 "
bitfld.long 0 4. " SMFWP0N "  "0 ,1 "
bitfld.long 0 5. " SMFWP1N "  "0 ,1 "
bitfld.long 0 6. " SMFWP2N "  "0 ,1 "
bitfld.long 0 7. " SMFWP3N "  "0 ,1 "
bitfld.long 0 8. " SMFRST0N "  "0 ,1 "
bitfld.long 0 9. " SMFRST1N "  "0 ,1 "
bitfld.long 0 10. " SMFRST2N "  "0 ,1 "
bitfld.long 0 11. " SMFRST3N "  "0 ,1 "
;tree.end

;tree "FSMC_BWTR0"
base ad:0x80000100
group 0--3
line.long 0 "FSMC_BWTR0"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

;tree "FSMC_BWTR1"
base ad:0x80000108
group 0--3
line.long 0 "FSMC_BWTR1"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

;tree "FSMC_BWTR2"
base ad:0x80000110
group 0--3
line.long 0 "FSMC_BWTR2"
bitfld.long 0 0.--3. " ADDSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " ADDHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " DATAST "
bitfld.long 0 16.--19. " BUSTURN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " CLKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DATLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--29. " ACCMOD "  "0 ,1 ,2 ,3 "
;tree.end

;tree "FSMC_PeriphID0"
base ad:0x80000fe0
rgroup 0--3
line.long 0 "FSMC_PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "FSMC_PeriphID1"
base ad:0x80000fe4
rgroup 0--3
line.long 0 "FSMC_PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "FSMC_PeriphID2"
base ad:0x80000fe8
rgroup 0--3
line.long 0 "FSMC_PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "FSMC_PeriphID3"
base ad:0x80000fec
rgroup 0--3
line.long 0 "FSMC_PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "FSMC_PCellID0"
base ad:0x80000ff0
rgroup 0--3
line.long 0 "FSMC_PCellID0"
bitfld.long 0 0. " _PCellID0 "  "0 ,1 "
;tree.end

;tree "FSMC_PCellID1"
base ad:0x80000ff4
rgroup 0--3
line.long 0 "FSMC_PCellID1"
bitfld.long 0 0. " _BCRPCellID1 "  "0 ,1 "
;tree.end

;tree "FSMC_PCellID2"
base ad:0x80000ff8
rgroup 0--3
line.long 0 "FSMC_PCellID2"
bitfld.long 0 0. " _BCRPCellID2 "  "0 ,1 "
;tree.end

;tree "FSMC_PCellID3"
base ad:0x80000ffc
rgroup 0--3
line.long 0 "FSMC_PCellID3"
bitfld.long 0 0. " _BCRPCellID3 "  "0 ,1 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "G12"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "G2D_BASE0"
base ad:0xa0320000
wgroup 0--3
line.long 0 "G2D_BASE0"
bitfld.long 0 0. " G2D_BASE0 "  "0 ,1 "
;tree.end

;tree "G2D_CFG0"
base ad:0xa0320004
wgroup 0--3
line.long 0 "G2D_CFG0"
bitfld.long 0 0. " G2D_CFG0 "  "0 ,1 "
;tree.end

;tree "G2D_BASE1"
base ad:0xa0320008
wgroup 0--3
line.long 0 "G2D_BASE1"
bitfld.long 0 0. " G2D_BASE1 "  "0 ,1 "
;tree.end

;tree "G2D_CFG1"
base ad:0xa032000c
wgroup 0--3
line.long 0 "G2D_CFG1"
bitfld.long 0 0. " G2D_CFG1 "  "0 ,1 "
;tree.end

;tree "G2D_BASE2"
base ad:0xa0320010
wgroup 0--3
line.long 0 "G2D_BASE2"
bitfld.long 0 0. " G2D_BASE2 "  "0 ,1 "
;tree.end

;tree "G2D_CFG2"
base ad:0xa0320014
wgroup 0--3
line.long 0 "G2D_CFG2"
bitfld.long 0 0. " G2D_CFG2 "  "0 ,1 "
;tree.end

;tree "G2D_BASE3"
base ad:0xa0320018
wgroup 0--3
line.long 0 "G2D_BASE3"
bitfld.long 0 0. " G2D_BASE3 "  "0 ,1 "
;tree.end

;tree "G2D_CFG3"
base ad:0xa032001c
wgroup 0--3
line.long 0 "G2D_CFG3"
bitfld.long 0 0. " G2D_CFG3 "  "0 ,1 "
;tree.end

;tree "G2D_SCISSORX"
base ad:0xa0320020
wgroup 0--3
line.long 0 "G2D_SCISSORX"
bitfld.long 0 0. " G2D_SCISSORX "  "0 ,1 "
;tree.end

;tree "G2D_SCISSORY"
base ad:0xa0320024
wgroup 0--3
line.long 0 "G2D_SCISSORY"
bitfld.long 0 0. " G2D_SCISSORY "  "0 ,1 "
;tree.end

;tree "G2D_FOREGROUND"
base ad:0xa0320028
wgroup 0--3
line.long 0 "G2D_FOREGROUND"
bitfld.long 0 0. " G2D_FOREGROUND "  "0 ,1 "
;tree.end

;tree "G2D_BACKGROUND"
base ad:0xa032002c
wgroup 0--3
line.long 0 "G2D_BACKGROUND"
bitfld.long 0 0. " G2D_BACKGROUND "  "0 ,1 "
;tree.end

;tree "G2D_ALPHABLEND"
base ad:0xa0320030
wgroup 0--3
line.long 0 "G2D_ALPHABLEND"
bitfld.long 0 0. " G2D_ALPHABLEND "  "0 ,1 "
;tree.end

;tree "G2D_ROP"
base ad:0xa0320034
wgroup 0--3
line.long 0 "G2D_ROP"
bitfld.long 0 0. " G2D_ROP "  "0 ,1 "
;tree.end

;tree "G2D_CONFIG"
base ad:0xa0320038
wgroup 0--3
line.long 0 "G2D_CONFIG"
bitfld.long 0 0. " G2D_CONFIG "  "0 ,1 "
;tree.end

;tree "G2D_INPUT"
base ad:0xa032003c
wgroup 0--3
line.long 0 "G2D_INPUT"
bitfld.long 0 0. " G2D_INPUT "  "0 ,1 "
;tree.end

;tree "G2D_MASK"
base ad:0xa0320040
wgroup 0--3
line.long 0 "G2D_MASK"
bitfld.long 0 0. " G2D_MASK "  "0 ,1 "
;tree.end

;tree "G2D_BLENDERCFG"
base ad:0xa0320044
wgroup 0--3
line.long 0 "G2D_BLENDERCFG"
bitfld.long 0 0. " G2D_BLENDERCFG "  "0 ,1 "
;tree.end

;tree "G2D_BLEND_A0"
base ad:0xa0320050
wgroup 0--3
line.long 0 "G2D_BLEND_A0"
bitfld.long 0 0. " G2D_BLEND_A0 "  "0 ,1 "
;tree.end

;tree "G2D_BLEND_A1"
base ad:0xa0320054
wgroup 0--3
line.long 0 "G2D_BLEND_A1"
bitfld.long 0 0. " G2D_BLEND_A1 "  "0 ,1 "
;tree.end

;tree "G2D_BLEND_A2"
base ad:0xa0320058
wgroup 0--3
line.long 0 "G2D_BLEND_A2"
bitfld.long 0 0. " G2D_BLEND_A2 "  "0 ,1 "
;tree.end

;tree "G2D_BLEND_A3"
base ad:0xa032005c
wgroup 0--3
line.long 0 "G2D_BLEND_A3"
bitfld.long 0 0. " G2D_BLEND_A3 "  "0 ,1 "
;tree.end

;tree "G2D_BLEND_C0"
base ad:0xa0320060
wgroup 0--3
line.long 0 "G2D_BLEND_C0"
bitfld.long 0 0. " G2D_BLEND_C0 "  "0 ,1 "
;tree.end

;tree "G2D_BLEND_C1"
base ad:0xa0320064
wgroup 0--3
line.long 0 "G2D_BLEND_C1"
bitfld.long 0 0. " G2D_BLEND_C1 "  "0 ,1 "
;tree.end

;tree "G2D_BLEND_C2"
base ad:0xa0320068
wgroup 0--3
line.long 0 "G2D_BLEND_C2"
bitfld.long 0 0. " G2D_BLEND_C2 "  "0 ,1 "
;tree.end

;tree "G2D_BLEND_C3"
base ad:0xa032006c
wgroup 0--3
line.long 0 "G2D_BLEND_C3"
bitfld.long 0 0. " G2D_BLEND_C3 "  "0 ,1 "
;tree.end

;tree "G2D_BLEND_C4"
base ad:0xa0320070
wgroup 0--3
line.long 0 "G2D_BLEND_C4"
bitfld.long 0 0. " G2D_BLEND_C4 "  "0 ,1 "
;tree.end

;tree "G2D_BLEND_C5"
base ad:0xa0320074
wgroup 0--3
line.long 0 "G2D_BLEND_C5"
bitfld.long 0 0. " G2D_BLEND_C5 "  "0 ,1 "
;tree.end

;tree "G2D_BLEND_C6"
base ad:0xa0320078
wgroup 0--3
line.long 0 "G2D_BLEND_C6"
bitfld.long 0 0. " G2D_BLEND_C6 "  "0 ,1 "
;tree.end

;tree "G2D_BLEND_C7"
base ad:0xa032007c
wgroup 0--3
line.long 0 "G2D_BLEND_C7"
bitfld.long 0 0. " G2D_BLEND_C7 "  "0 ,1 "
;tree.end

;tree "VGV1_VTX0"
base ad:0xa0320080
wgroup 0--3
line.long 0 "VGV1_VTX0"
bitfld.long 0 0. " VGV1_VTX0 "  "0 ,1 "
;tree.end

;tree "VGV1_VTX1"
base ad:0xa0320084
wgroup 0--3
line.long 0 "VGV1_VTX1"
bitfld.long 0 0. " VGV1_VTX1 "  "0 ,1 "
;tree.end

;tree "VGV1_TILEOFS"
base ad:0xa0320088
wgroup 0--3
line.long 0 "VGV1_TILEOFS"
bitfld.long 0 0. " VGV1_TILEOFS "  "0 ,1 "
;tree.end

;tree "VGV1_FILL"
base ad:0xa032008c
wgroup 0--3
line.long 0 "VGV1_FILL"
bitfld.long 0 0. " VGV1_FILL "  "0 ,1 "
;tree.end

;tree "VGV1_SCISSORX"
base ad:0xa0320090
wgroup 0--3
line.long 0 "VGV1_SCISSORX"
bitfld.long 0 0. " VGV1_SCISSORX "  "0 ,1 "
;tree.end

;tree "VGV1_SCISSORY"
base ad:0xa0320094
wgroup 0--3
line.long 0 "VGV1_SCISSORY"
bitfld.long 0 0. " VGV1_SCISSORY "  "0 ,1 "
;tree.end

;tree "VGV1_CFG1"
base ad:0xa032009c
wgroup 0--3
line.long 0 "VGV1_CFG1"
bitfld.long 0 0. " VGV1_CFG1 "  "0 ,1 "
;tree.end

;tree "VGV1_CFG2"
base ad:0xa03200a0
wgroup 0--3
line.long 0 "VGV1_CFG2"
bitfld.long 0 0. " VGV1_CFG2 "  "0 ,1 "
;tree.end

;tree "VGV1_DIRTYBASE"
base ad:0xa03200a4
wgroup 0--3
line.long 0 "VGV1_DIRTYBASE"
bitfld.long 0 0. " VGV1_DIRTYBASE "  "0 ,1 "
;tree.end

;tree "VGV1_CBASE1"
base ad:0xa03200a8
wgroup 0--3
line.long 0 "VGV1_CBASE1"
bitfld.long 0 0. " VGV1_CBASE1 "  "0 ,1 "
;tree.end

;tree "VGV1_UBASE2"
base ad:0xa03200ac
wgroup 0--3
line.long 0 "VGV1_UBASE2"
bitfld.long 0 0. " VGV1_UBASE2 "  "0 ,1 "
;tree.end

;tree "VGV2_C1X"
base ad:0xa0320100
wgroup 0--3
line.long 0 "VGV2_C1X"
bitfld.long 0 0. " VGV2_C1X "  "0 ,1 "
;tree.end

;tree "VGV2_C1Y"
base ad:0xa0320104
wgroup 0--3
line.long 0 "VGV2_C1Y"
bitfld.long 0 0. " VGV2_C1Y "  "0 ,1 "
;tree.end

;tree "VGV2_C2X"
base ad:0xa0320108
wgroup 0--3
line.long 0 "VGV2_C2X"
bitfld.long 0 0. " VGV2_C2X "  "0 ,1 "
;tree.end

;tree "VGV2_C2Y"
base ad:0xa032010c
wgroup 0--3
line.long 0 "VGV2_C2Y"
bitfld.long 0 0. " VGV2_C2Y "  "0 ,1 "
;tree.end

;tree "VGV2_C3X"
base ad:0xa0320110
wgroup 0--3
line.long 0 "VGV2_C3X"
bitfld.long 0 0. " VGV2_C3X "  "0 ,1 "
;tree.end

;tree "VGV2_C3Y"
base ad:0xa0320114
wgroup 0--3
line.long 0 "VGV2_C3Y"
bitfld.long 0 0. " VGV2_C3Y "  "0 ,1 "
;tree.end

;tree "VGV2_C4X"
base ad:0xa0320118
wgroup 0--3
line.long 0 "VGV2_C4X"
bitfld.long 0 0. " VGV2_C4X "  "0 ,1 "
;tree.end

;tree "VGV2_C4Y"
base ad:0xa032011c
wgroup 0--3
line.long 0 "VGV2_C4Y"
bitfld.long 0 0. " VGV2_C4Y "  "0 ,1 "
;tree.end

;tree "VGV2_C1XREL"
base ad:0xa0320120
wgroup 0--3
line.long 0 "VGV2_C1XREL"
bitfld.long 0 0. " VGV2_C1XREL "  "0 ,1 "
;tree.end

;tree "VGV2_C1YREL"
base ad:0xa0320124
wgroup 0--3
line.long 0 "VGV2_C1YREL"
bitfld.long 0 0. " VGV2_C1YREL "  "0 ,1 "
;tree.end

;tree "VGV2_C2XREL"
base ad:0xa0320128
wgroup 0--3
line.long 0 "VGV2_C2XREL"
bitfld.long 0 0. " VGV2_C2XREL "  "0 ,1 "
;tree.end

;tree "VGV2_C2YREL"
base ad:0xa032012c
wgroup 0--3
line.long 0 "VGV2_C2YREL"
bitfld.long 0 0. " VGV2_C2YREL "  "0 ,1 "
;tree.end

;tree "VGV2_C3XREL"
base ad:0xa0320130
wgroup 0--3
line.long 0 "VGV2_C3XREL"
bitfld.long 0 0. " VGV2_C3XREL "  "0 ,1 "
;tree.end

;tree "VGV2_C3YREL"
base ad:0xa0320134
wgroup 0--3
line.long 0 "VGV2_C3YREL"
bitfld.long 0 0. " VGV2_C3YREL "  "0 ,1 "
;tree.end

;tree "VGV2_C4XREL"
base ad:0xa0320138
wgroup 0--3
line.long 0 "VGV2_C4XREL"
bitfld.long 0 0. " VGV2_C4XREL "  "0 ,1 "
;tree.end

;tree "VGV2_C4YREL"
base ad:0xa032013c
wgroup 0--3
line.long 0 "VGV2_C4YREL"
bitfld.long 0 0. " VGV2_C4YREL "  "0 ,1 "
;tree.end

;tree "VGV2_XFXX"
base ad:0xa0320140
wgroup 0--3
line.long 0 "VGV2_XFXX"
bitfld.long 0 0. " VGV2_XFXX "  "0 ,1 "
;tree.end

;tree "VGV2_XFYX"
base ad:0xa0320144
wgroup 0--3
line.long 0 "VGV2_XFYX"
bitfld.long 0 0. " VGV2_XFYX "  "0 ,1 "
;tree.end

;tree "VGV2_XFXY"
base ad:0xa0320148
wgroup 0--3
line.long 0 "VGV2_XFXY"
bitfld.long 0 0. " VGV2_XFXY "  "0 ,1 "
;tree.end

;tree "VGV2_XFYY"
base ad:0xa032014c
wgroup 0--3
line.long 0 "VGV2_XFYY"
bitfld.long 0 0. " VGV2_XFYY "  "0 ,1 "
;tree.end

;tree "VGV2_XFXA"
base ad:0xa0320150
wgroup 0--3
line.long 0 "VGV2_XFXA"
bitfld.long 0 0. " VGV2_XFXA "  "0 ,1 "
;tree.end

;tree "VGV2_XFYA"
base ad:0xa0320154
wgroup 0--3
line.long 0 "VGV2_XFYA"
bitfld.long 0 0. " VGV2_XFYA "  "0 ,1 "
;tree.end

;tree "VGV2_XFSTXX"
base ad:0xa0320158
wgroup 0--3
line.long 0 "VGV2_XFSTXX"
bitfld.long 0 0. " VGV2_XFSTXX "  "0 ,1 "
;tree.end

;tree "VGV2_XFSTYX"
base ad:0xa032015c
wgroup 0--3
line.long 0 "VGV2_XFSTYX"
bitfld.long 0 0. " VGV2_XFSTYX "  "0 ,1 "
;tree.end

;tree "VGV2_XFSTXY"
base ad:0xa0320160
wgroup 0--3
line.long 0 "VGV2_XFSTXY"
bitfld.long 0 0. " VGV2_XFSTXY "  "0 ,1 "
;tree.end

;tree "VGV2_XFSTYY"
base ad:0xa0320164
wgroup 0--3
line.long 0 "VGV2_XFSTYY"
bitfld.long 0 0. " VGV2_XFSTYY "  "0 ,1 "
;tree.end

;tree "VGV2_BBOXMINX"
base ad:0xa0320168
wgroup 0--3
line.long 0 "VGV2_BBOXMINX"
bitfld.long 0 0. " VGV2_BBOXMINX "  "0 ,1 "
;tree.end

;tree "VGV2_BBOXMINY"
base ad:0xa032016c
wgroup 0--3
line.long 0 "VGV2_BBOXMINY"
bitfld.long 0 0. " VGV2_BBOXMINY "  "0 ,1 "
;tree.end

;tree "VGV2_BBOXMAXX"
base ad:0xa0320170
wgroup 0--3
line.long 0 "VGV2_BBOXMAXX"
bitfld.long 0 0. " VGV2_BBOXMAXX "  "0 ,1 "
;tree.end

;tree "VGV2_BBOXMAXY"
base ad:0xa0320174
wgroup 0--3
line.long 0 "VGV2_BBOXMAXY"
bitfld.long 0 0. " VGV2_BBOXMAXY "  "0 ,1 "
;tree.end

;tree "VGV2_SCALE"
base ad:0xa0320178
wgroup 0--3
line.long 0 "VGV2_SCALE"
bitfld.long 0 0. " VGV2_SCALE "  "0 ,1 "
;tree.end

;tree "VGV2_BIAS"
base ad:0xa032017c
wgroup 0--3
line.long 0 "VGV2_BIAS"
bitfld.long 0 0. " VGV2_BIAS "  "0 ,1 "
;tree.end

;tree "VGV2_ACCURACY"
base ad:0xa0320180
wgroup 0--3
line.long 0 "VGV2_ACCURACY"
bitfld.long 0 0. " VGV2_ACCURACY "  "0 ,1 "
;tree.end

;tree "VGV2_THINRADIUS"
base ad:0xa0320184
wgroup 0--3
line.long 0 "VGV2_THINRADIUS"
bitfld.long 0 0. " VGV2_THINRADIUS "  "0 ,1 "
;tree.end

;tree "VGV2_ARCCOS"
base ad:0xa0320188
wgroup 0--3
line.long 0 "VGV2_ARCCOS"
bitfld.long 0 0. " VGV2_ARCCOS "  "0 ,1 "
;tree.end

;tree "VGV2_ARCSIN"
base ad:0xa032018c
wgroup 0--3
line.long 0 "VGV2_ARCSIN"
bitfld.long 0 0. " VGV2_ARCSIN "  "0 ,1 "
;tree.end

;tree "VGV2_ARCTAN"
base ad:0xa0320190
wgroup 0--3
line.long 0 "VGV2_ARCTAN"
bitfld.long 0 0. " VGV2_ARCTAN "  "0 ,1 "
;tree.end

;tree "VGV2_RADIUS"
base ad:0xa0320194
wgroup 0--3
line.long 0 "VGV2_RADIUS"
bitfld.long 0 0. " VGV2_RADIUS "  "0 ,1 "
;tree.end

;tree "VGV2_MITER"
base ad:0xa0320198
wgroup 0--3
line.long 0 "VGV2_MITER"
bitfld.long 0 0. " VGV2_MITER "  "0 ,1 "
;tree.end

;tree "VGV2_CLIP"
base ad:0xa03201a0
wgroup 0--3
line.long 0 "VGV2_CLIP"
bitfld.long 0 0. " VGV2_CLIP "  "0 ,1 "
;tree.end

;tree "VGV2_MODE"
base ad:0xa03201b8
wgroup 0--3
line.long 0 "VGV2_MODE"
bitfld.long 0 0. " VGV2_MODE "  "0 ,1 "
;tree.end

;tree "VGV2_ACTION"
base ad:0xa03201bc
wgroup 0--3
line.long 0 "VGV2_ACTION"
bitfld.long 0 0. " VGV2_ACTION "  "0 ,1 "
;tree.end

;tree "VGV3_CONTROL"
base ad:0xa03201c0
wgroup 0--3
line.long 0 "VGV3_CONTROL"
bitfld.long 0 0. " VGV3_CONTROL "  "0 ,1 "
;tree.end

;tree "VGV3_MODE"
base ad:0xa03201c4
wgroup 0--3
line.long 0 "VGV3_MODE"
bitfld.long 0 0. " VGV3_MODE "  "0 ,1 "
;tree.end

;tree "VGV3_WRITEADDR"
base ad:0xa03201c8
wgroup 0--3
line.long 0 "VGV3_WRITEADDR"
bitfld.long 0 0. " VGV3_WRITEADDR "  "0 ,1 "
;tree.end

;tree "VGV3_WRITE"
base ad:0xa03201cc
wgroup 0--3
line.long 0 "VGV3_WRITE"
bitfld.long 0 0. " VGV3_WRITE "  "0 ,1 "
;tree.end

;tree "VGV3_WRITEIFPAUSED"
base ad:0xa03201d0
wgroup 0--3
line.long 0 "VGV3_WRITEIFPAUSED"
bitfld.long 0 0. " VGV3_WRITEIFPAUSED "  "0 ,1 "
;tree.end

;tree "VGV3_NEXTADDR"
base ad:0xa03201d4
wgroup 0--3
line.long 0 "VGV3_NEXTADDR"
bitfld.long 0 0. " VGV3_NEXTADDR "  "0 ,1 "
;tree.end

;tree "VGV3_NEXTCMD"
base ad:0xa03201d8
wgroup 0--3
line.long 0 "VGV3_NEXTCMD"
bitfld.long 0 0. " VGV3_NEXTCMD "  "0 ,1 "
;tree.end

;tree "VGV3_VGBYPASS"
base ad:0xa03201dc
wgroup 0--3
line.long 0 "VGV3_VGBYPASS"
bitfld.long 0 0. " VGV3_VGBYPASS "  "0 ,1 "
;tree.end

;tree "VGV3_WRITES8"
base ad:0xa03201e0
wgroup 0--3
line.long 0 "VGV3_WRITES8"
bitfld.long 0 0. " VGV3_WRITES8 "  "0 ,1 "
;tree.end

;tree "VGV3_WRITES16"
base ad:0xa03201e4
wgroup 0--3
line.long 0 "VGV3_WRITES16"
bitfld.long 0 0. " VGV3_WRITES16 "  "0 ,1 "
;tree.end

;tree "VGV3_WRITES32"
base ad:0xa03201e8
wgroup 0--3
line.long 0 "VGV3_WRITES32"
bitfld.long 0 0. " VGV3_WRITES32 "  "0 ,1 "
;tree.end

;tree "VGV3_WRITEF32"
base ad:0xa03201ec
wgroup 0--3
line.long 0 "VGV3_WRITEF32"
bitfld.long 0 0. " VGV3_WRITEF32 "  "0 ,1 "
;tree.end

;tree "VGV3_WRITERAW"
base ad:0xa03201f0
wgroup 0--3
line.long 0 "VGV3_WRITERAW"
bitfld.long 0 0. " VGV3_WRITERAW "  "0 ,1 "
;tree.end

;tree "VGV3_WRITEDMI"
base ad:0xa03201f4
wgroup 0--3
line.long 0 "VGV3_WRITEDMI"
bitfld.long 0 0. " VGV3_WRITEDMI "  "0 ,1 "
;tree.end

;tree "G2D_CONST0"
base ad:0xa03202c0
wgroup 0--3
line.long 0 "G2D_CONST0"
bitfld.long 0 0. " G2D_CONST0 "  "0 ,1 "
;tree.end

;tree "G2D_CONST1"
base ad:0xa03202c4
wgroup 0--3
line.long 0 "G2D_CONST1"
bitfld.long 0 0. " G2D_CONST1 "  "0 ,1 "
;tree.end

;tree "G2D_CONST2"
base ad:0xa03202c8
wgroup 0--3
line.long 0 "G2D_CONST2"
bitfld.long 0 0. " G2D_CONST2 "  "0 ,1 "
;tree.end

;tree "G2D_CONST3"
base ad:0xa03202cc
wgroup 0--3
line.long 0 "G2D_CONST3"
bitfld.long 0 0. " G2D_CONST3 "  "0 ,1 "
;tree.end

;tree "G2D_CONST4"
base ad:0xa03202d0
wgroup 0--3
line.long 0 "G2D_CONST4"
bitfld.long 0 0. " G2D_CONST4 "  "0 ,1 "
;tree.end

;tree "G2D_CONST5"
base ad:0xa03202d4
wgroup 0--3
line.long 0 "G2D_CONST5"
bitfld.long 0 0. " G2D_CONST5 "  "0 ,1 "
;tree.end

;tree "G2D_CONST6"
base ad:0xa03202d8
wgroup 0--3
line.long 0 "G2D_CONST6"
bitfld.long 0 0. " G2D_CONST6 "  "0 ,1 "
;tree.end

;tree "G2D_CONST7"
base ad:0xa03202dc
wgroup 0--3
line.long 0 "G2D_CONST7"
bitfld.long 0 0. " G2D_CONST7 "  "0 ,1 "
;tree.end

;tree "GRADW_CONST0"
base ad:0xa0320300
wgroup 0--3
line.long 0 "GRADW_CONST0"
bitfld.long 0 0. " GRADW_CONST0 "  "0 ,1 "
;tree.end

;tree "GRADW_CONST1"
base ad:0xa0320304
wgroup 0--3
line.long 0 "GRADW_CONST1"
bitfld.long 0 0. " GRADW_CONST1 "  "0 ,1 "
;tree.end

;tree "GRADW_CONST2"
base ad:0xa0320308
wgroup 0--3
line.long 0 "GRADW_CONST2"
bitfld.long 0 0. " GRADW_CONST2 "  "0 ,1 "
;tree.end

;tree "GRADW_CONST3"
base ad:0xa032030c
wgroup 0--3
line.long 0 "GRADW_CONST3"
bitfld.long 0 0. " GRADW_CONST3 "  "0 ,1 "
;tree.end

;tree "GRADW_CONST4"
base ad:0xa0320310
wgroup 0--3
line.long 0 "GRADW_CONST4"
bitfld.long 0 0. " GRADW_CONST4 "  "0 ,1 "
;tree.end

;tree "GRADW_CONST5"
base ad:0xa0320314
wgroup 0--3
line.long 0 "GRADW_CONST5"
bitfld.long 0 0. " GRADW_CONST5 "  "0 ,1 "
;tree.end

;tree "GRADW_CONST6"
base ad:0xa0320318
wgroup 0--3
line.long 0 "GRADW_CONST6"
bitfld.long 0 0. " GRADW_CONST6 "  "0 ,1 "
;tree.end

;tree "GRADW_CONST7"
base ad:0xa032031c
wgroup 0--3
line.long 0 "GRADW_CONST7"
bitfld.long 0 0. " GRADW_CONST7 "  "0 ,1 "
;tree.end

;tree "GRADW_CONST8"
base ad:0xa0320320
wgroup 0--3
line.long 0 "GRADW_CONST8"
bitfld.long 0 0. " GRADW_CONST8 "  "0 ,1 "
;tree.end

;tree "GRADW_CONST9"
base ad:0xa0320324
wgroup 0--3
line.long 0 "GRADW_CONST9"
bitfld.long 0 0. " GRADW_CONST9 "  "0 ,1 "
;tree.end

;tree "GRADW_CONSTA"
base ad:0xa0320328
wgroup 0--3
line.long 0 "GRADW_CONSTA"
bitfld.long 0 0. " GRADW_CONSTA "  "0 ,1 "
;tree.end

;tree "GRADW_CONSTB"
base ad:0xa032032c
wgroup 0--3
line.long 0 "GRADW_CONSTB"
bitfld.long 0 0. " GRADW_CONSTB "  "0 ,1 "
;tree.end

;tree "G2D_GRADIENT"
base ad:0xa0320340
wgroup 0--3
line.long 0 "G2D_GRADIENT"
bitfld.long 0 0. " G2D_GRADIENT "  "0 ,1 "
;tree.end

;tree "GRADW_TEXCFG"
base ad:0xa0320344
wgroup 0--3
line.long 0 "GRADW_TEXCFG"
bitfld.long 0 0. " GRADW_TEXCFG "  "0 ,1 "
;tree.end

;tree "GRADW_TEXSIZE"
base ad:0xa0320348
wgroup 0--3
line.long 0 "GRADW_TEXSIZE"
bitfld.long 0 0. " GRADW_TEXSIZE "  "0 ,1 "
;tree.end

;tree "GRADW_TEXBASE"
base ad:0xa032034c
wgroup 0--3
line.long 0 "GRADW_TEXBASE"
bitfld.long 0 0. " GRADW_TEXBASE "  "0 ,1 "
;tree.end

;tree "GRADW_BORDERCOLOR"
base ad:0xa0320350
wgroup 0--3
line.long 0 "GRADW_BORDERCOLOR"
bitfld.long 0 0. " GRADW_BORDERCOLOR "  "0 ,1 "
;tree.end

;tree "GRADW_INST0"
base ad:0xa0320380
wgroup 0--3
line.long 0 "GRADW_INST0"
bitfld.long 0 0. " GRADW_INST0 "  "0 ,1 "
;tree.end

;tree "GRADW_INST1"
base ad:0xa0320384
wgroup 0--3
line.long 0 "GRADW_INST1"
bitfld.long 0 0. " GRADW_INST1 "  "0 ,1 "
;tree.end

;tree "GRADW_INST2"
base ad:0xa0320388
wgroup 0--3
line.long 0 "GRADW_INST2"
bitfld.long 0 0. " GRADW_INST2 "  "0 ,1 "
;tree.end

;tree "GRADW_INST3"
base ad:0xa032038c
wgroup 0--3
line.long 0 "GRADW_INST3"
bitfld.long 0 0. " GRADW_INST3 "  "0 ,1 "
;tree.end

;tree "GRADW_INST4"
base ad:0xa0320390
wgroup 0--3
line.long 0 "GRADW_INST4"
bitfld.long 0 0. " GRADW_INST4 "  "0 ,1 "
;tree.end

;tree "GRADW_INST5"
base ad:0xa0320394
wgroup 0--3
line.long 0 "GRADW_INST5"
bitfld.long 0 0. " GRADW_INST5 "  "0 ,1 "
;tree.end

;tree "GRADW_INST6"
base ad:0xa0320398
wgroup 0--3
line.long 0 "GRADW_INST6"
bitfld.long 0 0. " GRADW_INST6 "  "0 ,1 "
;tree.end

;tree "GRADW_INST7"
base ad:0xa032039c
wgroup 0--3
line.long 0 "GRADW_INST7"
bitfld.long 0 0. " GRADW_INST7 "  "0 ,1 "
;tree.end

;tree "G2D_XY"
base ad:0xa03203c0
wgroup 0--3
line.long 0 "G2D_XY"
bitfld.long 0 0. " G2D_XY "  "0 ,1 "
;tree.end

;tree "G2D_WIDTHHEIGHT"
base ad:0xa03203c4
wgroup 0--3
line.long 0 "G2D_WIDTHHEIGHT"
bitfld.long 0 0. " G2D_WIDTHHEIGHT "  "0 ,1 "
;tree.end

;tree "G2D_SXY"
base ad:0xa03203c8
wgroup 0--3
line.long 0 "G2D_SXY"
bitfld.long 0 0. " G2D_SXY "  "0 ,1 "
;tree.end

;tree "G2D_SXY2"
base ad:0xa03203cc
wgroup 0--3
line.long 0 "G2D_SXY2"
bitfld.long 0 0. " G2D_SXY2 "  "0 ,1 "
;tree.end

;tree "G2D_VGSPAN"
base ad:0xa03203d0
wgroup 0--3
line.long 0 "G2D_VGSPAN"
bitfld.long 0 0. " G2D_VGSPAN "  "0 ,1 "
;tree.end

;tree "G2D_IDLE"
base ad:0xa03203f8
wgroup 0--3
line.long 0 "G2D_IDLE"
bitfld.long 0 0. " G2D_IDLE "  "0 ,1 "
;tree.end

;tree "G2D_COLOR"
base ad:0xa03203fc
wgroup 0--3
line.long 0 "G2D_COLOR"
bitfld.long 0 0. " G2D_COLOR "  "0 ,1 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "GIC"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CPU_ICR"
base ad:0xa0410100
group 0--3
line.long 0 "CPU_ICR"
bitfld.long 0 0. " CPUICREN "  "0 ,1 "
bitfld.long 0 1. " CPUICRENNS "  "0 ,1 "
bitfld.long 0 2. " CPUICRACKCTL "  "0 ,1 "
bitfld.long 0 3. " CPUICRFIQEN "  "0 ,1 "
bitfld.long 0 4. " CPUICRSBPR "  "0 ,1 "
;tree.end

;tree "PMR"
base ad:0xa0410104
group 0--3
line.long 0 "PMR"
bitfld.long 0 3.--7. " PMRPRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BPR"
base ad:0xa0410108
group 0--3
line.long 0 "BPR"
bitfld.long 0 0.--2. " BPRBP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "IAR"
base ad:0xa041010c
rgroup 0--3
line.long 0 "IAR"
bitfld.long 0 0.--9. " IARACKINTID "  " "
bitfld.long 0 10.--12. " IARSOURCECPUID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EOIR"
base ad:0xa0410110
wgroup 0--3
line.long 0 "EOIR"
bitfld.long 0 0.--9. " EOIREOIINTID "  " "
bitfld.long 0 10.--12. " EOIRSOURCECPUID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "RPR"
base ad:0xa0410114
rgroup 0--3
line.long 0 "RPR"
hexfld.byte 0 " RPRPRIORITY "
;tree.end

;tree "HPIR"
base ad:0xa0410118
rgroup 0--3
line.long 0 "HPIR"
bitfld.long 0 0.--9. " HPIRPENDINTID "  " "
bitfld.long 0 10.--12. " HPIRSOURCECPUID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "ANSBPR"
base ad:0xa041011c
group 0--3
line.long 0 "ANSBPR"
bitfld.long 0 0.--2. " ANSBPRBP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "CPU_IIIR"
base ad:0xa04101fc
rgroup 0--3
line.long 0 "CPU_IIIR"
bitfld.long 0 0.--11. " CPUIIIRIMPLEMENTOR "  " "
bitfld.long 0 12.--15. " CPUIIIRRN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " CPUIIIRAV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--31. " CPUIIIRPN "  " "
;tree.end

;tree "IDCR"
base ad:0xa0411000
group 0--3
line.long 0 "IDCR"
bitfld.long 0 0. " IDCEN "  "0 ,1 "
bitfld.long 0 1. " IDCENS "  "0 ,1 "
;tree.end

;tree "ICTR"
base ad:0xa0411004
rgroup 0--3
line.long 0 "ICTR"
bitfld.long 0 0.--4. " ICTITLN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " ICTCPUN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " ICTDOM "  "0 ,1 "
bitfld.long 0 11.--15. " ICTLSPI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DIIR"
base ad:0xa0411008
rgroup 0--3
line.long 0 "DIIR"
bitfld.long 0 0.--11. " DIIIMPL "  " "
bitfld.long 0 12.--23. " DIIRN "  " "
hexfld.byte 3 " DIIIMPL_DEFINED "
;tree.end

;tree "IS0R"
base ad:0xa0411080
group 0--3
line.long 0 "IS0R"
hexfld.long 0 " IS0 "
;tree.end

;tree "IS1R"
base ad:0xa0411084
group 0--3
line.long 0 "IS1R"
hexfld.long 0 " IS1 "
;tree.end

;tree "IS2R"
base ad:0xa0411088
group 0--3
line.long 0 "IS2R"
hexfld.long 0 " IS2 "
;tree.end

;tree "IS3R"
base ad:0xa041108c
group 0--3
line.long 0 "IS3R"
hexfld.long 0 " IS3 "
;tree.end

;tree "IS4R"
base ad:0xa0411090
group 0--3
line.long 0 "IS4R"
hexfld.long 0 " IS4 "
;tree.end

;tree "IS5R"
base ad:0xa0411094
group 0--3
line.long 0 "IS5R"
hexfld.long 0 " IS5 "
;tree.end

;tree "IS6R"
base ad:0xa0411098
group 0--3
line.long 0 "IS6R"
hexfld.long 0 " IS6 "
;tree.end

;tree "IS7R"
base ad:0xa041109c
group 0--3
line.long 0 "IS7R"
hexfld.long 0 " IS7 "
;tree.end

;tree "IS8R"
base ad:0xa04110a0
group 0--3
line.long 0 "IS8R"
hexfld.long 0 " IS8 "
;tree.end

;tree "IS9R"
base ad:0xa04110a4
group 0--3
line.long 0 "IS9R"
hexfld.long 0 " IS9 "
;tree.end

;tree "IS10R"
base ad:0xa04110a8
group 0--3
line.long 0 "IS10R"
hexfld.long 0 " IS10 "
;tree.end

;tree "IS11R"
base ad:0xa04110ac
group 0--3
line.long 0 "IS11R"
hexfld.long 0 " IS11 "
;tree.end

;tree "IS12R"
base ad:0xa04110b0
group 0--3
line.long 0 "IS12R"
hexfld.long 0 " IS12 "
;tree.end

;tree "IS13R"
base ad:0xa04110b4
group 0--3
line.long 0 "IS13R"
hexfld.long 0 " IS13 "
;tree.end

;tree "IS14R"
base ad:0xa04110b8
group 0--3
line.long 0 "IS14R"
hexfld.long 0 " IS14 "
;tree.end

;tree "IS15R"
base ad:0xa04110bc
group 0--3
line.long 0 "IS15R"
hexfld.long 0 " IS15 "
;tree.end

;tree "IS16R"
base ad:0xa04110c0
group 0--3
line.long 0 "IS16R"
hexfld.long 0 " IS16 "
;tree.end

;tree "IS17R"
base ad:0xa04110c4
group 0--3
line.long 0 "IS17R"
hexfld.long 0 " IS17 "
;tree.end

;tree "IS18R"
base ad:0xa04110c8
group 0--3
line.long 0 "IS18R"
hexfld.long 0 " IS18 "
;tree.end

;tree "IS19R"
base ad:0xa04110cc
group 0--3
line.long 0 "IS19R"
hexfld.long 0 " IS19 "
;tree.end

;tree "IS20R"
base ad:0xa04110d0
group 0--3
line.long 0 "IS20R"
hexfld.long 0 " IS20 "
;tree.end

;tree "IS21R"
base ad:0xa04110d4
group 0--3
line.long 0 "IS21R"
hexfld.long 0 " IS21 "
;tree.end

;tree "IS22R"
base ad:0xa04110d8
group 0--3
line.long 0 "IS22R"
hexfld.long 0 " IS22 "
;tree.end

;tree "IS23R"
base ad:0xa04110dc
group 0--3
line.long 0 "IS23R"
hexfld.long 0 " IS23 "
;tree.end

;tree "IS24R"
base ad:0xa04110e0
group 0--3
line.long 0 "IS24R"
hexfld.long 0 " IS24 "
;tree.end

;tree "IS25R"
base ad:0xa04110e4
group 0--3
line.long 0 "IS25R"
hexfld.long 0 " IS25 "
;tree.end

;tree "IS26R"
base ad:0xa04110e8
group 0--3
line.long 0 "IS26R"
hexfld.long 0 " IS26 "
;tree.end

;tree "IS27R"
base ad:0xa04110ec
group 0--3
line.long 0 "IS27R"
hexfld.long 0 " IS27 "
;tree.end

;tree "IS28R"
base ad:0xa04110f0
group 0--3
line.long 0 "IS28R"
hexfld.long 0 " IS28 "
;tree.end

;tree "IS29R"
base ad:0xa04110f4
group 0--3
line.long 0 "IS29R"
hexfld.long 0 " IS29 "
;tree.end

;tree "IS30R"
base ad:0xa04110f8
group 0--3
line.long 0 "IS30R"
hexfld.long 0 " IS30 "
;tree.end

;tree "IS31R"
base ad:0xa04110fc
group 0--3
line.long 0 "IS31R"
hexfld.long 0 " IS31 "
;tree.end

;tree "ES0R"
base ad:0xa0411100
group 0--3
line.long 0 "ES0R"
hexfld.long 0 " ES0 "
;tree.end

;tree "ES1R"
base ad:0xa0411104
group 0--3
line.long 0 "ES1R"
hexfld.long 0 " ES1 "
;tree.end

;tree "ES2R"
base ad:0xa0411108
group 0--3
line.long 0 "ES2R"
hexfld.long 0 " ES2 "
;tree.end

;tree "ES3R"
base ad:0xa041110c
group 0--3
line.long 0 "ES3R"
hexfld.long 0 " ES3 "
;tree.end

;tree "ES4R"
base ad:0xa0411110
group 0--3
line.long 0 "ES4R"
hexfld.long 0 " ES4 "
;tree.end

;tree "ES5R"
base ad:0xa0411114
group 0--3
line.long 0 "ES5R"
hexfld.long 0 " ES5 "
;tree.end

;tree "ES6R"
base ad:0xa0411118
group 0--3
line.long 0 "ES6R"
hexfld.long 0 " ES6 "
;tree.end

;tree "ES7R"
base ad:0xa041111c
group 0--3
line.long 0 "ES7R"
hexfld.long 0 " ES7 "
;tree.end

;tree "ES8R"
base ad:0xa0411120
group 0--3
line.long 0 "ES8R"
hexfld.long 0 " ES8 "
;tree.end

;tree "ES9R"
base ad:0xa0411124
group 0--3
line.long 0 "ES9R"
hexfld.long 0 " ES9 "
;tree.end

;tree "ES10R"
base ad:0xa0411128
group 0--3
line.long 0 "ES10R"
hexfld.long 0 " ES10 "
;tree.end

;tree "ES11R"
base ad:0xa041112c
group 0--3
line.long 0 "ES11R"
hexfld.long 0 " ES11 "
;tree.end

;tree "ES12R"
base ad:0xa0411130
group 0--3
line.long 0 "ES12R"
hexfld.long 0 " ES12 "
;tree.end

;tree "ES13R"
base ad:0xa0411134
group 0--3
line.long 0 "ES13R"
hexfld.long 0 " ES13 "
;tree.end

;tree "ES14R"
base ad:0xa0411138
group 0--3
line.long 0 "ES14R"
hexfld.long 0 " ES14 "
;tree.end

;tree "ES15R"
base ad:0xa041113c
group 0--3
line.long 0 "ES15R"
hexfld.long 0 " ES15 "
;tree.end

;tree "ES16R"
base ad:0xa0411140
group 0--3
line.long 0 "ES16R"
hexfld.long 0 " ES16 "
;tree.end

;tree "ES17R"
base ad:0xa0411144
group 0--3
line.long 0 "ES17R"
hexfld.long 0 " ES17 "
;tree.end

;tree "ES18R"
base ad:0xa0411148
group 0--3
line.long 0 "ES18R"
hexfld.long 0 " ES18 "
;tree.end

;tree "ES19R"
base ad:0xa041114c
group 0--3
line.long 0 "ES19R"
hexfld.long 0 " ES19 "
;tree.end

;tree "ES20R"
base ad:0xa0411150
group 0--3
line.long 0 "ES20R"
hexfld.long 0 " ES20 "
;tree.end

;tree "ES21R"
base ad:0xa0411154
group 0--3
line.long 0 "ES21R"
hexfld.long 0 " ES21 "
;tree.end

;tree "ES22R"
base ad:0xa0411158
group 0--3
line.long 0 "ES22R"
hexfld.long 0 " ES22 "
;tree.end

;tree "ES23R"
base ad:0xa041115c
group 0--3
line.long 0 "ES23R"
hexfld.long 0 " ES23 "
;tree.end

;tree "ES24R"
base ad:0xa0411160
group 0--3
line.long 0 "ES24R"
hexfld.long 0 " ES24 "
;tree.end

;tree "ES25R"
base ad:0xa0411164
group 0--3
line.long 0 "ES25R"
hexfld.long 0 " ES25 "
;tree.end

;tree "ES26R"
base ad:0xa0411168
group 0--3
line.long 0 "ES26R"
hexfld.long 0 " ES26 "
;tree.end

;tree "ES27R"
base ad:0xa041116c
group 0--3
line.long 0 "ES27R"
hexfld.long 0 " ES27 "
;tree.end

;tree "ES28R"
base ad:0xa0411170
group 0--3
line.long 0 "ES28R"
hexfld.long 0 " ES28 "
;tree.end

;tree "ES29R"
base ad:0xa0411174
group 0--3
line.long 0 "ES29R"
hexfld.long 0 " ES29 "
;tree.end

;tree "ES30R"
base ad:0xa0411178
group 0--3
line.long 0 "ES30R"
hexfld.long 0 " ES30 "
;tree.end

;tree "ES31R"
base ad:0xa041117c
group 0--3
line.long 0 "ES31R"
hexfld.long 0 " ES31 "
;tree.end

;tree "EC0R"
base ad:0xa0411180
group 0--3
line.long 0 "EC0R"
hexfld.long 0 " EC0 "
;tree.end

;tree "EC1R"
base ad:0xa0411184
group 0--3
line.long 0 "EC1R"
hexfld.long 0 " EC1 "
;tree.end

;tree "EC2R"
base ad:0xa0411188
group 0--3
line.long 0 "EC2R"
hexfld.long 0 " EC2 "
;tree.end

;tree "EC3R"
base ad:0xa041118c
group 0--3
line.long 0 "EC3R"
hexfld.long 0 " EC3 "
;tree.end

;tree "EC4R"
base ad:0xa0411190
group 0--3
line.long 0 "EC4R"
hexfld.long 0 " EC4 "
;tree.end

;tree "EC5R"
base ad:0xa0411194
group 0--3
line.long 0 "EC5R"
hexfld.long 0 " EC5 "
;tree.end

;tree "EC6R"
base ad:0xa0411198
group 0--3
line.long 0 "EC6R"
hexfld.long 0 " EC6 "
;tree.end

;tree "EC7R"
base ad:0xa041119c
group 0--3
line.long 0 "EC7R"
hexfld.long 0 " EC7 "
;tree.end

;tree "EC8R"
base ad:0xa04111a0
group 0--3
line.long 0 "EC8R"
hexfld.long 0 " EC8 "
;tree.end

;tree "EC9R"
base ad:0xa04111a4
group 0--3
line.long 0 "EC9R"
hexfld.long 0 " EC9 "
;tree.end

;tree "EC10R"
base ad:0xa04111a8
group 0--3
line.long 0 "EC10R"
hexfld.long 0 " EC10 "
;tree.end

;tree "EC11R"
base ad:0xa04111ac
group 0--3
line.long 0 "EC11R"
hexfld.long 0 " EC11 "
;tree.end

;tree "EC12R"
base ad:0xa04111b0
group 0--3
line.long 0 "EC12R"
hexfld.long 0 " EC12 "
;tree.end

;tree "EC13R"
base ad:0xa04111b4
group 0--3
line.long 0 "EC13R"
hexfld.long 0 " EC13 "
;tree.end

;tree "EC14R"
base ad:0xa04111b8
group 0--3
line.long 0 "EC14R"
hexfld.long 0 " EC14 "
;tree.end

;tree "EC15R"
base ad:0xa04111bc
group 0--3
line.long 0 "EC15R"
hexfld.long 0 " EC15 "
;tree.end

;tree "EC16R"
base ad:0xa04111c0
group 0--3
line.long 0 "EC16R"
hexfld.long 0 " EC16 "
;tree.end

;tree "EC17R"
base ad:0xa04111c4
group 0--3
line.long 0 "EC17R"
hexfld.long 0 " EC17 "
;tree.end

;tree "EC18R"
base ad:0xa04111c8
group 0--3
line.long 0 "EC18R"
hexfld.long 0 " EC18 "
;tree.end

;tree "EC19R"
base ad:0xa04111cc
group 0--3
line.long 0 "EC19R"
hexfld.long 0 " EC19 "
;tree.end

;tree "EC20R"
base ad:0xa04111d0
group 0--3
line.long 0 "EC20R"
hexfld.long 0 " EC20 "
;tree.end

;tree "EC21R"
base ad:0xa04111d4
group 0--3
line.long 0 "EC21R"
hexfld.long 0 " EC21 "
;tree.end

;tree "EC22R"
base ad:0xa04111d8
group 0--3
line.long 0 "EC22R"
hexfld.long 0 " EC22 "
;tree.end

;tree "EC23R"
base ad:0xa04111dc
group 0--3
line.long 0 "EC23R"
hexfld.long 0 " EC23 "
;tree.end

;tree "EC24R"
base ad:0xa04111e0
group 0--3
line.long 0 "EC24R"
hexfld.long 0 " EC24 "
;tree.end

;tree "EC25R"
base ad:0xa04111e4
group 0--3
line.long 0 "EC25R"
hexfld.long 0 " EC25 "
;tree.end

;tree "EC26R"
base ad:0xa04111e8
group 0--3
line.long 0 "EC26R"
hexfld.long 0 " EC26 "
;tree.end

;tree "EC27R"
base ad:0xa04111ec
group 0--3
line.long 0 "EC27R"
hexfld.long 0 " EC27 "
;tree.end

;tree "EC28R"
base ad:0xa04111f0
group 0--3
line.long 0 "EC28R"
hexfld.long 0 " EC28 "
;tree.end

;tree "EC29R"
base ad:0xa04111f4
group 0--3
line.long 0 "EC29R"
hexfld.long 0 " EC29 "
;tree.end

;tree "EC30R"
base ad:0xa04111f8
group 0--3
line.long 0 "EC30R"
hexfld.long 0 " EC30 "
;tree.end

;tree "EC31R"
base ad:0xa04111fc
group 0--3
line.long 0 "EC31R"
hexfld.long 0 " EC31 "
;tree.end

;tree "PS0R"
base ad:0xa0411200
group 0--3
line.long 0 "PS0R"
hexfld.long 0 " PS0 "
;tree.end

;tree "PS1R"
base ad:0xa0411204
group 0--3
line.long 0 "PS1R"
hexfld.long 0 " PS1 "
;tree.end

;tree "PS2R"
base ad:0xa0411208
group 0--3
line.long 0 "PS2R"
hexfld.long 0 " PS2 "
;tree.end

;tree "PS3R"
base ad:0xa041120c
group 0--3
line.long 0 "PS3R"
hexfld.long 0 " PS3 "
;tree.end

;tree "PS4R"
base ad:0xa0411210
group 0--3
line.long 0 "PS4R"
hexfld.long 0 " PS4 "
;tree.end

;tree "PS5R"
base ad:0xa0411214
group 0--3
line.long 0 "PS5R"
hexfld.long 0 " PS5 "
;tree.end

;tree "PS6R"
base ad:0xa0411218
group 0--3
line.long 0 "PS6R"
hexfld.long 0 " PS6 "
;tree.end

;tree "PS7R"
base ad:0xa041121c
group 0--3
line.long 0 "PS7R"
hexfld.long 0 " PS7 "
;tree.end

;tree "PS8R"
base ad:0xa0411220
group 0--3
line.long 0 "PS8R"
hexfld.long 0 " PS8 "
;tree.end

;tree "PS9R"
base ad:0xa0411224
group 0--3
line.long 0 "PS9R"
hexfld.long 0 " PS9 "
;tree.end

;tree "PS10R"
base ad:0xa0411228
group 0--3
line.long 0 "PS10R"
hexfld.long 0 " PS10 "
;tree.end

;tree "PS11R"
base ad:0xa041122c
group 0--3
line.long 0 "PS11R"
hexfld.long 0 " PS11 "
;tree.end

;tree "PS12R"
base ad:0xa0411230
group 0--3
line.long 0 "PS12R"
hexfld.long 0 " PS12 "
;tree.end

;tree "PS13R"
base ad:0xa0411234
group 0--3
line.long 0 "PS13R"
hexfld.long 0 " PS13 "
;tree.end

;tree "PS14R"
base ad:0xa0411238
group 0--3
line.long 0 "PS14R"
hexfld.long 0 " PS14 "
;tree.end

;tree "PS15R"
base ad:0xa041123c
group 0--3
line.long 0 "PS15R"
hexfld.long 0 " PS15 "
;tree.end

;tree "PS16R"
base ad:0xa0411240
group 0--3
line.long 0 "PS16R"
hexfld.long 0 " PS16 "
;tree.end

;tree "PS17R"
base ad:0xa0411244
group 0--3
line.long 0 "PS17R"
hexfld.long 0 " PS17 "
;tree.end

;tree "PS18R"
base ad:0xa0411248
group 0--3
line.long 0 "PS18R"
hexfld.long 0 " PS18 "
;tree.end

;tree "PS19R"
base ad:0xa041124c
group 0--3
line.long 0 "PS19R"
hexfld.long 0 " PS19 "
;tree.end

;tree "PS20R"
base ad:0xa0411250
group 0--3
line.long 0 "PS20R"
hexfld.long 0 " PS20 "
;tree.end

;tree "PS21R"
base ad:0xa0411254
group 0--3
line.long 0 "PS21R"
hexfld.long 0 " PS21 "
;tree.end

;tree "PS22R"
base ad:0xa0411258
group 0--3
line.long 0 "PS22R"
hexfld.long 0 " PS22 "
;tree.end

;tree "PS23R"
base ad:0xa041125c
group 0--3
line.long 0 "PS23R"
hexfld.long 0 " PS23 "
;tree.end

;tree "PS24R"
base ad:0xa0411260
group 0--3
line.long 0 "PS24R"
hexfld.long 0 " PS24 "
;tree.end

;tree "PS25R"
base ad:0xa0411264
group 0--3
line.long 0 "PS25R"
hexfld.long 0 " PS25 "
;tree.end

;tree "PS26R"
base ad:0xa0411268
group 0--3
line.long 0 "PS26R"
hexfld.long 0 " PS26 "
;tree.end

;tree "PS27R"
base ad:0xa041126c
group 0--3
line.long 0 "PS27R"
hexfld.long 0 " PS27 "
;tree.end

;tree "PS28R"
base ad:0xa0411270
group 0--3
line.long 0 "PS28R"
hexfld.long 0 " PS28 "
;tree.end

;tree "PS29R"
base ad:0xa0411274
group 0--3
line.long 0 "PS29R"
hexfld.long 0 " PS29 "
;tree.end

;tree "PS30R"
base ad:0xa0411278
group 0--3
line.long 0 "PS30R"
hexfld.long 0 " PS30 "
;tree.end

;tree "PS31R"
base ad:0xa041127c
group 0--3
line.long 0 "PS31R"
hexfld.long 0 " PS31 "
;tree.end

;tree "PC0R"
base ad:0xa0411280
group 0--3
line.long 0 "PC0R"
hexfld.long 0 " PC0 "
;tree.end

;tree "PC1R"
base ad:0xa0411284
group 0--3
line.long 0 "PC1R"
hexfld.long 0 " PC1 "
;tree.end

;tree "PC2R"
base ad:0xa0411288
group 0--3
line.long 0 "PC2R"
hexfld.long 0 " PC2 "
;tree.end

;tree "PC3R"
base ad:0xa041128c
group 0--3
line.long 0 "PC3R"
hexfld.long 0 " PC3 "
;tree.end

;tree "PC4R"
base ad:0xa0411290
group 0--3
line.long 0 "PC4R"
hexfld.long 0 " PC4 "
;tree.end

;tree "PC5R"
base ad:0xa0411294
group 0--3
line.long 0 "PC5R"
hexfld.long 0 " PC5 "
;tree.end

;tree "PC6R"
base ad:0xa0411298
group 0--3
line.long 0 "PC6R"
hexfld.long 0 " PC6 "
;tree.end

;tree "PC7R"
base ad:0xa041129c
group 0--3
line.long 0 "PC7R"
hexfld.long 0 " PC7 "
;tree.end

;tree "PC8R"
base ad:0xa04112a0
group 0--3
line.long 0 "PC8R"
hexfld.long 0 " PC8 "
;tree.end

;tree "PC9R"
base ad:0xa04112a4
group 0--3
line.long 0 "PC9R"
hexfld.long 0 " PC9 "
;tree.end

;tree "PC10R"
base ad:0xa04112a8
group 0--3
line.long 0 "PC10R"
hexfld.long 0 " PC10 "
;tree.end

;tree "PC11R"
base ad:0xa04112ac
group 0--3
line.long 0 "PC11R"
hexfld.long 0 " PC11 "
;tree.end

;tree "PC12R"
base ad:0xa04112b0
group 0--3
line.long 0 "PC12R"
hexfld.long 0 " PC12 "
;tree.end

;tree "PC13R"
base ad:0xa04112b4
group 0--3
line.long 0 "PC13R"
hexfld.long 0 " PC13 "
;tree.end

;tree "PC14R"
base ad:0xa04112b8
group 0--3
line.long 0 "PC14R"
hexfld.long 0 " PC14 "
;tree.end

;tree "PC15R"
base ad:0xa04112bc
group 0--3
line.long 0 "PC15R"
hexfld.long 0 " PC15 "
;tree.end

;tree "PC16R"
base ad:0xa04112c0
group 0--3
line.long 0 "PC16R"
hexfld.long 0 " PC16 "
;tree.end

;tree "PC17R"
base ad:0xa04112c4
group 0--3
line.long 0 "PC17R"
hexfld.long 0 " PC17 "
;tree.end

;tree "PC18R"
base ad:0xa04112c8
group 0--3
line.long 0 "PC18R"
hexfld.long 0 " PC18 "
;tree.end

;tree "PC19R"
base ad:0xa04112cc
group 0--3
line.long 0 "PC19R"
hexfld.long 0 " PC19 "
;tree.end

;tree "PC20R"
base ad:0xa04112d0
group 0--3
line.long 0 "PC20R"
hexfld.long 0 " PC20 "
;tree.end

;tree "PC21R"
base ad:0xa04112d4
group 0--3
line.long 0 "PC21R"
hexfld.long 0 " PC21 "
;tree.end

;tree "PC22R"
base ad:0xa04112d8
group 0--3
line.long 0 "PC22R"
hexfld.long 0 " PC22 "
;tree.end

;tree "PC23R"
base ad:0xa04112dc
group 0--3
line.long 0 "PC23R"
hexfld.long 0 " PC23 "
;tree.end

;tree "PC24R"
base ad:0xa04112e0
group 0--3
line.long 0 "PC24R"
hexfld.long 0 " PC24 "
;tree.end

;tree "PC25R"
base ad:0xa04112e4
group 0--3
line.long 0 "PC25R"
hexfld.long 0 " PC25 "
;tree.end

;tree "PC26R"
base ad:0xa04112e8
group 0--3
line.long 0 "PC26R"
hexfld.long 0 " PC26 "
;tree.end

;tree "PC27R"
base ad:0xa04112ec
group 0--3
line.long 0 "PC27R"
hexfld.long 0 " PC27 "
;tree.end

;tree "PC28R"
base ad:0xa04112f0
group 0--3
line.long 0 "PC28R"
hexfld.long 0 " PC28 "
;tree.end

;tree "PC29R"
base ad:0xa04112f4
group 0--3
line.long 0 "PC29R"
hexfld.long 0 " PC29 "
;tree.end

;tree "PC30R"
base ad:0xa04112f8
group 0--3
line.long 0 "PC30R"
hexfld.long 0 " PC30 "
;tree.end

;tree "PC31R"
base ad:0xa04112fc
group 0--3
line.long 0 "PC31R"
hexfld.long 0 " PC31 "
;tree.end

;tree "AS0R"
base ad:0xa0411300
rgroup 0--3
line.long 0 "AS0R"
hexfld.long 0 " AS0 "
;tree.end

;tree "AS1R"
base ad:0xa0411304
rgroup 0--3
line.long 0 "AS1R"
hexfld.long 0 " AS1 "
;tree.end

;tree "AS2R"
base ad:0xa0411308
rgroup 0--3
line.long 0 "AS2R"
hexfld.long 0 " AS2 "
;tree.end

;tree "AS3R"
base ad:0xa041130c
rgroup 0--3
line.long 0 "AS3R"
hexfld.long 0 " AS3 "
;tree.end

;tree "AS4R"
base ad:0xa0411310
rgroup 0--3
line.long 0 "AS4R"
hexfld.long 0 " AS4 "
;tree.end

;tree "AS5R"
base ad:0xa0411314
rgroup 0--3
line.long 0 "AS5R"
hexfld.long 0 " AS5 "
;tree.end

;tree "AS6R"
base ad:0xa0411318
rgroup 0--3
line.long 0 "AS6R"
hexfld.long 0 " AS6 "
;tree.end

;tree "AS7R"
base ad:0xa041131c
rgroup 0--3
line.long 0 "AS7R"
hexfld.long 0 " AS7 "
;tree.end

;tree "AS8R"
base ad:0xa0411320
rgroup 0--3
line.long 0 "AS8R"
hexfld.long 0 " AS8 "
;tree.end

;tree "AS9R"
base ad:0xa0411324
rgroup 0--3
line.long 0 "AS9R"
hexfld.long 0 " AS9 "
;tree.end

;tree "AS10R"
base ad:0xa0411328
rgroup 0--3
line.long 0 "AS10R"
hexfld.long 0 " AS10 "
;tree.end

;tree "AS11R"
base ad:0xa041132c
rgroup 0--3
line.long 0 "AS11R"
hexfld.long 0 " AS11 "
;tree.end

;tree "AS12R"
base ad:0xa0411330
rgroup 0--3
line.long 0 "AS12R"
hexfld.long 0 " AS12 "
;tree.end

;tree "AS13R"
base ad:0xa0411334
rgroup 0--3
line.long 0 "AS13R"
hexfld.long 0 " AS13 "
;tree.end

;tree "AS14R"
base ad:0xa0411338
rgroup 0--3
line.long 0 "AS14R"
hexfld.long 0 " AS14 "
;tree.end

;tree "AS15R"
base ad:0xa041133c
rgroup 0--3
line.long 0 "AS15R"
hexfld.long 0 " AS15 "
;tree.end

;tree "AS16R"
base ad:0xa0411340
rgroup 0--3
line.long 0 "AS16R"
hexfld.long 0 " AS16 "
;tree.end

;tree "AS17R"
base ad:0xa0411344
rgroup 0--3
line.long 0 "AS17R"
hexfld.long 0 " AS17 "
;tree.end

;tree "AS18R"
base ad:0xa0411348
rgroup 0--3
line.long 0 "AS18R"
hexfld.long 0 " AS18 "
;tree.end

;tree "AS19R"
base ad:0xa041134c
rgroup 0--3
line.long 0 "AS19R"
hexfld.long 0 " AS19 "
;tree.end

;tree "AS20R"
base ad:0xa0411350
rgroup 0--3
line.long 0 "AS20R"
hexfld.long 0 " AS20 "
;tree.end

;tree "AS21R"
base ad:0xa0411354
rgroup 0--3
line.long 0 "AS21R"
hexfld.long 0 " AS21 "
;tree.end

;tree "AS22R"
base ad:0xa0411358
rgroup 0--3
line.long 0 "AS22R"
hexfld.long 0 " AS22 "
;tree.end

;tree "AS23R"
base ad:0xa041135c
rgroup 0--3
line.long 0 "AS23R"
hexfld.long 0 " AS23 "
;tree.end

;tree "AS24R"
base ad:0xa0411360
rgroup 0--3
line.long 0 "AS24R"
hexfld.long 0 " AS24 "
;tree.end

;tree "AS25R"
base ad:0xa0411364
rgroup 0--3
line.long 0 "AS25R"
hexfld.long 0 " AS25 "
;tree.end

;tree "AS26R"
base ad:0xa0411368
rgroup 0--3
line.long 0 "AS26R"
hexfld.long 0 " AS26 "
;tree.end

;tree "AS27R"
base ad:0xa041136c
rgroup 0--3
line.long 0 "AS27R"
hexfld.long 0 " AS27 "
;tree.end

;tree "AS28R"
base ad:0xa0411370
rgroup 0--3
line.long 0 "AS28R"
hexfld.long 0 " AS28 "
;tree.end

;tree "AS29R"
base ad:0xa0411374
rgroup 0--3
line.long 0 "AS29R"
hexfld.long 0 " AS29 "
;tree.end

;tree "AS30R"
base ad:0xa0411378
rgroup 0--3
line.long 0 "AS30R"
hexfld.long 0 " AS30 "
;tree.end

;tree "AS31R"
base ad:0xa041137c
rgroup 0--3
line.long 0 "AS31R"
hexfld.long 0 " AS31 "
;tree.end

;tree "PL0R"
base ad:0xa0411400
group 0--3
line.long 0 "PL0R"
bitfld.long 0 3.--7. " PL0IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL0IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL0IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL0IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL1R"
base ad:0xa0411404
group 0--3
line.long 0 "PL1R"
bitfld.long 0 3.--7. " PL1IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL1IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL1IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL1IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL2R"
base ad:0xa0411408
group 0--3
line.long 0 "PL2R"
bitfld.long 0 3.--7. " PL2IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL2IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL2IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL2IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL3R"
base ad:0xa041140c
group 0--3
line.long 0 "PL3R"
bitfld.long 0 3.--7. " PL3IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL3IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL3IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL3IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL4R"
base ad:0xa0411410
group 0--3
line.long 0 "PL4R"
bitfld.long 0 3.--7. " PL4IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL4IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL4IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL4IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL5R"
base ad:0xa0411414
group 0--3
line.long 0 "PL5R"
bitfld.long 0 3.--7. " PL5IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL5IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL5IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL5IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL6R"
base ad:0xa0411418
group 0--3
line.long 0 "PL6R"
bitfld.long 0 3.--7. " PL6IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL6IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL6IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL6IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL7R"
base ad:0xa041141c
group 0--3
line.long 0 "PL7R"
bitfld.long 0 3.--7. " PL7IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL7IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL7IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL7IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL8R"
base ad:0xa0411420
group 0--3
line.long 0 "PL8R"
bitfld.long 0 3.--7. " PL8IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL8IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL8IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL8IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL9R"
base ad:0xa0411424
group 0--3
line.long 0 "PL9R"
bitfld.long 0 3.--7. " PL9IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL9IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL9IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL9IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL10R"
base ad:0xa0411428
group 0--3
line.long 0 "PL10R"
bitfld.long 0 3.--7. " PL10IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL10IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL10IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL10IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL11R"
base ad:0xa041142c
group 0--3
line.long 0 "PL11R"
bitfld.long 0 3.--7. " PL11IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL11IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL11IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL11IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL12R"
base ad:0xa0411430
group 0--3
line.long 0 "PL12R"
bitfld.long 0 3.--7. " PL12IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL12IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL12IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL12IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL13R"
base ad:0xa0411434
group 0--3
line.long 0 "PL13R"
bitfld.long 0 3.--7. " PL13IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL13IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL13IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL13IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL14R"
base ad:0xa0411438
group 0--3
line.long 0 "PL14R"
bitfld.long 0 3.--7. " PL14IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL14IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL14IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL14IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL15R"
base ad:0xa041143c
group 0--3
line.long 0 "PL15R"
bitfld.long 0 3.--7. " PL15IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL15IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL15IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL15IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL16R"
base ad:0xa0411440
group 0--3
line.long 0 "PL16R"
bitfld.long 0 3.--7. " PL16IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL16IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL16IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL16IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL17R"
base ad:0xa0411444
group 0--3
line.long 0 "PL17R"
bitfld.long 0 3.--7. " PL17IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL17IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL17IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL17IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL18R"
base ad:0xa0411448
group 0--3
line.long 0 "PL18R"
bitfld.long 0 3.--7. " PL18IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL18IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL18IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL18IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL19R"
base ad:0xa041144c
group 0--3
line.long 0 "PL19R"
bitfld.long 0 3.--7. " PL19IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL19IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL19IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL19IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL20R"
base ad:0xa0411450
group 0--3
line.long 0 "PL20R"
bitfld.long 0 3.--7. " PL20IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL20IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL20IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL20IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL21R"
base ad:0xa0411454
group 0--3
line.long 0 "PL21R"
bitfld.long 0 3.--7. " PL21IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL21IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL21IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL21IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL22R"
base ad:0xa0411458
group 0--3
line.long 0 "PL22R"
bitfld.long 0 3.--7. " PL22IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL22IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL22IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL22IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL23R"
base ad:0xa041145c
group 0--3
line.long 0 "PL23R"
bitfld.long 0 3.--7. " PL23IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL23IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL23IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL23IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL24R"
base ad:0xa0411460
group 0--3
line.long 0 "PL24R"
bitfld.long 0 3.--7. " PL24IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL24IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL24IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL24IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL25R"
base ad:0xa0411464
group 0--3
line.long 0 "PL25R"
bitfld.long 0 3.--7. " PL25IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL25IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL25IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL25IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL26R"
base ad:0xa0411468
group 0--3
line.long 0 "PL26R"
bitfld.long 0 3.--7. " PL26IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL26IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL26IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL26IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL27R"
base ad:0xa041146c
group 0--3
line.long 0 "PL27R"
bitfld.long 0 3.--7. " PL27IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL27IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL27IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL27IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL28R"
base ad:0xa0411470
group 0--3
line.long 0 "PL28R"
bitfld.long 0 3.--7. " PL28IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL28IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL28IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL28IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL29R"
base ad:0xa0411474
group 0--3
line.long 0 "PL29R"
bitfld.long 0 3.--7. " PL29IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL29IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL29IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL29IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL30R"
base ad:0xa0411478
group 0--3
line.long 0 "PL30R"
bitfld.long 0 3.--7. " PL30IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL30IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL30IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL30IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PL31R"
base ad:0xa041147c
group 0--3
line.long 0 "PL31R"
bitfld.long 0 3.--7. " PL31IDNP0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " PL31IDNP1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19.--23. " PL31IDNP2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 27.--31. " PL31IDNP3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPIT0R"
base ad:0xa0411800
group 0--3
line.long 0 "SPIT0R"
hexfld.byte 0 " SPIT0INTIDNP0 "
hexfld.byte 1 " SPIT0INTIDNP1 "
hexfld.byte 2 " SPIT0INTIDNP2 "
hexfld.byte 3 " SPIT0INTIDNP3 "
;tree.end

;tree "SPIT1R"
base ad:0xa0411804
group 0--3
line.long 0 "SPIT1R"
hexfld.byte 0 " SPIT1INTIDNP0 "
hexfld.byte 1 " SPIT1INTIDNP1 "
hexfld.byte 2 " SPIT1INTIDNP2 "
hexfld.byte 3 " SPIT1INTIDNP3 "
;tree.end

;tree "SPIT2R"
base ad:0xa0411808
group 0--3
line.long 0 "SPIT2R"
hexfld.byte 0 " SPIT2INTIDNP0 "
hexfld.byte 1 " SPIT2INTIDNP1 "
hexfld.byte 2 " SPIT2INTIDNP2 "
hexfld.byte 3 " SPIT2INTIDNP3 "
;tree.end

;tree "SPIT3R"
base ad:0xa041180c
group 0--3
line.long 0 "SPIT3R"
hexfld.byte 0 " SPIT3INTIDNP0 "
hexfld.byte 1 " SPIT3INTIDNP1 "
hexfld.byte 2 " SPIT3INTIDNP2 "
hexfld.byte 3 " SPIT3INTIDNP3 "
;tree.end

;tree "SPIT4R"
base ad:0xa0411810
group 0--3
line.long 0 "SPIT4R"
hexfld.byte 0 " SPIT4INTIDNP0 "
hexfld.byte 1 " SPIT4INTIDNP1 "
hexfld.byte 2 " SPIT4INTIDNP2 "
hexfld.byte 3 " SPIT4INTIDNP3 "
;tree.end

;tree "SPIT5R"
base ad:0xa0411814
group 0--3
line.long 0 "SPIT5R"
hexfld.byte 0 " SPIT5INTIDNP0 "
hexfld.byte 1 " SPIT5INTIDNP1 "
hexfld.byte 2 " SPIT5INTIDNP2 "
hexfld.byte 3 " SPIT5INTIDNP3 "
;tree.end

;tree "SPIT6R"
base ad:0xa0411818
group 0--3
line.long 0 "SPIT6R"
hexfld.byte 0 " SPIT6INTIDNP0 "
hexfld.byte 1 " SPIT6INTIDNP1 "
hexfld.byte 2 " SPIT6INTIDNP2 "
hexfld.byte 3 " SPIT6INTIDNP3 "
;tree.end

;tree "SPIT7R"
base ad:0xa041181c
group 0--3
line.long 0 "SPIT7R"
hexfld.byte 0 " SPIT7INTIDNP0 "
hexfld.byte 1 " SPIT7INTIDNP1 "
hexfld.byte 2 " SPIT7INTIDNP2 "
hexfld.byte 3 " SPIT7INTIDNP3 "
;tree.end

;tree "SPIT8R"
base ad:0xa0411820
group 0--3
line.long 0 "SPIT8R"
hexfld.byte 0 " SPIT8INTIDNP0 "
hexfld.byte 1 " SPIT8INTIDNP1 "
hexfld.byte 2 " SPIT8INTIDNP2 "
hexfld.byte 3 " SPIT8INTIDNP3 "
;tree.end

;tree "SPIT9R"
base ad:0xa0411824
group 0--3
line.long 0 "SPIT9R"
hexfld.byte 0 " SPIT9INTIDNP0 "
hexfld.byte 1 " SPIT9INTIDNP1 "
hexfld.byte 2 " SPIT9INTIDNP2 "
hexfld.byte 3 " SPIT9INTIDNP3 "
;tree.end

;tree "SPIT10R"
base ad:0xa0411828
group 0--3
line.long 0 "SPIT10R"
hexfld.byte 0 " SPIT10INTIDNP0 "
hexfld.byte 1 " SPIT10INTIDNP1 "
hexfld.byte 2 " SPIT10INTIDNP2 "
hexfld.byte 3 " SPIT10INTIDNP3 "
;tree.end

;tree "SPIT11R"
base ad:0xa041182c
group 0--3
line.long 0 "SPIT11R"
hexfld.byte 0 " SPIT11INTIDNP0 "
hexfld.byte 1 " SPIT11INTIDNP1 "
hexfld.byte 2 " SPIT11INTIDNP2 "
hexfld.byte 3 " SPIT11INTIDNP3 "
;tree.end

;tree "SPIT12R"
base ad:0xa0411830
group 0--3
line.long 0 "SPIT12R"
hexfld.byte 0 " SPIT12INTIDNP0 "
hexfld.byte 1 " SPIT12INTIDNP1 "
hexfld.byte 2 " SPIT12INTIDNP2 "
hexfld.byte 3 " SPIT12INTIDNP3 "
;tree.end

;tree "SPIT13R"
base ad:0xa0411834
group 0--3
line.long 0 "SPIT13R"
hexfld.byte 0 " SPIT13INTIDNP0 "
hexfld.byte 1 " SPIT13INTIDNP1 "
hexfld.byte 2 " SPIT13INTIDNP2 "
hexfld.byte 3 " SPIT13INTIDNP3 "
;tree.end

;tree "SPIT14R"
base ad:0xa0411838
group 0--3
line.long 0 "SPIT14R"
hexfld.byte 0 " SPIT14INTIDNP0 "
hexfld.byte 1 " SPIT14INTIDNP1 "
hexfld.byte 2 " SPIT14INTIDNP2 "
hexfld.byte 3 " SPIT14INTIDNP3 "
;tree.end

;tree "SPIT15R"
base ad:0xa041183c
group 0--3
line.long 0 "SPIT15R"
hexfld.byte 0 " SPIT15INTIDNP0 "
hexfld.byte 1 " SPIT15INTIDNP1 "
hexfld.byte 2 " SPIT15INTIDNP2 "
hexfld.byte 3 " SPIT15INTIDNP3 "
;tree.end

;tree "SPIT16R"
base ad:0xa0411840
group 0--3
line.long 0 "SPIT16R"
hexfld.byte 0 " SPIT16INTIDNP0 "
hexfld.byte 1 " SPIT16INTIDNP1 "
hexfld.byte 2 " SPIT16INTIDNP2 "
hexfld.byte 3 " SPIT16INTIDNP3 "
;tree.end

;tree "SPIT17R"
base ad:0xa0411844
group 0--3
line.long 0 "SPIT17R"
hexfld.byte 0 " SPIT17INTIDNP0 "
hexfld.byte 1 " SPIT17INTIDNP1 "
hexfld.byte 2 " SPIT17INTIDNP2 "
hexfld.byte 3 " SPIT17INTIDNP3 "
;tree.end

;tree "SPIT18R"
base ad:0xa0411848
group 0--3
line.long 0 "SPIT18R"
hexfld.byte 0 " SPIT18INTIDNP0 "
hexfld.byte 1 " SPIT18INTIDNP1 "
hexfld.byte 2 " SPIT18INTIDNP2 "
hexfld.byte 3 " SPIT18INTIDNP3 "
;tree.end

;tree "SPIT19R"
base ad:0xa041184c
group 0--3
line.long 0 "SPIT19R"
hexfld.byte 0 " SPIT19INTIDNP0 "
hexfld.byte 1 " SPIT19INTIDNP1 "
hexfld.byte 2 " SPIT19INTIDNP2 "
hexfld.byte 3 " SPIT19INTIDNP3 "
;tree.end

;tree "SPIT20R"
base ad:0xa0411850
group 0--3
line.long 0 "SPIT20R"
hexfld.byte 0 " SPIT20INTIDNP0 "
hexfld.byte 1 " SPIT20INTIDNP1 "
hexfld.byte 2 " SPIT20INTIDNP2 "
hexfld.byte 3 " SPIT20INTIDNP3 "
;tree.end

;tree "SPIT21R"
base ad:0xa0411854
group 0--3
line.long 0 "SPIT21R"
hexfld.byte 0 " SPIT21INTIDNP0 "
hexfld.byte 1 " SPIT21INTIDNP1 "
hexfld.byte 2 " SPIT21INTIDNP2 "
hexfld.byte 3 " SPIT21INTIDNP3 "
;tree.end

;tree "SPIT22R"
base ad:0xa0411858
group 0--3
line.long 0 "SPIT22R"
hexfld.byte 0 " SPIT22INTIDNP0 "
hexfld.byte 1 " SPIT22INTIDNP1 "
hexfld.byte 2 " SPIT22INTIDNP2 "
hexfld.byte 3 " SPIT22INTIDNP3 "
;tree.end

;tree "SPIT23R"
base ad:0xa041185c
group 0--3
line.long 0 "SPIT23R"
hexfld.byte 0 " SPIT23INTIDNP0 "
hexfld.byte 1 " SPIT23INTIDNP1 "
hexfld.byte 2 " SPIT23INTIDNP2 "
hexfld.byte 3 " SPIT23INTIDNP3 "
;tree.end

;tree "SPIT24R"
base ad:0xa0411860
group 0--3
line.long 0 "SPIT24R"
hexfld.byte 0 " SPIT24INTIDNP0 "
hexfld.byte 1 " SPIT24INTIDNP1 "
hexfld.byte 2 " SPIT24INTIDNP2 "
hexfld.byte 3 " SPIT24INTIDNP3 "
;tree.end

;tree "SPIT25R"
base ad:0xa0411864
group 0--3
line.long 0 "SPIT25R"
hexfld.byte 0 " SPIT25INTIDNP0 "
hexfld.byte 1 " SPIT25INTIDNP1 "
hexfld.byte 2 " SPIT25INTIDNP2 "
hexfld.byte 3 " SPIT25INTIDNP3 "
;tree.end

;tree "SPIT26R"
base ad:0xa0411868
group 0--3
line.long 0 "SPIT26R"
hexfld.byte 0 " SPIT26INTIDNP0 "
hexfld.byte 1 " SPIT26INTIDNP1 "
hexfld.byte 2 " SPIT26INTIDNP2 "
hexfld.byte 3 " SPIT26INTIDNP3 "
;tree.end

;tree "SPIT27R"
base ad:0xa041186c
group 0--3
line.long 0 "SPIT27R"
hexfld.byte 0 " SPIT27INTIDNP0 "
hexfld.byte 1 " SPIT27INTIDNP1 "
hexfld.byte 2 " SPIT27INTIDNP2 "
hexfld.byte 3 " SPIT27INTIDNP3 "
;tree.end

;tree "SPIT28R"
base ad:0xa0411870
group 0--3
line.long 0 "SPIT28R"
hexfld.byte 0 " SPIT28INTIDNP0 "
hexfld.byte 1 " SPIT28INTIDNP1 "
hexfld.byte 2 " SPIT28INTIDNP2 "
hexfld.byte 3 " SPIT28INTIDNP3 "
;tree.end

;tree "SPIT29R"
base ad:0xa0411874
group 0--3
line.long 0 "SPIT29R"
hexfld.byte 0 " SPIT29INTIDNP0 "
hexfld.byte 1 " SPIT29INTIDNP1 "
hexfld.byte 2 " SPIT29INTIDNP2 "
hexfld.byte 3 " SPIT29INTIDNP3 "
;tree.end

;tree "SPIT30R"
base ad:0xa0411878
group 0--3
line.long 0 "SPIT30R"
hexfld.byte 0 " SPIT30INTIDNP0 "
hexfld.byte 1 " SPIT30INTIDNP1 "
hexfld.byte 2 " SPIT30INTIDNP2 "
hexfld.byte 3 " SPIT30INTIDNP3 "
;tree.end

;tree "SPIT31R"
base ad:0xa041187c
group 0--3
line.long 0 "SPIT31R"
hexfld.byte 0 " SPIT31INTIDNP0 "
hexfld.byte 1 " SPIT31INTIDNP1 "
hexfld.byte 2 " SPIT31INTIDNP2 "
hexfld.byte 3 " SPIT31INTIDNP3 "
;tree.end

;tree "SPIT32R"
base ad:0xa0411880
group 0--3
line.long 0 "SPIT32R"
hexfld.byte 0 " SPIT32INTIDNP0 "
hexfld.byte 1 " SPIT32INTIDNP1 "
hexfld.byte 2 " SPIT32INTIDNP2 "
hexfld.byte 3 " SPIT32INTIDNP3 "
;tree.end

;tree "SPIT33R"
base ad:0xa0411884
group 0--3
line.long 0 "SPIT33R"
hexfld.byte 0 " SPIT33INTIDNP0 "
hexfld.byte 1 " SPIT33INTIDNP1 "
hexfld.byte 2 " SPIT33INTIDNP2 "
hexfld.byte 3 " SPIT33INTIDNP3 "
;tree.end

;tree "SPIT34R"
base ad:0xa0411888
group 0--3
line.long 0 "SPIT34R"
hexfld.byte 0 " SPIT34INTIDNP0 "
hexfld.byte 1 " SPIT34INTIDNP1 "
hexfld.byte 2 " SPIT34INTIDNP2 "
hexfld.byte 3 " SPIT34INTIDNP3 "
;tree.end

;tree "SPIT35R"
base ad:0xa041188c
group 0--3
line.long 0 "SPIT35R"
hexfld.byte 0 " SPIT35INTIDNP0 "
hexfld.byte 1 " SPIT35INTIDNP1 "
hexfld.byte 2 " SPIT35INTIDNP2 "
hexfld.byte 3 " SPIT35INTIDNP3 "
;tree.end

;tree "SPIT36R"
base ad:0xa0411890
group 0--3
line.long 0 "SPIT36R"
hexfld.byte 0 " SPIT36INTIDNP0 "
hexfld.byte 1 " SPIT36INTIDNP1 "
hexfld.byte 2 " SPIT36INTIDNP2 "
hexfld.byte 3 " SPIT36INTIDNP3 "
;tree.end

;tree "SPIT37R"
base ad:0xa0411894
group 0--3
line.long 0 "SPIT37R"
hexfld.byte 0 " SPIT37INTIDNP0 "
hexfld.byte 1 " SPIT37INTIDNP1 "
hexfld.byte 2 " SPIT37INTIDNP2 "
hexfld.byte 3 " SPIT37INTIDNP3 "
;tree.end

;tree "SPIT38R"
base ad:0xa0411898
group 0--3
line.long 0 "SPIT38R"
hexfld.byte 0 " SPIT38INTIDNP0 "
hexfld.byte 1 " SPIT38INTIDNP1 "
hexfld.byte 2 " SPIT38INTIDNP2 "
hexfld.byte 3 " SPIT38INTIDNP3 "
;tree.end

;tree "SPIT39R"
base ad:0xa041189c
group 0--3
line.long 0 "SPIT39R"
hexfld.byte 0 " SPIT39INTIDNP0 "
hexfld.byte 1 " SPIT39INTIDNP1 "
hexfld.byte 2 " SPIT39INTIDNP2 "
hexfld.byte 3 " SPIT39INTIDNP3 "
;tree.end

;tree "IC0R"
base ad:0xa0411c00
group 0--3
line.long 0 "IC0R"
hexfld.long 0 " IC0 "
;tree.end

;tree "IC1R"
base ad:0xa0411c04
group 0--3
line.long 0 "IC1R"
hexfld.long 0 " IC1 "
;tree.end

;tree "IC2R"
base ad:0xa0411c08
group 0--3
line.long 0 "IC2R"
hexfld.long 0 " IC2 "
;tree.end

;tree "IC3R"
base ad:0xa0411c0c
group 0--3
line.long 0 "IC3R"
hexfld.long 0 " IC3 "
;tree.end

;tree "IC4R"
base ad:0xa0411c10
group 0--3
line.long 0 "IC4R"
hexfld.long 0 " IC4 "
;tree.end

;tree "IC5R"
base ad:0xa0411c14
group 0--3
line.long 0 "IC5R"
hexfld.long 0 " IC5 "
;tree.end

;tree "IC6R"
base ad:0xa0411c18
group 0--3
line.long 0 "IC6R"
hexfld.long 0 " IC6 "
;tree.end

;tree "IC7R"
base ad:0xa0411c1c
group 0--3
line.long 0 "IC7R"
hexfld.long 0 " IC7 "
;tree.end

;tree "IC8R"
base ad:0xa0411c20
group 0--3
line.long 0 "IC8R"
hexfld.long 0 " IC8 "
;tree.end

;tree "IC9R"
base ad:0xa0411c24
group 0--3
line.long 0 "IC9R"
hexfld.long 0 " IC9 "
;tree.end

;tree "PPISR"
base ad:0xa0411d00
rgroup 0--3
line.long 0 "PPISR"
bitfld.long 0 12.--15. " PPISS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "SPIS0R"
base ad:0xa0411d04
rgroup 0--3
line.long 0 "SPIS0R"
hexfld.long 0 " SPIS0 "
;tree.end

;tree "SPIS1R"
base ad:0xa0411d08
rgroup 0--3
line.long 0 "SPIS1R"
hexfld.long 0 " SPIS1 "
;tree.end

;tree "SPIS2R"
base ad:0xa0411d0c
rgroup 0--3
line.long 0 "SPIS2R"
hexfld.long 0 " SPIS2 "
;tree.end

;tree "SPIS3R"
base ad:0xa0411d10
rgroup 0--3
line.long 0 "SPIS3R"
hexfld.long 0 " SPIS3 "
;tree.end

;tree "SPIS4R"
base ad:0xa0411d14
rgroup 0--3
line.long 0 "SPIS4R"
hexfld.long 0 " SPIS4 "
;tree.end

;tree "SPIS5R"
base ad:0xa0411d18
rgroup 0--3
line.long 0 "SPIS5R"
hexfld.long 0 " SPIS5 "
;tree.end

;tree "SPIS6R"
base ad:0xa0411d1c
rgroup 0--3
line.long 0 "SPIS6R"
hexfld.long 0 " SPIS6 "
;tree.end

;tree "SPIS7R"
base ad:0xa0411d20
rgroup 0--3
line.long 0 "SPIS7R"
hexfld.long 0 " SPIS7 "
;tree.end

;tree "SPIS8R"
base ad:0xa0411d24
rgroup 0--3
line.long 0 "SPIS8R"
hexfld.long 0 " SPIS8 "
;tree.end

;tree "SPIS9R"
base ad:0xa0411d28
rgroup 0--3
line.long 0 "SPIS9R"
hexfld.long 0 " SPIS9 "
;tree.end

;tree "SPIS10R"
base ad:0xa0411d2c
rgroup 0--3
line.long 0 "SPIS10R"
hexfld.long 0 " SPIS10 "
;tree.end

;tree "SPIS11R"
base ad:0xa0411d30
rgroup 0--3
line.long 0 "SPIS11R"
hexfld.long 0 " SPIS11 "
;tree.end

;tree "SPIS12R"
base ad:0xa0411d34
rgroup 0--3
line.long 0 "SPIS12R"
hexfld.long 0 " SPIS12 "
;tree.end

;tree "SPIS13R"
base ad:0xa0411d38
rgroup 0--3
line.long 0 "SPIS13R"
hexfld.long 0 " SPIS13 "
;tree.end

;tree "SPIS14R"
base ad:0xa0411d3c
rgroup 0--3
line.long 0 "SPIS14R"
hexfld.long 0 " SPIS14 "
;tree.end

;tree "SPIS15R"
base ad:0xa0411d40
rgroup 0--3
line.long 0 "SPIS15R"
hexfld.long 0 " SPIS15 "
;tree.end

;tree "SPIS16R"
base ad:0xa0411d44
rgroup 0--3
line.long 0 "SPIS16R"
hexfld.long 0 " SPIS16 "
;tree.end

;tree "SPIS17R"
base ad:0xa0411d48
rgroup 0--3
line.long 0 "SPIS17R"
hexfld.long 0 " SPIS17 "
;tree.end

;tree "SPIS18R"
base ad:0xa0411d4c
rgroup 0--3
line.long 0 "SPIS18R"
hexfld.long 0 " SPIS18 "
;tree.end

;tree "SPIS19R"
base ad:0xa0411d50
rgroup 0--3
line.long 0 "SPIS19R"
hexfld.long 0 " SPIS19 "
;tree.end

;tree "SPIS20R"
base ad:0xa0411d54
rgroup 0--3
line.long 0 "SPIS20R"
hexfld.long 0 " SPIS20 "
;tree.end

;tree "SPIS21R"
base ad:0xa0411d58
rgroup 0--3
line.long 0 "SPIS21R"
hexfld.long 0 " SPIS21 "
;tree.end

;tree "SPIS22R"
base ad:0xa0411d5c
rgroup 0--3
line.long 0 "SPIS22R"
hexfld.long 0 " SPIS22 "
;tree.end

;tree "SPIS23R"
base ad:0xa0411d60
rgroup 0--3
line.long 0 "SPIS23R"
hexfld.long 0 " SPIS23 "
;tree.end

;tree "SPIS24R"
base ad:0xa0411d64
rgroup 0--3
line.long 0 "SPIS24R"
hexfld.long 0 " SPIS24 "
;tree.end

;tree "SPIS25R"
base ad:0xa0411d68
rgroup 0--3
line.long 0 "SPIS25R"
hexfld.long 0 " SPIS25 "
;tree.end

;tree "SPIS26R"
base ad:0xa0411d6c
rgroup 0--3
line.long 0 "SPIS26R"
hexfld.long 0 " SPIS26 "
;tree.end

;tree "SPIS27R"
base ad:0xa0411d70
rgroup 0--3
line.long 0 "SPIS27R"
hexfld.long 0 " SPIS27 "
;tree.end

;tree "SPIS28R"
base ad:0xa0411d74
rgroup 0--3
line.long 0 "SPIS28R"
hexfld.long 0 " SPIS28 "
;tree.end

;tree "SPIS29R"
base ad:0xa0411d78
rgroup 0--3
line.long 0 "SPIS29R"
hexfld.long 0 " SPIS29 "
;tree.end

;tree "SPIS30R"
base ad:0xa0411d7c
rgroup 0--3
line.long 0 "SPIS30R"
hexfld.long 0 " SPIS30 "
;tree.end

;tree "STIR"
base ad:0xa0411f00
wgroup 0--3
line.long 0 "STIR"
bitfld.long 0 0.--3. " STIINTID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 15. " STISATT "  "0 ,1 "
hexfld.byte 2 " STICPUTL "
bitfld.long 0 24.--25. " STITLF "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PPLI0R"
base ad:0xa0411fe0
rgroup 0--3
line.long 0 "PPLI0R"
bitfld.long 0 0.--11. " PPLI0PN "  " "
bitfld.long 0 12.--18. " PPLI0JEP106 "  " "
bitfld.long 0 19. " PPLI0JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI0REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI0MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI0REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PPLI1R"
base ad:0xa0411fe4
rgroup 0--3
line.long 0 "PPLI1R"
bitfld.long 0 0.--11. " PPLI1PN "  " "
bitfld.long 0 12.--18. " PPLI1JEP106 "  " "
bitfld.long 0 19. " PPLI1JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI1REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI1MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI1REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PPLI2R"
base ad:0xa0411fe8
rgroup 0--3
line.long 0 "PPLI2R"
bitfld.long 0 0.--11. " PPLI2PN "  " "
bitfld.long 0 12.--18. " PPLI2JEP106 "  " "
bitfld.long 0 19. " PPLI2JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI2REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI2MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI2REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PPLI3R"
base ad:0xa0411fec
rgroup 0--3
line.long 0 "PPLI3R"
bitfld.long 0 0.--11. " PPLI3PN "  " "
bitfld.long 0 12.--18. " PPLI3JEP106 "  " "
bitfld.long 0 19. " PPLI3JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI3REV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " PPLI3MODNUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " PPLI3REVAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PCI0R"
base ad:0xa0411ff0
rgroup 0--3
line.long 0 "PCI0R"
hexfld.byte 0 " PCI0CID0 "
hexfld.byte 1 " PCI0CID1 "
hexfld.byte 2 " PCI0CID2 "
hexfld.byte 3 " PCI0CID3 "
;tree.end

;tree "PCI1R"
base ad:0xa0411ff4
rgroup 0--3
line.long 0 "PCI1R"
hexfld.byte 0 " PCI1CID0 "
hexfld.byte 1 " PCI1CID1 "
hexfld.byte 2 " PCI1CID2 "
hexfld.byte 3 " PCI1CID3 "
;tree.end

;tree "PCI2R"
base ad:0xa0411ff8
rgroup 0--3
line.long 0 "PCI2R"
hexfld.byte 0 " PCI2CID0 "
hexfld.byte 1 " PCI2CID1 "
hexfld.byte 2 " PCI2CID2 "
hexfld.byte 3 " PCI2CID3 "
;tree.end

;tree "PCI3R"
base ad:0xa0411ffc
rgroup 0--3
line.long 0 "PCI3R"
hexfld.byte 0 " PCI3CID0 "
hexfld.byte 1 " PCI3CID1 "
hexfld.byte 2 " PCI3CID2 "
hexfld.byte 3 " PCI3CID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "GPIO0"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
if ((data.long(ad:0x8012f010)&0x200)!=0x200)
base ad:0x0
hgroup 0--3
TEXTLINE "GPIO0 is not acessible. Please activate its clock or release its reset"
else
;tree "DAT"
base ad:0x8012e000
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

;tree "DATS"
base ad:0x8012e004
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

;tree "DATC"
base ad:0x8012e008
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

;tree "PDIS"
base ad:0x8012e00c
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

;tree "DIR"
base ad:0x8012e010
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

;tree "DIRS"
base ad:0x8012e014
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

;tree "DIRC"
base ad:0x8012e018
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

;tree "SLPM"
base ad:0x8012e01c
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

;tree "AFSELA"
base ad:0x8012e020
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

;tree "AFSELB"
base ad:0x8012e024
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

;tree "LOWEMI"
base ad:0x8012e028
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

;tree "RIMSC"
base ad:0x8012e040
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

;tree "FIMSC"
base ad:0x8012e044
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

;tree "IS"
base ad:0x8012e048
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

;tree "IC"
base ad:0x8012e04c
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

;tree "RWMSC"
base ad:0x8012e050
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

;tree "FWMSC"
base ad:0x8012e054
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

;tree "WKS"
base ad:0x8012e058
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

;tree "ITCR"
base ad:0x8012e7e0
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITOP"
base ad:0x8012e7e4
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " GPIOINTR "  "0 ,1 "
bitfld.long 0 1. " GPIOWKUP "  "0 ,1 "
;tree.end

;tree "CLKDIV"
base ad:0x8012e7e8
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PeriphID0"
base ad:0x8012efe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "PeriphID1"
base ad:0x8012efe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0x8012efe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0x8012efec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0x8012eff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " GPIOPCellID0 "
;tree.end

;tree "PCellID1"
base ad:0x8012eff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " GPIOPCellID1 "
;tree.end

;tree "PCellID2"
base ad:0x8012eff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " GPIOPCellID2 "
;tree.end

;tree "PCellID3"
base ad:0x8012effc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " GPIOPCellID3 "
;tree.end

endif
tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "GPIO1"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
if ((data.long(ad:0x8012f010)&0x200)!=0x200)
base ad:0x0
hgroup 0--3
TEXTLINE "GPIO1 is not acessible. Please activate its clock or release its reset"
else
;tree "DAT"
base ad:0x8012e080
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

;tree "DATS"
base ad:0x8012e084
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

;tree "DATC"
base ad:0x8012e088
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

;tree "PDIS"
base ad:0x8012e08c
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

;tree "DIR"
base ad:0x8012e090
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

;tree "DIRS"
base ad:0x8012e094
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

;tree "DIRC"
base ad:0x8012e098
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

;tree "SLPM"
base ad:0x8012e09c
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

;tree "AFSELA"
base ad:0x8012e0a0
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

;tree "AFSELB"
base ad:0x8012e0a4
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

;tree "LOWEMI"
base ad:0x8012e0a8
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

;tree "RIMSC"
base ad:0x8012e0c0
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

;tree "FIMSC"
base ad:0x8012e0c4
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

;tree "IS"
base ad:0x8012e0c8
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

;tree "IC"
base ad:0x8012e0cc
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

;tree "RWMSC"
base ad:0x8012e0d0
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

;tree "FWMSC"
base ad:0x8012e0d4
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

;tree "WKS"
base ad:0x8012e0d8
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

endif
tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "GPIO2"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "DAT"
base ad:0x8000e000
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

;tree "DATS"
base ad:0x8000e004
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

;tree "DATC"
base ad:0x8000e008
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

;tree "PDIS"
base ad:0x8000e00c
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

;tree "DIR"
base ad:0x8000e010
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

;tree "DIRS"
base ad:0x8000e014
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

;tree "DIRC"
base ad:0x8000e018
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

;tree "SLPM"
base ad:0x8000e01c
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

;tree "AFSELA"
base ad:0x8000e020
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

;tree "AFSELB"
base ad:0x8000e024
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

;tree "LOWEMI"
base ad:0x8000e028
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

;tree "RIMSC"
base ad:0x8000e040
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

;tree "FIMSC"
base ad:0x8000e044
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

;tree "IS"
base ad:0x8000e048
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

;tree "IC"
base ad:0x8000e04c
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

;tree "RWMSC"
base ad:0x8000e050
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

;tree "FWMSC"
base ad:0x8000e054
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

;tree "WKS"
base ad:0x8000e058
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

;tree "ITCR"
base ad:0x8000e7e0
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITOP"
base ad:0x8000e7e4
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " GPIOINTR "  "0 ,1 "
bitfld.long 0 1. " GPIOWKUP "  "0 ,1 "
;tree.end

;tree "CLKDIV"
base ad:0x8000e7e8
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PeriphID0"
base ad:0x8000efe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "PeriphID1"
base ad:0x8000efe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0x8000efe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0x8000efec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0x8000eff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " GPIOPCellID0 "
;tree.end

;tree "PCellID1"
base ad:0x8000eff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " GPIOPCellID1 "
;tree.end

;tree "PCellID2"
base ad:0x8000eff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " GPIOPCellID2 "
;tree.end

;tree "PCellID3"
base ad:0x8000effc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " GPIOPCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "GPIO3"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "DAT"
base ad:0x8000e080
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

;tree "DATS"
base ad:0x8000e084
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

;tree "DATC"
base ad:0x8000e088
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

;tree "PDIS"
base ad:0x8000e08c
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

;tree "DIR"
base ad:0x8000e090
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

;tree "DIRS"
base ad:0x8000e094
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

;tree "DIRC"
base ad:0x8000e098
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

;tree "SLPM"
base ad:0x8000e09c
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

;tree "AFSELA"
base ad:0x8000e0a0
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

;tree "AFSELB"
base ad:0x8000e0a4
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

;tree "LOWEMI"
base ad:0x8000e0a8
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

;tree "RIMSC"
base ad:0x8000e0c0
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

;tree "FIMSC"
base ad:0x8000e0c4
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

;tree "IS"
base ad:0x8000e0c8
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

;tree "IC"
base ad:0x8000e0cc
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

;tree "RWMSC"
base ad:0x8000e0d0
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

;tree "FWMSC"
base ad:0x8000e0d4
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

;tree "WKS"
base ad:0x8000e0d8
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "GPIO4"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "DAT"
base ad:0x8000e100
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

;tree "DATS"
base ad:0x8000e104
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

;tree "DATC"
base ad:0x8000e108
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

;tree "PDIS"
base ad:0x8000e10c
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

;tree "DIR"
base ad:0x8000e110
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

;tree "DIRS"
base ad:0x8000e114
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

;tree "DIRC"
base ad:0x8000e118
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

;tree "SLPM"
base ad:0x8000e11c
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

;tree "AFSELA"
base ad:0x8000e120
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

;tree "AFSELB"
base ad:0x8000e124
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

;tree "LOWEMI"
base ad:0x8000e128
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

;tree "RIMSC"
base ad:0x8000e140
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

;tree "FIMSC"
base ad:0x8000e144
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

;tree "IS"
base ad:0x8000e148
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

;tree "IC"
base ad:0x8000e14c
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

;tree "RWMSC"
base ad:0x8000e150
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

;tree "FWMSC"
base ad:0x8000e154
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

;tree "WKS"
base ad:0x8000e158
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "GPIO5"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "DAT"
base ad:0x8000e180
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

;tree "DATS"
base ad:0x8000e184
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

;tree "DATC"
base ad:0x8000e188
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

;tree "PDIS"
base ad:0x8000e18c
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

;tree "DIR"
base ad:0x8000e190
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

;tree "DIRS"
base ad:0x8000e194
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

;tree "DIRC"
base ad:0x8000e198
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

;tree "SLPM"
base ad:0x8000e19c
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

;tree "AFSELA"
base ad:0x8000e1a0
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

;tree "AFSELB"
base ad:0x8000e1a4
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

;tree "LOWEMI"
base ad:0x8000e1a8
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

;tree "RIMSC"
base ad:0x8000e1c0
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

;tree "FIMSC"
base ad:0x8000e1c4
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

;tree "IS"
base ad:0x8000e1c8
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

;tree "IC"
base ad:0x8000e1cc
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

;tree "RWMSC"
base ad:0x8000e1d0
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

;tree "FWMSC"
base ad:0x8000e1d4
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

;tree "WKS"
base ad:0x8000e1d8
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "GPIO6"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
if ((data.long(ad:0x8011f010)&0x800)!=0x800)
base ad:0x0
hgroup 0--3
TEXTLINE "GPIO6 is not acessible. Please activate its clock or release its reset"
else
;tree "DAT"
base ad:0x8011e000
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

;tree "DATS"
base ad:0x8011e004
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

;tree "DATC"
base ad:0x8011e008
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

;tree "PDIS"
base ad:0x8011e00c
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

;tree "DIR"
base ad:0x8011e010
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

;tree "DIRS"
base ad:0x8011e014
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

;tree "DIRC"
base ad:0x8011e018
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

;tree "SLPM"
base ad:0x8011e01c
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

;tree "AFSELA"
base ad:0x8011e020
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

;tree "AFSELB"
base ad:0x8011e024
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

;tree "LOWEMI"
base ad:0x8011e028
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

;tree "RIMSC"
base ad:0x8011e040
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

;tree "FIMSC"
base ad:0x8011e044
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

;tree "IS"
base ad:0x8011e048
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

;tree "IC"
base ad:0x8011e04c
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

;tree "RWMSC"
base ad:0x8011e050
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

;tree "FWMSC"
base ad:0x8011e054
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

;tree "WKS"
base ad:0x8011e058
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

;tree "ITCR"
base ad:0x8011e7e0
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITOP"
base ad:0x8011e7e4
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " GPIOINTR "  "0 ,1 "
bitfld.long 0 1. " GPIOWKUP "  "0 ,1 "
;tree.end

;tree "CLKDIV"
base ad:0x8011e7e8
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PeriphID0"
base ad:0x8011efe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "PeriphID1"
base ad:0x8011efe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0x8011efe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0x8011efec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0x8011eff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " GPIOPCellID0 "
;tree.end

;tree "PCellID1"
base ad:0x8011eff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " GPIOPCellID1 "
;tree.end

;tree "PCellID2"
base ad:0x8011eff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " GPIOPCellID2 "
;tree.end

;tree "PCellID3"
base ad:0x8011effc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " GPIOPCellID3 "
;tree.end

endif
tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "GPIO7"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
if ((data.long(ad:0x8011f010)&0x800)!=0x800)
base ad:0x0
hgroup 0--3
TEXTLINE "GPIO7 is not acessible. Please activate its clock or release its reset"
else
;tree "DAT"
base ad:0x8011e080
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

;tree "DATS"
base ad:0x8011e084
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

;tree "DATC"
base ad:0x8011e088
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

;tree "PDIS"
base ad:0x8011e08c
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

;tree "DIR"
base ad:0x8011e090
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

;tree "DIRS"
base ad:0x8011e094
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

;tree "DIRC"
base ad:0x8011e098
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

;tree "SLPM"
base ad:0x8011e09c
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

;tree "AFSELA"
base ad:0x8011e0a0
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

;tree "AFSELB"
base ad:0x8011e0a4
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

;tree "LOWEMI"
base ad:0x8011e0a8
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

;tree "RIMSC"
base ad:0x8011e0c0
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

;tree "FIMSC"
base ad:0x8011e0c4
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

;tree "IS"
base ad:0x8011e0c8
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

;tree "IC"
base ad:0x8011e0cc
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

;tree "RWMSC"
base ad:0x8011e0d0
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

;tree "FWMSC"
base ad:0x8011e0d4
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

;tree "WKS"
base ad:0x8011e0d8
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

endif
tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "GPIO8"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "DAT"
base ad:0xa03fe000
group 0--3
line.long 0 "DAT"
hexfld.long 0 " GPDAT "
;tree.end

;tree "DATS"
base ad:0xa03fe004
group 0--3
line.long 0 "DATS"
hexfld.long 0 " GPDATS "
;tree.end

;tree "DATC"
base ad:0xa03fe008
group 0--3
line.long 0 "DATC"
hexfld.long 0 " GPDATC "
;tree.end

;tree "PDIS"
base ad:0xa03fe00c
group 0--3
line.long 0 "PDIS"
hexfld.long 0 " PDIS "
;tree.end

;tree "DIR"
base ad:0xa03fe010
group 0--3
line.long 0 "DIR"
hexfld.long 0 " GPDIR "
;tree.end

;tree "DIRS"
base ad:0xa03fe014
group 0--3
line.long 0 "DIRS"
hexfld.long 0 " GPDIRS "
;tree.end

;tree "DIRC"
base ad:0xa03fe018
group 0--3
line.long 0 "DIRC"
hexfld.long 0 " GPDIRC "
;tree.end

;tree "SLPM"
base ad:0xa03fe01c
group 0--3
line.long 0 "SLPM"
hexfld.long 0 " SLPM "
;tree.end

;tree "AFSELA"
base ad:0xa03fe020
group 0--3
line.long 0 "AFSELA"
hexfld.long 0 " GPAFSA "
;tree.end

;tree "AFSELB"
base ad:0xa03fe024
group 0--3
line.long 0 "AFSELB"
hexfld.long 0 " GPAFSB "
;tree.end

;tree "LOWEMI"
base ad:0xa03fe028
group 0--3
line.long 0 "LOWEMI"
hexfld.long 0 " LOWEMI "
;tree.end

;tree "RIMSC"
base ad:0xa03fe040
group 0--3
line.long 0 "RIMSC"
hexfld.long 0 " RIMSC "
;tree.end

;tree "FIMSC"
base ad:0xa03fe044
group 0--3
line.long 0 "FIMSC"
hexfld.long 0 " FIMSC "
;tree.end

;tree "IS"
base ad:0xa03fe048
rgroup 0--3
line.long 0 "IS"
hexfld.long 0 " GPIS "
;tree.end

;tree "IC"
base ad:0xa03fe04c
group 0--3
line.long 0 "IC"
hexfld.long 0 " GPIC "
;tree.end

;tree "RWMSC"
base ad:0xa03fe050
group 0--3
line.long 0 "RWMSC"
hexfld.long 0 " RWMSC "
;tree.end

;tree "FWMSC"
base ad:0xa03fe054
group 0--3
line.long 0 "FWMSC"
hexfld.long 0 " FWMSC "
;tree.end

;tree "WKS"
base ad:0xa03fe058
rgroup 0--3
line.long 0 "WKS"
hexfld.long 0 " WKS "
;tree.end

;tree "ITCR"
base ad:0xa03fe7e0
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITOP"
base ad:0xa03fe7e4
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " GPIOINTR "  "0 ,1 "
bitfld.long 0 1. " GPIOWKUP "  "0 ,1 "
;tree.end

;tree "CLKDIV"
base ad:0xa03fe7e8
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PeriphID0"
base ad:0xa03fefe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "PeriphID1"
base ad:0xa03fefe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0xa03fefe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0xa03fefec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0xa03feff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " GPIOPCellID0 "
;tree.end

;tree "PCellID1"
base ad:0xa03feff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " GPIOPCellID1 "
;tree.end

;tree "PCellID2"
base ad:0xa03feff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " GPIOPCellID2 "
;tree.end

;tree "PCellID3"
base ad:0xa03feffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " GPIOPCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "GPIOMUXWRAPPER"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "BYPASS0"
base ad:0x63f00000
group 0--3
line.long 0 "BYPASS0"
hexfld.long 0 " BYPASS0 "
;tree.end

;tree "BYPASS1"
base ad:0x63f00004
group 0--3
line.long 0 "BYPASS1"
hexfld.long 0 " BYPASS1 "
;tree.end

;tree "BYPASS2"
base ad:0x63f00008
group 0--3
line.long 0 "BYPASS2"
hexfld.long 0 " BYPASS2 "
;tree.end

;tree "BYPASS3"
base ad:0x63f0000c
group 0--3
line.long 0 "BYPASS3"
hexfld.long 0 " BYPASS3 "
;tree.end

;tree "BYPASS4"
base ad:0x63f00010
group 0--3
line.long 0 "BYPASS4"
hexfld.long 0 " BYPASS4 "
;tree.end

;tree "BYPASS5"
base ad:0x63f00014
group 0--3
line.long 0 "BYPASS5"
hexfld.long 0 " BYPASS5 "
;tree.end

;tree "BYPASS6"
base ad:0x63f00018
group 0--3
line.long 0 "BYPASS6"
hexfld.long 0 " BYPASS6 "
;tree.end

;tree "BYPASS7"
base ad:0x63f0001c
group 0--3
line.long 0 "BYPASS7"
hexfld.long 0 " BYPASS7 "
;tree.end

;tree "BYPASS8"
base ad:0x63f00020
group 0--3
line.long 0 "BYPASS8"
hexfld.long 0 " BYPASS8 "
;tree.end

;tree "AFSELA0"
base ad:0x63f00024
group 0--3
line.long 0 "AFSELA0"
hexfld.long 0 " AFSELA0 "
;tree.end

;tree "AFSELA1"
base ad:0x63f00028
group 0--3
line.long 0 "AFSELA1"
hexfld.long 0 " AFSELA1 "
;tree.end

;tree "AFSELA2"
base ad:0x63f0002c
group 0--3
line.long 0 "AFSELA2"
hexfld.long 0 " AFSELA2 "
;tree.end

;tree "AFSELA3"
base ad:0x63f00030
group 0--3
line.long 0 "AFSELA3"
hexfld.long 0 " AFSELA3 "
;tree.end

;tree "AFSELA4"
base ad:0x63f00034
group 0--3
line.long 0 "AFSELA4"
hexfld.long 0 " AFSELA4 "
;tree.end

;tree "AFSELA5"
base ad:0x63f00038
group 0--3
line.long 0 "AFSELA5"
hexfld.long 0 " AFSELA5 "
;tree.end

;tree "AFSELA6"
base ad:0x63f0003c
group 0--3
line.long 0 "AFSELA6"
hexfld.long 0 " AFSELA6 "
;tree.end

;tree "AFSELA7"
base ad:0x63f00040
group 0--3
line.long 0 "AFSELA7"
hexfld.long 0 " AFSELA7 "
;tree.end

;tree "AFSELA8"
base ad:0x63f00044
group 0--3
line.long 0 "AFSELA8"
hexfld.long 0 " AFSELA8 "
;tree.end

;tree "AFSELB0"
base ad:0x63f00048
group 0--3
line.long 0 "AFSELB0"
hexfld.long 0 " AFSELB0 "
;tree.end

;tree "AFSELB1"
base ad:0x63f0004c
group 0--3
line.long 0 "AFSELB1"
hexfld.long 0 " AFSELB1 "
;tree.end

;tree "AFSELB2"
base ad:0x63f00050
group 0--3
line.long 0 "AFSELB2"
hexfld.long 0 " AFSELB2 "
;tree.end

;tree "AFSELB3"
base ad:0x63f00054
group 0--3
line.long 0 "AFSELB3"
hexfld.long 0 " AFSELB3 "
;tree.end

;tree "AFSELB4"
base ad:0x63f00058
group 0--3
line.long 0 "AFSELB4"
hexfld.long 0 " AFSELB4 "
;tree.end

;tree "AFSELB5"
base ad:0x63f0005c
group 0--3
line.long 0 "AFSELB5"
hexfld.long 0 " AFSELB5 "
;tree.end

;tree "AFSELB6"
base ad:0x63f00060
group 0--3
line.long 0 "AFSELB6"
hexfld.long 0 " AFSELB6 "
;tree.end

;tree "AFSELB7"
base ad:0x63f00064
group 0--3
line.long 0 "AFSELB7"
hexfld.long 0 " AFSELB7 "
;tree.end

;tree "AFSELB8"
base ad:0x63f00068
group 0--3
line.long 0 "AFSELB8"
hexfld.long 0 " AFSELB8 "
;tree.end

;tree "OTHER_AFSELA0"
base ad:0x63f0006c
group 0--3
line.long 0 "OTHER_AFSELA0"
hexfld.long 0 " OTHER_AFSELA0 "
;tree.end

;tree "OTHER_AFSELA1"
base ad:0x63f00070
group 0--3
line.long 0 "OTHER_AFSELA1"
hexfld.long 0 " OTHER_AFSELA1 "
;tree.end

;tree "OTHER_AFSELA2"
base ad:0x63f00074
group 0--3
line.long 0 "OTHER_AFSELA2"
hexfld.long 0 " OTHER_AFSELA2 "
;tree.end

;tree "OTHER_AFSELA3"
base ad:0x63f00078
group 0--3
line.long 0 "OTHER_AFSELA3"
hexfld.long 0 " OTHER_AFSELA3 "
;tree.end

;tree "OTHER_AFSELA4"
base ad:0x63f0007c
group 0--3
line.long 0 "OTHER_AFSELA4"
hexfld.long 0 " OTHER_AFSELA4 "
;tree.end

;tree "OTHER_AFSELA5"
base ad:0x63f00080
group 0--3
line.long 0 "OTHER_AFSELA5"
hexfld.long 0 " OTHER_AFSELA5 "
;tree.end

;tree "OTHER_AFSELA6"
base ad:0x63f00084
group 0--3
line.long 0 "OTHER_AFSELA6"
hexfld.long 0 " OTHER_AFSELA6 "
;tree.end

;tree "OTHER_AFSELA7"
base ad:0x63f00088
group 0--3
line.long 0 "OTHER_AFSELA7"
hexfld.long 0 " OTHER_AFSELA7 "
;tree.end

;tree "OTHER_AFSELA8"
base ad:0x63f0008c
group 0--3
line.long 0 "OTHER_AFSELA8"
hexfld.long 0 " OTHER_AFSELA8 "
;tree.end

;tree "OTHER_AFSELB0"
base ad:0x63f00090
group 0--3
line.long 0 "OTHER_AFSELB0"
hexfld.long 0 " OTHER_AFSELB0 "
;tree.end

;tree "OTHER_AFSELB1"
base ad:0x63f00094
group 0--3
line.long 0 "OTHER_AFSELB1"
hexfld.long 0 " OTHER_AFSELB1 "
;tree.end

;tree "OTHER_AFSELB2"
base ad:0x63f00098
group 0--3
line.long 0 "OTHER_AFSELB2"
hexfld.long 0 " OTHER_AFSELB2 "
;tree.end

;tree "OTHER_AFSELB3"
base ad:0x63f0009c
group 0--3
line.long 0 "OTHER_AFSELB3"
hexfld.long 0 " OTHER_AFSELB3 "
;tree.end

;tree "OTHER_AFSELB4"
base ad:0x63f000a0
group 0--3
line.long 0 "OTHER_AFSELB4"
hexfld.long 0 " OTHER_AFSELB4 "
;tree.end

;tree "OTHER_AFSELB5"
base ad:0x63f000a4
group 0--3
line.long 0 "OTHER_AFSELB5"
hexfld.long 0 " OTHER_AFSELB5 "
;tree.end

;tree "OTHER_AFSELB6"
base ad:0x63f000a8
group 0--3
line.long 0 "OTHER_AFSELB6"
hexfld.long 0 " OTHER_AFSELB6 "
;tree.end

;tree "OTHER_AFSELB7"
base ad:0x63f000ac
group 0--3
line.long 0 "OTHER_AFSELB7"
hexfld.long 0 " OTHER_AFSELB7 "
;tree.end

;tree "OTHER_AFSELB8"
base ad:0x63f000b0
group 0--3
line.long 0 "OTHER_AFSELB8"
hexfld.long 0 " OTHER_AFSELB8 "
;tree.end

;tree "CHIPSET0"
base ad:0x63f000b4
group 0--3
line.long 0 "CHIPSET0"
hexfld.long 0 " CHIPSET0 "
;tree.end

;tree "CHIPSET1"
base ad:0x63f000b8
group 0--3
line.long 0 "CHIPSET1"
hexfld.long 0 " CHIPSET1 "
;tree.end

;tree "CHIPSET2"
base ad:0x63f000bc
group 0--3
line.long 0 "CHIPSET2"
hexfld.long 0 " CHIPSET2 "
;tree.end

;tree "CHIPSET3"
base ad:0x63f000c0
group 0--3
line.long 0 "CHIPSET3"
hexfld.long 0 " CHIPSET3 "
;tree.end

;tree "CHIPSET4"
base ad:0x63f000c4
group 0--3
line.long 0 "CHIPSET4"
hexfld.long 0 " CHIPSET4 "
;tree.end

;tree "CHIPSET5"
base ad:0x63f000c8
group 0--3
line.long 0 "CHIPSET5"
hexfld.long 0 " CHIPSET5 "
;tree.end

;tree "CHIPSET6"
base ad:0x63f000cc
group 0--3
line.long 0 "CHIPSET6"
hexfld.long 0 " CHIPSET6 "
;tree.end

;tree "CHIPSET7"
base ad:0x63f000d0
group 0--3
line.long 0 "CHIPSET7"
hexfld.long 0 " CHIPSET7 "
;tree.end

;tree "CHIPSET8"
base ad:0x63f000d4
group 0--3
line.long 0 "CHIPSET8"
hexfld.long 0 " CHIPSET8 "
;tree.end

;tree "SigC1C4_A0"
base ad:0x63f000d8
group 0--3
line.long 0 "SigC1C4_A0"
hexfld.long 0 " SigC1C4_A0 "
;tree.end

;tree "SigC1C4_A1"
base ad:0x63f000dc
group 0--3
line.long 0 "SigC1C4_A1"
hexfld.long 0 " SigC1C4_A1 "
;tree.end

;tree "SigC1C4_A2"
base ad:0x63f000e0
group 0--3
line.long 0 "SigC1C4_A2"
hexfld.long 0 " SigC1C4_A2 "
;tree.end

;tree "SigC1C4_A3"
base ad:0x63f000e4
group 0--3
line.long 0 "SigC1C4_A3"
hexfld.long 0 " SigC1C4_A3 "
;tree.end

;tree "SigC1C4_A4"
base ad:0x63f000e8
group 0--3
line.long 0 "SigC1C4_A4"
hexfld.long 0 " SigC1C4_A4 "
;tree.end

;tree "SigC1C4_A5"
base ad:0x63f000ec
group 0--3
line.long 0 "SigC1C4_A5"
hexfld.long 0 " SigC1C4_A5 "
;tree.end

;tree "SigC1C4_A6"
base ad:0x63f000f0
group 0--3
line.long 0 "SigC1C4_A6"
hexfld.long 0 " SigC1C4_A6 "
;tree.end

;tree "SigC1C4_A7"
base ad:0x63f000f4
group 0--3
line.long 0 "SigC1C4_A7"
hexfld.long 0 " SigC1C4_A7 "
;tree.end

;tree "SigC1C4_A8"
base ad:0x63f000f8
group 0--3
line.long 0 "SigC1C4_A8"
hexfld.long 0 " SigC1C4_A8 "
;tree.end

;tree "SigC1C4_B0"
base ad:0x63f000fc
group 0--3
line.long 0 "SigC1C4_B0"
hexfld.long 0 " SigC1C4_B0 "
;tree.end

;tree "SigC1C4_B1"
base ad:0x63f00100
group 0--3
line.long 0 "SigC1C4_B1"
hexfld.long 0 " SigC1C4_B1 "
;tree.end

;tree "SigC1C4_B2"
base ad:0x63f00104
group 0--3
line.long 0 "SigC1C4_B2"
hexfld.long 0 " SigC1C4_B2 "
;tree.end

;tree "SigC1C4_B3"
base ad:0x63f00108
group 0--3
line.long 0 "SigC1C4_B3"
hexfld.long 0 " SigC1C4_B3 "
;tree.end

;tree "SigC1C4_B4"
base ad:0x63f0010c
group 0--3
line.long 0 "SigC1C4_B4"
hexfld.long 0 " SigC1C4_B4 "
;tree.end

;tree "SigC1C4_B5"
base ad:0x63f00110
group 0--3
line.long 0 "SigC1C4_B5"
hexfld.long 0 " SigC1C4_B5 "
;tree.end

;tree "SigC1C4_B6"
base ad:0x63f00114
group 0--3
line.long 0 "SigC1C4_B6"
hexfld.long 0 " SigC1C4_B6 "
;tree.end

;tree "SigC1C4_B7"
base ad:0x63f00118
group 0--3
line.long 0 "SigC1C4_B7"
hexfld.long 0 " SigC1C4_B7 "
;tree.end

;tree "SigC1C4_B8"
base ad:0x63f0011c
group 0--3
line.long 0 "SigC1C4_B8"
hexfld.long 0 " SigC1C4_B8 "
;tree.end

;tree "SigC1C4_C0"
base ad:0x63f00120
group 0--3
line.long 0 "SigC1C4_C0"
hexfld.long 0 " SigC1C4_C0 "
;tree.end

;tree "SigC1C4_C1"
base ad:0x63f00124
group 0--3
line.long 0 "SigC1C4_C1"
hexfld.long 0 " SigC1C4_C1 "
;tree.end

;tree "SigC1C4_C2"
base ad:0x63f00128
group 0--3
line.long 0 "SigC1C4_C2"
hexfld.long 0 " SigC1C4_C2 "
;tree.end

;tree "SigC1C4_C3"
base ad:0x63f0012c
group 0--3
line.long 0 "SigC1C4_C3"
hexfld.long 0 " SigC1C4_C3 "
;tree.end

;tree "SigC1C4_C4"
base ad:0x63f00130
group 0--3
line.long 0 "SigC1C4_C4"
hexfld.long 0 " SigC1C4_C4 "
;tree.end

;tree "SigC1C4_C5"
base ad:0x63f00134
group 0--3
line.long 0 "SigC1C4_C5"
hexfld.long 0 " SigC1C4_C5 "
;tree.end

;tree "SigC1C4_C6"
base ad:0x63f00138
group 0--3
line.long 0 "SigC1C4_C6"
hexfld.long 0 " SigC1C4_C6 "
;tree.end

;tree "SigC1C4_C7"
base ad:0x63f0013c
group 0--3
line.long 0 "SigC1C4_C7"
hexfld.long 0 " SigC1C4_C7 "
;tree.end

;tree "SigC1C4_C8"
base ad:0x63f00140
group 0--3
line.long 0 "SigC1C4_C8"
hexfld.long 0 " SigC1C4_C8 "
;tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "GPIOTB (9 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "GPIOTB-7"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "7ENR"
base ad:0x63080000
group 0--3
line.long 0 "ENR"
hexfld.word 0 " GTENR "
;tree.end

;tree "7OUTR"
base ad:0x63080004
group 0--3
line.long 0 "OUTR"
hexfld.word 0 " GTOUTR "
;tree.end

;tree "7INR"
base ad:0x63080008
group 0--3
line.long 0 "INR"
hexfld.word 0 " GTINR "
;tree.end

;tree "7AENR"
base ad:0x6308000c
group 0--3
line.long 0 "AENR"
hexfld.word 0 " GTAENR "
;tree.end

;tree "7AOUTR"
base ad:0x63080010
group 0--3
line.long 0 "AOUTR"
hexfld.word 0 " GTAOUTR "
;tree.end

;tree "7AINR"
base ad:0x63080014
group 0--3
line.long 0 "AINR"
hexfld.word 0 " GTAINR "
;tree.end

;tree "7INT"
base ad:0x63080018
group 0--3
line.long 0 "INT"
bitfld.long 0 0. " GTINT "  "0 ,1 "
;tree.end

;tree "7MIS"
base ad:0x6308001c
group 0--3
line.long 0 "MIS"
hexfld.word 0 " GTMIS "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "GPIOTB-8"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "8ENR"
base ad:0x63100000
group 0--3
line.long 0 "ENR"
hexfld.word 0 " GTENR "
;tree.end

;tree "8OUTR"
base ad:0x63100004
group 0--3
line.long 0 "OUTR"
hexfld.word 0 " GTOUTR "
;tree.end

;tree "8INR"
base ad:0x63100008
group 0--3
line.long 0 "INR"
hexfld.word 0 " GTINR "
;tree.end

;tree "8AENR"
base ad:0x6310000c
group 0--3
line.long 0 "AENR"
hexfld.word 0 " GTAENR "
;tree.end

;tree "8AOUTR"
base ad:0x63100010
group 0--3
line.long 0 "AOUTR"
hexfld.word 0 " GTAOUTR "
;tree.end

;tree "8AINR"
base ad:0x63100014
group 0--3
line.long 0 "AINR"
hexfld.word 0 " GTAINR "
;tree.end

;tree "8INT"
base ad:0x63100018
group 0--3
line.long 0 "INT"
bitfld.long 0 0. " GTINT "  "0 ,1 "
;tree.end

;tree "8MIS"
base ad:0x6310001c
group 0--3
line.long 0 "MIS"
hexfld.word 0 " GTMIS "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "GPIOTB-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0ENR"
base ad:0x63780000
group 0--3
line.long 0 "ENR"
hexfld.word 0 " GTENR "
;tree.end

;tree "0OUTR"
base ad:0x63780004
group 0--3
line.long 0 "OUTR"
hexfld.word 0 " GTOUTR "
;tree.end

;tree "0INR"
base ad:0x63780008
group 0--3
line.long 0 "INR"
hexfld.word 0 " GTINR "
;tree.end

;tree "0AENR"
base ad:0x6378000c
group 0--3
line.long 0 "AENR"
hexfld.word 0 " GTAENR "
;tree.end

;tree "0AOUTR"
base ad:0x63780010
group 0--3
line.long 0 "AOUTR"
hexfld.word 0 " GTAOUTR "
;tree.end

;tree "0AINR"
base ad:0x63780014
group 0--3
line.long 0 "AINR"
hexfld.word 0 " GTAINR "
;tree.end

;tree "0INT"
base ad:0x63780018
group 0--3
line.long 0 "INT"
bitfld.long 0 0. " GTINT "  "0 ,1 "
;tree.end

;tree "0MIS"
base ad:0x6378001c
group 0--3
line.long 0 "MIS"
hexfld.word 0 " GTMIS "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "GPIOTB-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1ENR"
base ad:0x63800000
group 0--3
line.long 0 "ENR"
hexfld.word 0 " GTENR "
;tree.end

;tree "1OUTR"
base ad:0x63800004
group 0--3
line.long 0 "OUTR"
hexfld.word 0 " GTOUTR "
;tree.end

;tree "1INR"
base ad:0x63800008
group 0--3
line.long 0 "INR"
hexfld.word 0 " GTINR "
;tree.end

;tree "1AENR"
base ad:0x6380000c
group 0--3
line.long 0 "AENR"
hexfld.word 0 " GTAENR "
;tree.end

;tree "1AOUTR"
base ad:0x63800010
group 0--3
line.long 0 "AOUTR"
hexfld.word 0 " GTAOUTR "
;tree.end

;tree "1AINR"
base ad:0x63800014
group 0--3
line.long 0 "AINR"
hexfld.word 0 " GTAINR "
;tree.end

;tree "1INT"
base ad:0x63800018
group 0--3
line.long 0 "INT"
bitfld.long 0 0. " GTINT "  "0 ,1 "
;tree.end

;tree "1MIS"
base ad:0x6380001c
group 0--3
line.long 0 "MIS"
hexfld.word 0 " GTMIS "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "GPIOTB-2"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "2ENR"
base ad:0x63880000
group 0--3
line.long 0 "ENR"
hexfld.word 0 " GTENR "
;tree.end

;tree "2OUTR"
base ad:0x63880004
group 0--3
line.long 0 "OUTR"
hexfld.word 0 " GTOUTR "
;tree.end

;tree "2INR"
base ad:0x63880008
group 0--3
line.long 0 "INR"
hexfld.word 0 " GTINR "
;tree.end

;tree "2AENR"
base ad:0x6388000c
group 0--3
line.long 0 "AENR"
hexfld.word 0 " GTAENR "
;tree.end

;tree "2AOUTR"
base ad:0x63880010
group 0--3
line.long 0 "AOUTR"
hexfld.word 0 " GTAOUTR "
;tree.end

;tree "2AINR"
base ad:0x63880014
group 0--3
line.long 0 "AINR"
hexfld.word 0 " GTAINR "
;tree.end

;tree "2INT"
base ad:0x63880018
group 0--3
line.long 0 "INT"
bitfld.long 0 0. " GTINT "  "0 ,1 "
;tree.end

;tree "2MIS"
base ad:0x6388001c
group 0--3
line.long 0 "MIS"
hexfld.word 0 " GTMIS "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "GPIOTB-3"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "3ENR"
base ad:0x63900000
group 0--3
line.long 0 "ENR"
hexfld.word 0 " GTENR "
;tree.end

;tree "3OUTR"
base ad:0x63900004
group 0--3
line.long 0 "OUTR"
hexfld.word 0 " GTOUTR "
;tree.end

;tree "3INR"
base ad:0x63900008
group 0--3
line.long 0 "INR"
hexfld.word 0 " GTINR "
;tree.end

;tree "3AENR"
base ad:0x6390000c
group 0--3
line.long 0 "AENR"
hexfld.word 0 " GTAENR "
;tree.end

;tree "3AOUTR"
base ad:0x63900010
group 0--3
line.long 0 "AOUTR"
hexfld.word 0 " GTAOUTR "
;tree.end

;tree "3AINR"
base ad:0x63900014
group 0--3
line.long 0 "AINR"
hexfld.word 0 " GTAINR "
;tree.end

;tree "3INT"
base ad:0x63900018
group 0--3
line.long 0 "INT"
bitfld.long 0 0. " GTINT "  "0 ,1 "
;tree.end

;tree "3MIS"
base ad:0x6390001c
group 0--3
line.long 0 "MIS"
hexfld.word 0 " GTMIS "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "GPIOTB-4"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "4ENR"
base ad:0x63980000
group 0--3
line.long 0 "ENR"
hexfld.word 0 " GTENR "
;tree.end

;tree "4OUTR"
base ad:0x63980004
group 0--3
line.long 0 "OUTR"
hexfld.word 0 " GTOUTR "
;tree.end

;tree "4INR"
base ad:0x63980008
group 0--3
line.long 0 "INR"
hexfld.word 0 " GTINR "
;tree.end

;tree "4AENR"
base ad:0x6398000c
group 0--3
line.long 0 "AENR"
hexfld.word 0 " GTAENR "
;tree.end

;tree "4AOUTR"
base ad:0x63980010
group 0--3
line.long 0 "AOUTR"
hexfld.word 0 " GTAOUTR "
;tree.end

;tree "4AINR"
base ad:0x63980014
group 0--3
line.long 0 "AINR"
hexfld.word 0 " GTAINR "
;tree.end

;tree "4INT"
base ad:0x63980018
group 0--3
line.long 0 "INT"
bitfld.long 0 0. " GTINT "  "0 ,1 "
;tree.end

;tree "4MIS"
base ad:0x6398001c
group 0--3
line.long 0 "MIS"
hexfld.word 0 " GTMIS "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "GPIOTB-5"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "5ENR"
base ad:0x63a00000
group 0--3
line.long 0 "ENR"
hexfld.word 0 " GTENR "
;tree.end

;tree "5OUTR"
base ad:0x63a00004
group 0--3
line.long 0 "OUTR"
hexfld.word 0 " GTOUTR "
;tree.end

;tree "5INR"
base ad:0x63a00008
group 0--3
line.long 0 "INR"
hexfld.word 0 " GTINR "
;tree.end

;tree "5AENR"
base ad:0x63a0000c
group 0--3
line.long 0 "AENR"
hexfld.word 0 " GTAENR "
;tree.end

;tree "5AOUTR"
base ad:0x63a00010
group 0--3
line.long 0 "AOUTR"
hexfld.word 0 " GTAOUTR "
;tree.end

;tree "5AINR"
base ad:0x63a00014
group 0--3
line.long 0 "AINR"
hexfld.word 0 " GTAINR "
;tree.end

;tree "5INT"
base ad:0x63a00018
group 0--3
line.long 0 "INT"
bitfld.long 0 0. " GTINT "  "0 ,1 "
;tree.end

;tree "5MIS"
base ad:0x63a0001c
group 0--3
line.long 0 "MIS"
hexfld.word 0 " GTMIS "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "GPIOTB-6"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "6ENR"
base ad:0x63a80000
group 0--3
line.long 0 "ENR"
hexfld.word 0 " GTENR "
;tree.end

;tree "6OUTR"
base ad:0x63a80004
group 0--3
line.long 0 "OUTR"
hexfld.word 0 " GTOUTR "
;tree.end

;tree "6INR"
base ad:0x63a80008
group 0--3
line.long 0 "INR"
hexfld.word 0 " GTINR "
;tree.end

;tree "6AENR"
base ad:0x63a8000c
group 0--3
line.long 0 "AENR"
hexfld.word 0 " GTAENR "
;tree.end

;tree "6AOUTR"
base ad:0x63a80010
group 0--3
line.long 0 "AOUTR"
hexfld.word 0 " GTAOUTR "
;tree.end

;tree "6AINR"
base ad:0x63a80014
group 0--3
line.long 0 "AINR"
hexfld.word 0 " GTAINR "
;tree.end

;tree "6INT"
base ad:0x63a80018
group 0--3
line.long 0 "INT"
bitfld.long 0 0. " GTINT "  "0 ,1 "
;tree.end

;tree "6MIS"
base ad:0x63a8001c
group 0--3
line.long 0 "MIS"
hexfld.word 0 " GTMIS "
;tree.end

tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "HAMACA"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "DMA0_CTRL"
base ad:0xa003a800
group 0--3
line.long 0 "DMA0_CTRL"
bitfld.long 0 0.--12. " value "  " "
;tree.end

;tree "DMA0_INT_BASE"
base ad:0xa003a804
group 0--3
line.long 0 "DMA0_INT_BASE"
hexfld.word 0 " value "
;tree.end

;tree "DMA0_INT_LENGTH"
base ad:0xa003a808
group 0--3
line.long 0 "DMA0_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA0_EXT_BASEH"
base ad:0xa003a80c
group 0--3
line.long 0 "DMA0_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

;tree "DMA0_EXT_BASEL"
base ad:0xa003a810
group 0--3
line.long 0 "DMA0_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

;tree "DMA0_COUNT"
base ad:0xa003a814
rgroup 0--3
line.long 0 "DMA0_COUNT"
hexfld.word 0 " value "
;tree.end

;tree "DMA0_EXT_LENGTH"
base ad:0xa003a818
group 0--3
line.long 0 "DMA0_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA_IT_STATUS"
base ad:0xa003a81c
rgroup 0--3
line.long 0 "DMA_IT_STATUS"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DMA1_CTRL"
base ad:0xa003a820
group 0--3
line.long 0 "DMA1_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

;tree "DMA1_INT_BASE"
base ad:0xa003a824
group 0--3
line.long 0 "DMA1_INT_BASE"
hexfld.word 0 " value "
;tree.end

;tree "DMA1_INT_LENGTH"
base ad:0xa003a828
group 0--3
line.long 0 "DMA1_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA1_EXT_BASEH"
base ad:0xa003a82c
group 0--3
line.long 0 "DMA1_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

;tree "DMA1_EXT_BASEL"
base ad:0xa003a830
group 0--3
line.long 0 "DMA1_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

;tree "DMA1_COUNT"
base ad:0xa003a834
rgroup 0--3
line.long 0 "DMA1_COUNT"
hexfld.word 0 " value "
;tree.end

;tree "DMA1_EXT_LENGTH"
base ad:0xa003a838
group 0--3
line.long 0 "DMA1_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_CTRL"
base ad:0xa003a840
group 0--3
line.long 0 "DMA2_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

;tree "DMA2_INT_BASE"
base ad:0xa003a844
group 0--3
line.long 0 "DMA2_INT_BASE"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_INT_LENGTH"
base ad:0xa003a848
group 0--3
line.long 0 "DMA2_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_EXT_BASEH"
base ad:0xa003a84c
group 0--3
line.long 0 "DMA2_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

;tree "DMA2_EXT_BASEL"
base ad:0xa003a850
group 0--3
line.long 0 "DMA2_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_COUNT"
base ad:0xa003a854
rgroup 0--3
line.long 0 "DMA2_COUNT"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_EXT_LENGTH"
base ad:0xa003a858
group 0--3
line.long 0 "DMA2_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_CTRL"
base ad:0xa003a860
group 0--3
line.long 0 "DMA3_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

;tree "DMA3_INT_BASE"
base ad:0xa003a864
group 0--3
line.long 0 "DMA3_INT_BASE"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_INT_LENGTH"
base ad:0xa003a868
group 0--3
line.long 0 "DMA3_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_EXT_BASEH"
base ad:0xa003a86c
group 0--3
line.long 0 "DMA3_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

;tree "DMA3_EXT_BASEL"
base ad:0xa003a870
group 0--3
line.long 0 "DMA3_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_COUNT"
base ad:0xa003a874
rgroup 0--3
line.long 0 "DMA3_COUNT"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_EXT_LENGTH"
base ad:0xa003a878
group 0--3
line.long 0 "DMA3_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_mode"
base ad:0xa003b014
group 0--3
line.long 0 "Dcache_mode"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "Dcache_control"
base ad:0xa003b018
group 0--3
line.long 0 "Dcache_control"
bitfld.long 0 0.--4. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "Dcache_way"
base ad:0xa003b01c
group 0--3
line.long 0 "Dcache_way"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "Dcache_line"
base ad:0xa003b020
group 0--3
line.long 0 "Dcache_line"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "Dcache_command"
base ad:0xa003b024
wgroup 0--3
line.long 0 "Dcache_command"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "Dcache_status"
base ad:0xa003b028
rgroup 0--3
line.long 0 "Dcache_status"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "Dcache_cptrl1l"
base ad:0xa003b02c
rgroup 0--3
line.long 0 "Dcache_cptrl1l"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl1h"
base ad:0xa003b030
rgroup 0--3
line.long 0 "Dcache_cptrl1h"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl2l"
base ad:0xa003b034
rgroup 0--3
line.long 0 "Dcache_cptrl2l"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl2h"
base ad:0xa003b038
rgroup 0--3
line.long 0 "Dcache_cptrl2h"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl3l"
base ad:0xa003b03c
rgroup 0--3
line.long 0 "Dcache_cptrl3l"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl3h"
base ad:0xa003b040
rgroup 0--3
line.long 0 "Dcache_cptrl3h"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrsel"
base ad:0xa003b044
group 0--3
line.long 0 "Dcache_cptrsel"
bitfld.long 0 0.--11. " value "  " "
;tree.end

;tree "IO_BIT0"
base ad:0xa003c000
group 0--3
line.long 0 "IO_BIT0"
bitfld.long 0 0. " IO_bit0 "  "0 ,1 "
;tree.end

;tree "IO_BIT1"
base ad:0xa003c008
group 0--3
line.long 0 "IO_BIT1"
bitfld.long 0 0. " IO_bit1 "  "0 ,1 "
;tree.end

;tree "IO_BIT2"
base ad:0xa003c010
group 0--3
line.long 0 "IO_BIT2"
bitfld.long 0 0. " IO_bit2 "  "0 ,1 "
;tree.end

;tree "IO_BIT3"
base ad:0xa003c018
group 0--3
line.long 0 "IO_BIT3"
bitfld.long 0 0. " IO_bit3 "  "0 ,1 "
;tree.end

;tree "IO_BIT4"
base ad:0xa003c020
group 0--3
line.long 0 "IO_BIT4"
bitfld.long 0 0. " IO_bit4 "  "0 ,1 "
;tree.end

;tree "IO_BIT5"
base ad:0xa003c028
group 0--3
line.long 0 "IO_BIT5"
bitfld.long 0 0. " IO_bit5 "  "0 ,1 "
;tree.end

;tree "IO_BIT6"
base ad:0xa003c030
group 0--3
line.long 0 "IO_BIT6"
bitfld.long 0 0. " IO_bit6 "  "0 ,1 "
;tree.end

;tree "IO_BIT7"
base ad:0xa003c038
group 0--3
line.long 0 "IO_BIT7"
bitfld.long 0 0. " IO_bit7 "  "0 ,1 "
;tree.end

;tree "IO_BIT8"
base ad:0xa003c040
group 0--3
line.long 0 "IO_BIT8"
bitfld.long 0 0. " IO_bit8 "  "0 ,1 "
;tree.end

;tree "IO_BIT9"
base ad:0xa003c048
group 0--3
line.long 0 "IO_BIT9"
bitfld.long 0 0. " IO_bit9 "  "0 ,1 "
;tree.end

;tree "IO_BITA"
base ad:0xa003c050
group 0--3
line.long 0 "IO_BITA"
bitfld.long 0 0. " IO_bitA "  "0 ,1 "
;tree.end

;tree "IO_BITB"
base ad:0xa003c058
group 0--3
line.long 0 "IO_BITB"
bitfld.long 0 0. " IO_bitB "  "0 ,1 "
;tree.end

;tree "IO_BITC"
base ad:0xa003c060
group 0--3
line.long 0 "IO_BITC"
bitfld.long 0 0. " IO_bitC "  "0 ,1 "
;tree.end

;tree "IO_BITD"
base ad:0xa003c068
group 0--3
line.long 0 "IO_BITD"
bitfld.long 0 0. " IO_bitD "  "0 ,1 "
;tree.end

;tree "IO_BITE"
base ad:0xa003c070
group 0--3
line.long 0 "IO_BITE"
bitfld.long 0 0. " IO_bitE "  "0 ,1 "
;tree.end

;tree "IO_BITF"
base ad:0xa003c078
group 0--3
line.long 0 "IO_BITF"
bitfld.long 0 0. " IO_bitF "  "0 ,1 "
;tree.end

;tree "IO_LSB"
base ad:0xa003c080
group 0--3
line.long 0 "IO_LSB"
bitfld.long 0 0. " IO_lsb "  "0 ,1 "
;tree.end

;tree "IO_MSB"
base ad:0xa003c088
group 0--3
line.long 0 "IO_MSB"
bitfld.long 0 0. " IO_msb "  "0 ,1 "
;tree.end

;tree "IO_ALL"
base ad:0xa003c090
group 0--3
line.long 0 "IO_ALL"
bitfld.long 0 0. " IO_all "  "0 ,1 "
;tree.end

;tree "IO_EN"
base ad:0xa003c098
group 0--3
line.long 0 "IO_EN"
bitfld.long 0 0. " IO_en "  "0 ,1 "
;tree.end

;tree "TIMER_MOD0_MSB"
base ad:0xa003c0c0
group 0--3
line.long 0 "TIMER_MOD0_MSB"
hexfld.byte 0 " value "
;tree.end

;tree "TIMER_MOD0_LSB"
base ad:0xa003c0c8
group 0--3
line.long 0 "TIMER_MOD0_LSB"
hexfld.word 0 " value "
;tree.end

;tree "TIMER_MOD1_MSB"
base ad:0xa003c0d0
group 0--3
line.long 0 "TIMER_MOD1_MSB"
hexfld.byte 0 " value "
;tree.end

;tree "TIMER_MOD1_LSB"
base ad:0xa003c0d8
group 0--3
line.long 0 "TIMER_MOD1_LSB"
hexfld.word 0 " value "
;tree.end

;tree "TIMER_MOD2_MSB"
base ad:0xa003c0e0
group 0--3
line.long 0 "TIMER_MOD2_MSB"
hexfld.byte 0 " value "
;tree.end

;tree "TIMER_MOD2_LSB"
base ad:0xa003c0e8
group 0--3
line.long 0 "TIMER_MOD2_LSB"
hexfld.word 0 " value "
;tree.end

;tree "SEM0"
base ad:0xa003c820
group 0--3
line.long 0 "SEM0"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM1"
base ad:0xa003c828
group 0--3
line.long 0 "SEM1"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM2"
base ad:0xa003c830
group 0--3
line.long 0 "SEM2"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM3"
base ad:0xa003c838
group 0--3
line.long 0 "SEM3"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM4"
base ad:0xa003c840
group 0--3
line.long 0 "SEM4"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM5"
base ad:0xa003c848
group 0--3
line.long 0 "SEM5"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM6"
base ad:0xa003c850
group 0--3
line.long 0 "SEM6"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM7"
base ad:0xa003c858
group 0--3
line.long 0 "SEM7"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "HAMACA_IPEN"
base ad:0xa003c8a0
group 0--3
line.long 0 "HAMACA_IPEN"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "HAMACA_ITIP_0"
base ad:0xa003c8a8
group 0--3
line.long 0 "HAMACA_ITIP_0"
hexfld.word 0 " value "
;tree.end

;tree "HAMACA_ITIP_1"
base ad:0xa003c8ac
group 0--3
line.long 0 "HAMACA_ITIP_1"
hexfld.word 0 " value "
;tree.end

;tree "HAMACA_ITIP_2"
base ad:0xa003c8b0
group 0--3
line.long 0 "HAMACA_ITIP_2"
hexfld.word 0 " value "
;tree.end

;tree "HAMACA_ITIP_3"
base ad:0xa003c8b4
group 0--3
line.long 0 "HAMACA_ITIP_3"
bitfld.long 0 0. " ITEXT11 "  "0 ,1 "
bitfld.long 0 1. " ITEXT12 "  "0 ,1 "
bitfld.long 0 2. " XDMA_LBREQ0 "  "0 ,1 "
bitfld.long 0 3. " XDMA_LBREQ1 "  "0 ,1 "
bitfld.long 0 4. " XDMA_LBREQ2 "  "0 ,1 "
bitfld.long 0 5. " XDMA_LBREQ3 "  "0 ,1 "
bitfld.long 0 6. " XDMA_LSREQ0 "  "0 ,1 "
bitfld.long 0 7. " XDMA_LSREQ1 "  "0 ,1 "
bitfld.long 0 8. " XDMA_LSREQ2 "  "0 ,1 "
bitfld.long 0 9. " XDMA_LSREQ3 "  "0 ,1 "
bitfld.long 0 10. " XDMA_BREQ0 "  "0 ,1 "
bitfld.long 0 11. " XDMA_BREQ1 "  "0 ,1 "
bitfld.long 0 12. " XDMA_BREQ2 "  "0 ,1 "
bitfld.long 0 13. " XDMA_BREQ3 "  "0 ,1 "
bitfld.long 0 14. " XDMA_SREQ0 "  "0 ,1 "
bitfld.long 0 15. " XDMA_SREQ1 "  "0 ,1 "
;tree.end

;tree "HAMACA_ITIP_4"
base ad:0xa003c914
group 0--3
line.long 0 "HAMACA_ITIP_4"
bitfld.long 0 0. " XDMA_SREQ2 "  "0 ,1 "
bitfld.long 0 1. " XDMA_SREQ3 "  "0 ,1 "
;tree.end

;tree "HAMACA_ITOP0"
base ad:0xa003c8b8
group 0--3
line.long 0 "HAMACA_ITOP0"
hexfld.word 0 " value "
;tree.end

;tree "HAMACA_ITOP1"
base ad:0xa003c8bc
group 0--3
line.long 0 "HAMACA_ITOP1"
hexfld.word 0 " value "
;tree.end

;tree "HAMACA_ITOP2"
base ad:0xa003c8c0
group 0--3
line.long 0 "HAMACA_ITOP2"
hexfld.word 0 " value "
;tree.end

;tree "HAMACA_ITOP3"
base ad:0xa003c8c4
group 0--3
line.long 0 "HAMACA_ITOP3"
hexfld.word 0 " value "
;tree.end

;tree "HAMACA_ITOP4"
base ad:0xa003c918
group 0--3
line.long 0 "HAMACA_ITOP4"
bitfld.long 0 0.--13. " value "  " "
;tree.end

;tree "ID0"
base ad:0xa003cfc0
rgroup 0--3
line.long 0 "ID0"
hexfld.byte 0 " value "
;tree.end

;tree "ID1"
base ad:0xa003cfc8
rgroup 0--3
line.long 0 "ID1"
hexfld.byte 0 " value "
;tree.end

;tree "ID2"
base ad:0xa003cfd0
rgroup 0--3
line.long 0 "ID2"
hexfld.byte 0 " value "
;tree.end

;tree "ID3"
base ad:0xa003cfd8
rgroup 0--3
line.long 0 "ID3"
hexfld.byte 0 " value "
;tree.end

;tree "IDP0"
base ad:0xa003cfe0
rgroup 0--3
line.long 0 "IDP0"
hexfld.byte 0 " value "
;tree.end

;tree "IDP1"
base ad:0xa003cfe8
rgroup 0--3
line.long 0 "IDP1"
hexfld.byte 0 " value "
;tree.end

;tree "IDP2"
base ad:0xa003cff0
rgroup 0--3
line.long 0 "IDP2"
hexfld.byte 0 " value "
;tree.end

;tree "IDP3"
base ad:0xa003cff8
rgroup 0--3
line.long 0 "IDP3"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA0_SREQ"
base ad:0xa003d000
group 0--3
line.long 0 "ARM_DMA0_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA0_BREQ"
base ad:0xa003d004
group 0--3
line.long 0 "ARM_DMA0_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA0_LSREQ"
base ad:0xa003d008
group 0--3
line.long 0 "ARM_DMA0_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA0_LBREQ"
base ad:0xa003d00c
group 0--3
line.long 0 "ARM_DMA0_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA0_MASKIT"
base ad:0xa003d010
group 0--3
line.long 0 "ARM_DMA0_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA0_IT"
base ad:0xa003d014
rgroup 0--3
line.long 0 "ARM_DMA0_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA0_AUTO"
base ad:0xa003d018
group 0--3
line.long 0 "ARM_DMA0_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA0_LAUTO"
base ad:0xa003d01c
group 0--3
line.long 0 "ARM_DMA0_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA1_SREQ"
base ad:0xa003d040
group 0--3
line.long 0 "ARM_DMA1_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA1_BREQ"
base ad:0xa003d044
group 0--3
line.long 0 "ARM_DMA1_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA1_LSREQ"
base ad:0xa003d048
group 0--3
line.long 0 "ARM_DMA1_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA1_LBREQ"
base ad:0xa003d04c
group 0--3
line.long 0 "ARM_DMA1_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA1_MASKIT"
base ad:0xa003d050
group 0--3
line.long 0 "ARM_DMA1_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA1_IT"
base ad:0xa003d054
rgroup 0--3
line.long 0 "ARM_DMA1_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA1_AUTO"
base ad:0xa003d058
group 0--3
line.long 0 "ARM_DMA1_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA1_LAUTO"
base ad:0xa003d05c
group 0--3
line.long 0 "ARM_DMA1_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA2_SREQ"
base ad:0xa003d080
group 0--3
line.long 0 "ARM_DMA2_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA2_BREQ"
base ad:0xa003d084
group 0--3
line.long 0 "ARM_DMA2_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA2_LSREQ"
base ad:0xa003d088
group 0--3
line.long 0 "ARM_DMA2_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA2_LBREQ"
base ad:0xa003d08c
group 0--3
line.long 0 "ARM_DMA2_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA2_MASKIT"
base ad:0xa003d090
group 0--3
line.long 0 "ARM_DMA2_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA2_IT"
base ad:0xa003d094
rgroup 0--3
line.long 0 "ARM_DMA2_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA2_AUTO"
base ad:0xa003d098
group 0--3
line.long 0 "ARM_DMA2_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA2_LAUTO"
base ad:0xa003d09c
group 0--3
line.long 0 "ARM_DMA2_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA3_SREQ"
base ad:0xa003d0c0
group 0--3
line.long 0 "ARM_DMA3_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA3_BREQ"
base ad:0xa003d0c4
group 0--3
line.long 0 "ARM_DMA3_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA3_LSREQ"
base ad:0xa003d0c8
group 0--3
line.long 0 "ARM_DMA3_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA3_LBREQ"
base ad:0xa003d0cc
group 0--3
line.long 0 "ARM_DMA3_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA3_MASKIT"
base ad:0xa003d0d0
group 0--3
line.long 0 "ARM_DMA3_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA3_IT"
base ad:0xa003d0d4
rgroup 0--3
line.long 0 "ARM_DMA3_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA3_AUTO"
base ad:0xa003d0d8
group 0--3
line.long 0 "ARM_DMA3_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA3_LAUTO"
base ad:0xa003d0dc
group 0--3
line.long 0 "ARM_DMA3_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA4_SREQ"
base ad:0xa003d100
group 0--3
line.long 0 "ARM_DMA4_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA4_BREQ"
base ad:0xa003d104
group 0--3
line.long 0 "ARM_DMA4_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA4_LSREQ"
base ad:0xa003d108
group 0--3
line.long 0 "ARM_DMA4_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA4_LBREQ"
base ad:0xa003d10c
group 0--3
line.long 0 "ARM_DMA4_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA4_MASKIT"
base ad:0xa003d110
group 0--3
line.long 0 "ARM_DMA4_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA4_IT"
base ad:0xa003d114
rgroup 0--3
line.long 0 "ARM_DMA4_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA4_AUTO"
base ad:0xa003d118
group 0--3
line.long 0 "ARM_DMA4_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA4_LAUTO"
base ad:0xa003d11c
group 0--3
line.long 0 "ARM_DMA4_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA5_SREQ"
base ad:0xa003d140
group 0--3
line.long 0 "ARM_DMA5_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA5_BREQ"
base ad:0xa003d144
group 0--3
line.long 0 "ARM_DMA5_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA5_LSREQ"
base ad:0xa003d148
group 0--3
line.long 0 "ARM_DMA5_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA5_LBREQ"
base ad:0xa003d14c
group 0--3
line.long 0 "ARM_DMA5_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA5_MASKIT"
base ad:0xa003d150
group 0--3
line.long 0 "ARM_DMA5_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA5_IT"
base ad:0xa003d154
rgroup 0--3
line.long 0 "ARM_DMA5_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA5_AUTO"
base ad:0xa003d158
group 0--3
line.long 0 "ARM_DMA5_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA5_LAUTO"
base ad:0xa003d15c
group 0--3
line.long 0 "ARM_DMA5_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA6_SREQ"
base ad:0xa003d180
group 0--3
line.long 0 "ARM_DMA6_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA6_BREQ"
base ad:0xa003d184
group 0--3
line.long 0 "ARM_DMA6_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA6_LSREQ"
base ad:0xa003d188
group 0--3
line.long 0 "ARM_DMA6_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA6_LBREQ"
base ad:0xa003d18c
group 0--3
line.long 0 "ARM_DMA6_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA6_MASKIT"
base ad:0xa003d190
group 0--3
line.long 0 "ARM_DMA6_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA6_IT"
base ad:0xa003d194
rgroup 0--3
line.long 0 "ARM_DMA6_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA6_AUTO"
base ad:0xa003d198
group 0--3
line.long 0 "ARM_DMA6_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA6_LAUTO"
base ad:0xa003d19c
group 0--3
line.long 0 "ARM_DMA6_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA7_SREQ"
base ad:0xa003d1c0
group 0--3
line.long 0 "ARM_DMA7_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA7_BREQ"
base ad:0xa003d1c4
group 0--3
line.long 0 "ARM_DMA7_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA7_LSREQ"
base ad:0xa003d1c8
group 0--3
line.long 0 "ARM_DMA7_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA7_LBREQ"
base ad:0xa003d1cc
group 0--3
line.long 0 "ARM_DMA7_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA7_MASKIT"
base ad:0xa003d1d0
group 0--3
line.long 0 "ARM_DMA7_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA7_IT"
base ad:0xa003d1d4
rgroup 0--3
line.long 0 "ARM_DMA7_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA7_AUTO"
base ad:0xa003d1d8
group 0--3
line.long 0 "ARM_DMA7_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA7_LAUTO"
base ad:0xa003d1dc
group 0--3
line.long 0 "ARM_DMA7_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "EMU_UNIT_MASKIT"
base ad:0xa003d800
group 0--3
line.long 0 "EMU_UNIT_MASKIT"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "CONFIG_DATA_MEM"
base ad:0xa003d820
group 0--3
line.long 0 "CONFIG_DATA_MEM"
bitfld.long 0 0.--13. " value "  " "
;tree.end

;tree "COMPATIBILITY_REGISTER"
base ad:0xa003d828
group 0--3
line.long 0 "COMPATIBILITY_REGISTER"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "AHB_IF_CONFIG"
base ad:0xa003e000
group 0--3
line.long 0 "AHB_IF_CONFIG"
bitfld.long 0 0.--3. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "AHB_IF_MODE"
base ad:0xa003e004
group 0--3
line.long 0 "AHB_IF_MODE"
bitfld.long 0 0.--3. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "AHB_IF_STATUS"
base ad:0xa003e008
rgroup 0--3
line.long 0 "AHB_IF_STATUS"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "AHB_IF_SECURITY"
base ad:0xa003e00c
group 0--3
line.long 0 "AHB_IF_SECURITY"
bitfld.long 0 0.--4. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "ITREMAP_REG0"
base ad:0xa003f800
group 0--3
line.long 0 "ITREMAP_REG0"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG1"
base ad:0xa003f808
group 0--3
line.long 0 "ITREMAP_REG1"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG2"
base ad:0xa003f810
group 0--3
line.long 0 "ITREMAP_REG2"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG3"
base ad:0xa003f818
group 0--3
line.long 0 "ITREMAP_REG3"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG4"
base ad:0xa003f820
group 0--3
line.long 0 "ITREMAP_REG4"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG5"
base ad:0xa003f828
group 0--3
line.long 0 "ITREMAP_REG5"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG6"
base ad:0xa003f830
group 0--3
line.long 0 "ITREMAP_REG6"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG7"
base ad:0xa003f838
group 0--3
line.long 0 "ITREMAP_REG7"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG8"
base ad:0xa003f840
group 0--3
line.long 0 "ITREMAP_REG8"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG9"
base ad:0xa003f848
group 0--3
line.long 0 "ITREMAP_REG9"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG10"
base ad:0xa003f850
group 0--3
line.long 0 "ITREMAP_REG10"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG11"
base ad:0xa003f858
group 0--3
line.long 0 "ITREMAP_REG11"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG12"
base ad:0xa003f860
group 0--3
line.long 0 "ITREMAP_REG12"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG13"
base ad:0xa003f868
group 0--3
line.long 0 "ITREMAP_REG13"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG14"
base ad:0xa003f870
group 0--3
line.long 0 "ITREMAP_REG14"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG15"
base ad:0xa003f878
group 0--3
line.long 0 "ITREMAP_REG15"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG16"
base ad:0xa003f880
group 0--3
line.long 0 "ITREMAP_REG16"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG17"
base ad:0xa003f888
group 0--3
line.long 0 "ITREMAP_REG17"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG18"
base ad:0xa003f890
group 0--3
line.long 0 "ITREMAP_REG18"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG19"
base ad:0xa003f898
group 0--3
line.long 0 "ITREMAP_REG19"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG20"
base ad:0xa003f8a0
group 0--3
line.long 0 "ITREMAP_REG20"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG21"
base ad:0xa003f8a8
group 0--3
line.long 0 "ITREMAP_REG21"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG22"
base ad:0xa003f8b0
group 0--3
line.long 0 "ITREMAP_REG22"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG23"
base ad:0xa003f8b8
group 0--3
line.long 0 "ITREMAP_REG23"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG24"
base ad:0xa003f8c0
group 0--3
line.long 0 "ITREMAP_REG24"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG25"
base ad:0xa003f8c8
group 0--3
line.long 0 "ITREMAP_REG25"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG26"
base ad:0xa003f8d0
group 0--3
line.long 0 "ITREMAP_REG26"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG27"
base ad:0xa003f8d8
group 0--3
line.long 0 "ITREMAP_REG27"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG28"
base ad:0xa003f8e0
group 0--3
line.long 0 "ITREMAP_REG28"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG29"
base ad:0xa003f8e8
group 0--3
line.long 0 "ITREMAP_REG29"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG30"
base ad:0xa003f8f0
group 0--3
line.long 0 "ITREMAP_REG30"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG31"
base ad:0xa003f8f8
group 0--3
line.long 0 "ITREMAP_REG31"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITMSK_L_REG"
base ad:0xa003f900
group 0--3
line.long 0 "ITMSK_L_REG"
hexfld.word 0 " value "
;tree.end

;tree "ITMSK_H_REG"
base ad:0xa003f908
group 0--3
line.long 0 "ITMSK_H_REG"
hexfld.word 0 " value "
;tree.end

;tree "ITMEMO_L_REG"
base ad:0xa003f938
group 0--3
line.long 0 "ITMEMO_L_REG"
hexfld.word 0 " value "
;tree.end

;tree "ITMEMO_H_REG"
base ad:0xa003f940
group 0--3
line.long 0 "ITMEMO_H_REG"
hexfld.word 0 " value "
;tree.end

;tree "ITREMAP1_REG0"
base ad:0xa003fa00
group 0--3
line.long 0 "ITREMAP1_REG0"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG1"
base ad:0xa003fa08
group 0--3
line.long 0 "ITREMAP1_REG1"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG2"
base ad:0xa003fa10
group 0--3
line.long 0 "ITREMAP1_REG2"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG3"
base ad:0xa003fa18
group 0--3
line.long 0 "ITREMAP1_REG3"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG4"
base ad:0xa003fa20
group 0--3
line.long 0 "ITREMAP1_REG4"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG5"
base ad:0xa003fa28
group 0--3
line.long 0 "ITREMAP1_REG5"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG6"
base ad:0xa003fa30
group 0--3
line.long 0 "ITREMAP1_REG6"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG7"
base ad:0xa003fa38
group 0--3
line.long 0 "ITREMAP1_REG7"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG8"
base ad:0xa003fa40
group 0--3
line.long 0 "ITREMAP1_REG8"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG9"
base ad:0xa003fa48
group 0--3
line.long 0 "ITREMAP1_REG9"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG10"
base ad:0xa003fa50
group 0--3
line.long 0 "ITREMAP1_REG10"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG11"
base ad:0xa003fa58
group 0--3
line.long 0 "ITREMAP1_REG11"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG12"
base ad:0xa003fa60
group 0--3
line.long 0 "ITREMAP1_REG12"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG13"
base ad:0xa003fa68
group 0--3
line.long 0 "ITREMAP1_REG13"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG14"
base ad:0xa003fa70
group 0--3
line.long 0 "ITREMAP1_REG14"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG15"
base ad:0xa003fa78
group 0--3
line.long 0 "ITREMAP1_REG15"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG16"
base ad:0xa003fa80
group 0--3
line.long 0 "ITREMAP1_REG16"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG17"
base ad:0xa003fa88
group 0--3
line.long 0 "ITREMAP1_REG17"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG18"
base ad:0xa003fa90
group 0--3
line.long 0 "ITREMAP1_REG18"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG19"
base ad:0xa003fa98
group 0--3
line.long 0 "ITREMAP1_REG19"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG20"
base ad:0xa003faa0
group 0--3
line.long 0 "ITREMAP1_REG20"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG21"
base ad:0xa003faa8
group 0--3
line.long 0 "ITREMAP1_REG21"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG22"
base ad:0xa003fab0
group 0--3
line.long 0 "ITREMAP1_REG22"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG23"
base ad:0xa003fab8
group 0--3
line.long 0 "ITREMAP1_REG23"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG24"
base ad:0xa003fac0
group 0--3
line.long 0 "ITREMAP1_REG24"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG25"
base ad:0xa003fac8
group 0--3
line.long 0 "ITREMAP1_REG25"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG26"
base ad:0xa003fad0
group 0--3
line.long 0 "ITREMAP1_REG26"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG27"
base ad:0xa003fad8
group 0--3
line.long 0 "ITREMAP1_REG27"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG28"
base ad:0xa003fae0
group 0--3
line.long 0 "ITREMAP1_REG28"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG29"
base ad:0xa003fae8
group 0--3
line.long 0 "ITREMAP1_REG29"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG30"
base ad:0xa003faf0
group 0--3
line.long 0 "ITREMAP1_REG30"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG31"
base ad:0xa003faf8
group 0--3
line.long 0 "ITREMAP1_REG31"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "HAMACA_HOST"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "HOST_IDENT"
base ad:0xa0060000
rgroup 0--3
line.long 0 "HOST_IDENT"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_IDENT0"
base ad:0xa0060004
rgroup 0--3
line.long 0 "HOST_IDENT0"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_IDENT1"
base ad:0xa0060008
rgroup 0--3
line.long 0 "HOST_IDENT1"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_IDENT2"
base ad:0xa006000c
rgroup 0--3
line.long 0 "HOST_IDENT2"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_IDENT3"
base ad:0xa0060010
rgroup 0--3
line.long 0 "HOST_IDENT3"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_R5"
base ad:0xa0060014
group 0--3
line.long 0 "HOST_R5"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_R6"
base ad:0xa0060018
group 0--3
line.long 0 "HOST_R6"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_INTE0"
base ad:0xa006001c
group 0--3
line.long 0 "HOST_INTE0"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_INTE1"
base ad:0xa0060020
group 0--3
line.long 0 "HOST_INTE1"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_INT0"
base ad:0xa0060024
group 0--3
line.long 0 "HOST_INT0"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_INT1"
base ad:0xa0060028
group 0--3
line.long 0 "HOST_INT1"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_INTPOL"
base ad:0xa0060034
group 0--3
line.long 0 "HOST_INTPOL"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "HOST_cmd0"
base ad:0xa006004c
group 0--3
line.long 0 "HOST_cmd0"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "HOST_cmd1"
base ad:0xa0060050
group 0--3
line.long 0 "HOST_cmd1"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "HOST_cmd2"
base ad:0xa0060054
group 0--3
line.long 0 "HOST_cmd2"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "HOST_cmd3"
base ad:0xa0060058
group 0--3
line.long 0 "HOST_cmd3"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "HOST_I2CDIV"
base ad:0xa0060070
group 0--3
line.long 0 "HOST_I2CDIV"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_UDATA0"
base ad:0xa0060080
group 0--3
line.long 0 "HOST_EMUL_UDATA0"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_UDATA1"
base ad:0xa0060084
group 0--3
line.long 0 "HOST_EMUL_UDATA1"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_UDATA2"
base ad:0xa0060088
group 0--3
line.long 0 "HOST_EMUL_UDATA2"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_UDATA3"
base ad:0xa006008c
group 0--3
line.long 0 "HOST_EMUL_UDATA3"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_UDATA4"
base ad:0xa0060090
group 0--3
line.long 0 "HOST_EMUL_UDATA4"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_UDATA5"
base ad:0xa0060094
group 0--3
line.long 0 "HOST_EMUL_UDATA5"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_UDATA6"
base ad:0xa0060098
group 0--3
line.long 0 "HOST_EMUL_UDATA6"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_UDATA7"
base ad:0xa006009c
group 0--3
line.long 0 "HOST_EMUL_UDATA7"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_UADDRL"
base ad:0xa00600a0
group 0--3
line.long 0 "HOST_EMUL_UADDRL"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_UADDRM"
base ad:0xa00600a4
group 0--3
line.long 0 "HOST_EMUL_UADDRM"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_BK2ADDL"
base ad:0xa00600b0
group 0--3
line.long 0 "HOST_EMUL_BK2ADDL"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_BK2ADDM"
base ad:0xa00600b4
group 0--3
line.long 0 "HOST_EMUL_BK2ADDM"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_BK2ADDH"
base ad:0xa00600b8
group 0--3
line.long 0 "HOST_EMUL_BK2ADDH"
bitfld.long 0 0.--3. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "HOST_EMUL_MDATA0"
base ad:0xa00600bc
group 0--3
line.long 0 "HOST_EMUL_MDATA0"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_MDATA1"
base ad:0xa00600c0
group 0--3
line.long 0 "HOST_EMUL_MDATA1"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_MDATA2"
base ad:0xa00600c4
group 0--3
line.long 0 "HOST_EMUL_MDATA2"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_MADDL"
base ad:0xa00600c8
group 0--3
line.long 0 "HOST_EMUL_MADDL"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_MADDM"
base ad:0xa00600cc
group 0--3
line.long 0 "HOST_EMUL_MADDM"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_MCMD"
base ad:0xa00600d0
group 0--3
line.long 0 "HOST_EMUL_MCMD"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "HOST_EMUL_MADDH"
base ad:0xa00600d4
group 0--3
line.long 0 "HOST_EMUL_MADDH"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_UADDRH"
base ad:0xa00600d8
group 0--3
line.long 0 "HOST_EMUL_UADDRH"
bitfld.long 0 0.--3. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "HOST_EMUL_BK_EQL"
base ad:0xa00600dc
group 0--3
line.long 0 "HOST_EMUL_BK_EQL"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_BK_EQH"
base ad:0xa00600e0
group 0--3
line.long 0 "HOST_EMUL_BK_EQH"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_BK_COMBI"
base ad:0xa00600e4
group 0--3
line.long 0 "HOST_EMUL_BK_COMBI"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "HOST_EMUL_SCANREG"
base ad:0xa00600f0
group 0--3
line.long 0 "HOST_EMUL_SCANREG"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_BREAKCOUNTL"
base ad:0xa00600f4
group 0--3
line.long 0 "HOST_EMUL_BREAKCOUNTL"
hexfld.byte 0 " value "
;tree.end

;tree "HOST_EMUL_BREAKCOUNTH"
base ad:0xa00600f8
group 0--3
line.long 0 "HOST_EMUL_BREAKCOUNTH"
hexfld.byte 0 " value "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "HAMACI_MMDSP"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
if (((data.long(ad:0x8015700c)&0x1100)!=0x1100)||((data.long(ad:0x8015741c)&0x28000)!=0x28000)||((data.long(ad:0x801571ec)&0x600)!=0x600)||((data.long(ad:0x80157428)&0x300)!=0x0))
base ad:0x0
hgroup 0--3
TEXTLINE "HAMACI_MMDSP is not acessible. Please activate its clock or release its reset"
else
;tree "DMA0_CTRL"
base ad:0xa023a800
group 0--3
line.long 0 "DMA0_CTRL"
bitfld.long 0 0.--12. " value "  " "
;tree.end

;tree "DMA0_INT_BASE"
base ad:0xa023a804
group 0--3
line.long 0 "DMA0_INT_BASE"
hexfld.word 0 " value "
;tree.end

;tree "DMA0_INT_LENGTH"
base ad:0xa023a808
group 0--3
line.long 0 "DMA0_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA0_EXT_BASEH"
base ad:0xa023a80c
group 0--3
line.long 0 "DMA0_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

;tree "DMA0_EXT_BASEL"
base ad:0xa023a810
group 0--3
line.long 0 "DMA0_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

;tree "DMA0_COUNT"
base ad:0xa023a814
rgroup 0--3
line.long 0 "DMA0_COUNT"
hexfld.word 0 " value "
;tree.end

;tree "DMA0_EXT_LENGTH"
base ad:0xa023a818
group 0--3
line.long 0 "DMA0_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA_IT_STATUS"
base ad:0xa023a81c
rgroup 0--3
line.long 0 "DMA_IT_STATUS"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DMA1_CTRL"
base ad:0xa023a820
group 0--3
line.long 0 "DMA1_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

;tree "DMA1_INT_BASE"
base ad:0xa023a824
group 0--3
line.long 0 "DMA1_INT_BASE"
hexfld.word 0 " value "
;tree.end

;tree "DMA1_INT_LENGTH"
base ad:0xa023a828
group 0--3
line.long 0 "DMA1_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA1_EXT_BASEH"
base ad:0xa023a82c
group 0--3
line.long 0 "DMA1_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

;tree "DMA1_EXT_BASEL"
base ad:0xa023a830
group 0--3
line.long 0 "DMA1_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

;tree "DMA1_COUNT"
base ad:0xa023a834
rgroup 0--3
line.long 0 "DMA1_COUNT"
hexfld.word 0 " value "
;tree.end

;tree "DMA1_EXT_LENGTH"
base ad:0xa023a838
group 0--3
line.long 0 "DMA1_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_CTRL"
base ad:0xa023a840
group 0--3
line.long 0 "DMA2_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

;tree "DMA2_INT_BASE"
base ad:0xa023a844
group 0--3
line.long 0 "DMA2_INT_BASE"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_INT_LENGTH"
base ad:0xa023a848
group 0--3
line.long 0 "DMA2_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_EXT_BASEH"
base ad:0xa023a84c
group 0--3
line.long 0 "DMA2_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

;tree "DMA2_EXT_BASEL"
base ad:0xa023a850
group 0--3
line.long 0 "DMA2_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_COUNT"
base ad:0xa023a854
rgroup 0--3
line.long 0 "DMA2_COUNT"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_EXT_LENGTH"
base ad:0xa023a858
group 0--3
line.long 0 "DMA2_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_CTRL"
base ad:0xa023a860
group 0--3
line.long 0 "DMA3_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

;tree "DMA3_INT_BASE"
base ad:0xa023a864
group 0--3
line.long 0 "DMA3_INT_BASE"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_INT_LENGTH"
base ad:0xa023a868
group 0--3
line.long 0 "DMA3_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_EXT_BASEH"
base ad:0xa023a86c
group 0--3
line.long 0 "DMA3_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

;tree "DMA3_EXT_BASEL"
base ad:0xa023a870
group 0--3
line.long 0 "DMA3_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_COUNT"
base ad:0xa023a874
rgroup 0--3
line.long 0 "DMA3_COUNT"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_EXT_LENGTH"
base ad:0xa023a878
group 0--3
line.long 0 "DMA3_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_mode"
base ad:0xa023b014
group 0--3
line.long 0 "Dcache_mode"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "Dcache_control"
base ad:0xa023b018
group 0--3
line.long 0 "Dcache_control"
bitfld.long 0 0.--4. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "Dcache_way"
base ad:0xa023b01c
group 0--3
line.long 0 "Dcache_way"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "Dcache_line"
base ad:0xa023b020
group 0--3
line.long 0 "Dcache_line"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "Dcache_command"
base ad:0xa023b024
wgroup 0--3
line.long 0 "Dcache_command"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "Dcache_status"
base ad:0xa023b028
rgroup 0--3
line.long 0 "Dcache_status"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "Dcache_cptrl1l"
base ad:0xa023b02c
rgroup 0--3
line.long 0 "Dcache_cptrl1l"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl1h"
base ad:0xa023b030
rgroup 0--3
line.long 0 "Dcache_cptrl1h"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl2l"
base ad:0xa023b034
rgroup 0--3
line.long 0 "Dcache_cptrl2l"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl2h"
base ad:0xa023b038
rgroup 0--3
line.long 0 "Dcache_cptrl2h"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl3l"
base ad:0xa023b03c
rgroup 0--3
line.long 0 "Dcache_cptrl3l"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl3h"
base ad:0xa023b040
rgroup 0--3
line.long 0 "Dcache_cptrl3h"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrsel"
base ad:0xa023b044
group 0--3
line.long 0 "Dcache_cptrsel"
bitfld.long 0 0.--11. " value "  " "
;tree.end

;tree "IO_BIT0"
base ad:0xa023c000
group 0--3
line.long 0 "IO_BIT0"
bitfld.long 0 0. " IO_bit0 "  "0 ,1 "
;tree.end

;tree "IO_BIT1"
base ad:0xa023c008
group 0--3
line.long 0 "IO_BIT1"
bitfld.long 0 0. " IO_bit1 "  "0 ,1 "
;tree.end

;tree "IO_BIT2"
base ad:0xa023c010
group 0--3
line.long 0 "IO_BIT2"
bitfld.long 0 0. " IO_bit2 "  "0 ,1 "
;tree.end

;tree "IO_BIT3"
base ad:0xa023c018
group 0--3
line.long 0 "IO_BIT3"
bitfld.long 0 0. " IO_bit3 "  "0 ,1 "
;tree.end

;tree "IO_BIT4"
base ad:0xa023c020
group 0--3
line.long 0 "IO_BIT4"
bitfld.long 0 0. " IO_bit4 "  "0 ,1 "
;tree.end

;tree "IO_BIT5"
base ad:0xa023c028
group 0--3
line.long 0 "IO_BIT5"
bitfld.long 0 0. " IO_bit5 "  "0 ,1 "
;tree.end

;tree "IO_BIT6"
base ad:0xa023c030
group 0--3
line.long 0 "IO_BIT6"
bitfld.long 0 0. " IO_bit6 "  "0 ,1 "
;tree.end

;tree "IO_BIT7"
base ad:0xa023c038
group 0--3
line.long 0 "IO_BIT7"
bitfld.long 0 0. " IO_bit7 "  "0 ,1 "
;tree.end

;tree "IO_BIT8"
base ad:0xa023c040
group 0--3
line.long 0 "IO_BIT8"
bitfld.long 0 0. " IO_bit8 "  "0 ,1 "
;tree.end

;tree "IO_BIT9"
base ad:0xa023c048
group 0--3
line.long 0 "IO_BIT9"
bitfld.long 0 0. " IO_bit9 "  "0 ,1 "
;tree.end

;tree "IO_BITA"
base ad:0xa023c050
group 0--3
line.long 0 "IO_BITA"
bitfld.long 0 0. " IO_bitA "  "0 ,1 "
;tree.end

;tree "IO_BITB"
base ad:0xa023c058
group 0--3
line.long 0 "IO_BITB"
bitfld.long 0 0. " IO_bitB "  "0 ,1 "
;tree.end

;tree "IO_BITC"
base ad:0xa023c060
group 0--3
line.long 0 "IO_BITC"
bitfld.long 0 0. " IO_bitC "  "0 ,1 "
;tree.end

;tree "IO_BITD"
base ad:0xa023c068
group 0--3
line.long 0 "IO_BITD"
bitfld.long 0 0. " IO_bitD "  "0 ,1 "
;tree.end

;tree "IO_BITE"
base ad:0xa023c070
group 0--3
line.long 0 "IO_BITE"
bitfld.long 0 0. " IO_bitE "  "0 ,1 "
;tree.end

;tree "IO_BITF"
base ad:0xa023c078
group 0--3
line.long 0 "IO_BITF"
bitfld.long 0 0. " IO_bitF "  "0 ,1 "
;tree.end

;tree "IO_LSB"
base ad:0xa023c080
group 0--3
line.long 0 "IO_LSB"
bitfld.long 0 0. " IO_lsb "  "0 ,1 "
;tree.end

;tree "IO_MSB"
base ad:0xa023c088
group 0--3
line.long 0 "IO_MSB"
bitfld.long 0 0. " IO_msb "  "0 ,1 "
;tree.end

;tree "IO_ALL"
base ad:0xa023c090
group 0--3
line.long 0 "IO_ALL"
bitfld.long 0 0. " IO_all "  "0 ,1 "
;tree.end

;tree "IO_EN"
base ad:0xa023c098
group 0--3
line.long 0 "IO_EN"
bitfld.long 0 0. " IO_en "  "0 ,1 "
;tree.end

;tree "TIMER_MOD0_MSB"
base ad:0xa023c0c0
group 0--3
line.long 0 "TIMER_MOD0_MSB"
hexfld.byte 0 " value "
;tree.end

;tree "TIMER_MOD0_LSB"
base ad:0xa023c0c8
group 0--3
line.long 0 "TIMER_MOD0_LSB"
hexfld.word 0 " value "
;tree.end

;tree "TIMER_MOD1_MSB"
base ad:0xa023c0d0
group 0--3
line.long 0 "TIMER_MOD1_MSB"
hexfld.byte 0 " value "
;tree.end

;tree "TIMER_MOD1_LSB"
base ad:0xa023c0d8
group 0--3
line.long 0 "TIMER_MOD1_LSB"
hexfld.word 0 " value "
;tree.end

;tree "TIMER_MOD2_MSB"
base ad:0xa023c0e0
group 0--3
line.long 0 "TIMER_MOD2_MSB"
hexfld.byte 0 " value "
;tree.end

;tree "TIMER_MOD2_LSB"
base ad:0xa023c0e8
group 0--3
line.long 0 "TIMER_MOD2_LSB"
hexfld.word 0 " value "
;tree.end

;tree "SEM0"
base ad:0xa023c820
group 0--3
line.long 0 "SEM0"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM1"
base ad:0xa023c828
group 0--3
line.long 0 "SEM1"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM2"
base ad:0xa023c830
group 0--3
line.long 0 "SEM2"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM3"
base ad:0xa023c838
group 0--3
line.long 0 "SEM3"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM4"
base ad:0xa023c840
group 0--3
line.long 0 "SEM4"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM5"
base ad:0xa023c848
group 0--3
line.long 0 "SEM5"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM6"
base ad:0xa023c850
group 0--3
line.long 0 "SEM6"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM7"
base ad:0xa023c858
group 0--3
line.long 0 "SEM7"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "HAMACI_IPEN"
base ad:0xa023c8a0
group 0--3
line.long 0 "HAMACI_IPEN"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "HAMACI_ITIP_0"
base ad:0xa023c8a8
group 0--3
line.long 0 "HAMACI_ITIP_0"
hexfld.word 0 " value "
;tree.end

;tree "HAMACI_ITIP_1"
base ad:0xa023c8ac
group 0--3
line.long 0 "HAMACI_ITIP_1"
hexfld.word 0 " value "
;tree.end

;tree "HAMACI_ITIP_2"
base ad:0xa023c8b0
group 0--3
line.long 0 "HAMACI_ITIP_2"
hexfld.word 0 " value "
;tree.end

;tree "HAMACI_ITIP_3"
base ad:0xa023c8b4
group 0--3
line.long 0 "HAMACI_ITIP_3"
bitfld.long 0 0. " ITEXT11 "  "0 ,1 "
bitfld.long 0 1. " ITEXT12 "  "0 ,1 "
bitfld.long 0 2. " XDMA_LBREQ0 "  "0 ,1 "
bitfld.long 0 3. " XDMA_LBREQ1 "  "0 ,1 "
bitfld.long 0 4. " XDMA_LBREQ2 "  "0 ,1 "
bitfld.long 0 5. " XDMA_LBREQ3 "  "0 ,1 "
bitfld.long 0 6. " XDMA_LSREQ0 "  "0 ,1 "
bitfld.long 0 7. " XDMA_LSREQ1 "  "0 ,1 "
bitfld.long 0 8. " XDMA_LSREQ2 "  "0 ,1 "
bitfld.long 0 9. " XDMA_LSREQ3 "  "0 ,1 "
bitfld.long 0 10. " XDMA_BREQ0 "  "0 ,1 "
bitfld.long 0 11. " XDMA_BREQ1 "  "0 ,1 "
bitfld.long 0 12. " XDMA_BREQ2 "  "0 ,1 "
bitfld.long 0 13. " XDMA_BREQ3 "  "0 ,1 "
bitfld.long 0 14. " XDMA_SREQ0 "  "0 ,1 "
bitfld.long 0 15. " XDMA_SREQ1 "  "0 ,1 "
;tree.end

;tree "HAMACI_ITIP_4"
base ad:0xa023c914
group 0--3
line.long 0 "HAMACI_ITIP_4"
bitfld.long 0 0. " XDMA_SREQ2 "  "0 ,1 "
bitfld.long 0 1. " XDMA_SREQ3 "  "0 ,1 "
;tree.end

;tree "HAMACI_ITOP0"
base ad:0xa023c8b8
group 0--3
line.long 0 "HAMACI_ITOP0"
hexfld.word 0 " value "
;tree.end

;tree "HAMACI_ITOP1"
base ad:0xa023c8bc
group 0--3
line.long 0 "HAMACI_ITOP1"
hexfld.word 0 " value "
;tree.end

;tree "HAMACI_ITOP2"
base ad:0xa023c8c0
group 0--3
line.long 0 "HAMACI_ITOP2"
hexfld.word 0 " value "
;tree.end

;tree "HAMACI_ITOP3"
base ad:0xa023c8c4
group 0--3
line.long 0 "HAMACI_ITOP3"
hexfld.word 0 " value "
;tree.end

;tree "HAMACI_ITOP4"
base ad:0xa023c918
group 0--3
line.long 0 "HAMACI_ITOP4"
bitfld.long 0 0.--13. " value "  " "
;tree.end

;tree "ID0"
base ad:0xa023cfc0
rgroup 0--3
line.long 0 "ID0"
hexfld.byte 0 " value "
;tree.end

;tree "ID1"
base ad:0xa023cfc8
rgroup 0--3
line.long 0 "ID1"
hexfld.byte 0 " value "
;tree.end

;tree "ID2"
base ad:0xa023cfd0
rgroup 0--3
line.long 0 "ID2"
hexfld.byte 0 " value "
;tree.end

;tree "ID3"
base ad:0xa023cfd8
rgroup 0--3
line.long 0 "ID3"
hexfld.byte 0 " value "
;tree.end

;tree "IDP0"
base ad:0xa023cfe0
rgroup 0--3
line.long 0 "IDP0"
hexfld.byte 0 " value "
;tree.end

;tree "IDP1"
base ad:0xa023cfe8
rgroup 0--3
line.long 0 "IDP1"
hexfld.byte 0 " value "
;tree.end

;tree "IDP2"
base ad:0xa023cff0
rgroup 0--3
line.long 0 "IDP2"
hexfld.byte 0 " value "
;tree.end

;tree "IDP3"
base ad:0xa023cff8
rgroup 0--3
line.long 0 "IDP3"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA0_SREQ"
base ad:0xa023d000
group 0--3
line.long 0 "ARM_DMA0_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA0_BREQ"
base ad:0xa023d004
group 0--3
line.long 0 "ARM_DMA0_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA0_LSREQ"
base ad:0xa023d008
group 0--3
line.long 0 "ARM_DMA0_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA0_LBREQ"
base ad:0xa023d00c
group 0--3
line.long 0 "ARM_DMA0_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA0_MASKIT"
base ad:0xa023d010
group 0--3
line.long 0 "ARM_DMA0_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA0_IT"
base ad:0xa023d014
rgroup 0--3
line.long 0 "ARM_DMA0_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA0_AUTO"
base ad:0xa023d018
group 0--3
line.long 0 "ARM_DMA0_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA0_LAUTO"
base ad:0xa023d01c
group 0--3
line.long 0 "ARM_DMA0_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA1_SREQ"
base ad:0xa023d040
group 0--3
line.long 0 "ARM_DMA1_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA1_BREQ"
base ad:0xa023d044
group 0--3
line.long 0 "ARM_DMA1_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA1_LSREQ"
base ad:0xa023d048
group 0--3
line.long 0 "ARM_DMA1_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA1_LBREQ"
base ad:0xa023d04c
group 0--3
line.long 0 "ARM_DMA1_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA1_MASKIT"
base ad:0xa023d050
group 0--3
line.long 0 "ARM_DMA1_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA1_IT"
base ad:0xa023d054
rgroup 0--3
line.long 0 "ARM_DMA1_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA1_AUTO"
base ad:0xa023d058
group 0--3
line.long 0 "ARM_DMA1_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA1_LAUTO"
base ad:0xa023d05c
group 0--3
line.long 0 "ARM_DMA1_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA2_SREQ"
base ad:0xa023d080
group 0--3
line.long 0 "ARM_DMA2_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA2_BREQ"
base ad:0xa023d084
group 0--3
line.long 0 "ARM_DMA2_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA2_LSREQ"
base ad:0xa023d088
group 0--3
line.long 0 "ARM_DMA2_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA2_LBREQ"
base ad:0xa023d08c
group 0--3
line.long 0 "ARM_DMA2_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA2_MASKIT"
base ad:0xa023d090
group 0--3
line.long 0 "ARM_DMA2_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA2_IT"
base ad:0xa023d094
rgroup 0--3
line.long 0 "ARM_DMA2_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA2_AUTO"
base ad:0xa023d098
group 0--3
line.long 0 "ARM_DMA2_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA2_LAUTO"
base ad:0xa023d09c
group 0--3
line.long 0 "ARM_DMA2_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA3_SREQ"
base ad:0xa023d0c0
group 0--3
line.long 0 "ARM_DMA3_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA3_BREQ"
base ad:0xa023d0c4
group 0--3
line.long 0 "ARM_DMA3_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA3_LSREQ"
base ad:0xa023d0c8
group 0--3
line.long 0 "ARM_DMA3_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA3_LBREQ"
base ad:0xa023d0cc
group 0--3
line.long 0 "ARM_DMA3_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA3_MASKIT"
base ad:0xa023d0d0
group 0--3
line.long 0 "ARM_DMA3_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA3_IT"
base ad:0xa023d0d4
rgroup 0--3
line.long 0 "ARM_DMA3_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA3_AUTO"
base ad:0xa023d0d8
group 0--3
line.long 0 "ARM_DMA3_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA3_LAUTO"
base ad:0xa023d0dc
group 0--3
line.long 0 "ARM_DMA3_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA4_SREQ"
base ad:0xa023d100
group 0--3
line.long 0 "ARM_DMA4_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA4_BREQ"
base ad:0xa023d104
group 0--3
line.long 0 "ARM_DMA4_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA4_LSREQ"
base ad:0xa023d108
group 0--3
line.long 0 "ARM_DMA4_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA4_LBREQ"
base ad:0xa023d10c
group 0--3
line.long 0 "ARM_DMA4_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA4_MASKIT"
base ad:0xa023d110
group 0--3
line.long 0 "ARM_DMA4_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA4_IT"
base ad:0xa023d114
rgroup 0--3
line.long 0 "ARM_DMA4_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA4_AUTO"
base ad:0xa023d118
group 0--3
line.long 0 "ARM_DMA4_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA4_LAUTO"
base ad:0xa023d11c
group 0--3
line.long 0 "ARM_DMA4_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA5_SREQ"
base ad:0xa023d140
group 0--3
line.long 0 "ARM_DMA5_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA5_BREQ"
base ad:0xa023d144
group 0--3
line.long 0 "ARM_DMA5_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA5_LSREQ"
base ad:0xa023d148
group 0--3
line.long 0 "ARM_DMA5_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA5_LBREQ"
base ad:0xa023d14c
group 0--3
line.long 0 "ARM_DMA5_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA5_MASKIT"
base ad:0xa023d150
group 0--3
line.long 0 "ARM_DMA5_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA5_IT"
base ad:0xa023d154
rgroup 0--3
line.long 0 "ARM_DMA5_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA5_AUTO"
base ad:0xa023d158
group 0--3
line.long 0 "ARM_DMA5_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA5_LAUTO"
base ad:0xa023d15c
group 0--3
line.long 0 "ARM_DMA5_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA6_SREQ"
base ad:0xa023d180
group 0--3
line.long 0 "ARM_DMA6_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA6_BREQ"
base ad:0xa023d184
group 0--3
line.long 0 "ARM_DMA6_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA6_LSREQ"
base ad:0xa023d188
group 0--3
line.long 0 "ARM_DMA6_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA6_LBREQ"
base ad:0xa023d18c
group 0--3
line.long 0 "ARM_DMA6_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA6_MASKIT"
base ad:0xa023d190
group 0--3
line.long 0 "ARM_DMA6_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA6_IT"
base ad:0xa023d194
rgroup 0--3
line.long 0 "ARM_DMA6_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA6_AUTO"
base ad:0xa023d198
group 0--3
line.long 0 "ARM_DMA6_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA6_LAUTO"
base ad:0xa023d19c
group 0--3
line.long 0 "ARM_DMA6_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA7_SREQ"
base ad:0xa023d1c0
group 0--3
line.long 0 "ARM_DMA7_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA7_BREQ"
base ad:0xa023d1c4
group 0--3
line.long 0 "ARM_DMA7_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA7_LSREQ"
base ad:0xa023d1c8
group 0--3
line.long 0 "ARM_DMA7_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA7_LBREQ"
base ad:0xa023d1cc
group 0--3
line.long 0 "ARM_DMA7_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA7_MASKIT"
base ad:0xa023d1d0
group 0--3
line.long 0 "ARM_DMA7_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA7_IT"
base ad:0xa023d1d4
rgroup 0--3
line.long 0 "ARM_DMA7_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA7_AUTO"
base ad:0xa023d1d8
group 0--3
line.long 0 "ARM_DMA7_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA7_LAUTO"
base ad:0xa023d1dc
group 0--3
line.long 0 "ARM_DMA7_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "EMU_UNIT_MASKIT"
base ad:0xa023d800
group 0--3
line.long 0 "EMU_UNIT_MASKIT"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "CONFIG_DATA_MEM"
base ad:0xa023d820
group 0--3
line.long 0 "CONFIG_DATA_MEM"
bitfld.long 0 0.--13. " value "  " "
;tree.end

;tree "COMPATIBILITY_REGISTER"
base ad:0xa023d828
group 0--3
line.long 0 "COMPATIBILITY_REGISTER"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "AHB_IF_CONFIG"
base ad:0xa023e000
group 0--3
line.long 0 "AHB_IF_CONFIG"
bitfld.long 0 0.--3. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "AHB_IF_MODE"
base ad:0xa023e004
group 0--3
line.long 0 "AHB_IF_MODE"
bitfld.long 0 0.--3. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "AHB_IF_STATUS"
base ad:0xa023e008
rgroup 0--3
line.long 0 "AHB_IF_STATUS"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "AHB_IF_SECURITY"
base ad:0xa023e00c
group 0--3
line.long 0 "AHB_IF_SECURITY"
bitfld.long 0 0.--4. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "ITREMAP_REG0"
base ad:0xa023f800
group 0--3
line.long 0 "ITREMAP_REG0"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG1"
base ad:0xa023f808
group 0--3
line.long 0 "ITREMAP_REG1"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG2"
base ad:0xa023f810
group 0--3
line.long 0 "ITREMAP_REG2"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG3"
base ad:0xa023f818
group 0--3
line.long 0 "ITREMAP_REG3"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG4"
base ad:0xa023f820
group 0--3
line.long 0 "ITREMAP_REG4"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG5"
base ad:0xa023f828
group 0--3
line.long 0 "ITREMAP_REG5"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG6"
base ad:0xa023f830
group 0--3
line.long 0 "ITREMAP_REG6"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG7"
base ad:0xa023f838
group 0--3
line.long 0 "ITREMAP_REG7"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG8"
base ad:0xa023f840
group 0--3
line.long 0 "ITREMAP_REG8"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG9"
base ad:0xa023f848
group 0--3
line.long 0 "ITREMAP_REG9"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG10"
base ad:0xa023f850
group 0--3
line.long 0 "ITREMAP_REG10"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG11"
base ad:0xa023f858
group 0--3
line.long 0 "ITREMAP_REG11"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG12"
base ad:0xa023f860
group 0--3
line.long 0 "ITREMAP_REG12"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG13"
base ad:0xa023f868
group 0--3
line.long 0 "ITREMAP_REG13"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG14"
base ad:0xa023f870
group 0--3
line.long 0 "ITREMAP_REG14"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG15"
base ad:0xa023f878
group 0--3
line.long 0 "ITREMAP_REG15"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG16"
base ad:0xa023f880
group 0--3
line.long 0 "ITREMAP_REG16"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG17"
base ad:0xa023f888
group 0--3
line.long 0 "ITREMAP_REG17"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG18"
base ad:0xa023f890
group 0--3
line.long 0 "ITREMAP_REG18"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG19"
base ad:0xa023f898
group 0--3
line.long 0 "ITREMAP_REG19"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG20"
base ad:0xa023f8a0
group 0--3
line.long 0 "ITREMAP_REG20"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG21"
base ad:0xa023f8a8
group 0--3
line.long 0 "ITREMAP_REG21"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG22"
base ad:0xa023f8b0
group 0--3
line.long 0 "ITREMAP_REG22"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG23"
base ad:0xa023f8b8
group 0--3
line.long 0 "ITREMAP_REG23"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG24"
base ad:0xa023f8c0
group 0--3
line.long 0 "ITREMAP_REG24"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG25"
base ad:0xa023f8c8
group 0--3
line.long 0 "ITREMAP_REG25"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG26"
base ad:0xa023f8d0
group 0--3
line.long 0 "ITREMAP_REG26"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG27"
base ad:0xa023f8d8
group 0--3
line.long 0 "ITREMAP_REG27"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG28"
base ad:0xa023f8e0
group 0--3
line.long 0 "ITREMAP_REG28"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG29"
base ad:0xa023f8e8
group 0--3
line.long 0 "ITREMAP_REG29"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG30"
base ad:0xa023f8f0
group 0--3
line.long 0 "ITREMAP_REG30"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG31"
base ad:0xa023f8f8
group 0--3
line.long 0 "ITREMAP_REG31"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITMSK_L_REG"
base ad:0xa023f900
group 0--3
line.long 0 "ITMSK_L_REG"
hexfld.word 0 " value "
;tree.end

;tree "ITMSK_H_REG"
base ad:0xa023f908
group 0--3
line.long 0 "ITMSK_H_REG"
hexfld.word 0 " value "
;tree.end

;tree "ITMEMO_L_REG"
base ad:0xa023f938
group 0--3
line.long 0 "ITMEMO_L_REG"
hexfld.word 0 " value "
;tree.end

;tree "ITMEMO_H_REG"
base ad:0xa023f940
group 0--3
line.long 0 "ITMEMO_H_REG"
hexfld.word 0 " value "
;tree.end

;tree "ITREMAP1_REG0"
base ad:0xa023fa00
group 0--3
line.long 0 "ITREMAP1_REG0"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG1"
base ad:0xa023fa08
group 0--3
line.long 0 "ITREMAP1_REG1"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG2"
base ad:0xa023fa10
group 0--3
line.long 0 "ITREMAP1_REG2"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG3"
base ad:0xa023fa18
group 0--3
line.long 0 "ITREMAP1_REG3"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG4"
base ad:0xa023fa20
group 0--3
line.long 0 "ITREMAP1_REG4"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG5"
base ad:0xa023fa28
group 0--3
line.long 0 "ITREMAP1_REG5"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG6"
base ad:0xa023fa30
group 0--3
line.long 0 "ITREMAP1_REG6"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG7"
base ad:0xa023fa38
group 0--3
line.long 0 "ITREMAP1_REG7"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG8"
base ad:0xa023fa40
group 0--3
line.long 0 "ITREMAP1_REG8"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG9"
base ad:0xa023fa48
group 0--3
line.long 0 "ITREMAP1_REG9"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG10"
base ad:0xa023fa50
group 0--3
line.long 0 "ITREMAP1_REG10"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG11"
base ad:0xa023fa58
group 0--3
line.long 0 "ITREMAP1_REG11"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG12"
base ad:0xa023fa60
group 0--3
line.long 0 "ITREMAP1_REG12"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG13"
base ad:0xa023fa68
group 0--3
line.long 0 "ITREMAP1_REG13"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG14"
base ad:0xa023fa70
group 0--3
line.long 0 "ITREMAP1_REG14"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG15"
base ad:0xa023fa78
group 0--3
line.long 0 "ITREMAP1_REG15"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG16"
base ad:0xa023fa80
group 0--3
line.long 0 "ITREMAP1_REG16"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG17"
base ad:0xa023fa88
group 0--3
line.long 0 "ITREMAP1_REG17"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG18"
base ad:0xa023fa90
group 0--3
line.long 0 "ITREMAP1_REG18"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG19"
base ad:0xa023fa98
group 0--3
line.long 0 "ITREMAP1_REG19"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG20"
base ad:0xa023faa0
group 0--3
line.long 0 "ITREMAP1_REG20"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG21"
base ad:0xa023faa8
group 0--3
line.long 0 "ITREMAP1_REG21"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG22"
base ad:0xa023fab0
group 0--3
line.long 0 "ITREMAP1_REG22"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG23"
base ad:0xa023fab8
group 0--3
line.long 0 "ITREMAP1_REG23"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG24"
base ad:0xa023fac0
group 0--3
line.long 0 "ITREMAP1_REG24"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG25"
base ad:0xa023fac8
group 0--3
line.long 0 "ITREMAP1_REG25"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG26"
base ad:0xa023fad0
group 0--3
line.long 0 "ITREMAP1_REG26"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG27"
base ad:0xa023fad8
group 0--3
line.long 0 "ITREMAP1_REG27"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG28"
base ad:0xa023fae0
group 0--3
line.long 0 "ITREMAP1_REG28"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG29"
base ad:0xa023fae8
group 0--3
line.long 0 "ITREMAP1_REG29"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG30"
base ad:0xa023faf0
group 0--3
line.long 0 "ITREMAP1_REG30"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG31"
base ad:0xa023faf8
group 0--3
line.long 0 "ITREMAP1_REG31"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

endif
tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "HAMACV_MMDSP"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
if (((data.long(ad:0x80157008)&0x1100)!=0x1100)||((data.long(ad:0x8015741c)&0x1400)!=0x1400)||((data.long(ad:0x801571ec)&0x30)!=0x30)||((data.long(ad:0x80157428)&0xC0)!=0x0))
base ad:0x0
hgroup 0--3
TEXTLINE "HAMACV_MMDSP is not acessible. Please activate its clock or release its reset"
else
;tree "DMA0_CTRL"
base ad:0xa013a800
group 0--3
line.long 0 "DMA0_CTRL"
bitfld.long 0 0.--12. " value "  " "
;tree.end

;tree "DMA0_INT_BASE"
base ad:0xa013a804
group 0--3
line.long 0 "DMA0_INT_BASE"
hexfld.word 0 " value "
;tree.end

;tree "DMA0_INT_LENGTH"
base ad:0xa013a808
group 0--3
line.long 0 "DMA0_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA0_EXT_BASEH"
base ad:0xa013a80c
group 0--3
line.long 0 "DMA0_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

;tree "DMA0_EXT_BASEL"
base ad:0xa013a810
group 0--3
line.long 0 "DMA0_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

;tree "DMA0_COUNT"
base ad:0xa013a814
rgroup 0--3
line.long 0 "DMA0_COUNT"
hexfld.word 0 " value "
;tree.end

;tree "DMA0_EXT_LENGTH"
base ad:0xa013a818
group 0--3
line.long 0 "DMA0_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA_IT_STATUS"
base ad:0xa013a81c
rgroup 0--3
line.long 0 "DMA_IT_STATUS"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "DMA1_CTRL"
base ad:0xa013a820
group 0--3
line.long 0 "DMA1_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

;tree "DMA1_INT_BASE"
base ad:0xa013a824
group 0--3
line.long 0 "DMA1_INT_BASE"
hexfld.word 0 " value "
;tree.end

;tree "DMA1_INT_LENGTH"
base ad:0xa013a828
group 0--3
line.long 0 "DMA1_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA1_EXT_BASEH"
base ad:0xa013a82c
group 0--3
line.long 0 "DMA1_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

;tree "DMA1_EXT_BASEL"
base ad:0xa013a830
group 0--3
line.long 0 "DMA1_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

;tree "DMA1_COUNT"
base ad:0xa013a834
rgroup 0--3
line.long 0 "DMA1_COUNT"
hexfld.word 0 " value "
;tree.end

;tree "DMA1_EXT_LENGTH"
base ad:0xa013a838
group 0--3
line.long 0 "DMA1_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_CTRL"
base ad:0xa013a840
group 0--3
line.long 0 "DMA2_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

;tree "DMA2_INT_BASE"
base ad:0xa013a844
group 0--3
line.long 0 "DMA2_INT_BASE"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_INT_LENGTH"
base ad:0xa013a848
group 0--3
line.long 0 "DMA2_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_EXT_BASEH"
base ad:0xa013a84c
group 0--3
line.long 0 "DMA2_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

;tree "DMA2_EXT_BASEL"
base ad:0xa013a850
group 0--3
line.long 0 "DMA2_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_COUNT"
base ad:0xa013a854
rgroup 0--3
line.long 0 "DMA2_COUNT"
hexfld.word 0 " value "
;tree.end

;tree "DMA2_EXT_LENGTH"
base ad:0xa013a858
group 0--3
line.long 0 "DMA2_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_CTRL"
base ad:0xa013a860
group 0--3
line.long 0 "DMA3_CTRL"
bitfld.long 0 0.--10. " value "  " "
;tree.end

;tree "DMA3_INT_BASE"
base ad:0xa013a864
group 0--3
line.long 0 "DMA3_INT_BASE"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_INT_LENGTH"
base ad:0xa013a868
group 0--3
line.long 0 "DMA3_INT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_EXT_BASEH"
base ad:0xa013a86c
group 0--3
line.long 0 "DMA3_EXT_BASEH"
hexfld.byte 0 " value "
;tree.end

;tree "DMA3_EXT_BASEL"
base ad:0xa013a870
group 0--3
line.long 0 "DMA3_EXT_BASEL"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_COUNT"
base ad:0xa013a874
rgroup 0--3
line.long 0 "DMA3_COUNT"
hexfld.word 0 " value "
;tree.end

;tree "DMA3_EXT_LENGTH"
base ad:0xa013a878
group 0--3
line.long 0 "DMA3_EXT_LENGTH"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_mode"
base ad:0xa013b014
group 0--3
line.long 0 "Dcache_mode"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "Dcache_control"
base ad:0xa013b018
group 0--3
line.long 0 "Dcache_control"
bitfld.long 0 0.--4. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "Dcache_way"
base ad:0xa013b01c
group 0--3
line.long 0 "Dcache_way"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "Dcache_line"
base ad:0xa013b020
group 0--3
line.long 0 "Dcache_line"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "Dcache_command"
base ad:0xa013b024
wgroup 0--3
line.long 0 "Dcache_command"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "Dcache_status"
base ad:0xa013b028
rgroup 0--3
line.long 0 "Dcache_status"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "Dcache_cptrl1l"
base ad:0xa013b02c
rgroup 0--3
line.long 0 "Dcache_cptrl1l"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl1h"
base ad:0xa013b030
rgroup 0--3
line.long 0 "Dcache_cptrl1h"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl2l"
base ad:0xa013b034
rgroup 0--3
line.long 0 "Dcache_cptrl2l"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl2h"
base ad:0xa013b038
rgroup 0--3
line.long 0 "Dcache_cptrl2h"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl3l"
base ad:0xa013b03c
rgroup 0--3
line.long 0 "Dcache_cptrl3l"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrl3h"
base ad:0xa013b040
rgroup 0--3
line.long 0 "Dcache_cptrl3h"
hexfld.word 0 " value "
;tree.end

;tree "Dcache_cptrsel"
base ad:0xa013b044
group 0--3
line.long 0 "Dcache_cptrsel"
bitfld.long 0 0.--11. " value "  " "
;tree.end

;tree "IO_BIT0"
base ad:0xa013c000
group 0--3
line.long 0 "IO_BIT0"
bitfld.long 0 0. " IO_bit0 "  "0 ,1 "
;tree.end

;tree "IO_BIT1"
base ad:0xa013c008
group 0--3
line.long 0 "IO_BIT1"
bitfld.long 0 0. " IO_bit1 "  "0 ,1 "
;tree.end

;tree "IO_BIT2"
base ad:0xa013c010
group 0--3
line.long 0 "IO_BIT2"
bitfld.long 0 0. " IO_bit2 "  "0 ,1 "
;tree.end

;tree "IO_BIT3"
base ad:0xa013c018
group 0--3
line.long 0 "IO_BIT3"
bitfld.long 0 0. " IO_bit3 "  "0 ,1 "
;tree.end

;tree "IO_BIT4"
base ad:0xa013c020
group 0--3
line.long 0 "IO_BIT4"
bitfld.long 0 0. " IO_bit4 "  "0 ,1 "
;tree.end

;tree "IO_BIT5"
base ad:0xa013c028
group 0--3
line.long 0 "IO_BIT5"
bitfld.long 0 0. " IO_bit5 "  "0 ,1 "
;tree.end

;tree "IO_BIT6"
base ad:0xa013c030
group 0--3
line.long 0 "IO_BIT6"
bitfld.long 0 0. " IO_bit6 "  "0 ,1 "
;tree.end

;tree "IO_BIT7"
base ad:0xa013c038
group 0--3
line.long 0 "IO_BIT7"
bitfld.long 0 0. " IO_bit7 "  "0 ,1 "
;tree.end

;tree "IO_BIT8"
base ad:0xa013c040
group 0--3
line.long 0 "IO_BIT8"
bitfld.long 0 0. " IO_bit8 "  "0 ,1 "
;tree.end

;tree "IO_BIT9"
base ad:0xa013c048
group 0--3
line.long 0 "IO_BIT9"
bitfld.long 0 0. " IO_bit9 "  "0 ,1 "
;tree.end

;tree "IO_BITA"
base ad:0xa013c050
group 0--3
line.long 0 "IO_BITA"
bitfld.long 0 0. " IO_bitA "  "0 ,1 "
;tree.end

;tree "IO_BITB"
base ad:0xa013c058
group 0--3
line.long 0 "IO_BITB"
bitfld.long 0 0. " IO_bitB "  "0 ,1 "
;tree.end

;tree "IO_BITC"
base ad:0xa013c060
group 0--3
line.long 0 "IO_BITC"
bitfld.long 0 0. " IO_bitC "  "0 ,1 "
;tree.end

;tree "IO_BITD"
base ad:0xa013c068
group 0--3
line.long 0 "IO_BITD"
bitfld.long 0 0. " IO_bitD "  "0 ,1 "
;tree.end

;tree "IO_BITE"
base ad:0xa013c070
group 0--3
line.long 0 "IO_BITE"
bitfld.long 0 0. " IO_bitE "  "0 ,1 "
;tree.end

;tree "IO_BITF"
base ad:0xa013c078
group 0--3
line.long 0 "IO_BITF"
bitfld.long 0 0. " IO_bitF "  "0 ,1 "
;tree.end

;tree "IO_LSB"
base ad:0xa013c080
group 0--3
line.long 0 "IO_LSB"
bitfld.long 0 0. " IO_lsb "  "0 ,1 "
;tree.end

;tree "IO_MSB"
base ad:0xa013c088
group 0--3
line.long 0 "IO_MSB"
bitfld.long 0 0. " IO_msb "  "0 ,1 "
;tree.end

;tree "IO_ALL"
base ad:0xa013c090
group 0--3
line.long 0 "IO_ALL"
bitfld.long 0 0. " IO_all "  "0 ,1 "
;tree.end

;tree "IO_EN"
base ad:0xa013c098
group 0--3
line.long 0 "IO_EN"
bitfld.long 0 0. " IO_en "  "0 ,1 "
;tree.end

;tree "TIMER_MOD0_MSB"
base ad:0xa013c0c0
group 0--3
line.long 0 "TIMER_MOD0_MSB"
hexfld.byte 0 " value "
;tree.end

;tree "TIMER_MOD0_LSB"
base ad:0xa013c0c8
group 0--3
line.long 0 "TIMER_MOD0_LSB"
hexfld.word 0 " value "
;tree.end

;tree "TIMER_MOD1_MSB"
base ad:0xa013c0d0
group 0--3
line.long 0 "TIMER_MOD1_MSB"
hexfld.byte 0 " value "
;tree.end

;tree "TIMER_MOD1_LSB"
base ad:0xa013c0d8
group 0--3
line.long 0 "TIMER_MOD1_LSB"
hexfld.word 0 " value "
;tree.end

;tree "TIMER_MOD2_MSB"
base ad:0xa013c0e0
group 0--3
line.long 0 "TIMER_MOD2_MSB"
hexfld.byte 0 " value "
;tree.end

;tree "TIMER_MOD2_LSB"
base ad:0xa013c0e8
group 0--3
line.long 0 "TIMER_MOD2_LSB"
hexfld.word 0 " value "
;tree.end

;tree "SEM0"
base ad:0xa013c820
group 0--3
line.long 0 "SEM0"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM1"
base ad:0xa013c828
group 0--3
line.long 0 "SEM1"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM2"
base ad:0xa013c830
group 0--3
line.long 0 "SEM2"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM3"
base ad:0xa013c838
group 0--3
line.long 0 "SEM3"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM4"
base ad:0xa013c840
group 0--3
line.long 0 "SEM4"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM5"
base ad:0xa013c848
group 0--3
line.long 0 "SEM5"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM6"
base ad:0xa013c850
group 0--3
line.long 0 "SEM6"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "SEM7"
base ad:0xa013c858
group 0--3
line.long 0 "SEM7"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "HAMACV_IPEN"
base ad:0xa013c8a0
group 0--3
line.long 0 "HAMACV_IPEN"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "HAMACV_ITIP_0"
base ad:0xa013c8a8
group 0--3
line.long 0 "HAMACV_ITIP_0"
hexfld.word 0 " value "
;tree.end

;tree "HAMACV_ITIP_1"
base ad:0xa013c8ac
group 0--3
line.long 0 "HAMACV_ITIP_1"
hexfld.word 0 " value "
;tree.end

;tree "HAMACV_ITIP_2"
base ad:0xa013c8b0
group 0--3
line.long 0 "HAMACV_ITIP_2"
hexfld.word 0 " value "
;tree.end

;tree "HAMACV_ITIP_3"
base ad:0xa013c8b4
group 0--3
line.long 0 "HAMACV_ITIP_3"
bitfld.long 0 0. " ITEXT11 "  "0 ,1 "
bitfld.long 0 1. " ITEXT12 "  "0 ,1 "
bitfld.long 0 2. " XDMA_LBREQ0 "  "0 ,1 "
bitfld.long 0 3. " XDMA_LBREQ1 "  "0 ,1 "
bitfld.long 0 4. " XDMA_LBREQ2 "  "0 ,1 "
bitfld.long 0 5. " XDMA_LBREQ3 "  "0 ,1 "
bitfld.long 0 6. " XDMA_LSREQ0 "  "0 ,1 "
bitfld.long 0 7. " XDMA_LSREQ1 "  "0 ,1 "
bitfld.long 0 8. " XDMA_LSREQ2 "  "0 ,1 "
bitfld.long 0 9. " XDMA_LSREQ3 "  "0 ,1 "
bitfld.long 0 10. " XDMA_BREQ0 "  "0 ,1 "
bitfld.long 0 11. " XDMA_BREQ1 "  "0 ,1 "
bitfld.long 0 12. " XDMA_BREQ2 "  "0 ,1 "
bitfld.long 0 13. " XDMA_BREQ3 "  "0 ,1 "
bitfld.long 0 14. " XDMA_SREQ0 "  "0 ,1 "
bitfld.long 0 15. " XDMA_SREQ1 "  "0 ,1 "
;tree.end

;tree "HAMACV_ITIP_4"
base ad:0xa013c914
group 0--3
line.long 0 "HAMACV_ITIP_4"
bitfld.long 0 0. " XDMA_SREQ2 "  "0 ,1 "
bitfld.long 0 1. " XDMA_SREQ3 "  "0 ,1 "
;tree.end

;tree "HAMACV_ITOP0"
base ad:0xa013c8b8
group 0--3
line.long 0 "HAMACV_ITOP0"
hexfld.word 0 " value "
;tree.end

;tree "HAMACV_ITOP1"
base ad:0xa013c8bc
group 0--3
line.long 0 "HAMACV_ITOP1"
hexfld.word 0 " value "
;tree.end

;tree "HAMACV_ITOP2"
base ad:0xa013c8c0
group 0--3
line.long 0 "HAMACV_ITOP2"
hexfld.word 0 " value "
;tree.end

;tree "HAMACV_ITOP3"
base ad:0xa013c8c4
group 0--3
line.long 0 "HAMACV_ITOP3"
hexfld.word 0 " value "
;tree.end

;tree "HAMACV_ITOP4"
base ad:0xa013c918
group 0--3
line.long 0 "HAMACV_ITOP4"
bitfld.long 0 0.--13. " value "  " "
;tree.end

;tree "ID0"
base ad:0xa013cfc0
rgroup 0--3
line.long 0 "ID0"
hexfld.byte 0 " value "
;tree.end

;tree "ID1"
base ad:0xa013cfc8
rgroup 0--3
line.long 0 "ID1"
hexfld.byte 0 " value "
;tree.end

;tree "ID2"
base ad:0xa013cfd0
rgroup 0--3
line.long 0 "ID2"
hexfld.byte 0 " value "
;tree.end

;tree "ID3"
base ad:0xa013cfd8
rgroup 0--3
line.long 0 "ID3"
hexfld.byte 0 " value "
;tree.end

;tree "IDP0"
base ad:0xa013cfe0
rgroup 0--3
line.long 0 "IDP0"
hexfld.byte 0 " value "
;tree.end

;tree "IDP1"
base ad:0xa013cfe8
rgroup 0--3
line.long 0 "IDP1"
hexfld.byte 0 " value "
;tree.end

;tree "IDP2"
base ad:0xa013cff0
rgroup 0--3
line.long 0 "IDP2"
hexfld.byte 0 " value "
;tree.end

;tree "IDP3"
base ad:0xa013cff8
rgroup 0--3
line.long 0 "IDP3"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA0_SREQ"
base ad:0xa013d000
group 0--3
line.long 0 "ARM_DMA0_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA0_BREQ"
base ad:0xa013d004
group 0--3
line.long 0 "ARM_DMA0_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA0_LSREQ"
base ad:0xa013d008
group 0--3
line.long 0 "ARM_DMA0_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA0_LBREQ"
base ad:0xa013d00c
group 0--3
line.long 0 "ARM_DMA0_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA0_MASKIT"
base ad:0xa013d010
group 0--3
line.long 0 "ARM_DMA0_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA0_IT"
base ad:0xa013d014
rgroup 0--3
line.long 0 "ARM_DMA0_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA0_AUTO"
base ad:0xa013d018
group 0--3
line.long 0 "ARM_DMA0_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA0_LAUTO"
base ad:0xa013d01c
group 0--3
line.long 0 "ARM_DMA0_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA1_SREQ"
base ad:0xa013d040
group 0--3
line.long 0 "ARM_DMA1_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA1_BREQ"
base ad:0xa013d044
group 0--3
line.long 0 "ARM_DMA1_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA1_LSREQ"
base ad:0xa013d048
group 0--3
line.long 0 "ARM_DMA1_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA1_LBREQ"
base ad:0xa013d04c
group 0--3
line.long 0 "ARM_DMA1_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA1_MASKIT"
base ad:0xa013d050
group 0--3
line.long 0 "ARM_DMA1_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA1_IT"
base ad:0xa013d054
rgroup 0--3
line.long 0 "ARM_DMA1_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA1_AUTO"
base ad:0xa013d058
group 0--3
line.long 0 "ARM_DMA1_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA1_LAUTO"
base ad:0xa013d05c
group 0--3
line.long 0 "ARM_DMA1_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA2_SREQ"
base ad:0xa013d080
group 0--3
line.long 0 "ARM_DMA2_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA2_BREQ"
base ad:0xa013d084
group 0--3
line.long 0 "ARM_DMA2_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA2_LSREQ"
base ad:0xa013d088
group 0--3
line.long 0 "ARM_DMA2_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA2_LBREQ"
base ad:0xa013d08c
group 0--3
line.long 0 "ARM_DMA2_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA2_MASKIT"
base ad:0xa013d090
group 0--3
line.long 0 "ARM_DMA2_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA2_IT"
base ad:0xa013d094
rgroup 0--3
line.long 0 "ARM_DMA2_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA2_AUTO"
base ad:0xa013d098
group 0--3
line.long 0 "ARM_DMA2_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA2_LAUTO"
base ad:0xa013d09c
group 0--3
line.long 0 "ARM_DMA2_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA3_SREQ"
base ad:0xa013d0c0
group 0--3
line.long 0 "ARM_DMA3_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA3_BREQ"
base ad:0xa013d0c4
group 0--3
line.long 0 "ARM_DMA3_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA3_LSREQ"
base ad:0xa013d0c8
group 0--3
line.long 0 "ARM_DMA3_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA3_LBREQ"
base ad:0xa013d0cc
group 0--3
line.long 0 "ARM_DMA3_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA3_MASKIT"
base ad:0xa013d0d0
group 0--3
line.long 0 "ARM_DMA3_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA3_IT"
base ad:0xa013d0d4
rgroup 0--3
line.long 0 "ARM_DMA3_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA3_AUTO"
base ad:0xa013d0d8
group 0--3
line.long 0 "ARM_DMA3_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA3_LAUTO"
base ad:0xa013d0dc
group 0--3
line.long 0 "ARM_DMA3_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA4_SREQ"
base ad:0xa013d100
group 0--3
line.long 0 "ARM_DMA4_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA4_BREQ"
base ad:0xa013d104
group 0--3
line.long 0 "ARM_DMA4_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA4_LSREQ"
base ad:0xa013d108
group 0--3
line.long 0 "ARM_DMA4_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA4_LBREQ"
base ad:0xa013d10c
group 0--3
line.long 0 "ARM_DMA4_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA4_MASKIT"
base ad:0xa013d110
group 0--3
line.long 0 "ARM_DMA4_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA4_IT"
base ad:0xa013d114
rgroup 0--3
line.long 0 "ARM_DMA4_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA4_AUTO"
base ad:0xa013d118
group 0--3
line.long 0 "ARM_DMA4_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA4_LAUTO"
base ad:0xa013d11c
group 0--3
line.long 0 "ARM_DMA4_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA5_SREQ"
base ad:0xa013d140
group 0--3
line.long 0 "ARM_DMA5_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA5_BREQ"
base ad:0xa013d144
group 0--3
line.long 0 "ARM_DMA5_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA5_LSREQ"
base ad:0xa013d148
group 0--3
line.long 0 "ARM_DMA5_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA5_LBREQ"
base ad:0xa013d14c
group 0--3
line.long 0 "ARM_DMA5_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA5_MASKIT"
base ad:0xa013d150
group 0--3
line.long 0 "ARM_DMA5_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA5_IT"
base ad:0xa013d154
rgroup 0--3
line.long 0 "ARM_DMA5_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA5_AUTO"
base ad:0xa013d158
group 0--3
line.long 0 "ARM_DMA5_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA5_LAUTO"
base ad:0xa013d15c
group 0--3
line.long 0 "ARM_DMA5_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA6_SREQ"
base ad:0xa013d180
group 0--3
line.long 0 "ARM_DMA6_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA6_BREQ"
base ad:0xa013d184
group 0--3
line.long 0 "ARM_DMA6_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA6_LSREQ"
base ad:0xa013d188
group 0--3
line.long 0 "ARM_DMA6_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA6_LBREQ"
base ad:0xa013d18c
group 0--3
line.long 0 "ARM_DMA6_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA6_MASKIT"
base ad:0xa013d190
group 0--3
line.long 0 "ARM_DMA6_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA6_IT"
base ad:0xa013d194
rgroup 0--3
line.long 0 "ARM_DMA6_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA6_AUTO"
base ad:0xa013d198
group 0--3
line.long 0 "ARM_DMA6_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA6_LAUTO"
base ad:0xa013d19c
group 0--3
line.long 0 "ARM_DMA6_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "ARM_DMA7_SREQ"
base ad:0xa013d1c0
group 0--3
line.long 0 "ARM_DMA7_SREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA7_BREQ"
base ad:0xa013d1c4
group 0--3
line.long 0 "ARM_DMA7_BREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA7_LSREQ"
base ad:0xa013d1c8
group 0--3
line.long 0 "ARM_DMA7_LSREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA7_LBREQ"
base ad:0xa013d1cc
group 0--3
line.long 0 "ARM_DMA7_LBREQ"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "ARM_DMA7_MASKIT"
base ad:0xa013d1d0
group 0--3
line.long 0 "ARM_DMA7_MASKIT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA7_IT"
base ad:0xa013d1d4
rgroup 0--3
line.long 0 "ARM_DMA7_IT"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "ARM_DMA7_AUTO"
base ad:0xa013d1d8
group 0--3
line.long 0 "ARM_DMA7_AUTO"
hexfld.byte 0 " value "
;tree.end

;tree "ARM_DMA7_LAUTO"
base ad:0xa013d1dc
group 0--3
line.long 0 "ARM_DMA7_LAUTO"
hexfld.word 0 " value "
;tree.end

;tree "EMU_UNIT_MASKIT"
base ad:0xa013d800
group 0--3
line.long 0 "EMU_UNIT_MASKIT"
bitfld.long 0 0. " value "  "0 ,1 "
;tree.end

;tree "CONFIG_DATA_MEM"
base ad:0xa013d820
group 0--3
line.long 0 "CONFIG_DATA_MEM"
bitfld.long 0 0.--13. " value "  " "
;tree.end

;tree "COMPATIBILITY_REGISTER"
base ad:0xa013d828
group 0--3
line.long 0 "COMPATIBILITY_REGISTER"
bitfld.long 0 0.--1. " value "  "0 ,1 ,2 ,3 "
;tree.end

;tree "AHB_IF_CONFIG"
base ad:0xa013e000
group 0--3
line.long 0 "AHB_IF_CONFIG"
bitfld.long 0 0.--3. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "AHB_IF_MODE"
base ad:0xa013e004
group 0--3
line.long 0 "AHB_IF_MODE"
bitfld.long 0 0.--3. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "AHB_IF_STATUS"
base ad:0xa013e008
rgroup 0--3
line.long 0 "AHB_IF_STATUS"
bitfld.long 0 0.--2. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "AHB_IF_SECURITY"
base ad:0xa013e00c
group 0--3
line.long 0 "AHB_IF_SECURITY"
bitfld.long 0 0.--4. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "ITREMAP_REG0"
base ad:0xa013f800
group 0--3
line.long 0 "ITREMAP_REG0"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG1"
base ad:0xa013f808
group 0--3
line.long 0 "ITREMAP_REG1"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG2"
base ad:0xa013f810
group 0--3
line.long 0 "ITREMAP_REG2"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG3"
base ad:0xa013f818
group 0--3
line.long 0 "ITREMAP_REG3"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG4"
base ad:0xa013f820
group 0--3
line.long 0 "ITREMAP_REG4"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG5"
base ad:0xa013f828
group 0--3
line.long 0 "ITREMAP_REG5"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG6"
base ad:0xa013f830
group 0--3
line.long 0 "ITREMAP_REG6"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG7"
base ad:0xa013f838
group 0--3
line.long 0 "ITREMAP_REG7"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG8"
base ad:0xa013f840
group 0--3
line.long 0 "ITREMAP_REG8"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG9"
base ad:0xa013f848
group 0--3
line.long 0 "ITREMAP_REG9"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG10"
base ad:0xa013f850
group 0--3
line.long 0 "ITREMAP_REG10"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG11"
base ad:0xa013f858
group 0--3
line.long 0 "ITREMAP_REG11"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG12"
base ad:0xa013f860
group 0--3
line.long 0 "ITREMAP_REG12"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG13"
base ad:0xa013f868
group 0--3
line.long 0 "ITREMAP_REG13"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG14"
base ad:0xa013f870
group 0--3
line.long 0 "ITREMAP_REG14"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG15"
base ad:0xa013f878
group 0--3
line.long 0 "ITREMAP_REG15"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG16"
base ad:0xa013f880
group 0--3
line.long 0 "ITREMAP_REG16"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG17"
base ad:0xa013f888
group 0--3
line.long 0 "ITREMAP_REG17"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG18"
base ad:0xa013f890
group 0--3
line.long 0 "ITREMAP_REG18"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG19"
base ad:0xa013f898
group 0--3
line.long 0 "ITREMAP_REG19"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG20"
base ad:0xa013f8a0
group 0--3
line.long 0 "ITREMAP_REG20"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG21"
base ad:0xa013f8a8
group 0--3
line.long 0 "ITREMAP_REG21"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG22"
base ad:0xa013f8b0
group 0--3
line.long 0 "ITREMAP_REG22"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG23"
base ad:0xa013f8b8
group 0--3
line.long 0 "ITREMAP_REG23"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG24"
base ad:0xa013f8c0
group 0--3
line.long 0 "ITREMAP_REG24"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG25"
base ad:0xa013f8c8
group 0--3
line.long 0 "ITREMAP_REG25"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG26"
base ad:0xa013f8d0
group 0--3
line.long 0 "ITREMAP_REG26"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG27"
base ad:0xa013f8d8
group 0--3
line.long 0 "ITREMAP_REG27"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG28"
base ad:0xa013f8e0
group 0--3
line.long 0 "ITREMAP_REG28"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG29"
base ad:0xa013f8e8
group 0--3
line.long 0 "ITREMAP_REG29"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG30"
base ad:0xa013f8f0
group 0--3
line.long 0 "ITREMAP_REG30"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP_REG31"
base ad:0xa013f8f8
group 0--3
line.long 0 "ITREMAP_REG31"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITMSK_L_REG"
base ad:0xa013f900
group 0--3
line.long 0 "ITMSK_L_REG"
hexfld.word 0 " value "
;tree.end

;tree "ITMSK_H_REG"
base ad:0xa013f908
group 0--3
line.long 0 "ITMSK_H_REG"
hexfld.word 0 " value "
;tree.end

;tree "ITMEMO_L_REG"
base ad:0xa013f938
group 0--3
line.long 0 "ITMEMO_L_REG"
hexfld.word 0 " value "
;tree.end

;tree "ITMEMO_H_REG"
base ad:0xa013f940
group 0--3
line.long 0 "ITMEMO_H_REG"
hexfld.word 0 " value "
;tree.end

;tree "ITREMAP1_REG0"
base ad:0xa013fa00
group 0--3
line.long 0 "ITREMAP1_REG0"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG1"
base ad:0xa013fa08
group 0--3
line.long 0 "ITREMAP1_REG1"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG2"
base ad:0xa013fa10
group 0--3
line.long 0 "ITREMAP1_REG2"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG3"
base ad:0xa013fa18
group 0--3
line.long 0 "ITREMAP1_REG3"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG4"
base ad:0xa013fa20
group 0--3
line.long 0 "ITREMAP1_REG4"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG5"
base ad:0xa013fa28
group 0--3
line.long 0 "ITREMAP1_REG5"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG6"
base ad:0xa013fa30
group 0--3
line.long 0 "ITREMAP1_REG6"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG7"
base ad:0xa013fa38
group 0--3
line.long 0 "ITREMAP1_REG7"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG8"
base ad:0xa013fa40
group 0--3
line.long 0 "ITREMAP1_REG8"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG9"
base ad:0xa013fa48
group 0--3
line.long 0 "ITREMAP1_REG9"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG10"
base ad:0xa013fa50
group 0--3
line.long 0 "ITREMAP1_REG10"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG11"
base ad:0xa013fa58
group 0--3
line.long 0 "ITREMAP1_REG11"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG12"
base ad:0xa013fa60
group 0--3
line.long 0 "ITREMAP1_REG12"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG13"
base ad:0xa013fa68
group 0--3
line.long 0 "ITREMAP1_REG13"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG14"
base ad:0xa013fa70
group 0--3
line.long 0 "ITREMAP1_REG14"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG15"
base ad:0xa013fa78
group 0--3
line.long 0 "ITREMAP1_REG15"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG16"
base ad:0xa013fa80
group 0--3
line.long 0 "ITREMAP1_REG16"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG17"
base ad:0xa013fa88
group 0--3
line.long 0 "ITREMAP1_REG17"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG18"
base ad:0xa013fa90
group 0--3
line.long 0 "ITREMAP1_REG18"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG19"
base ad:0xa013fa98
group 0--3
line.long 0 "ITREMAP1_REG19"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG20"
base ad:0xa013faa0
group 0--3
line.long 0 "ITREMAP1_REG20"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG21"
base ad:0xa013faa8
group 0--3
line.long 0 "ITREMAP1_REG21"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG22"
base ad:0xa013fab0
group 0--3
line.long 0 "ITREMAP1_REG22"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG23"
base ad:0xa013fab8
group 0--3
line.long 0 "ITREMAP1_REG23"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG24"
base ad:0xa013fac0
group 0--3
line.long 0 "ITREMAP1_REG24"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG25"
base ad:0xa013fac8
group 0--3
line.long 0 "ITREMAP1_REG25"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG26"
base ad:0xa013fad0
group 0--3
line.long 0 "ITREMAP1_REG26"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG27"
base ad:0xa013fad8
group 0--3
line.long 0 "ITREMAP1_REG27"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG28"
base ad:0xa013fae0
group 0--3
line.long 0 "ITREMAP1_REG28"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG29"
base ad:0xa013fae8
group 0--3
line.long 0 "ITREMAP1_REG29"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG30"
base ad:0xa013faf0
group 0--3
line.long 0 "ITREMAP1_REG30"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ITREMAP1_REG31"
base ad:0xa013faf8
group 0--3
line.long 0 "ITREMAP1_REG31"
bitfld.long 0 0.--5. " value "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

endif
tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "HASH (2 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "HASH-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0CR"
base ad:0xa03c1000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SECn "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " INIT "  "0 ,1 "
bitfld.long 0 3. " DMAE "  "0 ,1 "
bitfld.long 0 4.--5. " DATAFORM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " MODE "  "0 ,1 "
bitfld.long 0 7. " ALGO "  "0 ,1 "
bitfld.long 0 8.--11. " NBW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " DINF "  "0 ,1 "
bitfld.long 0 16. " LKEY "  "0 ,1 "
;tree.end

;tree "0DIN"
base ad:0xa03c1004
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
;tree.end

;tree "0STR"
base ad:0xa03c1008
group 0--3
line.long 0 "STR"
bitfld.long 0 0.--4. " NBLW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " DCAL "  "0 ,1 "
;tree.end

;tree "0H0"
base ad:0xa03c100c
group 0--3
line.long 0 "H0"
hexfld.long 0 " H0 "
;tree.end

;tree "0H1"
base ad:0xa03c1010
group 0--3
line.long 0 "H1"
hexfld.long 0 " H1 "
;tree.end

;tree "0H2"
base ad:0xa03c1014
group 0--3
line.long 0 "H2"
hexfld.long 0 " H2 "
;tree.end

;tree "0H3"
base ad:0xa03c1018
group 0--3
line.long 0 "H3"
hexfld.long 0 " H3 "
;tree.end

;tree "0H4"
base ad:0xa03c101c
group 0--3
line.long 0 "H4"
hexfld.long 0 " H4 "
;tree.end

;tree "0H5"
base ad:0xa03c1020
group 0--3
line.long 0 "H5"
hexfld.long 0 " H5 "
;tree.end

;tree "0H6"
base ad:0xa03c1024
group 0--3
line.long 0 "H6"
hexfld.long 0 " H6 "
;tree.end

;tree "0H7"
base ad:0xa03c1028
group 0--3
line.long 0 "H7"
hexfld.long 0 " H7 "
;tree.end

;tree "0CSR0"
base ad:0xa03c1100
group 0--3
line.long 0 "CSR0"
hexfld.long 0 " W0 "
;tree.end

;tree "0CSR1"
base ad:0xa03c1104
group 0--3
line.long 0 "CSR1"
hexfld.long 0 " W1 "
;tree.end

;tree "0CSR2"
base ad:0xa03c1108
group 0--3
line.long 0 "CSR2"
hexfld.long 0 " W2 "
;tree.end

;tree "0CSR3"
base ad:0xa03c110c
group 0--3
line.long 0 "CSR3"
hexfld.long 0 " W3 "
;tree.end

;tree "0CSR4"
base ad:0xa03c1110
group 0--3
line.long 0 "CSR4"
hexfld.long 0 " W4 "
;tree.end

;tree "0CSR5"
base ad:0xa03c1114
group 0--3
line.long 0 "CSR5"
hexfld.long 0 " W5 "
;tree.end

;tree "0CSR6"
base ad:0xa03c1118
group 0--3
line.long 0 "CSR6"
hexfld.long 0 " W6 "
;tree.end

;tree "0CSR7"
base ad:0xa03c111c
group 0--3
line.long 0 "CSR7"
hexfld.long 0 " W7 "
;tree.end

;tree "0CSR8"
base ad:0xa03c1120
group 0--3
line.long 0 "CSR8"
hexfld.long 0 " W8 "
;tree.end

;tree "0CSR9"
base ad:0xa03c1124
group 0--3
line.long 0 "CSR9"
hexfld.long 0 " W9 "
;tree.end

;tree "0CSR10"
base ad:0xa03c1128
group 0--3
line.long 0 "CSR10"
hexfld.long 0 " W10 "
;tree.end

;tree "0CSR11"
base ad:0xa03c112c
group 0--3
line.long 0 "CSR11"
hexfld.long 0 " W11 "
;tree.end

;tree "0CSR12"
base ad:0xa03c1130
group 0--3
line.long 0 "CSR12"
hexfld.long 0 " W12 "
;tree.end

;tree "0CSR13"
base ad:0xa03c1134
group 0--3
line.long 0 "CSR13"
hexfld.long 0 " W13 "
;tree.end

;tree "0CSR14"
base ad:0xa03c1138
group 0--3
line.long 0 "CSR14"
hexfld.long 0 " W14 "
;tree.end

;tree "0CSR15"
base ad:0xa03c113c
group 0--3
line.long 0 "CSR15"
hexfld.long 0 " W15 "
;tree.end

;tree "0CSR16"
base ad:0xa03c1140
group 0--3
line.long 0 "CSR16"
hexfld.long 0 " W16 "
;tree.end

;tree "0CSR17"
base ad:0xa03c1144
group 0--3
line.long 0 "CSR17"
hexfld.long 0 " W17 "
;tree.end

;tree "0CSR18"
base ad:0xa03c1148
group 0--3
line.long 0 "CSR18"
hexfld.long 0 " W18 "
;tree.end

;tree "0CSR19"
base ad:0xa03c114c
group 0--3
line.long 0 "CSR19"
hexfld.long 0 " W19 "
;tree.end

;tree "0CSR20"
base ad:0xa03c1150
group 0--3
line.long 0 "CSR20"
hexfld.long 0 " W20 "
;tree.end

;tree "0CSR21"
base ad:0xa03c1154
group 0--3
line.long 0 "CSR21"
hexfld.long 0 " W21 "
;tree.end

;tree "0CSR22"
base ad:0xa03c1158
group 0--3
line.long 0 "CSR22"
hexfld.long 0 " W22 "
;tree.end

;tree "0CSR23"
base ad:0xa03c115c
group 0--3
line.long 0 "CSR23"
hexfld.long 0 " W23 "
;tree.end

;tree "0CSR24"
base ad:0xa03c1160
group 0--3
line.long 0 "CSR24"
hexfld.long 0 " W24 "
;tree.end

;tree "0CSR25"
base ad:0xa03c1164
group 0--3
line.long 0 "CSR25"
hexfld.long 0 " W25 "
;tree.end

;tree "0CSR26"
base ad:0xa03c1168
group 0--3
line.long 0 "CSR26"
hexfld.long 0 " W26 "
;tree.end

;tree "0CSR27"
base ad:0xa03c116c
group 0--3
line.long 0 "CSR27"
hexfld.long 0 " W27 "
;tree.end

;tree "0CSR28"
base ad:0xa03c1170
group 0--3
line.long 0 "CSR28"
hexfld.long 0 " W28 "
;tree.end

;tree "0CSR29"
base ad:0xa03c1174
group 0--3
line.long 0 "CSR29"
hexfld.long 0 " W29 "
;tree.end

;tree "0CSR30"
base ad:0xa03c1178
group 0--3
line.long 0 "CSR30"
hexfld.long 0 " W30 "
;tree.end

;tree "0CSR31"
base ad:0xa03c117c
group 0--3
line.long 0 "CSR31"
hexfld.long 0 " W31 "
;tree.end

;tree "0CSR32"
base ad:0xa03c1180
group 0--3
line.long 0 "CSR32"
hexfld.long 0 " W32 "
;tree.end

;tree "0CSR33"
base ad:0xa03c1184
group 0--3
line.long 0 "CSR33"
hexfld.long 0 " W33 "
;tree.end

;tree "0CSR34"
base ad:0xa03c1188
group 0--3
line.long 0 "CSR34"
hexfld.long 0 " W34 "
;tree.end

;tree "0CSR35"
base ad:0xa03c118c
group 0--3
line.long 0 "CSR35"
hexfld.long 0 " W35 "
;tree.end

;tree "0CSR36"
base ad:0xa03c1190
group 0--3
line.long 0 "CSR36"
hexfld.long 0 " W36 "
;tree.end

;tree "0CSR37"
base ad:0xa03c1194
group 0--3
line.long 0 "CSR37"
hexfld.long 0 " W37 "
;tree.end

;tree "0CSR38"
base ad:0xa03c1198
group 0--3
line.long 0 "CSR38"
hexfld.long 0 " W38 "
;tree.end

;tree "0CSR39"
base ad:0xa03c119c
group 0--3
line.long 0 "CSR39"
hexfld.long 0 " W39 "
;tree.end

;tree "0CSR40"
base ad:0xa03c11a0
group 0--3
line.long 0 "CSR40"
hexfld.long 0 " W40 "
;tree.end

;tree "0CSR41"
base ad:0xa03c11a4
group 0--3
line.long 0 "CSR41"
hexfld.long 0 " W41 "
;tree.end

;tree "0CSR42"
base ad:0xa03c11a8
group 0--3
line.long 0 "CSR42"
hexfld.long 0 " W42 "
;tree.end

;tree "0CSR43"
base ad:0xa03c11ac
group 0--3
line.long 0 "CSR43"
hexfld.long 0 " W43 "
;tree.end

;tree "0CSR44"
base ad:0xa03c11b0
group 0--3
line.long 0 "CSR44"
hexfld.long 0 " W44 "
;tree.end

;tree "0CSR45"
base ad:0xa03c11b4
group 0--3
line.long 0 "CSR45"
hexfld.long 0 " W45 "
;tree.end

;tree "0CSR46"
base ad:0xa03c11b8
group 0--3
line.long 0 "CSR46"
hexfld.long 0 " W46 "
;tree.end

;tree "0CSR47"
base ad:0xa03c11bc
group 0--3
line.long 0 "CSR47"
hexfld.long 0 " W47 "
;tree.end

;tree "0CSR48"
base ad:0xa03c11c0
group 0--3
line.long 0 "CSR48"
hexfld.long 0 " W48 "
;tree.end

;tree "0CSR49"
base ad:0xa03c11c4
group 0--3
line.long 0 "CSR49"
hexfld.long 0 " W49 "
;tree.end

;tree "0CSR50"
base ad:0xa03c11c8
group 0--3
line.long 0 "CSR50"
hexfld.long 0 " W50 "
;tree.end

;tree "0CSR51"
base ad:0xa03c11cc
group 0--3
line.long 0 "CSR51"
hexfld.long 0 " W51 "
;tree.end

;tree "0CSFULL"
base ad:0xa03c10f8
group 0--3
line.long 0 "CSFULL"
hexfld.long 0 " W40 "
;tree.end

;tree "0CSDATAIN"
base ad:0xa03c10fc
group 0--3
line.long 0 "CSDATAIN"
hexfld.long 0 " W41 "
;tree.end

;tree "0ITCR"
base ad:0xa03c1080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "0ITIP"
base ad:0xa03c1084
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR "  "0 ,1 "
bitfld.long 0 1. " DMATC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
;tree.end

;tree "0ITOP"
base ad:0xa03c1088
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMABREQ "  "0 ,1 "
;tree.end

;tree "0PeriphID0"
base ad:0xa03c1fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "0PeriphID1"
base ad:0xa03c1fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID2"
base ad:0xa03c1fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID3"
base ad:0xa03c1fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "0PCellID0"
base ad:0xa03c1ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

;tree "0PCellID1"
base ad:0xa03c1ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

;tree "0PCellID2"
base ad:0xa03c1ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

;tree "0PCellID3"
base ad:0xa03c1ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "HASH-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1CR"
base ad:0xa03c2000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SECn "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " INIT "  "0 ,1 "
bitfld.long 0 3. " DMAE "  "0 ,1 "
bitfld.long 0 4.--5. " DATAFORM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " MODE "  "0 ,1 "
bitfld.long 0 7. " ALGO "  "0 ,1 "
bitfld.long 0 8.--11. " NBW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " DINF "  "0 ,1 "
bitfld.long 0 16. " LKEY "  "0 ,1 "
;tree.end

;tree "1DIN"
base ad:0xa03c2004
group 0--3
line.long 0 "DIN"
hexfld.long 0 " DATA "
;tree.end

;tree "1STR"
base ad:0xa03c2008
group 0--3
line.long 0 "STR"
bitfld.long 0 0.--4. " NBLW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " DCAL "  "0 ,1 "
;tree.end

;tree "1H0"
base ad:0xa03c200c
group 0--3
line.long 0 "H0"
hexfld.long 0 " H0 "
;tree.end

;tree "1H1"
base ad:0xa03c2010
group 0--3
line.long 0 "H1"
hexfld.long 0 " H1 "
;tree.end

;tree "1H2"
base ad:0xa03c2014
group 0--3
line.long 0 "H2"
hexfld.long 0 " H2 "
;tree.end

;tree "1H3"
base ad:0xa03c2018
group 0--3
line.long 0 "H3"
hexfld.long 0 " H3 "
;tree.end

;tree "1H4"
base ad:0xa03c201c
group 0--3
line.long 0 "H4"
hexfld.long 0 " H4 "
;tree.end

;tree "1H5"
base ad:0xa03c2020
group 0--3
line.long 0 "H5"
hexfld.long 0 " H5 "
;tree.end

;tree "1H6"
base ad:0xa03c2024
group 0--3
line.long 0 "H6"
hexfld.long 0 " H6 "
;tree.end

;tree "1H7"
base ad:0xa03c2028
group 0--3
line.long 0 "H7"
hexfld.long 0 " H7 "
;tree.end

;tree "1CSR0"
base ad:0xa03c2100
group 0--3
line.long 0 "CSR0"
hexfld.long 0 " W0 "
;tree.end

;tree "1CSR1"
base ad:0xa03c2104
group 0--3
line.long 0 "CSR1"
hexfld.long 0 " W1 "
;tree.end

;tree "1CSR2"
base ad:0xa03c2108
group 0--3
line.long 0 "CSR2"
hexfld.long 0 " W2 "
;tree.end

;tree "1CSR3"
base ad:0xa03c210c
group 0--3
line.long 0 "CSR3"
hexfld.long 0 " W3 "
;tree.end

;tree "1CSR4"
base ad:0xa03c2110
group 0--3
line.long 0 "CSR4"
hexfld.long 0 " W4 "
;tree.end

;tree "1CSR5"
base ad:0xa03c2114
group 0--3
line.long 0 "CSR5"
hexfld.long 0 " W5 "
;tree.end

;tree "1CSR6"
base ad:0xa03c2118
group 0--3
line.long 0 "CSR6"
hexfld.long 0 " W6 "
;tree.end

;tree "1CSR7"
base ad:0xa03c211c
group 0--3
line.long 0 "CSR7"
hexfld.long 0 " W7 "
;tree.end

;tree "1CSR8"
base ad:0xa03c2120
group 0--3
line.long 0 "CSR8"
hexfld.long 0 " W8 "
;tree.end

;tree "1CSR9"
base ad:0xa03c2124
group 0--3
line.long 0 "CSR9"
hexfld.long 0 " W9 "
;tree.end

;tree "1CSR10"
base ad:0xa03c2128
group 0--3
line.long 0 "CSR10"
hexfld.long 0 " W10 "
;tree.end

;tree "1CSR11"
base ad:0xa03c212c
group 0--3
line.long 0 "CSR11"
hexfld.long 0 " W11 "
;tree.end

;tree "1CSR12"
base ad:0xa03c2130
group 0--3
line.long 0 "CSR12"
hexfld.long 0 " W12 "
;tree.end

;tree "1CSR13"
base ad:0xa03c2134
group 0--3
line.long 0 "CSR13"
hexfld.long 0 " W13 "
;tree.end

;tree "1CSR14"
base ad:0xa03c2138
group 0--3
line.long 0 "CSR14"
hexfld.long 0 " W14 "
;tree.end

;tree "1CSR15"
base ad:0xa03c213c
group 0--3
line.long 0 "CSR15"
hexfld.long 0 " W15 "
;tree.end

;tree "1CSR16"
base ad:0xa03c2140
group 0--3
line.long 0 "CSR16"
hexfld.long 0 " W16 "
;tree.end

;tree "1CSR17"
base ad:0xa03c2144
group 0--3
line.long 0 "CSR17"
hexfld.long 0 " W17 "
;tree.end

;tree "1CSR18"
base ad:0xa03c2148
group 0--3
line.long 0 "CSR18"
hexfld.long 0 " W18 "
;tree.end

;tree "1CSR19"
base ad:0xa03c214c
group 0--3
line.long 0 "CSR19"
hexfld.long 0 " W19 "
;tree.end

;tree "1CSR20"
base ad:0xa03c2150
group 0--3
line.long 0 "CSR20"
hexfld.long 0 " W20 "
;tree.end

;tree "1CSR21"
base ad:0xa03c2154
group 0--3
line.long 0 "CSR21"
hexfld.long 0 " W21 "
;tree.end

;tree "1CSR22"
base ad:0xa03c2158
group 0--3
line.long 0 "CSR22"
hexfld.long 0 " W22 "
;tree.end

;tree "1CSR23"
base ad:0xa03c215c
group 0--3
line.long 0 "CSR23"
hexfld.long 0 " W23 "
;tree.end

;tree "1CSR24"
base ad:0xa03c2160
group 0--3
line.long 0 "CSR24"
hexfld.long 0 " W24 "
;tree.end

;tree "1CSR25"
base ad:0xa03c2164
group 0--3
line.long 0 "CSR25"
hexfld.long 0 " W25 "
;tree.end

;tree "1CSR26"
base ad:0xa03c2168
group 0--3
line.long 0 "CSR26"
hexfld.long 0 " W26 "
;tree.end

;tree "1CSR27"
base ad:0xa03c216c
group 0--3
line.long 0 "CSR27"
hexfld.long 0 " W27 "
;tree.end

;tree "1CSR28"
base ad:0xa03c2170
group 0--3
line.long 0 "CSR28"
hexfld.long 0 " W28 "
;tree.end

;tree "1CSR29"
base ad:0xa03c2174
group 0--3
line.long 0 "CSR29"
hexfld.long 0 " W29 "
;tree.end

;tree "1CSR30"
base ad:0xa03c2178
group 0--3
line.long 0 "CSR30"
hexfld.long 0 " W30 "
;tree.end

;tree "1CSR31"
base ad:0xa03c217c
group 0--3
line.long 0 "CSR31"
hexfld.long 0 " W31 "
;tree.end

;tree "1CSR32"
base ad:0xa03c2180
group 0--3
line.long 0 "CSR32"
hexfld.long 0 " W32 "
;tree.end

;tree "1CSR33"
base ad:0xa03c2184
group 0--3
line.long 0 "CSR33"
hexfld.long 0 " W33 "
;tree.end

;tree "1CSR34"
base ad:0xa03c2188
group 0--3
line.long 0 "CSR34"
hexfld.long 0 " W34 "
;tree.end

;tree "1CSR35"
base ad:0xa03c218c
group 0--3
line.long 0 "CSR35"
hexfld.long 0 " W35 "
;tree.end

;tree "1CSR36"
base ad:0xa03c2190
group 0--3
line.long 0 "CSR36"
hexfld.long 0 " W36 "
;tree.end

;tree "1CSR37"
base ad:0xa03c2194
group 0--3
line.long 0 "CSR37"
hexfld.long 0 " W37 "
;tree.end

;tree "1CSR38"
base ad:0xa03c2198
group 0--3
line.long 0 "CSR38"
hexfld.long 0 " W38 "
;tree.end

;tree "1CSR39"
base ad:0xa03c219c
group 0--3
line.long 0 "CSR39"
hexfld.long 0 " W39 "
;tree.end

;tree "1CSR40"
base ad:0xa03c21a0
group 0--3
line.long 0 "CSR40"
hexfld.long 0 " W40 "
;tree.end

;tree "1CSR41"
base ad:0xa03c21a4
group 0--3
line.long 0 "CSR41"
hexfld.long 0 " W41 "
;tree.end

;tree "1CSR42"
base ad:0xa03c21a8
group 0--3
line.long 0 "CSR42"
hexfld.long 0 " W42 "
;tree.end

;tree "1CSR43"
base ad:0xa03c21ac
group 0--3
line.long 0 "CSR43"
hexfld.long 0 " W43 "
;tree.end

;tree "1CSR44"
base ad:0xa03c21b0
group 0--3
line.long 0 "CSR44"
hexfld.long 0 " W44 "
;tree.end

;tree "1CSR45"
base ad:0xa03c21b4
group 0--3
line.long 0 "CSR45"
hexfld.long 0 " W45 "
;tree.end

;tree "1CSR46"
base ad:0xa03c21b8
group 0--3
line.long 0 "CSR46"
hexfld.long 0 " W46 "
;tree.end

;tree "1CSR47"
base ad:0xa03c21bc
group 0--3
line.long 0 "CSR47"
hexfld.long 0 " W47 "
;tree.end

;tree "1CSR48"
base ad:0xa03c21c0
group 0--3
line.long 0 "CSR48"
hexfld.long 0 " W48 "
;tree.end

;tree "1CSR49"
base ad:0xa03c21c4
group 0--3
line.long 0 "CSR49"
hexfld.long 0 " W49 "
;tree.end

;tree "1CSR50"
base ad:0xa03c21c8
group 0--3
line.long 0 "CSR50"
hexfld.long 0 " W50 "
;tree.end

;tree "1CSR51"
base ad:0xa03c21cc
group 0--3
line.long 0 "CSR51"
hexfld.long 0 " W51 "
;tree.end

;tree "1CSFULL"
base ad:0xa03c20f8
group 0--3
line.long 0 "CSFULL"
hexfld.long 0 " W40 "
;tree.end

;tree "1CSDATAIN"
base ad:0xa03c20fc
group 0--3
line.long 0 "CSDATAIN"
hexfld.long 0 " W41 "
;tree.end

;tree "1ITCR"
base ad:0xa03c2080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "1ITIP"
base ad:0xa03c2084
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR "  "0 ,1 "
bitfld.long 0 1. " DMATC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
;tree.end

;tree "1ITOP"
base ad:0xa03c2088
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMABREQ "  "0 ,1 "
;tree.end

;tree "1PeriphID0"
base ad:0xa03c2fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "1PeriphID1"
base ad:0xa03c2fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID2"
base ad:0xa03c2fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID3"
base ad:0xa03c2fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "1PCellID0"
base ad:0xa03c2ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

;tree "1PCellID1"
base ad:0xa03c2ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

;tree "1PCellID2"
base ad:0xa03c2ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

;tree "1PCellID3"
base ad:0xa03c2ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "HSEM"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CR"
base ad:0x80140000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PROT2 "  "0 ,1 "
;tree.end

;tree "R0"
base ad:0x80140008
group 0--3
line.long 0 "R0"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R1"
base ad:0x8014000c
group 0--3
line.long 0 "R1"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R2"
base ad:0x80140010
group 0--3
line.long 0 "R2"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R3"
base ad:0x80140014
group 0--3
line.long 0 "R3"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R4"
base ad:0x80140018
group 0--3
line.long 0 "R4"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R5"
base ad:0x8014001c
group 0--3
line.long 0 "R5"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R6"
base ad:0x80140020
group 0--3
line.long 0 "R6"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R7"
base ad:0x80140024
group 0--3
line.long 0 "R7"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R8"
base ad:0x80140028
group 0--3
line.long 0 "R8"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R9"
base ad:0x8014002c
group 0--3
line.long 0 "R9"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R10"
base ad:0x80140030
group 0--3
line.long 0 "R10"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R11"
base ad:0x80140034
group 0--3
line.long 0 "R11"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R12"
base ad:0x80140038
group 0--3
line.long 0 "R12"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R13"
base ad:0x8014003c
group 0--3
line.long 0 "R13"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R14"
base ad:0x80140040
group 0--3
line.long 0 "R14"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R15"
base ad:0x80140044
group 0--3
line.long 0 "R15"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R16"
base ad:0x80140048
group 0--3
line.long 0 "R16"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R17"
base ad:0x8014004c
group 0--3
line.long 0 "R17"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R18"
base ad:0x80140050
group 0--3
line.long 0 "R18"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R19"
base ad:0x80140054
group 0--3
line.long 0 "R19"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R20"
base ad:0x80140058
group 0--3
line.long 0 "R20"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R21"
base ad:0x8014005c
group 0--3
line.long 0 "R21"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R22"
base ad:0x80140060
group 0--3
line.long 0 "R22"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R23"
base ad:0x80140064
group 0--3
line.long 0 "R23"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R24"
base ad:0x80140068
group 0--3
line.long 0 "R24"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R25"
base ad:0x8014006c
group 0--3
line.long 0 "R25"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R26"
base ad:0x80140070
group 0--3
line.long 0 "R26"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R27"
base ad:0x80140074
group 0--3
line.long 0 "R27"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R28"
base ad:0x80140078
group 0--3
line.long 0 "R28"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R29"
base ad:0x8014007c
group 0--3
line.long 0 "R29"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R30"
base ad:0x80140080
group 0--3
line.long 0 "R30"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "R31"
base ad:0x80140084
group 0--3
line.long 0 "R31"
bitfld.long 0 0.--3. " HSEMDAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ICRALL"
base ad:0x80140090
wgroup 0--3
line.long 0 "ICRALL"
bitfld.long 0 0. " HSEMICALL0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICALL1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICALL2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICALL3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICALL4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICALL5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICALL6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICALL7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICALL8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICALL9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICALL10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICALL11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICALL12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICALL13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICALL14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICALL15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICALL16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICALL17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICALL18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICALL19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICALL20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICALL21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICALL22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICALL23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICALL24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICALL25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICALL26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICALL27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICALL28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICALL29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICALL30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICALL31 "  "0 ,1 "
;tree.end

;tree "IMSCA"
base ad:0x801400a0
group 0--3
line.long 0 "IMSCA"
bitfld.long 0 0. " HSEMIMA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMA31 "  "0 ,1 "
;tree.end

;tree "RISA"
base ad:0x801400a4
rgroup 0--3
line.long 0 "RISA"
bitfld.long 0 0. " HSEMRISA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISA31 "  "0 ,1 "
;tree.end

;tree "MISA"
base ad:0x801400a8
rgroup 0--3
line.long 0 "MISA"
bitfld.long 0 0. " HSEMMISA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISA31 "  "0 ,1 "
;tree.end

;tree "ICRA"
base ad:0x801400ac
wgroup 0--3
line.long 0 "ICRA"
bitfld.long 0 0. " HSEMICA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICA31 "  "0 ,1 "
;tree.end

;tree "IMSCB"
base ad:0x801400b0
group 0--3
line.long 0 "IMSCB"
bitfld.long 0 0. " HSEMIMB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMB31 "  "0 ,1 "
;tree.end

;tree "RISB"
base ad:0x801400b4
rgroup 0--3
line.long 0 "RISB"
bitfld.long 0 0. " HSEMRISB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISB31 "  "0 ,1 "
;tree.end

;tree "MISB"
base ad:0x801400b8
rgroup 0--3
line.long 0 "MISB"
bitfld.long 0 0. " HSEMMISB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISB31 "  "0 ,1 "
;tree.end

;tree "ICRB"
base ad:0x801400bc
wgroup 0--3
line.long 0 "ICRB"
bitfld.long 0 0. " HSEMICB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICB31 "  "0 ,1 "
;tree.end

;tree "IMSCC"
base ad:0x801400c0
group 0--3
line.long 0 "IMSCC"
bitfld.long 0 0. " HSEMIMC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMC31 "  "0 ,1 "
;tree.end

;tree "RISC"
base ad:0x801400c4
rgroup 0--3
line.long 0 "RISC"
bitfld.long 0 0. " HSEMRISC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISC31 "  "0 ,1 "
;tree.end

;tree "MISC"
base ad:0x801400c8
rgroup 0--3
line.long 0 "MISC"
bitfld.long 0 0. " HSEMMISC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISC31 "  "0 ,1 "
;tree.end

;tree "ICRC"
base ad:0x801400cc
wgroup 0--3
line.long 0 "ICRC"
bitfld.long 0 0. " HSEMICC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICC31 "  "0 ,1 "
;tree.end

;tree "IMSCD"
base ad:0x801400d0
group 0--3
line.long 0 "IMSCD"
bitfld.long 0 0. " HSEMIMD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMD31 "  "0 ,1 "
;tree.end

;tree "RISD"
base ad:0x801400d4
rgroup 0--3
line.long 0 "RISD"
bitfld.long 0 0. " HSEMRISD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISD31 "  "0 ,1 "
;tree.end

;tree "MISD"
base ad:0x801400d8
rgroup 0--3
line.long 0 "MISD"
bitfld.long 0 0. " HSEMMISD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISD31 "  "0 ,1 "
;tree.end

;tree "ICRD"
base ad:0x801400dc
wgroup 0--3
line.long 0 "ICRD"
bitfld.long 0 0. " HSEMICD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMID20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICD31 "  "0 ,1 "
;tree.end

;tree "IMSCE"
base ad:0x801400e0
group 0--3
line.long 0 "IMSCE"
bitfld.long 0 0. " HSEMIME0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIME1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIME2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIME3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIME4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIME5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIME6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIME7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIME8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIME9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIME10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIME11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIME12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIME13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIME14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIME15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIME16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIME17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIME18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIME19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIME20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIME21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIME22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIME23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIME24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIME25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIME26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIME27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIME28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIME29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIME30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIME31 "  "0 ,1 "
;tree.end

;tree "RISE"
base ad:0x801400e4
rgroup 0--3
line.long 0 "RISE"
bitfld.long 0 0. " HSEMRISE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISE31 "  "0 ,1 "
;tree.end

;tree "MISE"
base ad:0x801400e8
rgroup 0--3
line.long 0 "MISE"
bitfld.long 0 0. " HSEMMISE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISE31 "  "0 ,1 "
;tree.end

;tree "ICRE"
base ad:0x801400ec
wgroup 0--3
line.long 0 "ICRE"
bitfld.long 0 0. " HSEMICE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICE31 "  "0 ,1 "
;tree.end

;tree "ITCR"
base ad:0x80140100
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITOP"
base ad:0x80140108
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " HSEMINTRA "  "0 ,1 "
bitfld.long 0 1. " HSEMINTRB "  "0 ,1 "
bitfld.long 0 2. " HSEMINTRC "  "0 ,1 "
bitfld.long 0 3. " HSEMINTRD "  "0 ,1 "
bitfld.long 0 4. " HSEMINTRE "  "0 ,1 "
;tree.end

;tree "HSEMPeriphID0"
base ad:0x80140fe0
rgroup 0--3
line.long 0 "HSEMPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "HSEMPeriphID1"
base ad:0x80140fe4
rgroup 0--3
line.long 0 "HSEMPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "HSEMPeriphID2"
base ad:0x80140fe8
rgroup 0--3
line.long 0 "HSEMPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "HSEMPeriphID3"
base ad:0x80140fec
rgroup 0--3
line.long 0 "HSEMPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "HSEMPCellID0"
base ad:0x80140ff0
rgroup 0--3
line.long 0 "HSEMPCellID0"
hexfld.byte 0 " HSEMPCellID0 "
;tree.end

;tree "HSEMPCellID1"
base ad:0x80140ff4
rgroup 0--3
line.long 0 "HSEMPCellID1"
hexfld.byte 0 " HSEMPCellID1 "
;tree.end

;tree "HSEMPCellID2"
base ad:0x80140ff8
rgroup 0--3
line.long 0 "HSEMPCellID2"
hexfld.byte 0 " HSEMPCellID2 "
;tree.end

;tree "HSEMPCellID3"
base ad:0x80140ffc
rgroup 0--3
line.long 0 "HSEMPCellID3"
hexfld.byte 0 " HSEMPCellID3 "
;tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "HSI2C (5 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "HSI2C-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1CR"
base ad:0x80122000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " FS "  "0 ,1 "
;tree.end

;tree "1SCR"
base ad:0x80122004
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " SLSU "
;tree.end

;tree "1HSMCR"
base ad:0x80122008
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "1MCR"
base ad:0x8012200c
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

;tree "1TFR"
base ad:0x80122010
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

;tree "1SR"
base ad:0x80122014
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

;tree "1RFR"
base ad:0x80122018
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

;tree "1TFTR"
base ad:0x8012201c
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1RFTR"
base ad:0x80122020
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1DMAR"
base ad:0x80122024
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

;tree "1BRCR"
base ad:0x80122028
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 2 " BRCNT1 "
;tree.end

;tree "1IMSCR"
base ad:0x8012202c
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

;tree "1RISR"
base ad:0x80122030
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

;tree "1MISR"
base ad:0x80122034
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

;tree "1ICR"
base ad:0x80122038
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

;tree "1I2C_ITCR"
base ad:0x8012203c
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

;tree "1I2C_ITIP"
base ad:0x80122040
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

;tree "1I2C_ITOP"
base ad:0x80122044
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

;tree "1I2C_TDR"
base ad:0x80122048
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

;tree "1I2C_THDDAT"
base ad:0x8012204c
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

;tree "1I2C_THDSTA_FST_STD"
base ad:0x80122050
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

;tree "1I2C_THDSTA_FMP_HS"
base ad:0x80122054
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

;tree "1I2C_TSUSTA_FST_STD"
base ad:0x80122058
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

;tree "1I2C_TSUSTA_FMP_HS"
base ad:0x8012205c
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

;tree "1PERIPHID0"
base ad:0x80122fe0
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "1PERIPHID1"
base ad:0x80122fe4
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PERIPHID2"
base ad:0x80122fe8
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PERIPHID3"
base ad:0x80122fec
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "1PCELLID0"
base ad:0x80122ff0
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

;tree "1PCELLID1"
base ad:0x80122ff4
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

;tree "1PCELLID2"
base ad:0x80122ff8
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

;tree "1PCELLID3"
base ad:0x80122ffc
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "HSI2C-2"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "2CR"
base ad:0x80128000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " FS "  "0 ,1 "
;tree.end

;tree "2SCR"
base ad:0x80128004
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " SLSU "
;tree.end

;tree "2HSMCR"
base ad:0x80128008
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "2MCR"
base ad:0x8012800c
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

;tree "2TFR"
base ad:0x80128010
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

;tree "2SR"
base ad:0x80128014
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

;tree "2RFR"
base ad:0x80128018
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

;tree "2TFTR"
base ad:0x8012801c
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2RFTR"
base ad:0x80128020
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2DMAR"
base ad:0x80128024
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

;tree "2BRCR"
base ad:0x80128028
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 2 " BRCNT1 "
;tree.end

;tree "2IMSCR"
base ad:0x8012802c
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

;tree "2RISR"
base ad:0x80128030
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

;tree "2MISR"
base ad:0x80128034
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

;tree "2ICR"
base ad:0x80128038
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

;tree "2I2C_ITCR"
base ad:0x8012803c
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

;tree "2I2C_ITIP"
base ad:0x80128040
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

;tree "2I2C_ITOP"
base ad:0x80128044
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

;tree "2I2C_TDR"
base ad:0x80128048
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

;tree "2I2C_THDDAT"
base ad:0x8012804c
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

;tree "2I2C_THDSTA_FST_STD"
base ad:0x80128050
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

;tree "2I2C_THDSTA_FMP_HS"
base ad:0x80128054
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

;tree "2I2C_TSUSTA_FST_STD"
base ad:0x80128058
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

;tree "2I2C_TSUSTA_FMP_HS"
base ad:0x8012805c
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

;tree "2PERIPHID0"
base ad:0x80128fe0
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "2PERIPHID1"
base ad:0x80128fe4
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2PERIPHID2"
base ad:0x80128fe8
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2PERIPHID3"
base ad:0x80128fec
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "2PCELLID0"
base ad:0x80128ff0
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

;tree "2PCELLID1"
base ad:0x80128ff4
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

;tree "2PCELLID2"
base ad:0x80128ff8
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

;tree "2PCELLID3"
base ad:0x80128ffc
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "HSI2C-4"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "4CR"
base ad:0x8012a000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " FS "  "0 ,1 "
;tree.end

;tree "4SCR"
base ad:0x8012a004
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " SLSU "
;tree.end

;tree "4HSMCR"
base ad:0x8012a008
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "4MCR"
base ad:0x8012a00c
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

;tree "4TFR"
base ad:0x8012a010
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

;tree "4SR"
base ad:0x8012a014
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

;tree "4RFR"
base ad:0x8012a018
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

;tree "4TFTR"
base ad:0x8012a01c
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "4RFTR"
base ad:0x8012a020
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "4DMAR"
base ad:0x8012a024
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

;tree "4BRCR"
base ad:0x8012a028
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 2 " BRCNT1 "
;tree.end

;tree "4IMSCR"
base ad:0x8012a02c
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

;tree "4RISR"
base ad:0x8012a030
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

;tree "4MISR"
base ad:0x8012a034
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

;tree "4ICR"
base ad:0x8012a038
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

;tree "4I2C_ITCR"
base ad:0x8012a03c
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

;tree "4I2C_ITIP"
base ad:0x8012a040
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

;tree "4I2C_ITOP"
base ad:0x8012a044
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

;tree "4I2C_TDR"
base ad:0x8012a048
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

;tree "4I2C_THDDAT"
base ad:0x8012a04c
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

;tree "4I2C_THDSTA_FST_STD"
base ad:0x8012a050
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

;tree "4I2C_THDSTA_FMP_HS"
base ad:0x8012a054
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

;tree "4I2C_TSUSTA_FST_STD"
base ad:0x8012a058
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

;tree "4I2C_TSUSTA_FMP_HS"
base ad:0x8012a05c
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

;tree "4PERIPHID0"
base ad:0x8012afe0
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "4PERIPHID1"
base ad:0x8012afe4
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "4PERIPHID2"
base ad:0x8012afe8
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "4PERIPHID3"
base ad:0x8012afec
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "4PCELLID0"
base ad:0x8012aff0
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

;tree "4PCELLID1"
base ad:0x8012aff4
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

;tree "4PCELLID2"
base ad:0x8012aff8
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

;tree "4PCELLID3"
base ad:0x8012affc
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "HSI2C-3"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "3CR"
base ad:0x80110000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " FS "  "0 ,1 "
;tree.end

;tree "3SCR"
base ad:0x80110004
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " SLSU "
;tree.end

;tree "3HSMCR"
base ad:0x80110008
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "3MCR"
base ad:0x8011000c
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

;tree "3TFR"
base ad:0x80110010
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

;tree "3SR"
base ad:0x80110014
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

;tree "3RFR"
base ad:0x80110018
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

;tree "3TFTR"
base ad:0x8011001c
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "3RFTR"
base ad:0x80110020
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "3DMAR"
base ad:0x80110024
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

;tree "3BRCR"
base ad:0x80110028
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 2 " BRCNT1 "
;tree.end

;tree "3IMSCR"
base ad:0x8011002c
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

;tree "3RISR"
base ad:0x80110030
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

;tree "3MISR"
base ad:0x80110034
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

;tree "3ICR"
base ad:0x80110038
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

;tree "3I2C_ITCR"
base ad:0x8011003c
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

;tree "3I2C_ITIP"
base ad:0x80110040
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

;tree "3I2C_ITOP"
base ad:0x80110044
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

;tree "3I2C_TDR"
base ad:0x80110048
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

;tree "3I2C_THDDAT"
base ad:0x8011004c
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

;tree "3I2C_THDSTA_FST_STD"
base ad:0x80110050
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

;tree "3I2C_THDSTA_FMP_HS"
base ad:0x80110054
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

;tree "3I2C_TSUSTA_FST_STD"
base ad:0x80110058
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

;tree "3I2C_TSUSTA_FMP_HS"
base ad:0x8011005c
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

;tree "3PERIPHID0"
base ad:0x80110fe0
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "3PERIPHID1"
base ad:0x80110fe4
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "3PERIPHID2"
base ad:0x80110fe8
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "3PERIPHID3"
base ad:0x80110fec
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "3PCELLID0"
base ad:0x80110ff0
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

;tree "3PCELLID1"
base ad:0x80110ff4
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

;tree "3PCELLID2"
base ad:0x80110ff8
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

;tree "3PCELLID3"
base ad:0x80110ffc
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "HSI2C-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0CR"
base ad:0x80004000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " FS "  "0 ,1 "
;tree.end

;tree "0SCR"
base ad:0x80004004
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " SLSU "
;tree.end

;tree "0HSMCR"
base ad:0x80004008
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "0MCR"
base ad:0x8000400c
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

;tree "0TFR"
base ad:0x80004010
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

;tree "0SR"
base ad:0x80004014
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

;tree "0RFR"
base ad:0x80004018
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

;tree "0TFTR"
base ad:0x8000401c
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0RFTR"
base ad:0x80004020
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0DMAR"
base ad:0x80004024
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

;tree "0BRCR"
base ad:0x80004028
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 2 " BRCNT1 "
;tree.end

;tree "0IMSCR"
base ad:0x8000402c
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

;tree "0RISR"
base ad:0x80004030
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

;tree "0MISR"
base ad:0x80004034
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

;tree "0ICR"
base ad:0x80004038
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

;tree "0I2C_ITCR"
base ad:0x8000403c
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

;tree "0I2C_ITIP"
base ad:0x80004040
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

;tree "0I2C_ITOP"
base ad:0x80004044
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

;tree "0I2C_TDR"
base ad:0x80004048
group 0--3
line.long 0 "I2C_TDR"
hexfld.long 0 " TESTDATA "
;tree.end

;tree "0I2C_THDDAT"
base ad:0x8000404c
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
;tree.end

;tree "0I2C_THDSTA_FST_STD"
base ad:0x80004050
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

;tree "0I2C_THDSTA_FMP_HS"
base ad:0x80004054
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

;tree "0I2C_TSUSTA_FST_STD"
base ad:0x80004058
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
;tree.end

;tree "0I2C_TSUSTA_FMP_HS"
base ad:0x8000405c
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
;tree.end

;tree "0PERIPHID0"
base ad:0x80004fe0
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "0PERIPHID1"
base ad:0x80004fe4
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PERIPHID2"
base ad:0x80004fe8
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PERIPHID3"
base ad:0x80004fec
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "0PCELLID0"
base ad:0x80004ff0
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

;tree "0PCELLID1"
base ad:0x80004ff4
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

;tree "0PCELLID2"
base ad:0x80004ff8
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

;tree "0PCELLID3"
base ad:0x80004ffc
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "HSI2CMODEM"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CR"
base ad:0xb7e02000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  "0 ,1 ,2 ,3 "
;tree.end

;tree "SCR"
base ad:0xb7e02004
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
hexfld.word 2 " SLSU "
;tree.end

;tree "HSMCR"
base ad:0xb7e02008
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "MCR"
base ad:0xb7e0200c
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
;tree.end

;tree "TFR"
base ad:0xb7e02010
wgroup 0--3
line.long 0 "TFR"
hexfld.byte 0 " TDATA "
;tree.end

;tree "SR"
base ad:0xb7e02014
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--8. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--19. " LENGTH "  " "
;tree.end

;tree "RFR"
base ad:0xb7e02018
rgroup 0--3
line.long 0 "RFR"
hexfld.byte 0 " RDATA "
;tree.end

;tree "TFTR"
base ad:0xb7e0201c
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "RFTR"
base ad:0xb7e02020
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DMAR"
base ad:0xb7e02024
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
;tree.end

;tree "BRCR"
base ad:0xb7e02028
group 0--3
line.long 0 "BRCR"
hexfld.word 0 " BRCNT2 "
hexfld.word 2 " BRCNT1 "
;tree.end

;tree "IMSCR"
base ad:0xb7e0202c
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
;tree.end

;tree "RISR"
base ad:0xb7e02030
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
;tree.end

;tree "MISR"
base ad:0xb7e02034
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
;tree.end

;tree "ICR"
base ad:0xb7e02038
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
;tree.end

;tree "I2C_ITCR"
base ad:0xb7e0203c
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
;tree.end

;tree "I2C_ITIP"
base ad:0xb7e02040
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
;tree.end

;tree "I2C_ITOP"
base ad:0xb7e02044
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
;tree.end

;tree "PERIPHID0"
base ad:0xb7e02fe0
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "PERIPHID1"
base ad:0xb7e02fe4
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PERIPHID2"
base ad:0xb7e02fe8
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PERIPHID3"
base ad:0xb7e02fec
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCELLID0"
base ad:0xb7e02ff0
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " I2CPCellID0 "
;tree.end

;tree "PCELLID1"
base ad:0xb7e02ff4
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " I2CPCellID1 "
;tree.end

;tree "PCELLID2"
base ad:0xb7e02ff8
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " I2CPCellID2 "
;tree.end

;tree "PCELLID3"
base ad:0xb7e02ffc
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " I2CPCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "HSIR"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "ID"
base ad:0x8011b000
group 0--3
line.long 0 "ID"
hexfld.long 0 " ID "
;tree.end

;tree "MODE"
base ad:0x8011b004
group 0--3
line.long 0 "MODE"
bitfld.long 0 0.--2. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "RXSTATE"
base ad:0x8011b008
group 0--3
line.long 0 "RXSTATE"
bitfld.long 0 0.--1. " RXSTATE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "BUFSTATE"
base ad:0x8011b00c
group 0--3
line.long 0 "BUFSTATE"
bitfld.long 0 0. " BUFSTATE0 "  "0 ,1 "
bitfld.long 0 1. " BUFSTATE1 "  "0 ,1 "
bitfld.long 0 2. " BUFSTATE2 "  "0 ,1 "
bitfld.long 0 3. " BUFSTATE3 "  "0 ,1 "
bitfld.long 0 4. " BUFSTATE4 "  "0 ,1 "
bitfld.long 0 5. " BUFSTATE5 "  "0 ,1 "
bitfld.long 0 6. " BUFSTATE6 "  "0 ,1 "
bitfld.long 0 7. " BUFSTATE7 "  "0 ,1 "
;tree.end

;tree "THRESHOLD"
base ad:0x8011b010
group 0--3
line.long 0 "THRESHOLD"
bitfld.long 0 0.--5. " THRESHOLD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "DETECTOR"
base ad:0x8011b018
group 0--3
line.long 0 "DETECTOR"
bitfld.long 0 0. " DETECTOR "  "0 ,1 "
;tree.end

;tree "EXCEPTION"
base ad:0x8011b01c
group 0--3
line.long 0 "EXCEPTION"
bitfld.long 0 0. " TIMEOUT "  "0 ,1 "
bitfld.long 0 1. " OVERRUN "  "0 ,1 "
bitfld.long 0 2. " BREAK "  "0 ,1 "
;tree.end

;tree "ACKNOWLEDGE"
base ad:0x8011b020
wgroup 0--3
line.long 0 "ACKNOWLEDGE"
bitfld.long 0 0. " ACKTIMEOUT "  "0 ,1 "
bitfld.long 0 1. " ACKOVERRUN "  "0 ,1 "
bitfld.long 0 2. " ACKBREAK "  "0 ,1 "
;tree.end

;tree "CHANNELS"
base ad:0x8011b024
group 0--3
line.long 0 "CHANNELS"
bitfld.long 0 0.--3. " CHANNELS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "REALTIME"
base ad:0x8011b028
group 0--3
line.long 0 "REALTIME"
bitfld.long 0 0. " REALTIME0 "  "0 ,1 "
bitfld.long 0 1. " REALTIME1 "  "0 ,1 "
bitfld.long 0 2. " REALTIME2 "  "0 ,1 "
bitfld.long 0 3. " REALTIME3 "  "0 ,1 "
bitfld.long 0 4. " REALTIME4 "  "0 ,1 "
bitfld.long 0 5. " REALTIME5 "  "0 ,1 "
bitfld.long 0 6. " REALTIME6 "  "0 ,1 "
bitfld.long 0 7. " REALTIME7 "  "0 ,1 "
;tree.end

;tree "OVERRUN"
base ad:0x8011b02c
group 0--3
line.long 0 "OVERRUN"
bitfld.long 0 0. " OVERRUN0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUN1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUN2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUN3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUN4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUN5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUN6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUN7 "  "0 ,1 "
;tree.end

;tree "OVERRUNACK"
base ad:0x8011b030
rgroup 0--3
line.long 0 "OVERRUNACK"
bitfld.long 0 0. " OVERRUNACK0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUNACK1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUNACK2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUNACK3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUNACK4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUNACK5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUNACK6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUNACK7 "  "0 ,1 "
;tree.end

;tree "PREAMBLE"
base ad:0x8011b034
group 0--3
line.long 0 "PREAMBLE"
bitfld.long 0 0.--23. " PREAMBLE "  " "
;tree.end

;tree "PIPEGAUGE"
base ad:0x8011b038
group 0--3
line.long 0 "PIPEGAUGE"
bitfld.long 0 0.--1. " PIPEGAUGE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "STATICCONFID"
base ad:0x8011b03c
group 0--3
line.long 0 "STATICCONFID"
bitfld.long 0 0.--2. " LOG2MAXCHANNELS_C "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--6. " LOG2BUFFERSIZE_C "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 7.--10. " LOG2QUEUELENGH_C "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 11.--13. " LOG2CHIPSIZE_C "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "BUFFER0"
base ad:0x8011b080
group 0--3
line.long 0 "BUFFER0"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER1"
base ad:0x8011b084
group 0--3
line.long 0 "BUFFER1"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER2"
base ad:0x8011b088
group 0--3
line.long 0 "BUFFER2"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER3"
base ad:0x8011b08c
group 0--3
line.long 0 "BUFFER3"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER4"
base ad:0x8011b090
group 0--3
line.long 0 "BUFFER4"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER5"
base ad:0x8011b094
group 0--3
line.long 0 "BUFFER5"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER6"
base ad:0x8011b098
group 0--3
line.long 0 "BUFFER6"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER7"
base ad:0x8011b09c
group 0--3
line.long 0 "BUFFER7"
hexfld.long 0 " BUFFER "
;tree.end

;tree "FRAMELEN0"
base ad:0x8011b0c0
group 0--3
line.long 0 "FRAMELEN0"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN1"
base ad:0x8011b0c4
group 0--3
line.long 0 "FRAMELEN1"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN2"
base ad:0x8011b0c8
group 0--3
line.long 0 "FRAMELEN2"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN3"
base ad:0x8011b0cc
group 0--3
line.long 0 "FRAMELEN3"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN4"
base ad:0x8011b0d0
group 0--3
line.long 0 "FRAMELEN4"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN5"
base ad:0x8011b0d4
group 0--3
line.long 0 "FRAMELEN5"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN6"
base ad:0x8011b0d8
group 0--3
line.long 0 "FRAMELEN6"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN7"
base ad:0x8011b0dc
group 0--3
line.long 0 "FRAMELEN7"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE0"
base ad:0x8011b100
group 0--3
line.long 0 "BASE0"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE1"
base ad:0x8011b104
group 0--3
line.long 0 "BASE1"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE2"
base ad:0x8011b108
group 0--3
line.long 0 "BASE2"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE3"
base ad:0x8011b10c
group 0--3
line.long 0 "BASE3"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE4"
base ad:0x8011b110
group 0--3
line.long 0 "BASE4"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE5"
base ad:0x8011b114
group 0--3
line.long 0 "BASE5"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE6"
base ad:0x8011b118
group 0--3
line.long 0 "BASE6"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE7"
base ad:0x8011b11c
group 0--3
line.long 0 "BASE7"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN0"
base ad:0x8011b140
group 0--3
line.long 0 "SPAN0"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN1"
base ad:0x8011b144
group 0--3
line.long 0 "SPAN1"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN2"
base ad:0x8011b148
group 0--3
line.long 0 "SPAN2"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN3"
base ad:0x8011b14c
group 0--3
line.long 0 "SPAN3"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN4"
base ad:0x8011b150
group 0--3
line.long 0 "SPAN4"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN5"
base ad:0x8011b154
group 0--3
line.long 0 "SPAN5"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN6"
base ad:0x8011b158
group 0--3
line.long 0 "SPAN6"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN7"
base ad:0x8011b15c
group 0--3
line.long 0 "SPAN7"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE0"
base ad:0x8011b180
group 0--3
line.long 0 "GAUGE0"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE1"
base ad:0x8011b184
group 0--3
line.long 0 "GAUGE1"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE2"
base ad:0x8011b188
group 0--3
line.long 0 "GAUGE2"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE3"
base ad:0x8011b18c
group 0--3
line.long 0 "GAUGE3"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE4"
base ad:0x8011b190
group 0--3
line.long 0 "GAUGE4"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE5"
base ad:0x8011b194
group 0--3
line.long 0 "GAUGE5"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE6"
base ad:0x8011b198
group 0--3
line.long 0 "GAUGE6"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE7"
base ad:0x8011b19c
group 0--3
line.long 0 "GAUGE7"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK0"
base ad:0x8011b1c0
group 0--3
line.long 0 "WATERMARK0"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK1"
base ad:0x8011b1c4
group 0--3
line.long 0 "WATERMARK1"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK2"
base ad:0x8011b1c8
group 0--3
line.long 0 "WATERMARK2"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK3"
base ad:0x8011b1cc
group 0--3
line.long 0 "WATERMARK3"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK4"
base ad:0x8011b1d0
group 0--3
line.long 0 "WATERMARK4"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK5"
base ad:0x8011b1d4
group 0--3
line.long 0 "WATERMARK5"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK6"
base ad:0x8011b1d8
group 0--3
line.long 0 "WATERMARK6"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK7"
base ad:0x8011b1dc
group 0--3
line.long 0 "WATERMARK7"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMEBURSTCNT"
base ad:0x8011b1e0
group 0--3
line.long 0 "FRAMEBURSTCNT"
hexfld.byte 0 " FRAMEBURSTCNT "
;tree.end

;tree "DMAEN"
base ad:0x8011b200
group 0--3
line.long 0 "DMAEN"
bitfld.long 0 0. " DMAEN0 "  "0 ,1 "
bitfld.long 0 1. " DMAEN1 "  "0 ,1 "
bitfld.long 0 2. " DMAEN2 "  "0 ,1 "
bitfld.long 0 3. " DMAEN3 "  "0 ,1 "
bitfld.long 0 4. " DMAEN4 "  "0 ,1 "
bitfld.long 0 5. " DMAEN5 "  "0 ,1 "
bitfld.long 0 6. " DMAEN6 "  "0 ,1 "
bitfld.long 0 7. " DMAEN7 "  "0 ,1 "
;tree.end

;tree "WMARKMIS"
base ad:0x8011b204
rgroup 0--3
line.long 0 "WMARKMIS"
bitfld.long 0 0. " WATERMIS0 "  "0 ,1 "
bitfld.long 0 1. " WATERMIS1 "  "0 ,1 "
bitfld.long 0 2. " WATERMIS2 "  "0 ,1 "
bitfld.long 0 3. " WATERMIS3 "  "0 ,1 "
bitfld.long 0 4. " WATERMIS4 "  "0 ,1 "
bitfld.long 0 5. " WATERMIS5 "  "0 ,1 "
bitfld.long 0 6. " WATERMIS6 "  "0 ,1 "
bitfld.long 0 7. " WATERMIS7 "  "0 ,1 "
;tree.end

;tree "WMARKIM"
base ad:0x8011b208
group 0--3
line.long 0 "WMARKIM"
bitfld.long 0 0. " WMARKIM0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIM1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIM2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIM3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIM4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIM5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIM6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIM7 "  "0 ,1 "
;tree.end

;tree "WMARKIC"
base ad:0x8011b20c
wgroup 0--3
line.long 0 "WMARKIC"
bitfld.long 0 0. " WMARKIC0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIC1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIC2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIC3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIC4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIC5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIC6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIC7 "  "0 ,1 "
;tree.end

;tree "WMARKID"
base ad:0x8011b210
group 0--3
line.long 0 "WMARKID"
bitfld.long 0 0. " WMARKID0 "  "0 ,1 "
bitfld.long 0 1. " WMARKID1 "  "0 ,1 "
bitfld.long 0 2. " WMARKID2 "  "0 ,1 "
bitfld.long 0 3. " WMARKID3 "  "0 ,1 "
bitfld.long 0 4. " WMARKID4 "  "0 ,1 "
bitfld.long 0 5. " WMARKID5 "  "0 ,1 "
bitfld.long 0 6. " WMARKID6 "  "0 ,1 "
bitfld.long 0 7. " WMARKID7 "  "0 ,1 "
;tree.end

;tree "OVERRUNMIS"
base ad:0x8011b214
rgroup 0--3
line.long 0 "OVERRUNMIS"
bitfld.long 0 0. " OVERRUNMIS0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUNMIS1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUNMIS2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUNMIS3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUNMIS4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUNMIS5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUNMIS6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUNMIS7 "  "0 ,1 "
;tree.end

;tree "OVERRUNIM"
base ad:0x8011b218
group 0--3
line.long 0 "OVERRUNIM"
bitfld.long 0 0. " OVERRUNIM0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUNIM1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUNIM2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUNIM3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUNIM4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUNIM5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUNIM6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUNIM7 "  "0 ,1 "
;tree.end

;tree "EXCEPMIS"
base ad:0x8011b21c
rgroup 0--3
line.long 0 "EXCEPMIS"
bitfld.long 0 0. " TIMEOUTMIS "  "0 ,1 "
bitfld.long 0 1. " OVERRUNMIS "  "0 ,1 "
bitfld.long 0 2. " BREAKMIS "  "0 ,1 "
;tree.end

;tree "WMARKIS"
base ad:0x8011b224
group 0--3
line.long 0 "WMARKIS"
bitfld.long 0 0. " MARKIS0 "  "0 ,1 "
bitfld.long 0 1. " MARKIS1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIS2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIS3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIS4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIS5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIS6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIS7 "  "0 ,1 "
;tree.end

;tree "EXCEPIM"
base ad:0x8011b220
group 0--3
line.long 0 "EXCEPIM"
bitfld.long 0 0. " TIMEOUTIM "  "0 ,1 "
bitfld.long 0 1. " OVERRUNIM "  "0 ,1 "
bitfld.long 0 2. " BREAKIM "  "0 ,1 "
;tree.end

;tree "ITCR"
base ad:0x8011bd00
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITIP"
base ad:0x8011bd04
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR0 "  "0 ,1 "
bitfld.long 0 1. " DMACLR1 "  "0 ,1 "
bitfld.long 0 2. " DMACLR2 "  "0 ,1 "
bitfld.long 0 3. " DMACLR3 "  "0 ,1 "
bitfld.long 0 4. " DMACLR4 "  "0 ,1 "
bitfld.long 0 5. " DMACLR5 "  "0 ,1 "
bitfld.long 0 6. " DMACLR6 "  "0 ,1 "
bitfld.long 0 7. " DMACLR7 "  "0 ,1 "
bitfld.long 0 16. " DATA "  "0 ,1 "
bitfld.long 0 17. " FLAG "  "0 ,1 "
;tree.end

;tree "ITOP1"
base ad:0x8011bd08
group 0--3
line.long 0 "ITOP1"
hexfld.byte 0 " DMABREQ "
hexfld.byte 2 " DMASREQ "
;tree.end

;tree "ITOP2"
base ad:0x8011bd0c
group 0--3
line.long 0 "ITOP2"
bitfld.long 0 0. " WMARKD0INT "  "0 ,1 "
bitfld.long 0 1. " WMARKD1INT "  "0 ,1 "
bitfld.long 0 2. " EXCEPINT "  "0 ,1 "
bitfld.long 0 16. " READY "  "0 ,1 "
;tree.end

;tree "ITOP3"
base ad:0x8011bd10
group 0--3
line.long 0 "ITOP3"
hexfld.byte 0 " OVERRUNINT "
;tree.end

;tree "PERIPHID0"
base ad:0x8011bfe0
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " PARTMUMBER0 "
;tree.end

;tree "PERIPHID1"
base ad:0x8011bfe4
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " PARTNUMBER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " DESIGNER0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PERIPHID2"
base ad:0x8011bfe8
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " DESIGNER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " REVISION "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PERIPHID3"
base ad:0x8011bfec
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " CONFIGURATION "
;tree.end

;tree "PCELLID0"
base ad:0x8011bff0
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " PCELLID0 "
;tree.end

;tree "PCELLID1"
base ad:0x8011bff4
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " PCELLID1 "
;tree.end

;tree "PCELLID2"
base ad:0x8011bff8
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " PCELLID2 "
;tree.end

;tree "PCELLID3"
base ad:0x8011bffc
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " PCELLID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "HSIT"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "ID"
base ad:0x8011c000
group 0--3
line.long 0 "ID"
hexfld.long 0 " ID "
;tree.end

;tree "MODE"
base ad:0x8011c004
group 0--3
line.long 0 "MODE"
bitfld.long 0 0.--1. " MODE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "TXSTATE"
base ad:0x8011c008
group 0--3
line.long 0 "TXSTATE"
bitfld.long 0 0.--2. " TXSTATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "IOSTATE"
base ad:0x8011c00c
group 0--3
line.long 0 "IOSTATE"
bitfld.long 0 0. " DSTATE "  "0 ,1 "
bitfld.long 0 1. " FSTATE "  "0 ,1 "
bitfld.long 0 2. " RSTATE "  "0 ,1 "
;tree.end

;tree "BUFSTATE"
base ad:0x8011c010
group 0--3
line.long 0 "BUFSTATE"
bitfld.long 0 0. " BUFSTATE0 "  "0 ,1 "
bitfld.long 0 1. " BUFSTATE1 "  "0 ,1 "
bitfld.long 0 2. " BUFSTATE2 "  "0 ,1 "
bitfld.long 0 3. " BUFSTATE3 "  "0 ,1 "
bitfld.long 0 4. " BUFSTATE4 "  "0 ,1 "
bitfld.long 0 5. " BUFSTATE5 "  "0 ,1 "
bitfld.long 0 6. " BUFSTATE6 "  "0 ,1 "
bitfld.long 0 7. " BUFSTATE7 "  "0 ,1 "
;tree.end

;tree "DIVISOR"
base ad:0x8011c014
group 0--3
line.long 0 "DIVISOR"
bitfld.long 0 0.--23. " DIVISOR "  " "
;tree.end

;tree "BREAK"
base ad:0x8011c01c
group 0--3
line.long 0 "BREAK"
bitfld.long 0 0. " BREAK "  "0 ,1 "
;tree.end

;tree "CHANNELS"
base ad:0x8011c020
group 0--3
line.long 0 "CHANNELS"
bitfld.long 0 0.--3. " CHANNELS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "FLUSHBITS"
base ad:0x8011c024
group 0--3
line.long 0 "FLUSHBITS"
bitfld.long 0 0.--5. " FLUSHBITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "PRIORITY"
base ad:0x8011c028
group 0--3
line.long 0 "PRIORITY"
bitfld.long 0 0. " PRIORITY0 "  "0 ,1 "
bitfld.long 0 1. " PRIORITY1 "  "0 ,1 "
bitfld.long 0 2. " PRIORITY2 "  "0 ,1 "
bitfld.long 0 3. " PRIORITY3 "  "0 ,1 "
bitfld.long 0 4. " PRIORITY4 "  "0 ,1 "
bitfld.long 0 5. " PRIORITY5 "  "0 ,1 "
bitfld.long 0 6. " PRIORITY6 "  "0 ,1 "
bitfld.long 0 7. " PRIORITY7 "  "0 ,1 "
;tree.end

;tree "STATICCONFID"
base ad:0x8011c02c
group 0--3
line.long 0 "STATICCONFID"
bitfld.long 0 0.--2. " LOG2MAXCHANNELS_C "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--6. " LOG2BUFFERSIZE_C "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "DATASWAP"
base ad:0x8011c034
group 0--3
line.long 0 "DATASWAP"
bitfld.long 0 0.--1. " DATASWAP "  "0 ,1 ,2 ,3 "
;tree.end

;tree "FRAMELEN0"
base ad:0x8011c080
group 0--3
line.long 0 "FRAMELEN0"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN1"
base ad:0x8011c084
group 0--3
line.long 0 "FRAMELEN1"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN2"
base ad:0x8011c088
group 0--3
line.long 0 "FRAMELEN2"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN3"
base ad:0x8011c08c
group 0--3
line.long 0 "FRAMELEN3"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN4"
base ad:0x8011c090
group 0--3
line.long 0 "FRAMELEN4"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN5"
base ad:0x8011c094
group 0--3
line.long 0 "FRAMELEN5"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN6"
base ad:0x8011c098
group 0--3
line.long 0 "FRAMELEN6"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "FRAMELEN7"
base ad:0x8011c09c
group 0--3
line.long 0 "FRAMELEN7"
bitfld.long 0 0.--4. " FRAMELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BUFFER0"
base ad:0x8011c0c0
group 0--3
line.long 0 "BUFFER0"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER1"
base ad:0x8011c0c4
group 0--3
line.long 0 "BUFFER1"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER2"
base ad:0x8011c0c8
group 0--3
line.long 0 "BUFFER2"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER3"
base ad:0x8011c0cc
group 0--3
line.long 0 "BUFFER3"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER4"
base ad:0x8011c0d0
group 0--3
line.long 0 "BUFFER4"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER5"
base ad:0x8011c0d4
group 0--3
line.long 0 "BUFFER5"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER6"
base ad:0x8011c0d8
group 0--3
line.long 0 "BUFFER6"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BUFFER7"
base ad:0x8011c0dc
group 0--3
line.long 0 "BUFFER7"
hexfld.long 0 " BUFFER "
;tree.end

;tree "BASE0"
base ad:0x8011c100
group 0--3
line.long 0 "BASE0"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE1"
base ad:0x8011c104
group 0--3
line.long 0 "BASE1"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE2"
base ad:0x8011c108
group 0--3
line.long 0 "BASE2"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE3"
base ad:0x8011c10c
group 0--3
line.long 0 "BASE3"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE4"
base ad:0x8011c110
group 0--3
line.long 0 "BASE4"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE5"
base ad:0x8011c114
group 0--3
line.long 0 "BASE5"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE6"
base ad:0x8011c118
group 0--3
line.long 0 "BASE6"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "BASE7"
base ad:0x8011c11c
group 0--3
line.long 0 "BASE7"
bitfld.long 0 0.--4. " BASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN0"
base ad:0x8011c140
group 0--3
line.long 0 "SPAN0"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN1"
base ad:0x8011c144
group 0--3
line.long 0 "SPAN1"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN2"
base ad:0x8011c148
group 0--3
line.long 0 "SPAN2"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN3"
base ad:0x8011c14c
group 0--3
line.long 0 "SPAN3"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN4"
base ad:0x8011c150
group 0--3
line.long 0 "SPAN4"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN5"
base ad:0x8011c154
group 0--3
line.long 0 "SPAN5"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN6"
base ad:0x8011c158
group 0--3
line.long 0 "SPAN6"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SPAN7"
base ad:0x8011c15c
group 0--3
line.long 0 "SPAN7"
bitfld.long 0 0.--4. " SPAN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE0"
base ad:0x8011c180
group 0--3
line.long 0 "GAUGE0"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE1"
base ad:0x8011c184
group 0--3
line.long 0 "GAUGE1"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE2"
base ad:0x8011c188
group 0--3
line.long 0 "GAUGE2"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE3"
base ad:0x8011c18c
group 0--3
line.long 0 "GAUGE3"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE4"
base ad:0x8011c190
group 0--3
line.long 0 "GAUGE4"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE5"
base ad:0x8011c194
group 0--3
line.long 0 "GAUGE5"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE6"
base ad:0x8011c198
group 0--3
line.long 0 "GAUGE6"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GAUGE7"
base ad:0x8011c19c
group 0--3
line.long 0 "GAUGE7"
bitfld.long 0 0.--4. " GAUGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK0"
base ad:0x8011c1c0
group 0--3
line.long 0 "WATERMARK0"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK1"
base ad:0x8011c1c4
group 0--3
line.long 0 "WATERMARK1"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK2"
base ad:0x8011c1c8
group 0--3
line.long 0 "WATERMARK2"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK3"
base ad:0x8011c1cc
group 0--3
line.long 0 "WATERMARK3"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK4"
base ad:0x8011c1d0
group 0--3
line.long 0 "WATERMARK4"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK5"
base ad:0x8011c1d4
group 0--3
line.long 0 "WATERMARK5"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK6"
base ad:0x8011c1d8
group 0--3
line.long 0 "WATERMARK6"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "WATERMARK7"
base ad:0x8011c1dc
group 0--3
line.long 0 "WATERMARK7"
bitfld.long 0 0.--4. " WATERMARK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DMAEN"
base ad:0x8011c200
group 0--3
line.long 0 "DMAEN"
bitfld.long 0 0. " DMAEN0 "  "0 ,1 "
bitfld.long 0 1. " DMAEN1 "  "0 ,1 "
bitfld.long 0 2. " DMAEN2 "  "0 ,1 "
bitfld.long 0 3. " DMAEN3 "  "0 ,1 "
bitfld.long 0 4. " DMAEN4 "  "0 ,1 "
bitfld.long 0 5. " DMAEN5 "  "0 ,1 "
bitfld.long 0 6. " DMAEN6 "  "0 ,1 "
bitfld.long 0 7. " DMAEN7 "  "0 ,1 "
;tree.end

;tree "WMARKMIS"
base ad:0x8011c204
rgroup 0--3
line.long 0 "WMARKMIS"
bitfld.long 0 0. " WMARKMIS0 "  "0 ,1 "
bitfld.long 0 1. " WMARKMIS1 "  "0 ,1 "
bitfld.long 0 2. " WMARKMIS2 "  "0 ,1 "
bitfld.long 0 3. " WMARKMIS3 "  "0 ,1 "
bitfld.long 0 4. " WMARKMIS4 "  "0 ,1 "
bitfld.long 0 5. " WMARKMIS5 "  "0 ,1 "
bitfld.long 0 6. " WMARKMIS6 "  "0 ,1 "
bitfld.long 0 7. " WMARKMIS7 "  "0 ,1 "
;tree.end

;tree "WMARKIM"
base ad:0x8011c208
group 0--3
line.long 0 "WMARKIM"
bitfld.long 0 0. " WMARKIM0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIM1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIM2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIM3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIM4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIM5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIM6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIM7 "  "0 ,1 "
;tree.end

;tree "WMARKIC"
base ad:0x8011c20c
wgroup 0--3
line.long 0 "WMARKIC"
bitfld.long 0 0. " WMARKIC0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIC1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIC2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIC3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIC4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIC5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIC6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIC7 "  "0 ,1 "
;tree.end

;tree "WMARKID"
base ad:0x8011c210
group 0--3
line.long 0 "WMARKID"
bitfld.long 0 0. " WMARKID0 "  "0 ,1 "
bitfld.long 0 1. " WMARKID1 "  "0 ,1 "
bitfld.long 0 2. " WMARKID2 "  "0 ,1 "
bitfld.long 0 3. " WMARKID3 "  "0 ,1 "
bitfld.long 0 4. " WMARKID4 "  "0 ,1 "
bitfld.long 0 5. " WMARKID5 "  "0 ,1 "
bitfld.long 0 6. " WMARKID6 "  "0 ,1 "
bitfld.long 0 7. " WMARKID7 "  "0 ,1 "
;tree.end

;tree "WMARKIS"
base ad:0x8011c214
group 0--3
line.long 0 "WMARKIS"
bitfld.long 0 0. " WMARKIS0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIS1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIS2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIS3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIS4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIS5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIS6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIS7 "  "0 ,1 "
;tree.end

;tree "ITCR"
base ad:0x8011cd00
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITIP"
base ad:0x8011cd04
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR0 "  "0 ,1 "
bitfld.long 0 1. " DMACLR1 "  "0 ,1 "
bitfld.long 0 2. " DMACLR2 "  "0 ,1 "
bitfld.long 0 3. " DMACLR3 "  "0 ,1 "
bitfld.long 0 4. " DMACLR4 "  "0 ,1 "
bitfld.long 0 5. " DMACLR5 "  "0 ,1 "
bitfld.long 0 6. " DMACLR6 "  "0 ,1 "
bitfld.long 0 7. " DMACLR7 "  "0 ,1 "
bitfld.long 0 16. " READY "  "0 ,1 "
;tree.end

;tree "ITOP1"
base ad:0x8011cd08
group 0--3
line.long 0 "ITOP1"
hexfld.byte 0 " DMABREQ "
hexfld.byte 2 " DMASREQ "
;tree.end

;tree "ITOP2"
base ad:0x8011cd0c
group 0--3
line.long 0 "ITOP2"
bitfld.long 0 0. " WMARKD0INT "  "0 ,1 "
bitfld.long 0 1. " WMARKD1INT "  "0 ,1 "
bitfld.long 0 16. " DATA "  "0 ,1 "
bitfld.long 0 17. " FLAG "  "0 ,1 "
;tree.end

;tree "PERIPHID0"
base ad:0x8011cfe0
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.byte 0 " PARTNUMBER0 "
;tree.end

;tree "PERIPHID1"
base ad:0x8011cfe4
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " PARTNUMBER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " DESIGNER0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PERIPHID2"
base ad:0x8011cfe8
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " DESIGNER1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " REVISION "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PERIPHID3"
base ad:0x8011cfec
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.byte 0 " CONFIGURATION "
;tree.end

;tree "PCELLID0"
base ad:0x8011cff0
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.byte 0 " PCELLID0 "
;tree.end

;tree "PCELLID1"
base ad:0x8011cff4
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.byte 0 " PCELLID1 "
;tree.end

;tree "PCELLID2"
base ad:0x8011cff8
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.byte 0 " PCELLID2 "
;tree.end

;tree "PCELLID3"
base ad:0x8011cffc
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.byte 0 " PCELLID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "HVA"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "HIF_REG_RST"
base ad:0xa0320100
group 0--3
line.long 0 "HIF_REG_RST"
bitfld.long 0 0. " RST_0 "  "0 ,1 "
bitfld.long 0 1. " RST_1 "  "0 ,1 "
;tree.end

;tree "HIF_REG_RST_ACK"
base ad:0xa0320104
group 0--3
line.long 0 "HIF_REG_RST_ACK"
bitfld.long 0 0. " ACK "  "0 ,1 "
;tree.end

;tree "HIF_REG_MIF_CFG"
base ad:0xa0320108
group 0--3
line.long 0 "HIF_REG_MIF_CFG"
bitfld.long 0 0.--12. " LMI "  " "
bitfld.long 0 16.--28. " EMI "  " "
;tree.end

;tree "HIF_REG_HEC_MIF_CFG"
base ad:0xa032010c
group 0--3
line.long 0 "HIF_REG_HEC_MIF_CFG"
bitfld.long 0 0.--28. " HEC_MIF_CFG "  " "
;tree.end

;tree "HIF_REG_CFL"
base ad:0xa0320110
group 0--3
line.long 0 "HIF_REG_CFL"
bitfld.long 0 0.--3. " LEVEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "HIF_REG_FIFO_CMD"
base ad:0xa0320114
wgroup 0--3
line.long 0 "HIF_REG_FIFO_CMD"
hexfld.long 0 " CMD "
;tree.end

;tree "HIF_REG_FIFO_STS"
base ad:0xa0320118
group 0--3
line.long 0 "HIF_REG_FIFO_STS"
hexfld.long 0 " STATUS "
;tree.end

;tree "HIF_REG_SFL"
base ad:0xa032011c
group 0--3
line.long 0 "HIF_REG_SFL"
bitfld.long 0 0.--3. " LEVEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "HIF_REG_IT_ACK"
base ad:0xa0320120
group 0--3
line.long 0 "HIF_REG_IT_ACK"
bitfld.long 0 0. " ACK "  "0 ,1 "
;tree.end

;tree "HIF_REG_ERR_IT_ACK"
base ad:0xa0320124
group 0--3
line.long 0 "HIF_REG_ERR_IT_ACK"
bitfld.long 0 0. " ACK "  "0 ,1 "
;tree.end

;tree "HIF_REG_LMI_ERR"
base ad:0xa0320128
group 0--3
line.long 0 "HIF_REG_LMI_ERR"
bitfld.long 0 0.--6. " LMI_ERR "  " "
;tree.end

;tree "HIF_REG_EMI_ERR"
base ad:0xa032012c
group 0--3
line.long 0 "HIF_REG_EMI_ERR"
bitfld.long 0 0.--6. " EMI_ERR "  " "
;tree.end

;tree "HIF_REG_HEC_MIF_ERR"
base ad:0xa0320130
group 0--3
line.long 0 "HIF_REG_HEC_MIF_ERR"
bitfld.long 0 0.--1. " HEC_MIF_ERR "  "0 ,1 ,2 ,3 "
;tree.end

;tree "HIF_REG_HEC_STS"
base ad:0xa0320134
group 0--3
line.long 0 "HIF_REG_HEC_STS"
hexfld.long 0 " HEC_STS "
;tree.end

;tree "HIF_REG_HVC_STS"
base ad:0xa0320138
group 0--3
line.long 0 "HIF_REG_HVC_STS"
hexfld.long 0 " HVC_STS "
;tree.end

;tree "HIF_REG_HJE_STS"
base ad:0xa032013c
group 0--3
line.long 0 "HIF_REG_HJE_STS"
hexfld.long 0 " HJE_STS "
;tree.end

;tree "HIF_REG_CNT"
base ad:0xa0320140
group 0--3
line.long 0 "HIF_REG_CNT"
hexfld.long 0 " COUNTER "
;tree.end

;tree "HIF_REG_HEC_CHKSYN_DIS"
base ad:0xa0320144
group 0--3
line.long 0 "HIF_REG_HEC_CHKSYN_DIS"
bitfld.long 0 0.--16. " CHKSYN_DIS "  " "
;tree.end

;tree "HIF_REG_CLK_GATING"
base ad:0xa0320148
group 0--3
line.long 0 "HIF_REG_CLK_GATING"
bitfld.long 0 0.--2. " CLK_GATING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "HIF_REG_VERSION"
base ad:0xa032014c
group 0--3
line.long 0 "HIF_REG_VERSION"
hexfld.long 0 " VERSION "
;tree.end

;tree "NT3_REG_INIT_PRIORITY0"
base ad:0xa0320000
group 0--3
line.long 0 "NT3_REG_INIT_PRIORITY0"
bitfld.long 0 0.--4. " PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_TRUE "  "0 ,1 "
;tree.end

;tree "NT3_REG_INIT_PRIORITY1"
base ad:0xa0320004
group 0--3
line.long 0 "NT3_REG_INIT_PRIORITY1"
bitfld.long 0 0.--4. " PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_TRUE "  "0 ,1 "
;tree.end

;tree "NT3_REG_INIT_PRIORITY2"
base ad:0xa0320008
group 0--3
line.long 0 "NT3_REG_INIT_PRIORITY2"
bitfld.long 0 0.--4. " PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " IT_TRUE "  "0 ,1 "
;tree.end

;tree "NT3_REG_INIT_LIMIT0"
base ad:0xa0320024
group 0--3
line.long 0 "NT3_REG_INIT_LIMIT0"
bitfld.long 0 0.--3. " NEW_PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FRAME_SIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NT3_REG_INIT_LIMIT1"
base ad:0xa0320028
group 0--3
line.long 0 "NT3_REG_INIT_LIMIT1"
bitfld.long 0 0.--3. " NEW_PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FRAME_SIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NT3_REG_INIT_LIMIT2"
base ad:0xa032002c
group 0--3
line.long 0 "NT3_REG_INIT_LIMIT2"
bitfld.long 0 0.--3. " NEW_PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FRAME_SIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NT3_REG_TARG_PRIORITY"
base ad:0xa0320030
group 0--3
line.long 0 "NT3_REG_TARG_PRIORITY"
bitfld.long 0 0.--3. " PRIORITY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "ICN"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "NODE_HIBW1_ESRAM_IN_0_PRIORITY_REG"
base ad:0x81000000
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_1_PRIORITY_REG"
base ad:0x81000004
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_2_PRIORITY_REG"
base ad:0x81000008
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_3_PRIORITY_REG"
base ad:0x8100000c
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_3_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_0_ARB_1_LIMIT_REG"
base ad:0x81000030
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_0_ARB_2_LIMIT_REG"
base ad:0x81000034
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_0_ARB_3_LIMIT_REG"
base ad:0x81000038
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_1_ARB_1_LIMIT_REG"
base ad:0x8100003c
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_1_ARB_2_LIMIT_REG"
base ad:0x81000040
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_1_ARB_3_LIMIT_REG"
base ad:0x81000044
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_2_ARB_1_LIMIT_REG"
base ad:0x81000048
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_2_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_2_ARB_2_LIMIT_REG"
base ad:0x8100004c
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_2_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_2_ARB_3_LIMIT_REG"
base ad:0x81000050
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_2_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_3_ARB_1_LIMIT_REG"
base ad:0x81000054
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_3_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_3_ARB_2_LIMIT_REG"
base ad:0x81000058
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_3_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_ESRAM_IN_3_ARB_3_LIMIT_REG"
base ad:0x8100005c
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_3_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_DDR0_IN_0_PRIORITY_REG"
base ad:0x81000400
group 0--3
line.long 0 "NODE_HIBW1_DDR0_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW1_DDR0_IN_1_PRIORITY_REG"
base ad:0x81000404
group 0--3
line.long 0 "NODE_HIBW1_DDR0_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW1_DDR0_IN_2_PRIORITY_REG"
base ad:0x81000408
group 0--3
line.long 0 "NODE_HIBW1_DDR0_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW1_DDR0_IN_3_PRIORITY_REG"
base ad:0x8100040c
group 0--3
line.long 0 "NODE_HIBW1_DDR0_IN_3_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW1_DDR0_IN_0_LIMIT_REG"
base ad:0x81000430
group 0--3
line.long 0 "NODE_HIBW1_DDR0_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_DDR0_IN_1_LIMIT_REG"
base ad:0x81000434
group 0--3
line.long 0 "NODE_HIBW1_DDR0_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_DDR0_IN_2_LIMIT_REG"
base ad:0x81000438
group 0--3
line.long 0 "NODE_HIBW1_DDR0_IN_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_DDR0_IN_3_LIMIT_REG"
base ad:0x8100043c
group 0--3
line.long 0 "NODE_HIBW1_DDR0_IN_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_DDR0_OUT_0_PRIORITY_REG"
base ad:0x81000440
group 0--3
line.long 0 "NODE_HIBW1_DDR0_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW2_ESRAM_IN_0_PRIORITY_REG"
base ad:0x81000800
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW2_ESRAM_IN_1_PRIORITY_REG"
base ad:0x81000804
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW2_ESRAM_IN_0_ARB_1_LIMIT_REG"
base ad:0x81000818
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW2_ESRAM_IN_0_ARB_2_LIMIT_REG"
base ad:0x8100081c
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW2_ESRAM_IN_0_ARB_3_LIMIT_REG"
base ad:0x81000820
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW2_ESRAM_IN_1_ARB_1_LIMIT_REG"
base ad:0x81000824
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW2_ESRAM_IN_1_ARB_2_LIMIT_REG"
base ad:0x81000828
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW2_ESRAM_IN_1_ARB_3_LIMIT_REG"
base ad:0x8100082c
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW2_DDR0_IN_0_PRIORITY_REG"
base ad:0x81000c00
group 0--3
line.long 0 "NODE_HIBW2_DDR0_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW2_DDR0_IN_1_PRIORITY_REG"
base ad:0x81000c04
group 0--3
line.long 0 "NODE_HIBW2_DDR0_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW2_DDR0_IN_0_LIMIT_REG"
base ad:0x81000c18
group 0--3
line.long 0 "NODE_HIBW2_DDR0_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW2_DDR0_IN_1_LIMIT_REG"
base ad:0x81000c1c
group 0--3
line.long 0 "NODE_HIBW2_DDR0_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW2_DDR0_OUT_0_PRIORITY_REG"
base ad:0x81000c20
group 0--3
line.long 0 "NODE_HIBW2_DDR0_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM0_IN_0_PRIORITY_REG"
base ad:0x81001000
group 0--3
line.long 0 "NODE_ESRAM0_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_ESRAM0_IN_1_PRIORITY_REG"
base ad:0x81001004
group 0--3
line.long 0 "NODE_ESRAM0_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_ESRAM0_IN_2_PRIORITY_REG"
base ad:0x81001008
group 0--3
line.long 0 "NODE_ESRAM0_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_ESRAM0_IN_3_PRIORITY_REG"
base ad:0x8100100c
group 0--3
line.long 0 "NODE_ESRAM0_IN_3_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_ESRAM0_IN_0_LIMIT_REG"
base ad:0x81001030
group 0--3
line.long 0 "NODE_ESRAM0_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM0_IN_1_LIMIT_REG"
base ad:0x81001034
group 0--3
line.long 0 "NODE_ESRAM0_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM0_IN_2_LIMIT_REG"
base ad:0x81001038
group 0--3
line.long 0 "NODE_ESRAM0_IN_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM0_IN_3_LIMIT_REG"
base ad:0x8100103c
group 0--3
line.long 0 "NODE_ESRAM0_IN_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM0_OUT_0_PRIORITY_REG"
base ad:0x81001040
group 0--3
line.long 0 "NODE_ESRAM0_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM1_2_IN_0_PRIORITY_REG"
base ad:0x81001400
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_ESRAM1_2_IN_1_PRIORITY_REG"
base ad:0x81001404
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_ESRAM1_2_IN_2_PRIORITY_REG"
base ad:0x81001408
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_ESRAM1_2_IN_3_PRIORITY_REG"
base ad:0x8100140c
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_3_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_ESRAM1_2_IN_0_ARB_1_LIMIT_REG"
base ad:0x81001430
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM1_2_IN_0_ARB_2_LIMIT_REG"
base ad:0x81001434
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM1_2_IN_1_ARB_1_LIMIT_REG"
base ad:0x81001438
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM1_2_IN_1_ARB_2_LIMIT_REG"
base ad:0x8100143c
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM1_2_IN_2_ARB_1_LIMIT_REG"
base ad:0x81001440
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_2_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM1_2_IN_2_ARB_2_LIMIT_REG"
base ad:0x81001444
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_2_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM1_2_IN_3_ARB_1_LIMIT_REG"
base ad:0x81001448
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_3_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM1_2_IN_3_ARB_2_LIMIT_REG"
base ad:0x8100144c
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_3_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM3_4_IN_0_PRIORITY_REG"
base ad:0x81001800
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_ESRAM3_4_IN_1_PRIORITY_REG"
base ad:0x81001804
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_ESRAM3_4_IN_2_PRIORITY_REG"
base ad:0x81001808
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_ESRAM3_4_IN_3_PRIORITY_REG"
base ad:0x8100180c
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_3_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_ESRAM3_4_IN_0_ARB_1_LIMIT_REG"
base ad:0x81001830
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM3_4_IN_0_ARB_2_LIMIT_REG"
base ad:0x81001834
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM3_4_IN_1_ARB_1_LIMIT_REG"
base ad:0x81001838
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM3_4_IN_1_ARB_2_LIMIT_REG"
base ad:0x8100183c
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM3_4_IN_2_ARB_1_LIMIT_REG"
base ad:0x81001840
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_2_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM3_4_IN_2_ARB_2_LIMIT_REG"
base ad:0x81001844
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_2_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM3_4_IN_3_ARB_1_LIMIT_REG"
base ad:0x81001848
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_3_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_ESRAM3_4_IN_3_ARB_2_LIMIT_REG"
base ad:0x8100184c
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_3_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_DDR1_IN_0_PRIORITY_REG"
base ad:0x81001c00
group 0--3
line.long 0 "NODE_HIBW1_DDR1_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW1_DDR1_IN_1_PRIORITY_REG"
base ad:0x81001c04
group 0--3
line.long 0 "NODE_HIBW1_DDR1_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW1_DDR1_IN_2_PRIORITY_REG"
base ad:0x81001c08
group 0--3
line.long 0 "NODE_HIBW1_DDR1_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW1_DDR1_IN_3_PRIORITY_REG"
base ad:0x81001c0c
group 0--3
line.long 0 "NODE_HIBW1_DDR1_IN_3_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW1_DDR1_IN_0_LIMIT_REG"
base ad:0x81001c30
group 0--3
line.long 0 "NODE_HIBW1_DDR1_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_DDR1_IN_1_LIMIT_REG"
base ad:0x81001c34
group 0--3
line.long 0 "NODE_HIBW1_DDR1_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_DDR1_IN_2_LIMIT_REG"
base ad:0x81001c38
group 0--3
line.long 0 "NODE_HIBW1_DDR1_IN_2_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_DDR1_IN_3_LIMIT_REG"
base ad:0x81001c3c
group 0--3
line.long 0 "NODE_HIBW1_DDR1_IN_3_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW1_DDR1_OUT_0_PRIORITY_REG"
base ad:0x81001c40
group 0--3
line.long 0 "NODE_HIBW1_DDR1_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW2_DDR1_IN_0_PRIORITY_REG"
base ad:0x81002000
group 0--3
line.long 0 "NODE_HIBW2_DDR1_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW2_DDR1_IN_1_PRIORITY_REG"
base ad:0x81002004
group 0--3
line.long 0 "NODE_HIBW2_DDR1_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " MIR "  "0 ,1 "
;tree.end

;tree "NODE_HIBW2_DDR1_IN_0_LIMIT_REG"
base ad:0x81002018
group 0--3
line.long 0 "NODE_HIBW2_DDR1_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW2_DDR1_IN_1_LIMIT_REG"
base ad:0x8100201c
group 0--3
line.long 0 "NODE_HIBW2_DDR1_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " NEWPRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--11. " FSIZE "  " "
bitfld.long 0 12.--16. " LIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_HIBW2_DDR1_OUT_0_PRIORITY_REG"
base ad:0x81002020
group 0--3
line.long 0 "NODE_HIBW2_DDR1_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--4. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "NODE_DDR_AWQOS_DSP_DDR1_REG"
base ad:0x81003400
group 0--3
line.long 0 "NODE_DDR_AWQOS_DSP_DDR1_REG"
bitfld.long 0 0.--3. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "NODE_DDR_ARQOS_DSP_DDR1_REG"
base ad:0x81003404
group 0--3
line.long 0 "NODE_DDR_ARQOS_DSP_DDR1_REG"
bitfld.long 0 0.--3. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "NODE_DDR_ARQOS_DSP_DDR0_REG"
base ad:0x81003408
group 0--3
line.long 0 "NODE_DDR_ARQOS_DSP_DDR0_REG"
bitfld.long 0 0.--3. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "NODE_DDR_AWQOS_DSP_DDR0_REG"
base ad:0x8100340c
group 0--3
line.long 0 "NODE_DDR_AWQOS_DSP_DDR0_REG"
bitfld.long 0 0.--3. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "NODE_DDR_AWQOS_ARM_DDR_REG"
base ad:0x81003410
group 0--3
line.long 0 "NODE_DDR_AWQOS_ARM_DDR_REG"
bitfld.long 0 0.--3. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "NODE_DDR_ARQOS_ARM_DDR_REG"
base ad:0x81003414
group 0--3
line.long 0 "NODE_DDR_ARQOS_ARM_DDR_REG"
bitfld.long 0 0.--3. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "NODE_SGA_AWQOS_DDR0_HIBW2_REG"
base ad:0x81003418
group 0--3
line.long 0 "NODE_SGA_AWQOS_DDR0_HIBW2_REG"
bitfld.long 0 0.--3. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "NODE_SGA_ARQOS_DDR0_HIBW2_REG"
base ad:0x8100341c
group 0--3
line.long 0 "NODE_SGA_ARQOS_DDR0_HIBW2_REG"
bitfld.long 0 0.--3. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "NODE_SGA_AWQOS_SGA_HIBW2_REG"
base ad:0x81003420
group 0--3
line.long 0 "NODE_SGA_AWQOS_SGA_HIBW2_REG"
bitfld.long 0 0.--3. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "NODE_SGA_ARQOS_SGA_HIBW2_REG"
base ad:0x81003424
group 0--3
line.long 0 "NODE_SGA_ARQOS_SGA_HIBW2_REG"
bitfld.long 0 0.--3. " PRI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "ICNPMU"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "PMU_DFV0"
base ad:0x80157e00
group 0--3
line.long 0 "PMU_DFV0"
bitfld.long 0 0. " DFV0 "  "0 ,1 "
;tree.end

;tree "STOP_TRAFFIC"
base ad:0x80157e04
rgroup 0--3
line.long 0 "STOP_TRAFFIC"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "STOP_TRAFFIC_CLR"
base ad:0x80157e08
wgroup 0--3
line.long 0 "STOP_TRAFFIC_CLR"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "STOP_TRAFFIC_SET"
base ad:0x80157e0c
wgroup 0--3
line.long 0 "STOP_TRAFFIC_SET"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "CHANNEL_CLOSED_STA"
base ad:0x80157e10
rgroup 0--3
line.long 0 "CHANNEL_CLOSED_STA"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "CHANNEL_CLOSED_ITS"
base ad:0x80157e14
rgroup 0--3
line.long 0 "CHANNEL_CLOSED_ITS"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "CHANNEL_CLOSED_ITS_CLR"
base ad:0x80157e18
wgroup 0--3
line.long 0 "CHANNEL_CLOSED_ITS_CLR"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "CHANNEL_CLOSED_ITS_SET"
base ad:0x80157e1c
wgroup 0--3
line.long 0 "CHANNEL_CLOSED_ITS_SET"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "CHANNEL_CLOSED_ITM"
base ad:0x80157e20
rgroup 0--3
line.long 0 "CHANNEL_CLOSED_ITM"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "CHANNEL_CLOSED_ITM_CLR"
base ad:0x80157e24
wgroup 0--3
line.long 0 "CHANNEL_CLOSED_ITM_CLR"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "CHANNEL_CLOSED_ITM_SET"
base ad:0x80157e28
wgroup 0--3
line.long 0 "CHANNEL_CLOSED_ITM_SET"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "AUTO_PD_PROC"
base ad:0x80157e2c
rgroup 0--3
line.long 0 "AUTO_PD_PROC"
;tree.end

;tree "AUTO_PD_PROC_CLR"
base ad:0x80157e30
rgroup 0--3
line.long 0 "AUTO_PD_PROC_CLR"
;tree.end

;tree "AUTO_PD_PROC_SET"
base ad:0x80157e34
rgroup 0--3
line.long 0 "AUTO_PD_PROC_SET"
;tree.end

;tree "GATE"
base ad:0x80157e38
rgroup 0--3
line.long 0 "GATE"
;tree.end

;tree "GATE_SET"
base ad:0x80157e40
rgroup 0--3
line.long 0 "GATE_SET"
;tree.end

;tree "TARGET_READY_STA"
base ad:0x80157e44
rgroup 0--3
line.long 0 "TARGET_READY_STA"
;tree.end

;tree "TARGET_READY_ITS"
base ad:0x80157e48
rgroup 0--3
line.long 0 "TARGET_READY_ITS"
;tree.end

;tree "TARGET_READY_ITS_CLR"
base ad:0x80157e4c
rgroup 0--3
line.long 0 "TARGET_READY_ITS_CLR"
;tree.end

;tree "TARGET_READY_ITS_SET"
base ad:0x80157e50
rgroup 0--3
line.long 0 "TARGET_READY_ITS_SET"
;tree.end

;tree "TARGET_READY_ITM"
base ad:0x80157e54
rgroup 0--3
line.long 0 "TARGET_READY_ITM"
;tree.end

;tree "TARGET_READY_ITM_CLR"
base ad:0x80157e58
rgroup 0--3
line.long 0 "TARGET_READY_ITM_CLR"
;tree.end

;tree "TARGET_READY_ITM_SET"
base ad:0x80157e5c
rgroup 0--3
line.long 0 "TARGET_READY_ITM_SET"
;tree.end

;tree "AUTO_WU_PROC"
base ad:0x80157e60
rgroup 0--3
line.long 0 "AUTO_WU_PROC"
;tree.end

;tree "AUTO_WU_PROC_CLR"
base ad:0x80157e64
rgroup 0--3
line.long 0 "AUTO_WU_PROC_CLR"
;tree.end

;tree "AUTO_WU_PROC_SET"
base ad:0x80157e68
rgroup 0--3
line.long 0 "AUTO_WU_PROC_SET"
;tree.end

;tree "INTERRUPT_MODE"
base ad:0x80157e6c
group 0--3
line.long 0 "INTERRUPT_MODE"
bitfld.long 0 0. " MODE "  "0 ,1 "
;tree.end

;tree "EXTERNAL_INTERRUPT_STA"
base ad:0x80157e70
rgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_STA"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "EXTERNAL_INTERRUPT_ITS"
base ad:0x80157e74
rgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_ITS"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "EXTERNAL_INTERRUPT_ITS_CLR"
base ad:0x80157e78
wgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_ITS_CLR"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "EXTERNAL_INTERRUPT_ITS_SET"
base ad:0x80157e7c
wgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_ITS_SET"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "EXTERNAL_INTERRUPT_ITM"
base ad:0x80157e80
rgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_ITM"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "EXTERNAL_INTERRUPT_ITM_CLR"
base ad:0x80157e84
wgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_ITM_CLR"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "EXTERNAL_INTERRUPT_ITM_SET"
base ad:0x80157e88
wgroup 0--3
line.long 0 "EXTERNAL_INTERRUPT_ITM_SET"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

;tree "USER_CTRL_ERROR_MODE"
base ad:0x80157e8c
group 0--3
line.long 0 "USER_CTRL_ERROR_MODE"
bitfld.long 0 0. " SGA_S "  "0 ,1 "
bitfld.long 0 1. " SIA_S "  "0 ,1 "
bitfld.long 0 2. " DISP_S "  "0 ,1 "
bitfld.long 0 3. " SVA_S "  "0 ,1 "
bitfld.long 0 4. " DDR0_HIBW1 "  "0 ,1 "
bitfld.long 0 5. " DDR0_HIBW2 "  "0 ,1 "
bitfld.long 0 6. " B2R2_S "  "0 ,1 "
bitfld.long 0 7. " DDR0_LOLAT "  "0 ,1 "
bitfld.long 0 8. " DDR1_LOLAT "  "0 ,1 "
bitfld.long 0 9. " DDR1_HIBW1 "  "0 ,1 "
bitfld.long 0 10. " DDR1_HIBW2 "  "0 ,1 "
bitfld.long 0 11. " B2R2_1_S "  "0 ,1 "
bitfld.long 0 12. " G1_S "  "0 ,1 "
bitfld.long 0 13. " HVA_S "  "0 ,1 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "L220"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "L2CC_ID"
base ad:0xa0414000
rgroup 0--3
line.long 0 "L2CC_ID"
bitfld.long 0 0.--5. " RTL_RLS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--9. " PART_NBR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10.--15. " CACHE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
hexfld.byte 3 " IMP_ID "
;tree.end

;tree "L2CC_TYPE"
base ad:0xa0414004
rgroup 0--3
line.long 0 "L2CC_TYPE"
bitfld.long 0 0.--11. " ISIZE "  " "
bitfld.long 0 12.--13. " DLINELGTH "  "0 ,1 ,2 ,3 "
bitfld.long 0 15.--18. " DASS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--22. " DWAYSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " H "  "0 ,1 "
bitfld.long 0 25.--28. " CTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "L2CC_CR"
base ad:0xa0414100
group 0--3
line.long 0 "L2CC_CR"
bitfld.long 0 0. " CEN "  "0 ,1 "
;tree.end

;tree "L2CC_ACR"
base ad:0xa0414104
group 0--3
line.long 0 "L2CC_ACR"
bitfld.long 0 0.--2. " LATDRAMR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " LATDRAMW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--8. " LATTRAM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9.--11. " LATDRTYRAM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--16. " ASSOC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 17.--19. " WAYSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " EVTMBEN "  "0 ,1 "
bitfld.long 0 21. " PEN "  "0 ,1 "
bitfld.long 0 22. " SAOVREN "  "0 ,1 "
bitfld.long 0 23.--24. " FWA "  "0 ,1 ,2 ,3 "
bitfld.long 0 25. " OVRSCK "  "0 ,1 "
bitfld.long 0 26. " NSLDEN "  "0 ,1 "
bitfld.long 0 27. " NSIAC "  "0 ,1 "
;tree.end

;tree "L2CC_EVTCNT"
base ad:0xa0414200
group 0--3
line.long 0 "L2CC_EVTCNT"
bitfld.long 0 0. " EVTCNTEN "  "0 ,1 "
bitfld.long 0 1.--2. " CNTRST "  "0 ,1 ,2 ,3 "
;tree.end

;tree "L2CC_EVTCNT1CFG"
base ad:0xa0414204
group 0--3
line.long 0 "L2CC_EVTCNT1CFG"
bitfld.long 0 0.--1. " ITGEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--5. " EVTSRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "L2CC_EVTCNT0CFG"
base ad:0xa0414208
group 0--3
line.long 0 "L2CC_EVTCNT0CFG"
bitfld.long 0 0.--1. " ITGEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--5. " EVTSRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "L2CC_EVTCNT1"
base ad:0xa041420c
group 0--3
line.long 0 "L2CC_EVTCNT1"
hexfld.long 0 " EVTCNTVAL "
;tree.end

;tree "L2CC_EVTCNT0"
base ad:0xa0414210
group 0--3
line.long 0 "L2CC_EVTCNT0"
hexfld.long 0 " EVTCNTVAL "
;tree.end

;tree "L2CC_IMSC"
base ad:0xa0414214
group 0--3
line.long 0 "L2CC_IMSC"
bitfld.long 0 0. " ECNTRIM "  "0 ,1 "
bitfld.long 0 1. " PARRTIM "  "0 ,1 "
bitfld.long 0 2. " PARRDIM "  "0 ,1 "
bitfld.long 0 3. " ERRWTIM "  "0 ,1 "
bitfld.long 0 4. " ERRWDIM "  "0 ,1 "
bitfld.long 0 5. " ERRRTIM "  "0 ,1 "
bitfld.long 0 6. " ERRRDIM "  "0 ,1 "
bitfld.long 0 7. " SLVERRIM "  "0 ,1 "
bitfld.long 0 8. " DECERRIM "  "0 ,1 "
;tree.end

;tree "L2CC_MIS"
base ad:0xa0414218
rgroup 0--3
line.long 0 "L2CC_MIS"
bitfld.long 0 0. " ECNTRMIS "  "0 ,1 "
bitfld.long 0 1. " PARRTMIS "  "0 ,1 "
bitfld.long 0 2. " PARRDMIS "  "0 ,1 "
bitfld.long 0 3. " ERRWTMIS "  "0 ,1 "
bitfld.long 0 4. " ERRWDMIS "  "0 ,1 "
bitfld.long 0 5. " ERRRTMIS "  "0 ,1 "
bitfld.long 0 6. " ERRRDMIS "  "0 ,1 "
bitfld.long 0 7. " SLVERRMIS "  "0 ,1 "
bitfld.long 0 8. " DECERRMIS "  "0 ,1 "
;tree.end

;tree "L2CC_RIS"
base ad:0xa041421c
rgroup 0--3
line.long 0 "L2CC_RIS"
bitfld.long 0 0. " ECNTRRIS "  "0 ,1 "
bitfld.long 0 1. " PARRTRIS "  "0 ,1 "
bitfld.long 0 2. " PARRDRIS "  "0 ,1 "
bitfld.long 0 3. " ERRWTRIS "  "0 ,1 "
bitfld.long 0 4. " ERRWDRIS "  "0 ,1 "
bitfld.long 0 5. " ERRRTRIS "  "0 ,1 "
bitfld.long 0 6. " ERRRDRIS "  "0 ,1 "
bitfld.long 0 7. " SLVERRRIS "  "0 ,1 "
bitfld.long 0 8. " DECERRRIS "  "0 ,1 "
;tree.end

;tree "L2CC_ICR"
base ad:0xa0414220
group 0--3
line.long 0 "L2CC_ICR"
bitfld.long 0 0. " ECNTRIC "  "0 ,1 "
bitfld.long 0 1. " PARRTIC "  "0 ,1 "
bitfld.long 0 2. " PARRDIC "  "0 ,1 "
bitfld.long 0 3. " ERRWTIC "  "0 ,1 "
bitfld.long 0 4. " ERRWDIC "  "0 ,1 "
bitfld.long 0 5. " ERRRTIC "  "0 ,1 "
bitfld.long 0 6. " ERRRDIC "  "0 ,1 "
bitfld.long 0 7. " SLVERRIC "  "0 ,1 "
bitfld.long 0 8. " DECERRIC "  "0 ,1 "
;tree.end

;tree "L2CC_CS"
base ad:0xa0414730
group 0--3
line.long 0 "L2CC_CS"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 1.--31. " RAZ "  " "
;tree.end

;tree "L2CC_ILPA"
base ad:0xa0414770
group 0--3
line.long 0 "L2CC_ILPA"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--15. " Index "  " "
hexfld.word 2 " TAG "
;tree.end

;tree "L2CC_IW"
base ad:0xa041477c
group 0--3
line.long 0 "L2CC_IW"
hexfld.byte 0 " Way_bits "
;tree.end

;tree "L2CC_CLPA"
base ad:0xa04147b0
group 0--3
line.long 0 "L2CC_CLPA"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--15. " Index "  " "
hexfld.word 2 " TAG "
;tree.end

;tree "L2CC_CLIW"
base ad:0xa04147b8
group 0--3
line.long 0 "L2CC_CLIW"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--15. " Index "  " "
bitfld.long 0 29.--31. " WAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "L2CC_CW"
base ad:0xa04147bc
group 0--3
line.long 0 "L2CC_CW"
hexfld.byte 0 " Way_bits "
;tree.end

;tree "L2CC_CILPA"
base ad:0xa04147f0
group 0--3
line.long 0 "L2CC_CILPA"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--15. " Index "  " "
hexfld.word 2 " TAG "
;tree.end

;tree "L2CC_CILIW"
base ad:0xa04147f8
group 0--3
line.long 0 "L2CC_CILIW"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--15. " Index "  " "
bitfld.long 0 29.--31. " WAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "L2CC_CIW"
base ad:0xa04147fc
group 0--3
line.long 0 "L2CC_CIW"
hexfld.byte 0 " Way_bits "
;tree.end

;tree "L2CC_DLOCKD"
base ad:0xa0414900
group 0--3
line.long 0 "L2CC_DLOCKD"
hexfld.byte 0 " datalock "
;tree.end

;tree "L2CC_ILOCKD"
base ad:0xa0414904
group 0--3
line.long 0 "L2CC_ILOCKD"
hexfld.byte 0 " instrlock "
;tree.end

;tree "L2CC_TOR"
base ad:0xa0414f00
group 0--3
line.long 0 "L2CC_TOR"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--15. " INDEX "  " "
bitfld.long 0 29.--31. " WAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "L2CC_LDR0"
base ad:0xa0414f10
group 0--3
line.long 0 "L2CC_LDR0"
hexfld.long 0 " data "
;tree.end

;tree "L2CC_LDR1"
base ad:0xa0414f14
group 0--3
line.long 0 "L2CC_LDR1"
hexfld.long 0 " data "
;tree.end

;tree "L2CC_LDR2"
base ad:0xa0414f18
group 0--3
line.long 0 "L2CC_LDR2"
hexfld.long 0 " data "
;tree.end

;tree "L2CC_LDR3"
base ad:0xa0414f1c
group 0--3
line.long 0 "L2CC_LDR3"
hexfld.long 0 " data "
;tree.end

;tree "L2CC_LDR4"
base ad:0xa0414f20
group 0--3
line.long 0 "L2CC_LDR4"
hexfld.long 0 " data "
;tree.end

;tree "L2CC_LDR5"
base ad:0xa0414f24
group 0--3
line.long 0 "L2CC_LDR5"
hexfld.long 0 " data "
;tree.end

;tree "L2CC_LDR6"
base ad:0xa0414f28
group 0--3
line.long 0 "L2CC_LDR6"
hexfld.long 0 " data "
;tree.end

;tree "L2CC_LDR7"
base ad:0xa0414f2c
group 0--3
line.long 0 "L2CC_LDR7"
hexfld.long 0 " data "
;tree.end

;tree "L2CC_LTR"
base ad:0xa0414f30
group 0--3
line.long 0 "L2CC_LTR"
bitfld.long 0 7. " NS "  "0 ,1 "
bitfld.long 0 8.--10. " VPNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " D0 "  "0 ,1 "
bitfld.long 0 12. " D1 "  "0 ,1 "
bitfld.long 0 13. " VLD "  "0 ,1 "
bitfld.long 0 14.--31. " TAG "  " "
;tree.end

;tree "L2CC_DR"
base ad:0xa0414f40
group 0--3
line.long 0 "L2CC_DR"
bitfld.long 0 0. " DCL "  "0 ,1 "
bitfld.long 0 1. " DWB "  "0 ,1 "
bitfld.long 0 2. " SPNIDEN "  "0 ,1 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "MCDE"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
if (((data.long(ad:0x80157064)&0x100)!=0x100)||((data.long(ad:0x8015741c)&0x100000)!=0x100000)||((data.long(ad:0x801571ec)&0x4)!=0x4)||((data.long(ad:0x80157428)&0x400)!=0x0))
base ad:0x0
hgroup 0--3
TEXTLINE "MCDE is not acessible. Please activate its clock or release its reset"
else
;tree "CR"
base ad:0xa0350000
group 0--3
line.long 0 "CR"
bitfld.long 0 15. " IFIFOCTRLEN "  "0 ,1 "
bitfld.long 0 30. " AUTOCLKG_EN "  "0 ,1 "
bitfld.long 0 31. " MCDEEN "  "0 ,1 "
;tree.end

;tree "CONF0"
base ad:0xa0350004
group 0--3
line.long 0 "CONF0"
bitfld.long 0 0. " SYNCMUX0 "  "0 ,1 "
bitfld.long 0 1. " SYNCMUX1 "  "0 ,1 "
bitfld.long 0 2. " SYNCMUX2 "  "0 ,1 "
bitfld.long 0 3. " SYNCMUX3 "  "0 ,1 "
bitfld.long 0 4. " SYNCMUX4 "  "0 ,1 "
bitfld.long 0 5. " SYNCMUX5 "  "0 ,1 "
bitfld.long 0 6. " SYNCMUX6 "  "0 ,1 "
bitfld.long 0 7. " SYNCMUX7 "  "0 ,1 "
bitfld.long 0 12.--14. " IFIFOCTRLWTRMRKLVL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " OUTMUX0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--21. " OUTMUX1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 22.--24. " OUTMUX2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 25.--27. " OUTMUX3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 28.--30. " OUTMUX4 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "AIS"
base ad:0xa0350100
group 0--3
line.long 0 "AIS"
bitfld.long 0 0. " MCDEPPI "  "0 ,1 "
bitfld.long 0 1. " MCDEOVLI "  "0 ,1 "
bitfld.long 0 2. " MCDECHNLI "  "0 ,1 "
bitfld.long 0 3. " MCDEERRI "  "0 ,1 "
bitfld.long 0 4. " DSI0AI "  "0 ,1 "
bitfld.long 0 5. " DSI1AI "  "0 ,1 "
bitfld.long 0 6. " DSI2AI "  "0 ,1 "
;tree.end

;tree "IMSC"
base ad:0xa0350104
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " VCMPAIM "  "0 ,1 "
bitfld.long 0 1. " VCMPBIM "  "0 ,1 "
bitfld.long 0 2. " VSCC0IM "  "0 ,1 "
bitfld.long 0 3. " VSCC1IM "  "0 ,1 "
bitfld.long 0 4. " VCMPC0IM "  "0 ,1 "
bitfld.long 0 5. " VCMPC1IM "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDIM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "IMSCOVL"
base ad:0xa0350108
group 0--3
line.long 0 "IMSCOVL"
hexfld.word 0 " OVLRDIM "
hexfld.word 2 " OVLFDIM "
;tree.end

;tree "IMSCCHNL"
base ad:0xa035010c
group 0--3
line.long 0 "IMSCCHNL"
hexfld.word 0 " CHNLRDIM "
hexfld.word 2 " CHNLAIM "
;tree.end

;tree "IMSCERR"
base ad:0xa0350110
group 0--3
line.long 0 "IMSCERR"
bitfld.long 0 0. " FUAIM "  "0 ,1 "
bitfld.long 0 1. " FUBIM "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDIM "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFEIM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " ROTBFEIM "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " FUC0IM "  "0 ,1 "
bitfld.long 0 8. " FUC1IM "  "0 ,1 "
hexfld.word 2 " OVLFERRIM "
;tree.end

;tree "RIS"
base ad:0xa0350114
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " VCMPARIS "  "0 ,1 "
bitfld.long 0 1. " VCMPBRIS "  "0 ,1 "
bitfld.long 0 2. " VSCC0RIS "  "0 ,1 "
bitfld.long 0 3. " VSCC1RIS "  "0 ,1 "
bitfld.long 0 4. " VCMPC0RIS "  "0 ,1 "
bitfld.long 0 5. " VCMPC1RIS "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDRIS "  "0 ,1 ,2 ,3 "
;tree.end

;tree "RISOVL"
base ad:0xa0350118
rgroup 0--3
line.long 0 "RISOVL"
hexfld.word 0 " OVLRDRIS "
hexfld.word 2 " OVLFDRIS "
;tree.end

;tree "RISCHNL"
base ad:0xa035011c
rgroup 0--3
line.long 0 "RISCHNL"
hexfld.word 0 " CHNLRDRIS "
hexfld.word 2 " CHNLARIS "
;tree.end

;tree "RISERR"
base ad:0xa0350120
rgroup 0--3
line.long 0 "RISERR"
bitfld.long 0 0. " FUARIS "  "0 ,1 "
bitfld.long 0 1. " FUBRIS "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDRIS "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFERIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " ROTBFERIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " FUC0RIS "  "0 ,1 "
bitfld.long 0 8. " FUC1RIS "  "0 ,1 "
hexfld.word 2 " OVLFERRIS "
;tree.end

;tree "MIS"
base ad:0xa0350124
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " VCMPAMIS "  "0 ,1 "
bitfld.long 0 1. " VCMPBMIS "  "0 ,1 "
bitfld.long 0 2. " VSCC0MIS "  "0 ,1 "
bitfld.long 0 3. " VSCC1MIS "  "0 ,1 "
bitfld.long 0 4. " VCMPC0MIS "  "0 ,1 "
bitfld.long 0 5. " VCMPC1MIS "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDMIS "  "0 ,1 ,2 ,3 "
;tree.end

;tree "MISOVL"
base ad:0xa0350128
group 0--3
line.long 0 "MISOVL"
hexfld.word 0 " OVLRDMIS "
hexfld.word 2 " OVLFDMIS "
;tree.end

;tree "MISCHNL"
base ad:0xa035012c
group 0--3
line.long 0 "MISCHNL"
hexfld.word 0 " CHNLRDMIS "
hexfld.word 2 " CHNLAMIS "
;tree.end

;tree "MISERR"
base ad:0xa0350130
group 0--3
line.long 0 "MISERR"
bitfld.long 0 0. " FUAMIS "  "0 ,1 "
bitfld.long 0 1. " FUBMIS "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDMIS "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFEMIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " ROTBFEMIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " FUC0MIS "  "0 ,1 "
bitfld.long 0 8. " FUC1MIS "  "0 ,1 "
hexfld.word 2 " OVLFERMIS "
;tree.end

;tree "SIS"
base ad:0xa0350134
group 0--3
line.long 0 "SIS"
bitfld.long 0 0. " VCMPASIS "  "0 ,1 "
bitfld.long 0 1. " VCMPBSIS "  "0 ,1 "
bitfld.long 0 2. " VSCC0SIS "  "0 ,1 "
bitfld.long 0 3. " VSCC1SIS "  "0 ,1 "
bitfld.long 0 4. " VCMPC0SIS "  "0 ,1 "
bitfld.long 0 5. " VCMPC1SIS "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDSIS "  "0 ,1 ,2 ,3 "
;tree.end

;tree "SISOVL"
base ad:0xa0350138
group 0--3
line.long 0 "SISOVL"
hexfld.word 0 " OVLRDSIS "
hexfld.word 2 " OVLFDSIS "
;tree.end

;tree "SISCHNL"
base ad:0xa035013c
group 0--3
line.long 0 "SISCHNL"
hexfld.word 0 " CHNLRDSIS "
hexfld.word 2 " CHNLASIS "
;tree.end

;tree "SISERR"
base ad:0xa0350140
group 0--3
line.long 0 "SISERR"
bitfld.long 0 0. " FUASIS "  "0 ,1 "
bitfld.long 0 1. " FUBSIS "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDSIS "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFESIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " ROTBFESIS "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " FUC0SIS "  "0 ,1 "
bitfld.long 0 8. " FUC1SIS "  "0 ,1 "
hexfld.word 2 " OVLFERSIS "
;tree.end

;tree "PID"
base ad:0xa03501fc
group 0--3
line.long 0 "PID"
hexfld.byte 0 " METALFIX_VERSION "
hexfld.byte 1 " DEVELOPMENT_VERSION "
hexfld.byte 2 " MINOR_VERSION "
hexfld.byte 3 " MAJOR_VERSION "
;tree.end

;tree "EXTSRC0A0"
base ad:0xa0350200
group 0--3
line.long 0 "EXTSRC0A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

;tree "EXTSRC0A1"
base ad:0xa0350204
group 0--3
line.long 0 "EXTSRC0A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

;tree "EXTSRC0CONF"
base ad:0xa035020c
group 0--3
line.long 0 "EXTSRC0CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

;tree "EXTSRC0CR"
base ad:0xa0350210
group 0--3
line.long 0 "EXTSRC0CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

;tree "EXTSRC1A0"
base ad:0xa0350220
group 0--3
line.long 0 "EXTSRC1A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

;tree "EXTSRC1A1"
base ad:0xa0350224
group 0--3
line.long 0 "EXTSRC1A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

;tree "EXTSRC1CONF"
base ad:0xa035022c
group 0--3
line.long 0 "EXTSRC1CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

;tree "EXTSRC1CR"
base ad:0xa0350230
group 0--3
line.long 0 "EXTSRC1CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

;tree "EXTSRC2A0"
base ad:0xa0350240
group 0--3
line.long 0 "EXTSRC2A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

;tree "EXTSRC2A1"
base ad:0xa0350244
group 0--3
line.long 0 "EXTSRC2A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

;tree "EXTSRC2CONF"
base ad:0xa035024c
group 0--3
line.long 0 "EXTSRC2CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

;tree "EXTSRC2CR"
base ad:0xa0350250
group 0--3
line.long 0 "EXTSRC2CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

;tree "EXTSRC3A0"
base ad:0xa0350260
group 0--3
line.long 0 "EXTSRC3A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

;tree "EXTSRC3A1"
base ad:0xa0350264
group 0--3
line.long 0 "EXTSRC3A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

;tree "EXTSRC3CONF"
base ad:0xa035026c
group 0--3
line.long 0 "EXTSRC3CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

;tree "EXTSRC3CR"
base ad:0xa0350270
group 0--3
line.long 0 "EXTSRC3CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

;tree "EXTSRC4A0"
base ad:0xa0350280
group 0--3
line.long 0 "EXTSRC4A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

;tree "EXTSRC4A1"
base ad:0xa0350284
group 0--3
line.long 0 "EXTSRC4A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

;tree "EXTSRC4CONF"
base ad:0xa035028c
group 0--3
line.long 0 "EXTSRC4CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

;tree "EXTSRC4CR"
base ad:0xa0350290
group 0--3
line.long 0 "EXTSRC4CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

;tree "EXTSRC5A0"
base ad:0xa03502a0
group 0--3
line.long 0 "EXTSRC5A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

;tree "EXTSRC5A1"
base ad:0xa03502a4
group 0--3
line.long 0 "EXTSRC5A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

;tree "EXTSRC5CONF"
base ad:0xa03502ac
group 0--3
line.long 0 "EXTSRC5CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

;tree "EXTSRC5CR"
base ad:0xa03502b0
group 0--3
line.long 0 "EXTSRC5CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

;tree "EXTSRC6A0"
base ad:0xa03502c0
group 0--3
line.long 0 "EXTSRC6A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

;tree "EXTSRC6A1"
base ad:0xa03502c4
group 0--3
line.long 0 "EXTSRC6A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

;tree "EXTSRC6A2"
base ad:0xa03502c8
group 0--3
line.long 0 "EXTSRC6A2"
bitfld.long 0 0.--2. " BASEADDRESS2_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS2_MSB "  " "
;tree.end

;tree "EXTSRC6CONF"
base ad:0xa03502cc
group 0--3
line.long 0 "EXTSRC6CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

;tree "EXTSRC6CR"
base ad:0xa03502d0
group 0--3
line.long 0 "EXTSRC6CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

;tree "EXTSRC7A0"
base ad:0xa03502e0
group 0--3
line.long 0 "EXTSRC7A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

;tree "EXTSRC7A1"
base ad:0xa03502e4
group 0--3
line.long 0 "EXTSRC7A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

;tree "EXTSRC7CONF"
base ad:0xa03502ec
group 0--3
line.long 0 "EXTSRC7CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

;tree "EXTSRC7CR"
base ad:0xa03502f0
group 0--3
line.long 0 "EXTSRC7CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

;tree "EXTSRC8A0"
base ad:0xa0350300
group 0--3
line.long 0 "EXTSRC8A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

;tree "EXTSRC8A1"
base ad:0xa0350304
group 0--3
line.long 0 "EXTSRC8A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

;tree "EXTSRC8CONF"
base ad:0xa035030c
group 0--3
line.long 0 "EXTSRC8CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

;tree "EXTSRC8CR"
base ad:0xa0350310
group 0--3
line.long 0 "EXTSRC8CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

;tree "EXTSRC9A0"
base ad:0xa0350320
group 0--3
line.long 0 "EXTSRC9A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
;tree.end

;tree "EXTSRC9A1"
base ad:0xa0350324
group 0--3
line.long 0 "EXTSRC9A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
;tree.end

;tree "EXTSRC9CONF"
base ad:0xa035032c
group 0--3
line.long 0 "EXTSRC9CONF"
bitfld.long 0 0.--1. " BUF_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " BUF_NB "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " PRI_OVLID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
;tree.end

;tree "EXTSRC9CR"
base ad:0xa0350330
group 0--3
line.long 0 "EXTSRC9CR"
bitfld.long 0 0.--1. " SEL_MOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
;tree.end

;tree "OVL0CR"
base ad:0xa0350400
group 0--3
line.long 0 "OVL0CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "OVL0CONF"
base ad:0xa0350404
group 0--3
line.long 0 "OVL0CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

;tree "OVL0CONF2"
base ad:0xa0350408
group 0--3
line.long 0 "OVL0CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
;tree.end

;tree "OVL0JINC"
base ad:0xa035040c
group 0--3
line.long 0 "OVL0JINC"
hexfld.long 0 " LJINC "
;tree.end

;tree "OVL0CROP"
base ad:0xa0350410
group 0--3
line.long 0 "OVL0CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

;tree "OVL0COMP"
base ad:0xa0350414
group 0--3
line.long 0 "OVL0COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "OVL1CR"
base ad:0xa0350420
group 0--3
line.long 0 "OVL1CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "OVL1CONF"
base ad:0xa0350424
group 0--3
line.long 0 "OVL1CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

;tree "OVL1CONF2"
base ad:0xa0350428
group 0--3
line.long 0 "OVL1CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
;tree.end

;tree "OVL1JINC"
base ad:0xa035042c
group 0--3
line.long 0 "OVL1JINC"
hexfld.long 0 " LJINC "
;tree.end

;tree "OVL1CROP"
base ad:0xa0350430
group 0--3
line.long 0 "OVL1CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

;tree "OVL1COMP"
base ad:0xa0350434
group 0--3
line.long 0 "OVL1COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "OVL2CR"
base ad:0xa0350440
group 0--3
line.long 0 "OVL2CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "OVL2CONF"
base ad:0xa0350444
group 0--3
line.long 0 "OVL2CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

;tree "OVL2CONF2"
base ad:0xa0350448
group 0--3
line.long 0 "OVL2CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
;tree.end

;tree "OVL2JINC"
base ad:0xa035044c
group 0--3
line.long 0 "OVL2JINC"
hexfld.long 0 " LJINC "
;tree.end

;tree "OVL2CROP"
base ad:0xa0350450
group 0--3
line.long 0 "OVL2CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

;tree "OVL2COMP"
base ad:0xa0350454
group 0--3
line.long 0 "OVL2COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "OVL3CR"
base ad:0xa0350460
group 0--3
line.long 0 "OVL3CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "OVL3CONF"
base ad:0xa0350464
group 0--3
line.long 0 "OVL3CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

;tree "OVL3CONF2"
base ad:0xa0350468
group 0--3
line.long 0 "OVL3CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
;tree.end

;tree "OVL3JINC"
base ad:0xa035046c
group 0--3
line.long 0 "OVL3JINC"
hexfld.long 0 " LJINC "
;tree.end

;tree "OVL3CROP"
base ad:0xa0350470
group 0--3
line.long 0 "OVL3CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

;tree "OVL3COMP"
base ad:0xa0350474
group 0--3
line.long 0 "OVL3COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "OVL4CR"
base ad:0xa0350480
group 0--3
line.long 0 "OVL4CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "OVL4CONF"
base ad:0xa0350484
group 0--3
line.long 0 "OVL4CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

;tree "OVL4CONF2"
base ad:0xa0350488
group 0--3
line.long 0 "OVL4CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
;tree.end

;tree "OVL4JINC"
base ad:0xa035048c
group 0--3
line.long 0 "OVL4JINC"
hexfld.long 0 " LJINC "
;tree.end

;tree "OVL4CROP"
base ad:0xa0350490
group 0--3
line.long 0 "OVL4CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

;tree "OVL4COMP"
base ad:0xa0350494
group 0--3
line.long 0 "OVL4COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "OVL5CR"
base ad:0xa03504a0
group 0--3
line.long 0 "OVL5CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
hexfld.byte 1 " FETCH_ROPC "
bitfld.long 0 16.--19. " STBPRIO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " BURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "OVL5CONF"
base ad:0xa03504a4
group 0--3
line.long 0 "OVL5CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

;tree "OVL5CONF2"
base ad:0xa03504a8
group 0--3
line.long 0 "OVL5CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
;tree.end

;tree "OVL5JINC"
base ad:0xa03504ac
group 0--3
line.long 0 "OVL5JINC"
hexfld.long 0 " LJINC "
;tree.end

;tree "OVL5CROP"
base ad:0xa03504b0
group 0--3
line.long 0 "OVL5CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
;tree.end

;tree "OVL5COMP"
base ad:0xa03504b4
group 0--3
line.long 0 "OVL5COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CHNL0CONF"
base ad:0xa0350600
group 0--3
line.long 0 "CHNL0CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

;tree "CHNL0STAT"
base ad:0xa0350604
group 0--3
line.long 0 "CHNL0STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
;tree.end

;tree "CHNL0SYNCMOD"
base ad:0xa0350608
group 0--3
line.long 0 "CHNL0SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "CHNL0SYNCHSW"
base ad:0xa035060c
wgroup 0--3
line.long 0 "CHNL0SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

;tree "CHNL0BCKCL"
base ad:0xa0350610
group 0--3
line.long 0 "CHNL0BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

;tree "CHNL0MUXING"
base ad:0xa0350614
group 0--3
line.long 0 "CHNL0MUXING"
bitfld.long 0 0.--2. " FIFOID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "CHNL1CONF"
base ad:0xa0350620
group 0--3
line.long 0 "CHNL1CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

;tree "CHNL1STAT"
base ad:0xa0350624
group 0--3
line.long 0 "CHNL1STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
;tree.end

;tree "CHNL1SYNCMOD"
base ad:0xa0350628
group 0--3
line.long 0 "CHNL1SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "CHNL1SYNCHSW"
base ad:0xa035062c
wgroup 0--3
line.long 0 "CHNL1SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

;tree "CHNL1BCKCL"
base ad:0xa0350630
group 0--3
line.long 0 "CHNL1BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

;tree "CHNL1MUXING"
base ad:0xa0350634
group 0--3
line.long 0 "CHNL1MUXING"
bitfld.long 0 0.--2. " FIFOID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "CHNL2CONF"
base ad:0xa0350640
group 0--3
line.long 0 "CHNL2CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

;tree "CHNL2STAT"
base ad:0xa0350644
group 0--3
line.long 0 "CHNL2STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
;tree.end

;tree "CHNL2SYNCMOD"
base ad:0xa0350648
group 0--3
line.long 0 "CHNL2SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "CHNL2SYNCHSW"
base ad:0xa035064c
wgroup 0--3
line.long 0 "CHNL2SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

;tree "CHNL2BCKCL"
base ad:0xa0350650
group 0--3
line.long 0 "CHNL2BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

;tree "CHNL2MUXING"
base ad:0xa0350654
group 0--3
line.long 0 "CHNL2MUXING"
bitfld.long 0 0.--2. " FIFOID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "CHNL3CONF"
base ad:0xa0350660
group 0--3
line.long 0 "CHNL3CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
;tree.end

;tree "CHNL3STAT"
base ad:0xa0350664
group 0--3
line.long 0 "CHNL3STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
;tree.end

;tree "CHNL3SYNCMOD"
base ad:0xa0350668
group 0--3
line.long 0 "CHNL3SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "CHNL3SYNCHSW"
base ad:0xa035066c
wgroup 0--3
line.long 0 "CHNL3SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
;tree.end

;tree "CHNL3BCKCL"
base ad:0xa0350670
group 0--3
line.long 0 "CHNL3BCKCL"
hexfld.byte 0 " B "
hexfld.byte 1 " G "
hexfld.byte 2 " R "
;tree.end

;tree "CHNL3MUXING"
base ad:0xa0350674
group 0--3
line.long 0 "CHNL3MUXING"
bitfld.long 0 0.--2. " FIFOID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "CRA0"
base ad:0xa0350800
group 0--3
line.long 0 "CRA0"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 2. " BLENDEN "  "0 ,1 "
bitfld.long 0 3. " AFLICKEN "  "0 ,1 "
bitfld.long 0 4. " PALEN "  "0 ,1 "
bitfld.long 0 5. " DITHEN "  "0 ,1 "
bitfld.long 0 6. " GAMEN "  "0 ,1 "
bitfld.long 0 7.--9. " KEYCTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " BLENDCTRL "  "0 ,1 "
bitfld.long 0 11.--12. " FLICKMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " FLICKFORMAT "  "0 ,1 "
bitfld.long 0 14. " PALMODE "  "0 ,1 "
bitfld.long 0 15. " OLEDEN "  "0 ,1 "
hexfld.byte 2 " ALPHABLEND "
bitfld.long 0 24. " ROTEN "  "0 ,1 "
;tree.end

;tree "CRA1"
base ad:0xa0350804
group 0--3
line.long 0 "CRA1"
bitfld.long 0 0.--9. " PCD "  " "
bitfld.long 0 10.--12. " CLKSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--16. " CDWIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 25.--28. " OUTBPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 29. " BCD "  "0 ,1 "
bitfld.long 0 30. " CLKTYPE "  "0 ,1 "
;tree.end

;tree "COLKEYA"
base ad:0xa0350808
group 0--3
line.long 0 "COLKEYA"
hexfld.byte 0 " KEYB "
hexfld.byte 1 " KEYG "
hexfld.byte 2 " KEYR "
hexfld.byte 3 " KEYA "
;tree.end

;tree "FCOLKEYA"
base ad:0xa035080c
group 0--3
line.long 0 "FCOLKEYA"
hexfld.byte 0 " FKEYB "
hexfld.byte 1 " FKEYG "
hexfld.byte 2 " FKEYR "
hexfld.byte 3 " FKEYA "
;tree.end

;tree "RGBCONV1A"
base ad:0xa0350810
group 0--3
line.long 0 "RGBCONV1A"
bitfld.long 0 0.--10. " YR_GREEN "  " "
bitfld.long 0 16.--26. " YR_RED "  " "
;tree.end

;tree "RGBCONV2A"
base ad:0xa0350814
group 0--3
line.long 0 "RGBCONV2A"
bitfld.long 0 0.--10. " CR_RED "  " "
bitfld.long 0 16.--26. " YR_BLUE "  " "
;tree.end

;tree "RGBCONV3A"
base ad:0xa0350818
group 0--3
line.long 0 "RGBCONV3A"
bitfld.long 0 0.--10. " CR_BLUE "  " "
bitfld.long 0 16.--26. " CR_GREEN "  " "
;tree.end

;tree "RGBCONV4A"
base ad:0xa035081c
group 0--3
line.long 0 "RGBCONV4A"
bitfld.long 0 0.--10. " CB_GREEN "  " "
bitfld.long 0 16.--26. " CB_RED "  " "
;tree.end

;tree "RGBCONV5A"
base ad:0xa0350820
group 0--3
line.long 0 "RGBCONV5A"
bitfld.long 0 0.--10. " OFF_RED "  " "
bitfld.long 0 16.--26. " CB_BLUE "  " "
;tree.end

;tree "RGBCONV6A"
base ad:0xa0350824
group 0--3
line.long 0 "RGBCONV6A"
bitfld.long 0 0.--10. " OFF_BLUE "  " "
bitfld.long 0 16.--26. " OFF_GREEN "  " "
;tree.end

;tree "FFCOEF0A"
base ad:0xa0350828
group 0--3
line.long 0 "FFCOEF0A"
hexfld.byte 0 " COEFF0_N1 "
hexfld.byte 1 " COEFF0_N2 "
hexfld.byte 2 " COEFF0_N3 "
bitfld.long 0 24.--27. " T0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "FFCOEF1A"
base ad:0xa035082c
group 0--3
line.long 0 "FFCOEF1A"
hexfld.byte 0 " COEFF1_N1 "
hexfld.byte 1 " COEFF1_N2 "
hexfld.byte 2 " COEFF1_N3 "
bitfld.long 0 24.--27. " T1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "FFCOEF2A"
base ad:0xa0350830
group 0--3
line.long 0 "FFCOEF2A"
hexfld.byte 0 " COEFF2_N1 "
hexfld.byte 1 " COEFF2_N2 "
hexfld.byte 2 " COEFF2_N3 "
bitfld.long 0 24.--27. " T2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WDATAA"
base ad:0xa0350834
group 0--3
line.long 0 "WDATAA"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
;tree.end

;tree "TVCRA"
base ad:0xa0350838
group 0--3
line.long 0 "TVCRA"
bitfld.long 0 0. " SEL_MOD "  "0 ,1 "
bitfld.long 0 1. " INTEREN "  "0 ,1 "
bitfld.long 0 2. " IFIELD "  "0 ,1 "
bitfld.long 0 3.--5. " TVMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--7. " SDTVMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8. " AVRGEN "  "0 ,1 "
bitfld.long 0 9. " CKINV "  "0 ,1 "
;tree.end

;tree "TVBL1A"
base ad:0xa035083c
group 0--3
line.long 0 "TVBL1A"
bitfld.long 0 0.--10. " BEL1 "  " "
bitfld.long 0 16.--26. " BSL1 "  " "
;tree.end

;tree "TVISLA"
base ad:0xa0350840
group 0--3
line.long 0 "TVISLA"
bitfld.long 0 0.--10. " FSL1 "  " "
bitfld.long 0 16.--26. " FSL2 "  " "
;tree.end

;tree "TVDVOA"
base ad:0xa0350844
group 0--3
line.long 0 "TVDVOA"
bitfld.long 0 0.--10. " DVO1 "  " "
bitfld.long 0 16.--26. " DVO2 "  " "
;tree.end

;tree "TVTIM1A"
base ad:0xa035084c
group 0--3
line.long 0 "TVTIM1A"
bitfld.long 0 0.--10. " DHO "  " "
;tree.end

;tree "TVLBALWA"
base ad:0xa0350850
group 0--3
line.long 0 "TVLBALWA"
bitfld.long 0 0.--10. " LBW "  " "
bitfld.long 0 16.--26. " ALW "  " "
;tree.end

;tree "TVBL2A"
base ad:0xa0350854
group 0--3
line.long 0 "TVBL2A"
bitfld.long 0 0.--10. " BEL2 "  " "
bitfld.long 0 16.--26. " BSL2 "  " "
;tree.end

;tree "TVBLUA"
base ad:0xa0350858
group 0--3
line.long 0 "TVBLUA"
hexfld.byte 0 " TVBLU "
hexfld.byte 1 " TVBCB "
hexfld.byte 2 " TVBCR "
;tree.end

;tree "LCDTIM1A"
base ad:0xa0350860
group 0--3
line.long 0 "LCDTIM1A"
bitfld.long 0 19. " IVP "  "0 ,1 "
bitfld.long 0 20. " IVS "  "0 ,1 "
bitfld.long 0 21. " IHS "  "0 ,1 "
bitfld.long 0 22. " IPC "  "0 ,1 "
bitfld.long 0 23. " IOE "  "0 ,1 "
;tree.end

;tree "DITCTRLA"
base ad:0xa0350864
group 0--3
line.long 0 "DITCTRLA"
bitfld.long 0 0. " TEMP "  "0 ,1 "
bitfld.long 0 1. " COMP "  "0 ,1 "
bitfld.long 0 2.--3. " MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MASK "  "0 ,1 "
bitfld.long 0 5.--9. " FOFFX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--14. " FOFFY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DITOFFA"
base ad:0xa0350868
group 0--3
line.long 0 "DITOFFA"
bitfld.long 0 0.--4. " XG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " YG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " XB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--28. " YB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PAL0A"
base ad:0xa035086c
group 0--3
line.long 0 "PAL0A"
bitfld.long 0 0.--11. " BLUE "  " "
bitfld.long 0 16.--27. " GREEN "  " "
;tree.end

;tree "PAL1A"
base ad:0xa0350870
group 0--3
line.long 0 "PAL1A"
bitfld.long 0 0.--11. " RED "  " "
;tree.end

;tree "ROTADD0A"
base ad:0xa0350874
group 0--3
line.long 0 "ROTADD0A"
bitfld.long 0 0.--2. " ROTADD0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " ROTADD0_MSB "  " "
;tree.end

;tree "ROTADD1A"
base ad:0xa0350878
group 0--3
line.long 0 "ROTADD1A"
bitfld.long 0 0.--2. " ROTADD1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " ROTADD1_MSB "  " "
;tree.end

;tree "ROTACONF"
base ad:0xa035087c
group 0--3
line.long 0 "ROTACONF"
bitfld.long 0 0.--2. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " ROTDIR "  "0 ,1 "
bitfld.long 0 4.--5. " WR_MAXOUT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " RD_MAXOUT "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--14. " STRIP_WIDTH "  " "
bitfld.long 0 15. " SINGLE_BUF "  "0 ,1 "
hexfld.byte 2 " WR_ROPC "
hexfld.byte 3 " RD_ROPC "
;tree.end

;tree "SYNCHCONFA"
base ad:0xa0350880
group 0--3
line.long 0 "SYNCHCONFA"
bitfld.long 0 0.--1. " HWREQVEVENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--15. " HWREQVCNT "  " "
bitfld.long 0 16.--17. " SWINTVEVENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--31. " SWINTVCNT "  " "
;tree.end

;tree "CTRLA"
base ad:0xa0350884
group 0--3
line.long 0 "CTRLA"
bitfld.long 0 0.--9. " FIFOWTRMRK "  " "
bitfld.long 0 12. " FIFOEMPTY "  "0 ,1 "
bitfld.long 0 13. " FIFOFULL "  "0 ,1 "
bitfld.long 0 16.--18. " FORMID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " FORMTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "GAM0A"
base ad:0xa0350888
group 0--3
line.long 0 "GAM0A"
bitfld.long 0 0.--23. " BLUE "  " "
;tree.end

;tree "GAM1A"
base ad:0xa035088c
group 0--3
line.long 0 "GAM1A"
bitfld.long 0 0.--23. " GREEN "  " "
;tree.end

;tree "GAM2A"
base ad:0xa0350890
group 0--3
line.long 0 "GAM2A"
bitfld.long 0 0.--23. " RED "  " "
;tree.end

;tree "OLEDCONV1A"
base ad:0xa0350894
group 0--3
line.long 0 "OLEDCONV1A"
bitfld.long 0 0.--13. " ALPHA_RED "  " "
bitfld.long 0 16.--29. " ALPHA_GREEN "  " "
;tree.end

;tree "OLEDCONV2A"
base ad:0xa0350898
group 0--3
line.long 0 "OLEDCONV2A"
bitfld.long 0 0.--13. " ALPHA_BLUE "  " "
bitfld.long 0 16.--29. " BETA_RED "  " "
;tree.end

;tree "OLEDCONV3A"
base ad:0xa035089c
group 0--3
line.long 0 "OLEDCONV3A"
bitfld.long 0 0.--13. " BETA_GREEN "  " "
bitfld.long 0 16.--29. " BETA_BLUE "  " "
;tree.end

;tree "OLEDCONV4A"
base ad:0xa03508a0
group 0--3
line.long 0 "OLEDCONV4A"
bitfld.long 0 0.--13. " GAMMA_RED "  " "
bitfld.long 0 16.--29. " GAMMA_GREEN "  " "
;tree.end

;tree "OLEDCONV5A"
base ad:0xa03508a4
group 0--3
line.long 0 "OLEDCONV5A"
bitfld.long 0 0.--13. " GAMMA_BLUE "  " "
bitfld.long 0 16.--29. " OFF_RED "  " "
;tree.end

;tree "OLEDCONV6A"
base ad:0xa03508a8
group 0--3
line.long 0 "OLEDCONV6A"
bitfld.long 0 0.--13. " OFF_GREEN "  " "
bitfld.long 0 16.--29. " OFF_BLUE "  " "
;tree.end

;tree "CRB0"
base ad:0xa0350a00
group 0--3
line.long 0 "CRB0"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 2. " BLENDEN "  "0 ,1 "
