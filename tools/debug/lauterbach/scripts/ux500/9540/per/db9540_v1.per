bitfld.long 0 3. " AFLICKEN "  "0 ,1 "
bitfld.long 0 4. " PALEN "  "0 ,1 "
bitfld.long 0 5. " DITHEN "  "0 ,1 "
bitfld.long 0 6. " GAMEN "  "0 ,1 "
bitfld.long 0 7.--9. " KEYCTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10. " BLENDCTRL "  "0 ,1 "
bitfld.long 0 11.--12. " FLICKMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " FLICKFORMAT "  "0 ,1 "
bitfld.long 0 14. " PALMODE "  "0 ,1 "
bitfld.long 0 15. " OLEDEN "  "0 ,1 "
hexfld.byte 2 " ALPHABLEND "
bitfld.long 0 24. " ROTEN "  "0 ,1 "
;tree.end

;tree "CRB1"
base ad:0xa0350a04
group 0--3
line.long 0 "CRB1"
bitfld.long 0 0.--9. " PCD "  " "
bitfld.long 0 10.--12. " CLKSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--16. " CDWIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 25.--28. " OUTBPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 29. " BCD "  "0 ,1 "
bitfld.long 0 30. " CLKTYPE "  "0 ,1 "
;tree.end

;tree "COLKEYB"
base ad:0xa0350a08
group 0--3
line.long 0 "COLKEYB"
hexfld.byte 0 " KEYB "
hexfld.byte 1 " KEYG "
hexfld.byte 2 " KEYR "
hexfld.byte 3 " KEYA "
;tree.end

;tree "FCOLKEYB"
base ad:0xa0350a0c
group 0--3
line.long 0 "FCOLKEYB"
hexfld.byte 0 " FKEYB "
hexfld.byte 1 " FKEYG "
hexfld.byte 2 " FKEYR "
hexfld.byte 3 " FKEYA "
;tree.end

;tree "RGBCONV1B"
base ad:0xa0350a10
group 0--3
line.long 0 "RGBCONV1B"
bitfld.long 0 0.--10. " YR_GREEN "  " "
bitfld.long 0 16.--26. " YR_RED "  " "
;tree.end

;tree "RGBCONV2B"
base ad:0xa0350a14
group 0--3
line.long 0 "RGBCONV2B"
bitfld.long 0 0.--10. " CR_RED "  " "
bitfld.long 0 16.--26. " YR_BLUE "  " "
;tree.end

;tree "RGBCONV3B"
base ad:0xa0350a18
group 0--3
line.long 0 "RGBCONV3B"
bitfld.long 0 0.--10. " CR_BLUE "  " "
bitfld.long 0 16.--26. " CR_GREEN "  " "
;tree.end

;tree "RGBCONV4B"
base ad:0xa0350a1c
group 0--3
line.long 0 "RGBCONV4B"
bitfld.long 0 0.--10. " CB_GREEN "  " "
bitfld.long 0 16.--26. " CB_RED "  " "
;tree.end

;tree "RGBCONV5B"
base ad:0xa0350a20
group 0--3
line.long 0 "RGBCONV5B"
bitfld.long 0 0.--10. " OFF_RED "  " "
bitfld.long 0 16.--26. " CB_BLUE "  " "
;tree.end

;tree "RGBCONV6B"
base ad:0xa0350a24
group 0--3
line.long 0 "RGBCONV6B"
bitfld.long 0 0.--10. " OFF_BLUE "  " "
bitfld.long 0 16.--26. " OFF_GREEN "  " "
;tree.end

;tree "WDATAB"
base ad:0xa0350a34
group 0--3
line.long 0 "WDATAB"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
;tree.end

;tree "TVCRB"
base ad:0xa0350a38
group 0--3
line.long 0 "TVCRB"
bitfld.long 0 0. " SEL_MOD "  "0 ,1 "
bitfld.long 0 1. " INTEREN "  "0 ,1 "
bitfld.long 0 2. " IFIELD "  "0 ,1 "
bitfld.long 0 3.--5. " TVMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--7. " SDTVMODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8. " AVRGEN "  "0 ,1 "
bitfld.long 0 9. " CKINV "  "0 ,1 "
;tree.end

;tree "TVBL1B"
base ad:0xa0350a3c
group 0--3
line.long 0 "TVBL1B"
bitfld.long 0 0.--10. " BEL1 "  " "
bitfld.long 0 16.--26. " BSL1 "  " "
;tree.end

;tree "TVISLB"
base ad:0xa0350a40
group 0--3
line.long 0 "TVISLB"
bitfld.long 0 0.--10. " FSL1 "  " "
bitfld.long 0 16.--26. " FSL2 "  " "
;tree.end

;tree "TVDVOB"
base ad:0xa0350a44
group 0--3
line.long 0 "TVDVOB"
bitfld.long 0 0.--10. " DVO1 "  " "
bitfld.long 0 16.--26. " DVO2 "  " "
;tree.end

;tree "TVTIM1B"
base ad:0xa0350a4c
group 0--3
line.long 0 "TVTIM1B"
bitfld.long 0 0.--10. " DHO "  " "
;tree.end

;tree "TVLBALWB"
base ad:0xa0350a50
group 0--3
line.long 0 "TVLBALWB"
bitfld.long 0 0.--10. " LBW "  " "
bitfld.long 0 16.--26. " ALW "  " "
;tree.end

;tree "TVBL2B"
base ad:0xa0350a54
group 0--3
line.long 0 "TVBL2B"
bitfld.long 0 0.--10. " BEL2 "  " "
bitfld.long 0 16.--26. " BSL2 "  " "
;tree.end

;tree "TVBLUB"
base ad:0xa0350a58
group 0--3
line.long 0 "TVBLUB"
hexfld.byte 0 " TVBLU "
hexfld.byte 1 " TVBCB "
hexfld.byte 2 " TVBCR "
;tree.end

;tree "LCDTIM1B"
base ad:0xa0350a60
group 0--3
line.long 0 "LCDTIM1B"
bitfld.long 0 19. " IVP "  "0 ,1 "
bitfld.long 0 20. " IVS "  "0 ,1 "
bitfld.long 0 21. " IHS "  "0 ,1 "
bitfld.long 0 22. " IPC "  "0 ,1 "
bitfld.long 0 23. " IOE "  "0 ,1 "
;tree.end

;tree "DITCTRLB"
base ad:0xa0350a64
group 0--3
line.long 0 "DITCTRLB"
bitfld.long 0 0. " TEMP "  "0 ,1 "
bitfld.long 0 1. " COMP "  "0 ,1 "
bitfld.long 0 2.--3. " MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MASK "  "0 ,1 "
bitfld.long 0 5.--9. " FOFFX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--14. " FOFFY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "DITOFFB"
base ad:0xa0350a68
group 0--3
line.long 0 "DITOFFB"
bitfld.long 0 0.--4. " XG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--12. " YG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--20. " XB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--28. " YB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PAL0B"
base ad:0xa0350a6c
group 0--3
line.long 0 "PAL0B"
bitfld.long 0 0.--11. " BLUE "  " "
bitfld.long 0 16.--27. " GREEN "  " "
;tree.end

;tree "PAL1B"
base ad:0xa0350a70
group 0--3
line.long 0 "PAL1B"
bitfld.long 0 0.--11. " RED "  " "
;tree.end

;tree "ROTADD0B"
base ad:0xa0350a74
group 0--3
line.long 0 "ROTADD0B"
bitfld.long 0 0.--2. " ROTADD0_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " ROTADD0_MSB "  " "
;tree.end

;tree "ROTADD1B"
base ad:0xa0350a78
group 0--3
line.long 0 "ROTADD1B"
bitfld.long 0 0.--2. " ROTADD1_LSB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--31. " ROTADD1_MSB "  " "
;tree.end

;tree "ROTBCONF"
base ad:0xa0350a7c
group 0--3
line.long 0 "ROTBCONF"
bitfld.long 0 0.--2. " ROTBURSTSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " ROTDIR "  "0 ,1 "
bitfld.long 0 4.--5. " WR_MAXOUT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " RD_MAXOUT "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--14. " STRIP_WIDTH "  " "
bitfld.long 0 15. " SINGLE_BUF "  "0 ,1 "
hexfld.byte 2 " WR_ROPC "
hexfld.byte 3 " RD_ROPC "
;tree.end

;tree "SYNCHCONFB"
base ad:0xa0350a80
group 0--3
line.long 0 "SYNCHCONFB"
bitfld.long 0 0.--1. " HWREQVEVENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--15. " HWREQVCNT "  " "
bitfld.long 0 16.--17. " SWINTVEVENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--31. " SWINTVCNT "  " "
;tree.end

;tree "CTRLB"
base ad:0xa0350a84
group 0--3
line.long 0 "CTRLB"
bitfld.long 0 0.--9. " FIFOWTRMRK "  " "
bitfld.long 0 12. " FIFOEMPTY "  "0 ,1 "
bitfld.long 0 13. " FIFOFULL "  "0 ,1 "
bitfld.long 0 16.--18. " FORMID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " FORMTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "GAM0B"
base ad:0xa0350a88
group 0--3
line.long 0 "GAM0B"
bitfld.long 0 0.--23. " BLUE "  " "
;tree.end

;tree "GAM1B"
base ad:0xa0350a8c
group 0--3
line.long 0 "GAM1B"
bitfld.long 0 0.--23. " GREEN "  " "
;tree.end

;tree "GAM2B"
base ad:0xa0350a90
group 0--3
line.long 0 "GAM2B"
bitfld.long 0 0.--23. " RED "  " "
;tree.end

;tree "OLEDCONV1B"
base ad:0xa0350a94
group 0--3
line.long 0 "OLEDCONV1B"
bitfld.long 0 0.--13. " ALPHA_RED "  " "
bitfld.long 0 16.--29. " ALPHA_GREEN "  " "
;tree.end

;tree "OLEDCONV2B"
base ad:0xa0350a98
group 0--3
line.long 0 "OLEDCONV2B"
bitfld.long 0 0.--13. " ALPHA_BLUE "  " "
bitfld.long 0 16.--29. " BETA_RED "  " "
;tree.end

;tree "OLEDCONV3B"
base ad:0xa0350a9c
group 0--3
line.long 0 "OLEDCONV3B"
bitfld.long 0 0.--13. " BETA_GREEN "  " "
bitfld.long 0 16.--29. " BETA_BLUE "  " "
;tree.end

;tree "OLEDCONV4B"
base ad:0xa0350aa0
group 0--3
line.long 0 "OLEDCONV4B"
bitfld.long 0 0.--13. " GAMMA_RED "  " "
bitfld.long 0 16.--29. " GAMMA_GREEN "  " "
;tree.end

;tree "OLEDCONV5B"
base ad:0xa0350aa4
group 0--3
line.long 0 "OLEDCONV5B"
bitfld.long 0 0.--13. " GAMMA_BLUE "  " "
bitfld.long 0 16.--29. " OFF_RED "  " "
;tree.end

;tree "OLEDCONV6B"
base ad:0xa0350aa8
group 0--3
line.long 0 "OLEDCONV6B"
bitfld.long 0 0.--13. " OFF_GREEN "  " "
bitfld.long 0 16.--29. " OFF_BLUE "  " "
;tree.end

;tree "CRC"
base ad:0xa0350c00
group 0--3
line.long 0 "CRC"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 1. " POWEREN "  "0 ,1 "
bitfld.long 0 2. " C1EN "  "0 ,1 "
bitfld.long 0 3. " C2EN "  "0 ,1 "
bitfld.long 0 4. " WMLVL1 "  "0 ,1 "
bitfld.long 0 5. " WMLVL2 "  "0 ,1 "
bitfld.long 0 6. " SYNCSEL "  "0 ,1 "
bitfld.long 0 7. " SYCEN0 "  "0 ,1 "
bitfld.long 0 8. " SYCEN1 "  "0 ,1 "
bitfld.long 0 9. " SIZE1 "  "0 ,1 "
bitfld.long 0 10. " SIZE2 "  "0 ,1 "
bitfld.long 0 11. " INBAND1 "  "0 ,1 "
bitfld.long 0 12. " INBAND2 "  "0 ,1 "
bitfld.long 0 13.--14. " CLKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " YUVCONVC1EN "  "0 ,1 "
bitfld.long 0 16. " CS1EN "  "0 ,1 "
bitfld.long 0 17. " CS2EN "  "0 ,1 "
bitfld.long 0 18. " RESEN "  "0 ,1 "
bitfld.long 0 19. " CS1POL "  "0 ,1 "
bitfld.long 0 20. " CS2POL "  "0 ,1 "
bitfld.long 0 21. " CD1POL "  "0 ,1 "
bitfld.long 0 22. " CD2POL "  "0 ,1 "
bitfld.long 0 23. " WR1POL "  "0 ,1 "
bitfld.long 0 24. " WR2POL "  "0 ,1 "
bitfld.long 0 25. " RD1POL "  "0 ,1 "
bitfld.long 0 26. " RD2POL "  "0 ,1 "
bitfld.long 0 27. " RES1POL "  "0 ,1 "
bitfld.long 0 28. " RES2POL "  "0 ,1 "
bitfld.long 0 29.--30. " SYNCCTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 31. " CLAMPC1EN "  "0 ,1 "
;tree.end

;tree "PBCCRC0"
base ad:0xa0350c04
group 0--3
line.long 0 "PBCCRC0"
bitfld.long 0 0.--2. " BSCM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " BSDM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " PDM "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PDCTRL "  "0 ,1 "
bitfld.long 0 13.--15. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PBCCRC1"
base ad:0xa0350c08
group 0--3
line.long 0 "PBCCRC1"
bitfld.long 0 0.--2. " BSCM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " BSDM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " PDM "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " PDCTRL "  "0 ,1 "
bitfld.long 0 13.--15. " BPP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PBCBMRC00"
base ad:0xa0350c0c
group 0--3
line.long 0 "PBCBMRC00"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

;tree "PBCBMRC01"
base ad:0xa0350c10
group 0--3
line.long 0 "PBCBMRC01"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

;tree "PBCBMRC02"
base ad:0xa0350c14
group 0--3
line.long 0 "PBCBMRC02"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

;tree "PBCBMRC03"
base ad:0xa0350c18
group 0--3
line.long 0 "PBCBMRC03"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

;tree "PBCBMRC04"
base ad:0xa0350c1c
group 0--3
line.long 0 "PBCBMRC04"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

;tree "PBCBMRC10"
base ad:0xa0350c20
group 0--3
line.long 0 "PBCBMRC10"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

;tree "PBCBMRC11"
base ad:0xa0350c24
group 0--3
line.long 0 "PBCBMRC11"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

;tree "PBCBMRC12"
base ad:0xa0350c28
group 0--3
line.long 0 "PBCBMRC12"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

;tree "PBCBMRC13"
base ad:0xa0350c2c
group 0--3
line.long 0 "PBCBMRC13"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

;tree "PBCBMRC14"
base ad:0xa0350c30
group 0--3
line.long 0 "PBCBMRC14"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
;tree.end

;tree "PBCBCR00"
base ad:0xa0350c34
group 0--3
line.long 0 "PBCBCR00"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
;tree.end

;tree "PBCBCR01"
base ad:0xa0350c38
group 0--3
line.long 0 "PBCBCR01"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
;tree.end

;tree "PBCBCR10"
base ad:0xa0350c48
group 0--3
line.long 0 "PBCBCR10"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
;tree.end

;tree "PBCBCR11"
base ad:0xa0350c4c
group 0--3
line.long 0 "PBCBCR11"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
;tree.end

;tree "VSCRC0"
base ad:0xa0350c5c
group 0--3
line.long 0 "VSCRC0"
bitfld.long 0 0.--11. " VSPMIN "  " "
bitfld.long 0 12.--23. " VSPMAX "  " "
bitfld.long 0 24.--26. " VSPDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 27. " VSPOL "  "0 ,1 "
bitfld.long 0 28. " VSSEL "  "0 ,1 "
bitfld.long 0 29.--31. " VSDBL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "VSCRC1"
base ad:0xa0350c60
group 0--3
line.long 0 "VSCRC1"
bitfld.long 0 0.--11. " VSPMIN "  " "
bitfld.long 0 12.--23. " VSPMAX "  " "
bitfld.long 0 24.--26. " VSPDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 27. " VSPOL "  "0 ,1 "
bitfld.long 0 28. " VSSEL "  "0 ,1 "
bitfld.long 0 29.--31. " VSDBL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "SCTRC"
base ad:0xa0350c64
group 0--3
line.long 0 "SCTRC"
hexfld.byte 0 " SYNCDELC0 "
hexfld.byte 1 " SYNCDELC1 "
bitfld.long 0 16.--27. " TRDELC "  " "
;tree.end

;tree "BCNR0"
base ad:0xa0350c6c
group 0--3
line.long 0 "BCNR0"
hexfld.byte 0 " BCN "
;tree.end

;tree "BCNR1"
base ad:0xa0350c70
group 0--3
line.long 0 "BCNR1"
hexfld.byte 0 " BCN "
;tree.end

;tree "CSCDTRC0"
base ad:0xa0350c74
group 0--3
line.long 0 "CSCDTRC0"
hexfld.byte 0 " CSACT "
hexfld.byte 1 " CSDEACT "
hexfld.byte 2 " CDACT "
hexfld.byte 3 " CDDEACT "
;tree.end

;tree "CSCDTRC1"
base ad:0xa0350c78
group 0--3
line.long 0 "CSCDTRC1"
hexfld.byte 0 " CSACT "
hexfld.byte 1 " CSDEACT "
hexfld.byte 2 " CDACT "
hexfld.byte 3 " CDDEACT "
;tree.end

;tree "RDWRTRC0"
base ad:0xa0350c7c
group 0--3
line.long 0 "RDWRTRC0"
hexfld.byte 0 " RWACT "
hexfld.byte 1 " RWDEACT "
bitfld.long 0 16. " MOTINT "  "0 ,1 "
;tree.end

;tree "RDWRTRC1"
base ad:0xa0350c80
group 0--3
line.long 0 "RDWRTRC1"
hexfld.byte 0 " RWACT "
hexfld.byte 1 " RWDEACT "
bitfld.long 0 16. " MOTINT "  "0 ,1 "
;tree.end

;tree "DOTRC0"
base ad:0xa0350c84
group 0--3
line.long 0 "DOTRC0"
hexfld.byte 0 " DOACT "
hexfld.byte 1 " DODEACT "
;tree.end

;tree "DOTRC1"
base ad:0xa0350c88
group 0--3
line.long 0 "DOTRC1"
hexfld.byte 0 " DOACT "
hexfld.byte 1 " DODEACT "
;tree.end

;tree "WDATADC0"
base ad:0xa0350c94
group 0--3
line.long 0 "WDATADC0"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
;tree.end

;tree "WDATADC1"
base ad:0xa0350c98
group 0--3
line.long 0 "WDATADC1"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
;tree.end

;tree "RDATADC0"
base ad:0xa0350c9c
group 0--3
line.long 0 "RDATADC0"
hexfld.word 0 " DATAREADFROMDISPLAYMODULE "
bitfld.long 0 16. " STARTREAD "  "0 ,1 "
;tree.end

;tree "RDATADC1"
base ad:0xa0350ca0
group 0--3
line.long 0 "RDATADC1"
hexfld.word 0 " DATAREADFROMDISPLAYMODULE "
bitfld.long 0 16. " STARTREAD "  "0 ,1 "
;tree.end

;tree "STATC"
base ad:0xa0350ca4
rgroup 0--3
line.long 0 "STATC"
bitfld.long 0 0. " STATBUSY0 "  "0 ,1 "
bitfld.long 0 5. " STATBUSY1 "  "0 ,1 "
;tree.end

;tree "CTRLC0"
base ad:0xa0350ca8
group 0--3
line.long 0 "CTRLC0"
bitfld.long 0 0.--9. " FIFOWTRMRK "  " "
bitfld.long 0 12. " FIFOEMPTY "  "0 ,1 "
bitfld.long 0 13. " FIFOFULL "  "0 ,1 "
bitfld.long 0 16.--18. " FORMID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " FORMTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "CTRLC1"
base ad:0xa0350cac
group 0--3
line.long 0 "CTRLC1"
bitfld.long 0 0.--9. " FIFOWTRMRK "  " "
bitfld.long 0 12. " FIFOEMPTY "  "0 ,1 "
bitfld.long 0 13. " FIFOFULL "  "0 ,1 "
bitfld.long 0 16.--18. " FORMID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " FORMTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DSI0CONF0"
base ad:0xa0350e00
group 0--3
line.long 0 "DSI0CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DSI0FRAME"
base ad:0xa0350e04
group 0--3
line.long 0 "DSI0FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

;tree "DSI0PKT"
base ad:0xa0350e08
group 0--3
line.long 0 "DSI0PKT"
hexfld.word 0 " PACKET "
;tree.end

;tree "DSI0SYNC"
base ad:0xa0350e0c
group 0--3
line.long 0 "DSI0SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
;tree.end

;tree "DSI0CMDW"
base ad:0xa0350e10
group 0--3
line.long 0 "DSI0CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 2 " CMDW_START "
;tree.end

;tree "DSI0DELAY0"
base ad:0xa0350e14
group 0--3
line.long 0 "DSI0DELAY0"
hexfld.word 0 " INTPKTDEL "
;tree.end

;tree "DSI0DELAY1"
base ad:0xa0350e18
group 0--3
line.long 0 "DSI0DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
;tree.end

;tree "DSI1CONF0"
base ad:0xa0350e20
group 0--3
line.long 0 "DSI1CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DSI1FRAME"
base ad:0xa0350e24
group 0--3
line.long 0 "DSI1FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

;tree "DSI1PKT"
base ad:0xa0350e28
group 0--3
line.long 0 "DSI1PKT"
hexfld.word 0 " PACKET "
;tree.end

;tree "DSI1SYNC"
base ad:0xa0350e2c
group 0--3
line.long 0 "DSI1SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
;tree.end

;tree "DSI1CMDW"
base ad:0xa0350e30
group 0--3
line.long 0 "DSI1CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 2 " CMDW_START "
;tree.end

;tree "DSI1DELAY0"
base ad:0xa0350e34
group 0--3
line.long 0 "DSI1DELAY0"
hexfld.word 0 " INTPKTDEL "
;tree.end

;tree "DSI1DELAY1"
base ad:0xa0350e38
group 0--3
line.long 0 "DSI1DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
;tree.end

;tree "DSI2CONF0"
base ad:0xa0350e40
group 0--3
line.long 0 "DSI2CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DSI2FRAME"
base ad:0xa0350e44
group 0--3
line.long 0 "DSI2FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

;tree "DSI2PKT"
base ad:0xa0350e48
group 0--3
line.long 0 "DSI2PKT"
hexfld.word 0 " PACKET "
;tree.end

;tree "DSI2SYNC"
base ad:0xa0350e4c
group 0--3
line.long 0 "DSI2SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
;tree.end

;tree "DSI2CMDW"
base ad:0xa0350e50
group 0--3
line.long 0 "DSI2CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 2 " CMDW_START "
;tree.end

;tree "DSI2DELAY0"
base ad:0xa0350e54
group 0--3
line.long 0 "DSI2DELAY0"
hexfld.word 0 " INTPKTDEL "
;tree.end

;tree "DSI2DELAY1"
base ad:0xa0350e58
group 0--3
line.long 0 "DSI2DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
;tree.end

;tree "DSI3CONF0"
base ad:0xa0350e60
group 0--3
line.long 0 "DSI3CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DSI3FRAME"
base ad:0xa0350e64
group 0--3
line.long 0 "DSI3FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

;tree "DSI3PKT"
base ad:0xa0350e68
group 0--3
line.long 0 "DSI3PKT"
hexfld.word 0 " PACKET "
;tree.end

;tree "DSI3SYNC"
base ad:0xa0350e6c
group 0--3
line.long 0 "DSI3SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
;tree.end

;tree "DSI3CMDW"
base ad:0xa0350e70
group 0--3
line.long 0 "DSI3CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 2 " CMDW_START "
;tree.end

;tree "DSI3DELAY0"
base ad:0xa0350e74
group 0--3
line.long 0 "DSI3DELAY0"
hexfld.word 0 " INTPKTDEL "
;tree.end

;tree "DSI3DELAY1"
base ad:0xa0350e78
group 0--3
line.long 0 "DSI3DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
;tree.end

;tree "DSI4CONF0"
base ad:0xa0350e80
group 0--3
line.long 0 "DSI4CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DSI4FRAME"
base ad:0xa0350e84
group 0--3
line.long 0 "DSI4FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

;tree "DSI4PKT"
base ad:0xa0350e88
group 0--3
line.long 0 "DSI4PKT"
hexfld.word 0 " PACKET "
;tree.end

;tree "DSI4SYNC"
base ad:0xa0350e8c
group 0--3
line.long 0 "DSI4SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
;tree.end

;tree "DSI4CMDW"
base ad:0xa0350e90
group 0--3
line.long 0 "DSI4CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 2 " CMDW_START "
;tree.end

;tree "DSI4DELAY0"
base ad:0xa0350e94
group 0--3
line.long 0 "DSI4DELAY0"
hexfld.word 0 " INTPKTDEL "
;tree.end

;tree "DSI4DELAY1"
base ad:0xa0350e98
group 0--3
line.long 0 "DSI4DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
;tree.end

;tree "DSI5CONF0"
base ad:0xa0350ea0
group 0--3
line.long 0 "DSI5CONF0"
hexfld.byte 0 " BLANKING "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DSI5FRAME"
base ad:0xa0350ea4
group 0--3
line.long 0 "DSI5FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
;tree.end

;tree "DSI5PKT"
base ad:0xa0350ea8
group 0--3
line.long 0 "DSI5PKT"
hexfld.word 0 " PACKET "
;tree.end

;tree "DSI5SYNC"
base ad:0xa0350eac
group 0--3
line.long 0 "DSI5SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
;tree.end

;tree "DSI5CMDW"
base ad:0xa0350eb0
group 0--3
line.long 0 "DSI5CMDW"
hexfld.word 0 " CMDW_CONTINUE "
hexfld.word 2 " CMDW_START "
;tree.end

;tree "DSI5DELAY0"
base ad:0xa0350eb4
group 0--3
line.long 0 "DSI5DELAY0"
hexfld.word 0 " INTPKTDEL "
;tree.end

;tree "DSI5DELAY1"
base ad:0xa0350eb8
group 0--3
line.long 0 "DSI5DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
hexfld.byte 2 " FRAMESTARTDEL "
;tree.end

endif
tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "MCDETB"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "SCR"
base ad:0x63700000
group 0--3
line.long 0 "SCR"
bitfld.long 0 0. " Power "  "0 ,1 "
bitfld.long 0 1. " TFT "  "0 ,1 "
bitfld.long 0 2.--4. " Bpp "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--12. " FrameNumber "  " "
bitfld.long 0 14. " PWR_DBI "  "0 ,1 "
bitfld.long 0 15. " Te_start "  "0 ,1 "
hexfld.byte 2 " TE_pulse_count "
;tree.end

;tree "Addressed_data"
base ad:0x63700004
group 0--3
line.long 0 "Addressed_data"
hexfld.long 0 " Data "
;tree.end

;tree "HSYNC"
base ad:0x63700008
group 0--3
line.long 0 "HSYNC"
hexfld.byte 0 " HSW "
hexfld.byte 1 " HFP "
hexfld.byte 2 " HBP "
hexfld.byte 3 " LCD_number_frame "
;tree.end

;tree "VSYNC"
base ad:0x6370000c
group 0--3
line.long 0 "VSYNC"
hexfld.byte 0 " VSW "
hexfld.byte 1 " VFP "
hexfld.byte 2 " VBP "
hexfld.byte 3 " ACBIAS "
;tree.end

;tree "Frame"
base ad:0x63700010
group 0--3
line.long 0 "Frame"
bitfld.long 0 0.--11. " PPL "  " "
bitfld.long 0 16.--27. " LPP "  " "
;tree.end

;tree "Addressed_data_DBI2"
base ad:0x63700014
group 0--3
line.long 0 "Addressed_data_DBI2"
hexfld.long 0 " Data "
;tree.end

;tree "Addressed_cmd_DBI2"
base ad:0x63700018
group 0--3
line.long 0 "Addressed_cmd_DBI2"
hexfld.long 0 " Data "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "MCSBAG"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "BA_ENABLE"
base ad:0xa0390000
group 0--3
line.long 0 "BA_ENABLE"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
;tree.end

;tree "BA_MODE"
base ad:0xa0390004
group 0--3
line.long 0 "BA_MODE"
bitfld.long 0 0.--2. " MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "BA_MSG_PORT_PACE"
base ad:0xa0390008
group 0--3
line.long 0 "BA_MSG_PORT_PACE"
hexfld.word 0 " DIVIDER "
;tree.end

;tree "BA_STATUS"
base ad:0xa039000c
rgroup 0--3
line.long 0 "BA_STATUS"
bitfld.long 0 0.--1. " FF_FLAGS "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WPSAT_ENABLE"
base ad:0xa0390020
group 0--3
line.long 0 "WPSAT_ENABLE"
bitfld.long 0 0.--3. " WPSen "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WPSAT_PROG_MODE"
base ad:0xa0390024
group 0--3
line.long 0 "WPSAT_PROG_MODE"
bitfld.long 0 0.--3. " WPSprog "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WPSAT_PROG_STATUS"
base ad:0xa0390028
rgroup 0--3
line.long 0 "WPSAT_PROG_STATUS"
bitfld.long 0 0.--3. " WPSprogstatus "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WPSAT_PROG_CLEAR"
base ad:0xa039002c
group 0--3
line.long 0 "WPSAT_PROG_CLEAR"
bitfld.long 0 0. " CLEAR "  "0 ,1 "
;tree.end

;tree "TMSAT_ENABLE"
base ad:0xa0390040
group 0--3
line.long 0 "TMSAT_ENABLE"
hexfld.byte 0 " TMSen "
;tree.end

;tree "TMSAT_PROG_MODE"
base ad:0xa0390044
group 0--3
line.long 0 "TMSAT_PROG_MODE"
hexfld.byte 0 " TMSprog "
;tree.end

;tree "TMSAT_PROG_STATUS"
base ad:0xa0390048
rgroup 0--3
line.long 0 "TMSAT_PROG_STATUS"
hexfld.byte 0 " TMSprogstatus "
;tree.end

;tree "TMSAT_PROG_CLEAR"
base ad:0xa039004c
group 0--3
line.long 0 "TMSAT_PROG_CLEAR"
bitfld.long 0 0. " CLEAR "  "0 ,1 "
;tree.end

;tree "TMSAT_READ_STATUS"
base ad:0xa0390050
rgroup 0--3
line.long 0 "TMSAT_READ_STATUS"
hexfld.byte 0 " TMSreadstatus "
;tree.end

;tree "WPSAT_ITS"
base ad:0xa0390060
rgroup 0--3
line.long 0 "WPSAT_ITS"
bitfld.long 0 0.--3. " WPSAT_ITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WPSAT_ITS_CLR"
base ad:0xa0390064
group 0--3
line.long 0 "WPSAT_ITS_CLR"
bitfld.long 0 0.--3. " WPSAT_ITS_CLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WPSAT_ITS_SET"
base ad:0xa0390068
wgroup 0--3
line.long 0 "WPSAT_ITS_SET"
bitfld.long 0 0.--3. " WPSAT_ITS_SET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WPSAT_ITM"
base ad:0xa039006c
rgroup 0--3
line.long 0 "WPSAT_ITM"
bitfld.long 0 0.--3. " WPSAT_ITM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WPSAT_ITM_CLR"
base ad:0xa0390070
group 0--3
line.long 0 "WPSAT_ITM_CLR"
bitfld.long 0 0.--3. " WPSAT_ITM_CLR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WPSAT_ITM_SET"
base ad:0xa0390074
wgroup 0--3
line.long 0 "WPSAT_ITM_SET"
bitfld.long 0 0.--3. " WPSAT_ITM_SET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PI_ITS"
base ad:0xa0390078
rgroup 0--3
line.long 0 "PI_ITS"
hexfld.word 0 " PI_ITS "
;tree.end

;tree "PI_ITS_CLR"
base ad:0xa039007c
group 0--3
line.long 0 "PI_ITS_CLR"
hexfld.word 0 " PI_ITS_CLR "
;tree.end

;tree "PI_ITS_SET"
base ad:0xa0390080
wgroup 0--3
line.long 0 "PI_ITS_SET"
hexfld.word 0 " PI_ITS_SET "
;tree.end

;tree "PI_ITM"
base ad:0xa0390084
rgroup 0--3
line.long 0 "PI_ITM"
hexfld.word 0 " PI_ITM "
;tree.end

;tree "PI_ITM_CLR"
base ad:0xa0390088
group 0--3
line.long 0 "PI_ITM_CLR"
hexfld.word 0 " PI_ITM_CLR "
;tree.end

;tree "PI_ITM_SET"
base ad:0xa039008c
wgroup 0--3
line.long 0 "PI_ITM_SET"
hexfld.word 0 " PI_ITM_SET "
;tree.end

;tree "TMSAT_ITS"
base ad:0xa0390090
rgroup 0--3
line.long 0 "TMSAT_ITS"
hexfld.byte 0 " TMSAT_ITS "
;tree.end

;tree "TMSAT_ITS_CLR"
base ad:0xa0390094
group 0--3
line.long 0 "TMSAT_ITS_CLR"
hexfld.byte 0 " TMSAT_ITS_CLR "
;tree.end

;tree "TMSAT_ITS_SET"
base ad:0xa0390098
wgroup 0--3
line.long 0 "TMSAT_ITS_SET"
hexfld.byte 0 " TMSAT_ITS_SET "
;tree.end

;tree "TMSAT_ITM"
base ad:0xa039009c
rgroup 0--3
line.long 0 "TMSAT_ITM"
hexfld.byte 0 " TMSAT_ITM "
;tree.end

;tree "TMSAT_ITM_CLR"
base ad:0xa03900a0
group 0--3
line.long 0 "TMSAT_ITM_CLR"
hexfld.byte 0 " TMSAT_ITM_CLR "
;tree.end

;tree "TMSAT_ITM_SET"
base ad:0xa03900a4
wgroup 0--3
line.long 0 "TMSAT_ITM_SET"
hexfld.byte 0 " TMSAT_ITM_SET "
;tree.end

;tree "PI_ERROR"
base ad:0xa03900a8
rgroup 0--3
line.long 0 "PI_ERROR"
hexfld.word 0 " PI_ERROR "
;tree.end

;tree "PI_ERROR_CLR"
base ad:0xa03900ac
group 0--3
line.long 0 "PI_ERROR_CLR"
hexfld.word 0 " PI_ERROR_CLR "
;tree.end

;tree "TMSAT0_T7_ERROR"
base ad:0xa03900b0
rgroup 0--3
line.long 0 "TMSAT0_T7_ERROR"
hexfld.long 0 " TMSAT0_T7_ERROR "
;tree.end

;tree "TMSAT8_T15_ERROR"
base ad:0xa03900b4
rgroup 0--3
line.long 0 "TMSAT8_T15_ERROR"
hexfld.long 0 " TMSAT8_T15_ERROR "
;tree.end

;tree "TM_LOST_ERROR"
base ad:0xa03900b8
rgroup 0--3
line.long 0 "TM_LOST_ERROR"
bitfld.long 0 0. " TM_ERROR "  "0 ,1 "
;tree.end

;tree "TM_ERROR_CLR"
base ad:0xa03900bc
group 0--3
line.long 0 "TM_ERROR_CLR"
bitfld.long 0 0. " TM_ERROR_CLR "  "0 ,1 "
;tree.end

;tree "SBAG_DVF0"
base ad:0xa03900c0
group 0--3
line.long 0 "SBAG_DVF0"
bitfld.long 0 0. " SBAG_DVF0 "  "0 ,1 "
;tree.end

;tree "TIME_ABSOLUTE_LSB"
base ad:0xa03900c4
group 0--3
line.long 0 "TIME_ABSOLUTE_LSB"
hexfld.long 0 " TIME_ABSOLUTE_LSB "
;tree.end

;tree "TIME_ABSOLUTE_MSB"
base ad:0xa03900c8
rgroup 0--3
line.long 0 "TIME_ABSOLUTE_MSB"
hexfld.long 0 " TIME_ABSOLUTE_MSB "
;tree.end

;tree "WPSAT0_REG1"
base ad:0xa0390200
group 0--3
line.long 0 "WPSAT0_REG1"
hexfld.long 0 " REG1 "
;tree.end

;tree "WPSAT0_REG2"
base ad:0xa0390204
group 0--3
line.long 0 "WPSAT0_REG2"
hexfld.long 0 " REG2 "
;tree.end

;tree "WPSAT0_REG3"
base ad:0xa0390208
group 0--3
line.long 0 "WPSAT0_REG3"
hexfld.long 0 " REG3 "
;tree.end

;tree "WPSAT0_REG4"
base ad:0xa039020c
group 0--3
line.long 0 "WPSAT0_REG4"
hexfld.long 0 " REG4 "
;tree.end

;tree "WPSAT0_REQ_NOT_RSP"
base ad:0xa0390210
rgroup 0--3
line.long 0 "WPSAT0_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
;tree.end

;tree "WPSAT1_REG1"
base ad:0xa0390214
group 0--3
line.long 0 "WPSAT1_REG1"
hexfld.long 0 " REG1 "
;tree.end

;tree "WPSAT1_REG2"
base ad:0xa0390218
group 0--3
line.long 0 "WPSAT1_REG2"
hexfld.long 0 " REG2 "
;tree.end

;tree "WPSAT1_REG3"
base ad:0xa039021c
group 0--3
line.long 0 "WPSAT1_REG3"
hexfld.long 0 " REG3 "
;tree.end

;tree "WPSAT1_REG4"
base ad:0xa0390220
group 0--3
line.long 0 "WPSAT1_REG4"
hexfld.long 0 " REG4 "
;tree.end

;tree "WPSAT1_REQ_NOT_RSP"
base ad:0xa0390224
rgroup 0--3
line.long 0 "WPSAT1_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
;tree.end

;tree "WPSAT2_REG1"
base ad:0xa0390228
group 0--3
line.long 0 "WPSAT2_REG1"
hexfld.long 0 " REG1 "
;tree.end

;tree "WPSAT2_REG2"
base ad:0xa039022c
group 0--3
line.long 0 "WPSAT2_REG2"
hexfld.long 0 " REG2 "
;tree.end

;tree "WPSAT2_REG3"
base ad:0xa0390230
group 0--3
line.long 0 "WPSAT2_REG3"
hexfld.long 0 " REG3 "
;tree.end

;tree "WPSAT2_REG4"
base ad:0xa0390234
group 0--3
line.long 0 "WPSAT2_REG4"
hexfld.long 0 " REG4 "
;tree.end

;tree "WPSAT2_REQ_NOT_RSP"
base ad:0xa0390238
rgroup 0--3
line.long 0 "WPSAT2_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
;tree.end

;tree "WPSAT3_REG1"
base ad:0xa039023c
group 0--3
line.long 0 "WPSAT3_REG1"
hexfld.long 0 " REG1 "
;tree.end

;tree "WPSAT3_REG2"
base ad:0xa0390240
group 0--3
line.long 0 "WPSAT3_REG2"
hexfld.long 0 " REG2 "
;tree.end

;tree "WPSAT3_REG3"
base ad:0xa0390244
group 0--3
line.long 0 "WPSAT3_REG3"
hexfld.long 0 " REG3 "
;tree.end

;tree "WPSAT3_REG4"
base ad:0xa0390248
group 0--3
line.long 0 "WPSAT3_REG4"
hexfld.long 0 " REG4 "
;tree.end

;tree "WPSAT3_REQ_NOT_RSP"
base ad:0xa039024c
rgroup 0--3
line.long 0 "WPSAT3_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
;tree.end

;tree "MSG_REF_PACE"
base ad:0xa0390400
group 0--3
line.long 0 "MSG_REF_PACE"
hexfld.long 0 " PACE "
;tree.end

;tree "MSG_FPF_DATA"
base ad:0xa0390404
group 0--3
line.long 0 "MSG_FPF_DATA"
hexfld.long 0 " DATA "
;tree.end

;tree "MSG_FPF_TRACE_CTRL"
base ad:0xa0390408
group 0--3
line.long 0 "MSG_FPF_TRACE_CTRL"
bitfld.long 0 0. " DATA "  "0 ,1 "
bitfld.long 0 24. " TIME "  "0 ,1 "
bitfld.long 0 31. " EN "  "0 ,1 "
;tree.end

;tree "MSG_PI_TRACE_CTRL"
base ad:0xa039040c
group 0--3
line.long 0 "MSG_PI_TRACE_CTRL"
hexfld.word 0 " INCDATA "
bitfld.long 0 24. " TIME "  "0 ,1 "
bitfld.long 0 31. " EN "  "0 ,1 "
;tree.end

;tree "MSG_REF_TRACE_CONTROL"
base ad:0xa0390410
group 0--3
line.long 0 "MSG_REF_TRACE_CONTROL"
bitfld.long 0 31. " EN "  "0 ,1 "
;tree.end

;tree "MSG_ERR_TRACE_CONTROL"
base ad:0xa0390414
group 0--3
line.long 0 "MSG_ERR_TRACE_CONTROL"
bitfld.long 0 0. " FL0 "  "0 ,1 "
bitfld.long 0 8. " FL1 "  "0 ,1 "
bitfld.long 0 9. " FL2 "  "0 ,1 "
bitfld.long 0 16. " FL3 "  "0 ,1 "
bitfld.long 0 31. " EN "  "0 ,1 "
;tree.end

;tree "MSG_WP_ENABLE"
base ad:0xa0390418
group 0--3
line.long 0 "MSG_WP_ENABLE"
bitfld.long 0 0.--3. " MSGWPEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "MSG_WP_TRACE_CTRL"
base ad:0xa039041c
group 0--3
line.long 0 "MSG_WP_TRACE_CTRL"
bitfld.long 0 0. " C1 "  "0 ,1 "
bitfld.long 0 1. " C2 "  "0 ,1 "
bitfld.long 0 8. " DATA "  "0 ,1 "
bitfld.long 0 24. " TIME "  "0 ,1 "
;tree.end

;tree "MSG_TM_ENABLE"
base ad:0xa0390420
group 0--3
line.long 0 "MSG_TM_ENABLE"
hexfld.byte 0 " MSGTMEN "
;tree.end

;tree "MSG_TM_TRACE_CTRL_L"
base ad:0xa0390424
group 0--3
line.long 0 "MSG_TM_TRACE_CTRL_L"
bitfld.long 0 0. " ERR_M3_M2_M1 "  "0 ,1 "
;tree.end

;tree "MSG_TM_TRACE_CTRL_M"
base ad:0xa0390428
group 0--3
line.long 0 "MSG_TM_TRACE_CTRL_M"
bitfld.long 0 0. " ERR_M3_M2_M1 "  "0 ,1 "
;tree.end

;tree "TMSAT0_REG1"
base ad:0xa0390600
group 0--3
line.long 0 "TMSAT0_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT0_REG2"
base ad:0xa0390604
group 0--3
line.long 0 "TMSAT0_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT0_REG3"
base ad:0xa0390608
group 0--3
line.long 0 "TMSAT0_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT1_REG1"
base ad:0xa039060c
group 0--3
line.long 0 "TMSAT1_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT1_REG2"
base ad:0xa0390610
group 0--3
line.long 0 "TMSAT1_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT1_REG3"
base ad:0xa0390614
group 0--3
line.long 0 "TMSAT1_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT2_REG1"
base ad:0xa0390618
group 0--3
line.long 0 "TMSAT2_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT2_REG2"
base ad:0xa039061c
group 0--3
line.long 0 "TMSAT2_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT2_REG3"
base ad:0xa0390620
group 0--3
line.long 0 "TMSAT2_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT3_REG1"
base ad:0xa0390624
group 0--3
line.long 0 "TMSAT3_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT3_REG2"
base ad:0xa0390628
group 0--3
line.long 0 "TMSAT3_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT3_REG3"
base ad:0xa039062c
group 0--3
line.long 0 "TMSAT3_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT4_REG1"
base ad:0xa0390630
group 0--3
line.long 0 "TMSAT4_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT4_REG2"
base ad:0xa0390634
group 0--3
line.long 0 "TMSAT4_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT4_REG3"
base ad:0xa0390638
group 0--3
line.long 0 "TMSAT4_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT5_REG1"
base ad:0xa039063c
group 0--3
line.long 0 "TMSAT5_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT5_REG2"
base ad:0xa0390640
group 0--3
line.long 0 "TMSAT5_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT5_REG3"
base ad:0xa0390644
group 0--3
line.long 0 "TMSAT5_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT6_REG1"
base ad:0xa0390648
group 0--3
line.long 0 "TMSAT6_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT6_REG2"
base ad:0xa039064c
group 0--3
line.long 0 "TMSAT6_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT6_REG3"
base ad:0xa0390650
group 0--3
line.long 0 "TMSAT6_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT7_REG1"
base ad:0xa0390654
group 0--3
line.long 0 "TMSAT7_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT7_REG2"
base ad:0xa0390658
group 0--3
line.long 0 "TMSAT7_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT7_REG3"
base ad:0xa039065c
group 0--3
line.long 0 "TMSAT7_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT8_REG1"
base ad:0xa0390660
group 0--3
line.long 0 "TMSAT8_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT8_REG2"
base ad:0xa0390664
group 0--3
line.long 0 "TMSAT8_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT8_REG3"
base ad:0xa0390668
group 0--3
line.long 0 "TMSAT8_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT9_REG1"
base ad:0xa039066c
group 0--3
line.long 0 "TMSAT9_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT9_REG2"
base ad:0xa0390670
group 0--3
line.long 0 "TMSAT9_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT9_REG3"
base ad:0xa0390674
group 0--3
line.long 0 "TMSAT9_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT10_REG1"
base ad:0xa0390678
group 0--3
line.long 0 "TMSAT10_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT10_REG2"
base ad:0xa039067c
group 0--3
line.long 0 "TMSAT10_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT10_REG3"
base ad:0xa0390680
group 0--3
line.long 0 "TMSAT10_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT11_REG1"
base ad:0xa0390684
group 0--3
line.long 0 "TMSAT11_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT11_REG2"
base ad:0xa0390688
group 0--3
line.long 0 "TMSAT11_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT11_REG3"
base ad:0xa039068c
group 0--3
line.long 0 "TMSAT11_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT12_REG1"
base ad:0xa0390690
group 0--3
line.long 0 "TMSAT12_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT12_REG2"
base ad:0xa0390694
group 0--3
line.long 0 "TMSAT12_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT12_REG3"
base ad:0xa0390698
group 0--3
line.long 0 "TMSAT12_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT13_REG1"
base ad:0xa039069c
group 0--3
line.long 0 "TMSAT13_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT13_REG2"
base ad:0xa03906a0
group 0--3
line.long 0 "TMSAT13_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "TMSAT13_REG3"
base ad:0xa03906a4
group 0--3
line.long 0 "TMSAT13_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

;tree "PI_TRIGGER_RAISE"
base ad:0xa0390800
group 0--3
line.long 0 "PI_TRIGGER_RAISE"
hexfld.word 0 " RISING "
;tree.end

;tree "PI_TRIGGER_FALLING"
base ad:0xa0390804
group 0--3
line.long 0 "PI_TRIGGER_FALLING"
hexfld.word 0 " FALLING "
;tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "MMCI (6 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "MMCI-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0Power"
base ad:0x80126000
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
;tree.end

;tree "0Clock"
base ad:0x80126004
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
;tree.end

;tree "0Argument"
base ad:0x80126008
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

;tree "0Command"
base ad:0x8012600c
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

;tree "0RespCmd"
base ad:0x80126010
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "0Rsp0"
base ad:0x80126014
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

;tree "0Rsp1"
base ad:0x80126018
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

;tree "0Rsp2"
base ad:0x8012601c
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

;tree "0Rsp3"
base ad:0x80126020
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

;tree "0Datatimer"
base ad:0x80126024
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

;tree "0DataLength"
base ad:0x80126028
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

;tree "0DataCtrl"
base ad:0x8012602c
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
;tree.end

;tree "0DataCnt"
base ad:0x80126030
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

;tree "0Status"
base ad:0x80126034
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
;tree.end

;tree "0Clear"
base ad:0x80126038
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
;tree.end

;tree "0Mask0"
base ad:0x8012603c
group 0--3
line.long 0 "Mask0"
;tree.end

;tree "0Mask1"
base ad:0x80126040
group 0--3
line.long 0 "Mask1"
;tree.end

;tree "0CardSel"
base ad:0x80126044
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0FifoCnt"
base ad:0x80126048
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

;tree "0Fifo"
base ad:0x80126080
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
;tree.end

;tree "0DBtimer"
base ad:0x801260c0
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

;tree "0TRSCA"
base ad:0x801260c4
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
;tree.end

;tree "0PeriphID0"
base ad:0x80126fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "0PeriphID1"
base ad:0x80126fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID2"
base ad:0x80126fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID3"
base ad:0x80126fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "0PCellID0"
base ad:0x80126ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

;tree "0PCellID1"
base ad:0x80126ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

;tree "0PCellID2"
base ad:0x80126ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

;tree "0PCellID3"
base ad:0x80126ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "MMCI-4"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "4Power"
base ad:0x80114000
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
;tree.end

;tree "4Clock"
base ad:0x80114004
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
;tree.end

;tree "4Argument"
base ad:0x80114008
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

;tree "4Command"
base ad:0x8011400c
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

;tree "4RespCmd"
base ad:0x80114010
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "4Rsp0"
base ad:0x80114014
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

;tree "4Rsp1"
base ad:0x80114018
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

;tree "4Rsp2"
base ad:0x8011401c
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

;tree "4Rsp3"
base ad:0x80114020
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

;tree "4Datatimer"
base ad:0x80114024
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

;tree "4DataLength"
base ad:0x80114028
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

;tree "4DataCtrl"
base ad:0x8011402c
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
;tree.end

;tree "4DataCnt"
base ad:0x80114030
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

;tree "4Status"
base ad:0x80114034
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
;tree.end

;tree "4Clear"
base ad:0x80114038
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
;tree.end

;tree "4Mask0"
base ad:0x8011403c
group 0--3
line.long 0 "Mask0"
;tree.end

;tree "4Mask1"
base ad:0x80114040
group 0--3
line.long 0 "Mask1"
;tree.end

;tree "4CardSel"
base ad:0x80114044
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "4FifoCnt"
base ad:0x80114048
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

;tree "4Fifo"
base ad:0x80114080
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
;tree.end

;tree "4DBtimer"
base ad:0x801140c0
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

;tree "4TRSCA"
base ad:0x801140c4
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
;tree.end

;tree "4PeriphID0"
base ad:0x80114fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "4PeriphID1"
base ad:0x80114fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "4PeriphID2"
base ad:0x80114fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "4PeriphID3"
base ad:0x80114fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "4PCellID0"
base ad:0x80114ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

;tree "4PCellID1"
base ad:0x80114ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

;tree "4PCellID2"
base ad:0x80114ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

;tree "4PCellID3"
base ad:0x80114ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "MMCI-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1Power"
base ad:0x80118000
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
;tree.end

;tree "1Clock"
base ad:0x80118004
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
;tree.end

;tree "1Argument"
base ad:0x80118008
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

;tree "1Command"
base ad:0x8011800c
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

;tree "1RespCmd"
base ad:0x80118010
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "1Rsp0"
base ad:0x80118014
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

;tree "1Rsp1"
base ad:0x80118018
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

;tree "1Rsp2"
base ad:0x8011801c
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

;tree "1Rsp3"
base ad:0x80118020
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

;tree "1Datatimer"
base ad:0x80118024
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

;tree "1DataLength"
base ad:0x80118028
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

;tree "1DataCtrl"
base ad:0x8011802c
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
;tree.end

;tree "1DataCnt"
base ad:0x80118030
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

;tree "1Status"
base ad:0x80118034
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
;tree.end

;tree "1Clear"
base ad:0x80118038
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
;tree.end

;tree "1Mask0"
base ad:0x8011803c
group 0--3
line.long 0 "Mask0"
;tree.end

;tree "1Mask1"
base ad:0x80118040
group 0--3
line.long 0 "Mask1"
;tree.end

;tree "1CardSel"
base ad:0x80118044
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1FifoCnt"
base ad:0x80118048
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

;tree "1Fifo"
base ad:0x80118080
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
;tree.end

;tree "1DBtimer"
base ad:0x801180c0
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

;tree "1TRSCA"
base ad:0x801180c4
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
;tree.end

;tree "1PeriphID0"
base ad:0x80118fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "1PeriphID1"
base ad:0x80118fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID2"
base ad:0x80118fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID3"
base ad:0x80118fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "1PCellID0"
base ad:0x80118ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

;tree "1PCellID1"
base ad:0x80118ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

;tree "1PCellID2"
base ad:0x80118ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

;tree "1PCellID3"
base ad:0x80118ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "MMCI-3"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "3Power"
base ad:0x80119000
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
;tree.end

;tree "3Clock"
base ad:0x80119004
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
;tree.end

;tree "3Argument"
base ad:0x80119008
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

;tree "3Command"
base ad:0x8011900c
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

;tree "3RespCmd"
base ad:0x80119010
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "3Rsp0"
base ad:0x80119014
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

;tree "3Rsp1"
base ad:0x80119018
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

;tree "3Rsp2"
base ad:0x8011901c
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

;tree "3Rsp3"
base ad:0x80119020
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

;tree "3Datatimer"
base ad:0x80119024
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

;tree "3DataLength"
base ad:0x80119028
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

;tree "3DataCtrl"
base ad:0x8011902c
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
;tree.end

;tree "3DataCnt"
base ad:0x80119030
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

;tree "3Status"
base ad:0x80119034
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
;tree.end

;tree "3Clear"
base ad:0x80119038
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
;tree.end

;tree "3Mask0"
base ad:0x8011903c
group 0--3
line.long 0 "Mask0"
;tree.end

;tree "3Mask1"
base ad:0x80119040
group 0--3
line.long 0 "Mask1"
;tree.end

;tree "3CardSel"
base ad:0x80119044
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "3FifoCnt"
base ad:0x80119048
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

;tree "3Fifo"
base ad:0x80119080
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
;tree.end

;tree "3DBtimer"
base ad:0x801190c0
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

;tree "3TRSCA"
base ad:0x801190c4
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
;tree.end

;tree "3PeriphID0"
base ad:0x80119fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "3PeriphID1"
base ad:0x80119fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "3PeriphID2"
base ad:0x80119fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "3PeriphID3"
base ad:0x80119fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "3PCellID0"
base ad:0x80119ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

;tree "3PCellID1"
base ad:0x80119ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

;tree "3PCellID2"
base ad:0x80119ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

;tree "3PCellID3"
base ad:0x80119ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "MMCI-2"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "2Power"
base ad:0x80005000
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
;tree.end

;tree "2Clock"
base ad:0x80005004
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
;tree.end

;tree "2Argument"
base ad:0x80005008
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

;tree "2Command"
base ad:0x8000500c
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

;tree "2RespCmd"
base ad:0x80005010
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "2Rsp0"
base ad:0x80005014
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

;tree "2Rsp1"
base ad:0x80005018
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

;tree "2Rsp2"
base ad:0x8000501c
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

;tree "2Rsp3"
base ad:0x80005020
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

;tree "2Datatimer"
base ad:0x80005024
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

;tree "2DataLength"
base ad:0x80005028
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

;tree "2DataCtrl"
base ad:0x8000502c
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
;tree.end

;tree "2DataCnt"
base ad:0x80005030
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

;tree "2Status"
base ad:0x80005034
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
;tree.end

;tree "2Clear"
base ad:0x80005038
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
;tree.end

;tree "2Mask0"
base ad:0x8000503c
group 0--3
line.long 0 "Mask0"
;tree.end

;tree "2Mask1"
base ad:0x80005040
group 0--3
line.long 0 "Mask1"
;tree.end

;tree "2CardSel"
base ad:0x80005044
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2FifoCnt"
base ad:0x80005048
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

;tree "2Fifo"
base ad:0x80005080
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
;tree.end

;tree "2DBtimer"
base ad:0x800050c0
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

;tree "2TRSCA"
base ad:0x800050c4
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
;tree.end

;tree "2PeriphID0"
base ad:0x80005fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "2PeriphID1"
base ad:0x80005fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2PeriphID2"
base ad:0x80005fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2PeriphID3"
base ad:0x80005fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "2PCellID0"
base ad:0x80005ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

;tree "2PCellID1"
base ad:0x80005ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

;tree "2PCellID2"
base ad:0x80005ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

;tree "2PCellID3"
base ad:0x80005ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "MMCI-5"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "5Power"
base ad:0x80008000
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  "0 ,1 ,2 ,3 "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
;tree.end

;tree "5Clock"
base ad:0x80008004
group 0--3
line.long 0 "Clock"
hexfld.byte 0 " ClkDiv "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
;tree.end

;tree "5Argument"
base ad:0x80008008
group 0--3
line.long 0 "Argument"
hexfld.long 0 " CmdArg "
;tree.end

;tree "5Command"
base ad:0x8000800c
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
;tree.end

;tree "5RespCmd"
base ad:0x80008010
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "5Rsp0"
base ad:0x80008014
rgroup 0--3
line.long 0 "Rsp0"
hexfld.long 0 " Status "
;tree.end

;tree "5Rsp1"
base ad:0x80008018
rgroup 0--3
line.long 0 "Rsp1"
hexfld.long 0 " Status "
;tree.end

;tree "5Rsp2"
base ad:0x8000801c
rgroup 0--3
line.long 0 "Rsp2"
hexfld.long 0 " Status "
;tree.end

;tree "5Rsp3"
base ad:0x80008020
rgroup 0--3
line.long 0 "Rsp3"
hexfld.long 0 " Status "
;tree.end

;tree "5Datatimer"
base ad:0x80008024
group 0--3
line.long 0 "Datatimer"
hexfld.long 0 " DataTime "
;tree.end

;tree "5DataLength"
base ad:0x80008028
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
;tree.end

;tree "5DataCtrl"
base ad:0x8000802c
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
;tree.end

;tree "5DataCnt"
base ad:0x80008030
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
;tree.end

;tree "5Status"
base ad:0x80008034
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
;tree.end

;tree "5Clear"
base ad:0x80008038
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
;tree.end

;tree "5Mask0"
base ad:0x8000803c
group 0--3
line.long 0 "Mask0"
;tree.end

;tree "5Mask1"
base ad:0x80008040
group 0--3
line.long 0 "Mask1"
;tree.end

;tree "5CardSel"
base ad:0x80008044
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "5FifoCnt"
base ad:0x80008048
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
;tree.end

;tree "5Fifo"
base ad:0x80008080
group 0--3
line.long 0 "Fifo"
hexfld.long 0 " FIFOData "
;tree.end

;tree "5DBtimer"
base ad:0x800080c0
group 0--3
line.long 0 "DBtimer"
hexfld.long 0 " DBTIME "
;tree.end

;tree "5TRSCA"
base ad:0x800080c4
group 0--3
line.long 0 "TRSCA"
hexfld.long 0 " TRSCA "
;tree.end

;tree "5PeriphID0"
base ad:0x80008fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "5PeriphID1"
base ad:0x80008fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "5PeriphID2"
base ad:0x80008fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "5PeriphID3"
base ad:0x80008fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "5PCellID0"
base ad:0x80008ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SDIPCellID0 "
;tree.end

;tree "5PCellID1"
base ad:0x80008ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SDIPCellID1 "
;tree.end

;tree "5PCellID2"
base ad:0x80008ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SDIPCellID2 "
;tree.end

;tree "5PCellID3"
base ad:0x80008ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SDIPCellID3 "
;tree.end

tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "MSHC"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "FDR"
base ad:0x8012d000
group 0--3
line.long 0 "FDR"
hexfld.long 0 " Data "
;tree.end

;tree "GCR"
base ad:0x8012d004
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " DMAREN "  "0 ,1 "
bitfld.long 0 2.--7. " BSYCNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8. " RED "  "0 ,1 "
bitfld.long 0 9. " BEND "  "0 ,1 "
bitfld.long 0 10. " FAEEN "  "0 ,1 "
bitfld.long 0 11. " IEPEN "  "0 ,1 "
;tree.end

;tree "GCT"
base ad:0x8012d008
group 0--3
line.long 0 "GCT"
bitfld.long 0 0. " PIEN "  "0 ,1 "
bitfld.long 0 1. " FCLR "  "0 ,1 "
bitfld.long 0 2. " ATPC "  "0 ,1 "
bitfld.long 0 3. " EFBSCLKEN "  "0 ,1 "
;tree.end

;tree "ACR"
base ad:0x8012d00c
group 0--3
line.long 0 "ACR"
bitfld.long 0 0. " ACEN "  "0 ,1 "
bitfld.long 0 1. " AGIEN "  "0 ,1 "
bitfld.long 0 2. " STPEN "  "0 ,1 "
bitfld.long 0 3. " EDEN "  "0 ,1 "
bitfld.long 0 4.--7. " PBTPC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--9. " EDS "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--15. " FSCD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "ACP"
base ad:0x8012d010
group 0--3
line.long 0 "ACP"
bitfld.long 0 0. " PGNB "  "0 ,1 "
;tree.end

;tree "CDR"
base ad:0x8012d014
group 0--3
line.long 0 "CDR"
bitfld.long 0 0.--9. " DATA_SIZE "  " "
bitfld.long 0 10.--13. " PID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CRC"
base ad:0x8012d018
rgroup 0--3
line.long 0 "CRC"
hexfld.word 0 " CRC "
;tree.end

;tree "CLK"
base ad:0x8012d01c
group 0--3
line.long 0 "CLK"
bitfld.long 0 0.--1. " DIV "  "0 ,1 ,2 ,3 "
;tree.end

;tree "FFR"
base ad:0x8012d020
rgroup 0--3
line.long 0 "FFR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TFF "  "0 ,1 "
bitfld.long 0 2. " RFE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " TOV "  "0 ,1 "
bitfld.long 0 5. " RUN "  "0 ,1 "
bitfld.long 0 6. " FDE "  "0 ,1 "
;tree.end

;tree "MFR"
base ad:0x8012d024
rgroup 0--3
line.long 0 "MFR"
bitfld.long 0 0. " CRC "  "0 ,1 "
bitfld.long 0 1. " TOE "  "0 ,1 "
bitfld.long 0 2. " SCG "  "0 ,1 "
bitfld.long 0 3. " VAL "  "0 ,1 "
bitfld.long 0 4. " RDY "  "0 ,1 "
bitfld.long 0 5. " INT "  "0 ,1 "
bitfld.long 0 6. " INS "  "0 ,1 "
;tree.end

;tree "DIT"
base ad:0x8012d028
rgroup 0--3
line.long 0 "DIT"
bitfld.long 0 0. " CED "  "0 ,1 "
bitfld.long 0 1. " ERR "  "0 ,1 "
bitfld.long 0 2. " BREQ "  "0 ,1 "
bitfld.long 0 3. " CMDNK "  "0 ,1 "
;tree.end

;tree "AFR"
base ad:0x8012d02c
rgroup 0--3
line.long 0 "AFR"
bitfld.long 0 0. " RDY "  "0 ,1 "
bitfld.long 0 1. " NOER "  "0 ,1 "
bitfld.long 0 2. " NOHD "  "0 ,1 "
bitfld.long 0 3. " NTPC "  "0 ,1 "
bitfld.long 0 4. " TRER "  "0 ,1 "
;tree.end

;tree "RIS"
base ad:0x8012d030
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " SRDRIS "  "0 ,1 "
bitfld.long 0 1. " BDRRIS "  "0 ,1 "
bitfld.long 0 2. " RDYRIS "  "0 ,1 "
bitfld.long 0 3. " INTRIS "  "0 ,1 "
bitfld.long 0 4. " INSRIS "  "0 ,1 "
bitfld.long 0 9. " FDERIS "  "0 ,1 "
bitfld.long 0 10. " RUNRIS "  "0 ,1 "
bitfld.long 0 11. " TOVRIS "  "0 ,1 "
bitfld.long 0 12. " TOERIS "  "0 ,1 "
bitfld.long 0 13. " CRCRIS "  "0 ,1 "
bitfld.long 0 14. " INTRRIS "  "0 ,1 "
;tree.end

;tree "IMSC"
base ad:0x8012d034
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " SDRIMS "  "0 ,1 "
bitfld.long 0 1. " BDRIMS "  "0 ,1 "
bitfld.long 0 2. " RDYIMS "  "0 ,1 "
bitfld.long 0 3. " INTIMS "  "0 ,1 "
bitfld.long 0 4. " INSIMS "  "0 ,1 "
bitfld.long 0 9. " FDEIMS "  "0 ,1 "
bitfld.long 0 10. " RUNIMS "  "0 ,1 "
bitfld.long 0 11. " TOVIMS "  "0 ,1 "
bitfld.long 0 12. " TOEIMS "  "0 ,1 "
bitfld.long 0 13. " CRCIMS "  "0 ,1 "
bitfld.long 0 14. " INTRIMS "  "0 ,1 "
;tree.end

;tree "MIS"
base ad:0x8012d038
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " SRDMIS "  "0 ,1 "
bitfld.long 0 1. " BDRMIS "  "0 ,1 "
bitfld.long 0 2. " RDYMIS "  "0 ,1 "
bitfld.long 0 3. " INTMIS "  "0 ,1 "
bitfld.long 0 4. " INSMIS "  "0 ,1 "
bitfld.long 0 9. " FDEMIS "  "0 ,1 "
bitfld.long 0 10. " RUNMIS "  "0 ,1 "
bitfld.long 0 11. " TOVMIS "  "0 ,1 "
bitfld.long 0 12. " TOEMIS "  "0 ,1 "
bitfld.long 0 13. " CRCMIS "  "0 ,1 "
bitfld.long 0 14. " INTRCMIS "  "0 ,1 "
;tree.end

;tree "ICR"
base ad:0x8012d03c
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 2. " RDYIC "  "0 ,1 "
bitfld.long 0 3. " INTIC "  "0 ,1 "
bitfld.long 0 4. " INSIC "  "0 ,1 "
bitfld.long 0 9. " FDEIC "  "0 ,1 "
bitfld.long 0 10. " RUNIC "  "0 ,1 "
bitfld.long 0 11. " TOVIC "  "0 ,1 "
bitfld.long 0 12. " TOEIC "  "0 ,1 "
bitfld.long 0 13. " CRCIC "  "0 ,1 "
;tree.end

;tree "TSTCR"
base ad:0x8012d080
group 0--3
line.long 0 "TSTCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1.--2. " FIFOTEST "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " REGTEST "  "0 ,1 "
;tree.end

;tree "ITIP"
base ad:0x8012d084
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR "  "0 ,1 "
bitfld.long 0 1. " IEP "  "0 ,1 "
bitfld.long 0 2.--5. " DATA_IN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "ITOP"
base ad:0x8012d088
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " CINTR "  "0 ,1 "
bitfld.long 0 1. " MSEINTR "  "0 ,1 "
bitfld.long 0 2. " FAEINTR "  "0 ,1 "
bitfld.long 0 5. " INSINTR "  "0 ,1 "
bitfld.long 0 6. " INTINTR "  "0 ,1 "
bitfld.long 0 7. " MSRINTR "  "0 ,1 "
bitfld.long 0 8. " BDRINTR "  "0 ,1 "
bitfld.long 0 9. " SDRINTR "  "0 ,1 "
bitfld.long 0 10. " DMASREQ "  "0 ,1 "
bitfld.long 0 11. " DMABREQ "  "0 ,1 "
bitfld.long 0 12.--15. " DATA_OUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID0"
base ad:0x8012dfe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PeriphID1"
base ad:0x8012dfe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0x8012dfe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0x8012dfec
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0. " Configuration "  "0 ,1 "
;tree.end

;tree "PCellID0"
base ad:0x8012dff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

;tree "PCellID1"
base ad:0x8012dff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

;tree "PCellID2"
base ad:0x8012dff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

;tree "PCellID3"
base ad:0x8012dffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "MSP (5 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "MSP-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0DR"
base ad:0x80123000
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

;tree "0GCR"
base ad:0x80123004
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
;tree.end

;tree "0TCF"
base ad:0x80123008
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

;tree "0RCF"
base ad:0x8012300c
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

;tree "0SRG"
base ad:0x80123010
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
;tree.end

;tree "0FLR"
base ad:0x80123014
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
;tree.end

;tree "0DMACR"
base ad:0x80123018
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
;tree.end

;tree "0WMRK"
base ad:0x8012301c
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
;tree.end

;tree "0IMSC"
base ad:0x80123020
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
;tree.end

;tree "0RIS"
base ad:0x80123024
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
;tree.end

;tree "0MIS"
base ad:0x80123028
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
;tree.end

;tree "0ICR"
base ad:0x8012302c
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
;tree.end

;tree "0MCR"
base ad:0x80123030
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
;tree.end

;tree "0RCV"
base ad:0x80123034
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
;tree.end

;tree "0RCM"
base ad:0x80123038
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
;tree.end

;tree "0TCE0"
base ad:0x80123040
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
;tree.end

;tree "0TCE1"
base ad:0x80123044
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
;tree.end

;tree "0TCE2"
base ad:0x80123048
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
;tree.end

;tree "0TCE3"
base ad:0x8012304c
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
;tree.end

;tree "0RCE0"
base ad:0x80123060
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
;tree.end

;tree "0RCE1"
base ad:0x80123064
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
;tree.end

;tree "0RCE2"
base ad:0x80123068
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
;tree.end

;tree "0RCE3"
base ad:0x8012306c
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
;tree.end

;tree "0IODLY"
base ad:0x80123070
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "0ITCR"
base ad:0x80123080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

;tree "0ITIP"
base ad:0x80123084
group 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
;tree.end

;tree "0ITOP"
base ad:0x80123088
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
;tree.end

;tree "0TSTDR"
base ad:0x8012308c
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
;tree.end

;tree "0PERIPHID0"
base ad:0x80123fe0
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
;tree.end

;tree "0PERIPHID1"
base ad:0x80123fe4
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
;tree.end

;tree "0PERIPHID2"
base ad:0x80123fe8
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
;tree.end

;tree "0PERIPHID3"
base ad:0x80123fec
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
;tree.end

;tree "0PCELLID0"
base ad:0x80123ff0
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
;tree.end

;tree "0PCELLID1"
base ad:0x80123ff4
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
;tree.end

;tree "0PCELLID2"
base ad:0x80123ff8
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
;tree.end

;tree "0PCELLID3"
base ad:0x80123ffc
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "MSP-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1DR"
base ad:0x80124000
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

;tree "1GCR"
base ad:0x80124004
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
;tree.end

;tree "1TCF"
base ad:0x80124008
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

;tree "1RCF"
base ad:0x8012400c
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

;tree "1SRG"
base ad:0x80124010
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
;tree.end

;tree "1FLR"
base ad:0x80124014
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
;tree.end

;tree "1DMACR"
base ad:0x80124018
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
;tree.end

;tree "1WMRK"
base ad:0x8012401c
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
;tree.end

;tree "1IMSC"
base ad:0x80124020
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
;tree.end

;tree "1RIS"
base ad:0x80124024
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
;tree.end

;tree "1MIS"
base ad:0x80124028
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
;tree.end

;tree "1ICR"
base ad:0x8012402c
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
;tree.end

;tree "1MCR"
base ad:0x80124030
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
;tree.end

;tree "1RCV"
base ad:0x80124034
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
;tree.end

;tree "1RCM"
base ad:0x80124038
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
;tree.end

;tree "1TCE0"
base ad:0x80124040
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
;tree.end

;tree "1TCE1"
base ad:0x80124044
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
;tree.end

;tree "1TCE2"
base ad:0x80124048
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
;tree.end

;tree "1TCE3"
base ad:0x8012404c
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
;tree.end

;tree "1RCE0"
base ad:0x80124060
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
;tree.end

;tree "1RCE1"
base ad:0x80124064
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
;tree.end

;tree "1RCE2"
base ad:0x80124068
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
;tree.end

;tree "1RCE3"
base ad:0x8012406c
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
;tree.end

;tree "1IODLY"
base ad:0x80124070
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "1ITCR"
base ad:0x80124080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

;tree "1ITIP"
base ad:0x80124084
group 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
;tree.end

;tree "1ITOP"
base ad:0x80124088
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
;tree.end

;tree "1TSTDR"
base ad:0x8012408c
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
;tree.end

;tree "1PERIPHID0"
base ad:0x80124fe0
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
;tree.end

;tree "1PERIPHID1"
base ad:0x80124fe4
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
;tree.end

;tree "1PERIPHID2"
base ad:0x80124fe8
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
;tree.end

;tree "1PERIPHID3"
base ad:0x80124fec
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
;tree.end

;tree "1PCELLID0"
base ad:0x80124ff0
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
;tree.end

;tree "1PCELLID1"
base ad:0x80124ff4
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
;tree.end

;tree "1PCELLID2"
base ad:0x80124ff8
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
;tree.end

;tree "1PCELLID3"
base ad:0x80124ffc
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "MSP-3"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "3DR"
base ad:0x80125000
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

;tree "3GCR"
base ad:0x80125004
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
;tree.end

;tree "3TCF"
base ad:0x80125008
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

;tree "3RCF"
base ad:0x8012500c
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

;tree "3SRG"
base ad:0x80125010
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
;tree.end

;tree "3FLR"
base ad:0x80125014
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
;tree.end

;tree "3DMACR"
base ad:0x80125018
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
;tree.end

;tree "3WMRK"
base ad:0x8012501c
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
;tree.end

;tree "3IMSC"
base ad:0x80125020
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
;tree.end

;tree "3RIS"
base ad:0x80125024
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
;tree.end

;tree "3MIS"
base ad:0x80125028
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
;tree.end

;tree "3ICR"
base ad:0x8012502c
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
;tree.end

;tree "3MCR"
base ad:0x80125030
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
;tree.end

;tree "3RCV"
base ad:0x80125034
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
;tree.end

;tree "3RCM"
base ad:0x80125038
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
;tree.end

;tree "3TCE0"
base ad:0x80125040
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
;tree.end

;tree "3TCE1"
base ad:0x80125044
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
;tree.end

;tree "3TCE2"
base ad:0x80125048
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
;tree.end

;tree "3TCE3"
base ad:0x8012504c
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
;tree.end

;tree "3RCE0"
base ad:0x80125060
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
;tree.end

;tree "3RCE1"
base ad:0x80125064
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
;tree.end

;tree "3RCE2"
base ad:0x80125068
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
;tree.end

;tree "3RCE3"
base ad:0x8012506c
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
;tree.end

;tree "3IODLY"
base ad:0x80125070
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "3ITCR"
base ad:0x80125080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

;tree "3ITIP"
base ad:0x80125084
group 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
;tree.end

;tree "3ITOP"
base ad:0x80125088
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
;tree.end

;tree "3TSTDR"
base ad:0x8012508c
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
;tree.end

;tree "3PERIPHID0"
base ad:0x80125fe0
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
;tree.end

;tree "3PERIPHID1"
base ad:0x80125fe4
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
;tree.end

;tree "3PERIPHID2"
base ad:0x80125fe8
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
;tree.end

;tree "3PERIPHID3"
base ad:0x80125fec
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
;tree.end

;tree "3PCELLID0"
base ad:0x80125ff0
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
;tree.end

;tree "3PCELLID1"
base ad:0x80125ff4
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
;tree.end

;tree "3PCELLID2"
base ad:0x80125ff8
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
;tree.end

;tree "3PCELLID3"
base ad:0x80125ffc
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "MSP-4"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "4DR"
base ad:0x80116000
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

;tree "4GCR"
base ad:0x80116004
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
;tree.end

;tree "4TCF"
base ad:0x80116008
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

;tree "4RCF"
base ad:0x8011600c
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

;tree "4SRG"
base ad:0x80116010
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
;tree.end

;tree "4FLR"
base ad:0x80116014
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
;tree.end

;tree "4DMACR"
base ad:0x80116018
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
;tree.end

;tree "4WMRK"
base ad:0x8011601c
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
;tree.end

;tree "4IMSC"
base ad:0x80116020
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
;tree.end

;tree "4RIS"
base ad:0x80116024
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
;tree.end

;tree "4MIS"
base ad:0x80116028
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
;tree.end

;tree "4ICR"
base ad:0x8011602c
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
;tree.end

;tree "4MCR"
base ad:0x80116030
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
;tree.end

;tree "4RCV"
base ad:0x80116034
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
;tree.end

;tree "4RCM"
base ad:0x80116038
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
;tree.end

;tree "4TCE0"
base ad:0x80116040
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
;tree.end

;tree "4TCE1"
base ad:0x80116044
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
;tree.end

;tree "4TCE2"
base ad:0x80116048
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
;tree.end

;tree "4TCE3"
base ad:0x8011604c
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
;tree.end

;tree "4RCE0"
base ad:0x80116060
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
;tree.end

;tree "4RCE1"
base ad:0x80116064
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
;tree.end

;tree "4RCE2"
base ad:0x80116068
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
;tree.end

;tree "4RCE3"
base ad:0x8011606c
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
;tree.end

;tree "4IODLY"
base ad:0x80116070
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "4ITCR"
base ad:0x80116080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

;tree "4ITIP"
base ad:0x80116084
group 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
;tree.end

;tree "4ITOP"
base ad:0x80116088
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
;tree.end

;tree "4TSTDR"
base ad:0x8011608c
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
;tree.end

;tree "4PERIPHID0"
base ad:0x80116fe0
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
;tree.end

;tree "4PERIPHID1"
base ad:0x80116fe4
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
;tree.end

;tree "4PERIPHID2"
base ad:0x80116fe8
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
;tree.end

;tree "4PERIPHID3"
base ad:0x80116fec
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
;tree.end

;tree "4PCELLID0"
base ad:0x80116ff0
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
;tree.end

;tree "4PCELLID1"
base ad:0x80116ff4
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
;tree.end

;tree "4PCELLID2"
base ad:0x80116ff8
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
;tree.end

;tree "4PCELLID3"
base ad:0x80116ffc
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "MSP-2"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "2DR"
base ad:0x80117000
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

;tree "2GCR"
base ad:0x80117004
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  "0 ,1 ,2 ,3 "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
;tree.end

;tree "2TCF"
base ad:0x80117008
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

;tree "2RCF"
base ad:0x8011700c
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  "0 ,1 ,2 ,3 "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  "0 ,1 ,2 ,3 "
;tree.end

;tree "2SRG"
base ad:0x80117010
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--28. " FRPER "  " "
;tree.end

;tree "2FLR"
base ad:0x80117014
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
;tree.end

;tree "2DMACR"
base ad:0x80117018
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
;tree.end

;tree "2WMRK"
base ad:0x8011701c
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
;tree.end

;tree "2IMSC"
base ad:0x80117020
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
;tree.end

;tree "2RIS"
base ad:0x80117024
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
;tree.end

;tree "2MIS"
base ad:0x80117028
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
;tree.end

;tree "2ICR"
base ad:0x8011702c
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
;tree.end

;tree "2MCR"
base ad:0x80117030
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " RCMPM "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  "0 ,1 ,2 ,3 "
;tree.end

;tree "2RCV"
base ad:0x80117034
group 0--3
line.long 0 "RCV"
hexfld.long 0 " RCV "
;tree.end

;tree "2RCM"
base ad:0x80117038
group 0--3
line.long 0 "RCM"
hexfld.long 0 " RCM "
;tree.end

;tree "2TCE0"
base ad:0x80117040
group 0--3
line.long 0 "TCE0"
hexfld.long 0 " TCE0 "
;tree.end

;tree "2TCE1"
base ad:0x80117044
group 0--3
line.long 0 "TCE1"
hexfld.long 0 " TCE1 "
;tree.end

;tree "2TCE2"
base ad:0x80117048
group 0--3
line.long 0 "TCE2"
hexfld.long 0 " TCE2 "
;tree.end

;tree "2TCE3"
base ad:0x8011704c
group 0--3
line.long 0 "TCE3"
hexfld.long 0 " TCE3 "
;tree.end

;tree "2RCE0"
base ad:0x80117060
group 0--3
line.long 0 "RCE0"
hexfld.long 0 " RCE0 "
;tree.end

;tree "2RCE1"
base ad:0x80117064
group 0--3
line.long 0 "RCE1"
hexfld.long 0 " RCE1 "
;tree.end

;tree "2RCE2"
base ad:0x80117068
group 0--3
line.long 0 "RCE2"
hexfld.long 0 " RCE2 "
;tree.end

;tree "2RCE3"
base ad:0x8011706c
group 0--3
line.long 0 "RCE3"
hexfld.long 0 " RCE3 "
;tree.end

;tree "2IODLY"
base ad:0x80117070
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " TFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " TDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " RCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " RFSDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " RDXDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " SCKDLY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "2ITCR"
base ad:0x80117080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

;tree "2ITIP"
base ad:0x80117084
group 0--3
line.long 0 "ITIP"
hexfld.long 0 " DATA "
;tree.end

;tree "2ITOP"
base ad:0x80117088
group 0--3
line.long 0 "ITOP"
hexfld.long 0 " DATA "
;tree.end

;tree "2TSTDR"
base ad:0x8011708c
group 0--3
line.long 0 "TSTDR"
hexfld.long 0 " DATA "
;tree.end

;tree "2PERIPHID0"
base ad:0x80117fe0
rgroup 0--3
line.long 0 "PERIPHID0"
hexfld.long 0 " DATA "
;tree.end

;tree "2PERIPHID1"
base ad:0x80117fe4
rgroup 0--3
line.long 0 "PERIPHID1"
hexfld.long 0 " DATA "
;tree.end

;tree "2PERIPHID2"
base ad:0x80117fe8
rgroup 0--3
line.long 0 "PERIPHID2"
hexfld.long 0 " DATA "
;tree.end

;tree "2PERIPHID3"
base ad:0x80117fec
rgroup 0--3
line.long 0 "PERIPHID3"
hexfld.long 0 " DATA "
;tree.end

;tree "2PCELLID0"
base ad:0x80117ff0
rgroup 0--3
line.long 0 "PCELLID0"
hexfld.long 0 " DATA "
;tree.end

;tree "2PCELLID1"
base ad:0x80117ff4
rgroup 0--3
line.long 0 "PCELLID1"
hexfld.long 0 " DATA "
;tree.end

;tree "2PCELLID2"
base ad:0x80117ff8
rgroup 0--3
line.long 0 "PCELLID2"
hexfld.long 0 " DATA "
;tree.end

;tree "2PCELLID3"
base ad:0x80117ffc
rgroup 0--3
line.long 0 "PCELLID3"
hexfld.long 0 " DATA "
;tree.end

tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "OWMTB"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "TSLOTREG"
base ad:0x63600000
group 0--3
line.long 0 "TSLOTREG"
bitfld.long 0 0.--1. " TSLOT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "RWREG"
base ad:0x63600004
group 0--3
line.long 0 "RWREG"
bitfld.long 0 0. " RDWR "  "0 ,1 "
bitfld.long 0 1. " WAIT "  "0 ,1 "
bitfld.long 0 2. " WDONE "  "0 ,1 "
bitfld.long 0 3. " RDONE "  "0 ,1 "
;tree.end

;tree "WRITEREG"
base ad:0x63600008
group 0--3
line.long 0 "WRITEREG"
hexfld.byte 0 " DATAWR "
;tree.end

;tree "READREG"
base ad:0x6360000c
group 0--3
line.long 0 "READREG"
hexfld.byte 0 " DATARD "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "PKA"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CR"
base ad:0xa03c4000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PKAGO "  "0 ,1 "
bitfld.long 0 1. " PKASTOP "  "0 ,1 "
bitfld.long 0 2. " PKARESTORE "  "0 ,1 "
;tree.end

;tree "CFG"
base ad:0xa03c4004
group 0--3
line.long 0 "CFG"
bitfld.long 0 0. " SEC "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGOMODE "  "0 ,1 "
bitfld.long 0 3.--4. " ALGOCALC "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " SECLVL "  "0 ,1 ,2 ,3 "
bitfld.long 0 7.--8. " DATASWAP "  "0 ,1 ,2 ,3 "
;tree.end

;tree "SR"
base ad:0xa03c4008
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " BUSY "  "0 ,1 "
bitfld.long 0 1. " STATUSSTOP "  "0 ,1 "
bitfld.long 0 2. " STATUSRESTORE "  "0 ,1 "
;tree.end

;tree "IMSC"
base ad:0xa03c400c
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " PKAIM "  "0 ,1 "
;tree.end

;tree "RIS"
base ad:0xa03c4010
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " PKARIS "  "0 ,1 "
;tree.end

;tree "MIS"
base ad:0xa03c4014
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " PKAMIS "  "0 ,1 "
;tree.end

;tree "ICR"
base ad:0xa03c4018
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " PKAIC "  "0 ,1 "
;tree.end

;tree "ITCR"
base ad:0xa03c4800
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITIP"
base ad:0xa03c4804
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
;tree.end

;tree "ITOP"
base ad:0xa03c4808
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " PKAINTR "  "0 ,1 "
;tree.end

;tree "PeriphID0"
base ad:0xa03c4fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PeriphID1"
base ad:0xa03c4fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0xa03c4fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0xa03c4fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0xa03c4ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PKAPCellID0 "
;tree.end

;tree "PCellID1"
base ad:0xa03c4ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PKAPCellID1 "
;tree.end

;tree "PCellID2"
base ad:0xa03c4ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PKAPCellID2 "
;tree.end

;tree "PCellID3"
base ad:0xa03c4ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PKA0PCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "PMU"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CTRL"
base ad:0xa03a7000
group 0--3
line.long 0 "CTRL"
bitfld.long 0 2. " IOFORCE "  "0 ,1 "
bitfld.long 0 3. " SDMCHLD "  "0 ,1 "
bitfld.long 0 4. " DEEPDIS "  "0 ,1 "
bitfld.long 0 5. " HPIWKEN "  "0 ,1 "
bitfld.long 0 6. " HPIBYPEN "  "0 ,1 "
bitfld.long 0 7. " HPIEV "  "0 ,1 "
bitfld.long 0 8. " HPICTEN "  "0 ,1 "
bitfld.long 0 9. " HPIMOD "  "0 ,1 "
bitfld.long 0 10. " HPIEND "  "0 ,1 "
bitfld.long 0 11. " HPIPSRAM "  "0 ,1 "
bitfld.long 0 15. " GPIORSTCFG "  "0 ,1 "
bitfld.long 0 16.--17. " SXAGPIO "  "0 ,1 ,2 ,3 "
bitfld.long 0 21. " DDR2V5 "  "0 ,1 "
bitfld.long 0 22. " DIFCLCDHiZ "  "0 ,1 "
bitfld.long 0 23.--24. " SDMCSTR "  "0 ,1 ,2 ,3 "
bitfld.long 0 25. " SDMCPDEN "  "0 ,1 "
bitfld.long 0 26. " SDMCZOUTPRG "  "0 ,1 "
bitfld.long 0 27. " HTIMEN "  "0 ,1 "
bitfld.long 0 28. " EXTBRKEN "  "0 ,1 "
bitfld.long 0 30. " DSPDBG "  "0 ,1 "
;tree.end

;tree "STA"
base ad:0xa03a7004
group 0--3
line.long 0 "STA"
bitfld.long 0 0. " RTCWKSTA "  "0 ,1 "
bitfld.long 0 1. " HPIWKSTA "  "0 ,1 "
bitfld.long 0 2. " GP0WKSTA "  "0 ,1 "
bitfld.long 0 3. " GP1WKSTA "  "0 ,1 "
bitfld.long 0 4. " GP2WKSTA "  "0 ,1 "
bitfld.long 0 5. " GP3WKSTA "  "0 ,1 "
bitfld.long 0 6. " GP4WKSTA "  "0 ,1 "
bitfld.long 0 7. " GP5WKSTA "  "0 ,1 "
bitfld.long 0 8. " GP6WKSTA "  "0 ,1 "
bitfld.long 0 9. " SWDGWKSTA "  "0 ,1 "
bitfld.long 0 15. " SCRLOCK "  "0 ,1 "
bitfld.long 0 16. " COMPOK "  "0 ,1 "
bitfld.long 0 17. " DRAMCOMPOK "  "0 ,1 "
bitfld.long 0 18.--24. " DRAMNASRC "  " "
bitfld.long 0 25.--31. " NASRC "  " "
;tree.end

;tree "CTRL2"
base ad:0xa03a7008
group 0--3
line.long 0 "CTRL2"
hexfld.byte 0 " WKUP_TEMPO_CORE "
hexfld.byte 1 " WKUP_TEMPO_CPU "
bitfld.long 0 16. " IOLVLA "  "0 ,1 "
bitfld.long 0 17. " IOLVLB "  "0 ,1 "
bitfld.long 0 18. " IOLVLC "  "0 ,1 "
bitfld.long 0 28. " DRAMCOMPTYP "  "0 ,1 "
bitfld.long 0 29. " DRAMCOMPFRZ "  "0 ,1 "
bitfld.long 0 30. " COMPTYP "  "0 ,1 "
bitfld.long 0 31. " COMPFRZ "  "0 ,1 "
;tree.end

;tree "CTRL3"
base ad:0xa03a700c
group 0--3
line.long 0 "CTRL3"
bitfld.long 0 0. " MSPBYP01AEN "  "0 ,1 "
bitfld.long 0 1. " MSPBYP01CK10 "  "0 ,1 "
bitfld.long 0 2. " MSPBYP01CK01 "  "0 ,1 "
bitfld.long 0 3. " MSPBYP01FS10 "  "0 ,1 "
bitfld.long 0 4. " MSPBYP01FS01 "  "0 ,1 "
bitfld.long 0 8. " MSPBYP03AEN "  "0 ,1 "
bitfld.long 0 9. " MSPBYP03CK30 "  "0 ,1 "
bitfld.long 0 10. " MSPBYP03CK03 "  "0 ,1 "
bitfld.long 0 11. " MSPBYP03FS30 "  "0 ,1 "
bitfld.long 0 12. " MSPBYP03FS03 "  "0 ,1 "
bitfld.long 0 16. " MSP0WR "  "0 ,1 "
bitfld.long 0 17. " MMCI1WR "  "0 ,1 "
bitfld.long 0 18. " MMC2WR "  "0 ,1 "
bitfld.long 0 24. " SAAMSP "  "0 ,1 "
bitfld.long 0 25. " SVAMSP "  "0 ,1 "
bitfld.long 0 26. " SIAMSP "  "0 ,1 "
bitfld.long 0 27. " MSP1CLR "  "0 ,1 "
bitfld.long 0 28. " MSP3CLR "  "0 ,1 "
;tree.end

;tree "SPR0"
base ad:0xa03a7010
group 0--3
line.long 0 "SPR0"
hexfld.long 0 " SPR0 "
;tree.end

;tree "SPR1"
base ad:0xa03a7014
group 0--3
line.long 0 "SPR1"
hexfld.long 0 " SPR1 "
;tree.end

;tree "SPR2"
base ad:0xa03a7018
group 0--3
line.long 0 "SPR2"
hexfld.long 0 " SPR2 "
;tree.end

;tree "SPR3"
base ad:0xa03a701c
group 0--3
line.long 0 "SPR3"
hexfld.long 0 " SPR3 "
;tree.end

;tree "CTRL4"
base ad:0xa03a7020
group 0--3
line.long 0 "CTRL4"
bitfld.long 0 0.--3. " SBAGD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " SBAGT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " MSPBYP13FS13 "  "0 ,1 "
bitfld.long 0 9. " MSPBYP13FS31 "  "0 ,1 "
bitfld.long 0 10. " MSPBYP13CK13 "  "0 ,1 "
bitfld.long 0 11. " MSPBYP13CK31 "  "0 ,1 "
bitfld.long 0 12. " MSPBYP13AEN "  "0 ,1 "
bitfld.long 0 13.--15. " SPARE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--17. " SAADMACH0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " SAADMACH1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " SAADMACH2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " SAADMACH3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "RIS"
base ad:0xa03a7028
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 1. " HWI2C_ABTRIS "  "0 ,1 "
;tree.end

;tree "ICR"
base ad:0xa03a702c
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 1. " HWI2CABTIC "  "0 ,1 "
;tree.end

;tree "SWCR"
base ad:0xa03a7030
group 0--3
line.long 0 "SWCR"
bitfld.long 0 0. " SAAEN "  "0 ,1 "
bitfld.long 0 1. " SIAEN "  "0 ,1 "
bitfld.long 0 2. " SVAEN "  "0 ,1 "
bitfld.long 0 3. " SGAEN "  "0 ,1 "
;tree.end

;tree "SWSR"
base ad:0xa03a7034
rgroup 0--3
line.long 0 "SWSR"
bitfld.long 0 0. " SAAST "  "0 ,1 "
bitfld.long 0 1. " SIAST "  "0 ,1 "
bitfld.long 0 2. " SVAST "  "0 ,1 "
bitfld.long 0 3. " SGAST "  "0 ,1 "
bitfld.long 0 4. " COREST "  "0 ,1 "
;tree.end

;tree "CTRL5"
base ad:0xa03a7038
group 0--3
line.long 0 "CTRL5"
bitfld.long 0 0.--1. " SVADMACH0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " SVADMACH1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " SVADMACH2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " SVADMACH3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--17. " SIADMACH0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " SIADMACH1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--23. " SIADMACH2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " SIADMACH3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CTRL6"
base ad:0xa03a703c
group 0--3
line.long 0 "CTRL6"
bitfld.long 0 0.--3. " KPSKA0MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " KPSKA1MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " KPSKA2MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " KPSKB0MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " KPSB1MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " KPSKB2MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--26. " KPO8MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 27.--29. " KPO9MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 31. " KBDORETM "  "0 ,1 "
;tree.end

;tree "CTRL7"
base ad:0xa03a7040
group 0--3
line.long 0 "CTRL7"
bitfld.long 0 0.--2. " VPIPPWM8MUX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--7. " G12_ATTR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "ATTR0"
base ad:0xa03a7060
group 0--3
line.long 0 "ATTR0"
bitfld.long 0 0.--3. " SAA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " HPI "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " SVADSP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " SIADSP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " DMAM1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " SVADMA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " DISP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " SGA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "ATTR1"
base ad:0xa03a7064
group 0--3
line.long 0 "ATTR1"
bitfld.long 0 0.--3. " B2R2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " DMAM2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " ARMM1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " ARMM0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " SIADMA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "SLVDDCPUVAL"
base ad:0xa03a7100
group 0--3
line.long 0 "SLVDDCPUVAL"
bitfld.long 0 0.--5. " SLVDDCPUVAL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " SLEN "  "0 ,1 "
;tree.end

;tree "HWI2C"
base ad:0xa03a7104
group 0--3
line.long 0 "HWI2C"
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 12. " HWGCEN "  "0 ,1 "
bitfld.long 0 14. " STOPEN "  "0 ,1 "
hexfld.byte 2 " REG_ADD "
;tree.end

;tree "HWI2CSR"
base ad:0xa03a7108
rgroup 0--3
line.long 0 "HWI2CSR"
bitfld.long 0 2.--3. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PWRDCNT"
base ad:0xa03a710c
group 0--3
line.long 0 "PWRDCNT"
hexfld.word 0 " INTVAL "
;tree.end

;tree "ITCR"
base ad:0xa03a7f00
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITIP"
base ad:0xa03a7f04
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " nWARMRESET "  "0 ,1 "
bitfld.long 0 1. " SOFTRESREQ "  "0 ,1 "
bitfld.long 0 2. " WDRES "  "0 ,1 "
bitfld.long 0 4. " RTCWKUP "  "0 ,1 "
;tree.end

;tree "ITOP"
base ad:0xa03a7f08
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " PWR_EN "  "0 ,1 "
bitfld.long 0 2. " WAKEUP "  "0 ,1 "
bitfld.long 0 4. " IOFORCE "  "0 ,1 "
bitfld.long 0 5. " SDRAM_HLD "  "0 ,1 "
bitfld.long 0 6. " SOFTRESSTAT "  "0 ,1 "
bitfld.long 0 7. " WATRESSTAT "  "0 ,1 "
bitfld.long 0 8. " EXTRESSTAT "  "0 ,1 "
bitfld.long 0 9. " PORESSTAT "  "0 ,1 "
bitfld.long 0 10. " SLEEPRESSTAT "  "0 ,1 "
bitfld.long 0 18. " FSMCPUP "  "0 ,1 "
bitfld.long 0 19. " SDMCPDEN "  "0 ,1 "
bitfld.long 0 20. " SDMCSTR0 "  "0 ,1 "
bitfld.long 0 21. " SDMCSTR1 "  "0 ,1 "
;tree.end

;tree "PeriphID0"
base ad:0xa03a7fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "PeriphID1"
base ad:0xa03a7fe4
rgroup 0--3
line.long 0 "PeriphID1"
hexfld.byte 0 " Partnumber1 "
;tree.end

;tree "PeriphID2"
base ad:0xa03a7fe8
rgroup 0--3
line.long 0 "PeriphID2"
hexfld.byte 0 " Partnumber2 "
;tree.end

;tree "PeriphID3"
base ad:0xa03a7fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Partnumber3 "
;tree.end

;tree "PCellID0"
base ad:0xa03a7ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

;tree "PCellID1"
base ad:0xa03a7ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

;tree "PCellID2"
base ad:0xa03a7ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

;tree "PCellID3"
base ad:0xa03a7ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "PRCMU"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "PRCM_ARMCLKFIX_MGT"
base ad:0x80157000
group 0--3
line.long 0 "PRCM_ARMCLKFIX_MGT"
bitfld.long 0 0.--4. " ARMCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " ARMCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 9. " ARMCLK38 "  "0 ,1 "
bitfld.long 0 10. " ARMCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " ARMCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_ACLK_MGT"
base ad:0x80157004
group 0--3
line.long 0 "PRCM_ACLK_MGT"
bitfld.long 0 0.--4. " ACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " ACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " ACLKEN "  "0 ,1 "
bitfld.long 0 9. " ACLK38 "  "0 ,1 "
bitfld.long 0 10. " ACLK38SRC "  "0 ,1 "
bitfld.long 0 11. " ACLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_SVAMMDSPCLK_MGT"
base ad:0x80157008
group 0--3
line.long 0 "PRCM_SVAMMDSPCLK_MGT"
bitfld.long 0 0.--4. " SVAMMDSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SVAMMDSPCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 9. " SVAMMDSPCLK38 "  "0 ,1 "
bitfld.long 0 10. " SVAMMDSPCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SVA_LOW_FREQ "  "0 ,1 "
bitfld.long 0 12. " SVA_PHY_EN "  "0 ,1 "
bitfld.long 0 13. " SVAMMDSPCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_SIAMMDSPCLK_MGT"
base ad:0x8015700c
group 0--3
line.long 0 "PRCM_SIAMMDSPCLK_MGT"
bitfld.long 0 0.--4. " SIAMMDSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SIAMMDSPCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 9. " SIAMMDSPCLK38 "  "0 ,1 "
bitfld.long 0 10. " SIAMMDSPCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SIA_LOW_FREQ "  "0 ,1 "
bitfld.long 0 12. " SIA_PHY_EN "  "0 ,1 "
bitfld.long 0 13. " SIAMMDSPCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_SGACLK_MGT"
base ad:0x80157014
group 0--3
line.long 0 "PRCM_SGACLK_MGT"
bitfld.long 0 0.--4. " SGACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SGACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SGACLKEN "  "0 ,1 "
bitfld.long 0 9. " SGACLK38 "  "0 ,1 "
bitfld.long 0 10. " SGACLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SGACLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_UARTCLK_MGT"
base ad:0x80157018
group 0--3
line.long 0 "PRCM_UARTCLK_MGT"
bitfld.long 0 0.--4. " UARTCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " UARTCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 9. " UARTCLK38 "  "0 ,1 "
bitfld.long 0 10. " UARTCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " UARTCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_MSP02CLK_MGT"
base ad:0x8015701c
group 0--3
line.long 0 "PRCM_MSP02CLK_MGT"
bitfld.long 0 0.--4. " MSP02CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " MSP02CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 9. " MSP02CLK38 "  "0 ,1 "
bitfld.long 0 10. " MSP02CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " MSP02CLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_I2CCLK_MGT"
base ad:0x80157020
group 0--3
line.long 0 "PRCM_I2CCLK_MGT"
bitfld.long 0 0.--4. " I2CCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " I2CCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " I2CCLK38 "  "0 ,1 "
bitfld.long 0 10. " I2CCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " I2CCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_SDMMCCLK_MGT"
base ad:0x80157024
group 0--3
line.long 0 "PRCM_SDMMCCLK_MGT"
bitfld.long 0 0.--4. " SDMMCCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SDMMCCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLK38 "  "0 ,1 "
bitfld.long 0 10. " SDMMCCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SDMMCCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_SLIMCLK_MGT"
base ad:0x80157028
group 0--3
line.long 0 "PRCM_SLIMCLK_MGT"
bitfld.long 0 0.--4. " SLIMCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SLIMCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SLIMCLKEN "  "0 ,1 "
bitfld.long 0 9. " SLIMCLK38 "  "0 ,1 "
bitfld.long 0 10. " SLIMCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SLIMCLK38DIV "  "0 ,1 "
bitfld.long 0 12.--14. " SLIMCLKMSP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PRCM_PER1CLK_MGT"
base ad:0x8015702c
group 0--3
line.long 0 "PRCM_PER1CLK_MGT"
bitfld.long 0 0.--4. " PER1CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER1CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER1CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER1CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER1CLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_PER2CLK_MGT"
base ad:0x80157030
group 0--3
line.long 0 "PRCM_PER2CLK_MGT"
bitfld.long 0 0.--4. " PER2CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER2CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER2CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER2CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER2CLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_PER3CLK_MGT"
base ad:0x80157034
group 0--3
line.long 0 "PRCM_PER3CLK_MGT"
bitfld.long 0 0.--4. " PER3CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER3CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER3CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER3CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER3CLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_PER5CLK_MGT"
base ad:0x80157038
group 0--3
line.long 0 "PRCM_PER5CLK_MGT"
bitfld.long 0 0.--4. " PER5CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER5CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER5CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER5CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER5CLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_PER6CLK_MGT"
base ad:0x8015703c
group 0--3
line.long 0 "PRCM_PER6CLK_MGT"
bitfld.long 0 0.--4. " PER6CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER6CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER6CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER6CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER6CLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_PER7CLK_MGT"
base ad:0x80157040
group 0--3
line.long 0 "PRCM_PER7CLK_MGT"
bitfld.long 0 0.--4. " PER7CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " PER7CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER7CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER7CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER7CLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_LCDCLK_MGT"
base ad:0x80157044
group 0--3
line.long 0 "PRCM_LCDCLK_MGT"
bitfld.long 0 0.--4. " LCDCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " LCDCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 9. " LCDCLK38 "  "0 ,1 "
bitfld.long 0 10. " LCDCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " LCDCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_SPARE1CLK_MGT"
base ad:0x80157048
group 0--3
line.long 0 "PRCM_SPARE1CLK_MGT"
bitfld.long 0 0.--11. " SPARE "  " "
;tree.end

;tree "PRCM_BMLCLK_MGT"
base ad:0x8015704c
group 0--3
line.long 0 "PRCM_BMLCLK_MGT"
bitfld.long 0 0.--4. " BMLCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " BMLCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " BMLCLKEN "  "0 ,1 "
bitfld.long 0 9. " BMLCLK38 "  "0 ,1 "
bitfld.long 0 10. " BMLCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " BMLCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_HSITXCLK_MGT"
base ad:0x80157050
group 0--3
line.long 0 "PRCM_HSITXCLK_MGT"
bitfld.long 0 0.--4. " HSITXCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " HSITXCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 9. " HSITXCLK38 "  "0 ,1 "
bitfld.long 0 10. " HSITXCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " HSITXCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_HSIRXCLK_MGT"
base ad:0x80157054
group 0--3
line.long 0 "PRCM_HSIRXCLK_MGT"
bitfld.long 0 0.--4. " HSIRXCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " HSIRXCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 9. " HSIRXCLK38 "  "0 ,1 "
bitfld.long 0 10. " HSIRXCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " HSIRXCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_HDMICLK_MGT"
base ad:0x80157058
group 0--3
line.long 0 "PRCM_HDMICLK_MGT"
bitfld.long 0 0.--4. " HDMICLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " HDMICLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 9. " HDMICLK38 "  "0 ,1 "
bitfld.long 0 10. " HDMICLK38SRC "  "0 ,1 "
bitfld.long 0 11. " HDMICLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_APEATCLK_MGT"
base ad:0x8015705c
group 0--3
line.long 0 "PRCM_APEATCLK_MGT"
bitfld.long 0 0.--4. " APEATCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " APEATCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 9. " APEATCLK38 "  "0 ,1 "
bitfld.long 0 10. " APEATCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " APEATCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_APETRACECLK_MGT"
base ad:0x80157060
group 0--3
line.long 0 "PRCM_APETRACECLK_MGT"
bitfld.long 0 0.--4. " APETRACECLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " APETRACECLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 9. " APETRACECLK38 "  "0 ,1 "
bitfld.long 0 10. " APETRACECLK38SRC "  "0 ,1 "
bitfld.long 0 11. " APETRACECLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_MCDECLK_MGT"
base ad:0x80157064
group 0--3
line.long 0 "PRCM_MCDECLK_MGT"
bitfld.long 0 0.--4. " MCDECLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " MCDECLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 9. " MCDECLK38 "  "0 ,1 "
bitfld.long 0 10. " MCDECLK38SRC "  "0 ,1 "
bitfld.long 0 11. " MCDECLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_IPI2CCLK_MGT"
base ad:0x80157068
group 0--3
line.long 0 "PRCM_IPI2CCLK_MGT"
bitfld.long 0 0.--4. " IPI2CCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " IPI2CCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " IPI2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " IPI2CCLK38 "  "0 ,1 "
bitfld.long 0 10. " IPI2CCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " IPI2CCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_DSIALTCLK_MGT"
base ad:0x8015706c
group 0--3
line.long 0 "PRCM_DSIALTCLK_MGT"
bitfld.long 0 0.--4. " DSIALTCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " DSIALTCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 9. " DSIALTCLK38 "  "0 ,1 "
bitfld.long 0 10. " DSIALTCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " DSIALTCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_SPARE2CLK_MGT"
base ad:0x80157070
group 0--3
line.long 0 "PRCM_SPARE2CLK_MGT"
bitfld.long 0 0.--11. " SPARE "  " "
;tree.end

;tree "PRCM_DMACLK_MGT"
base ad:0x80157074
group 0--3
line.long 0 "PRCM_DMACLK_MGT"
bitfld.long 0 0.--4. " DMACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " DMACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " DMACLKEN "  "0 ,1 "
bitfld.long 0 9. " DMACLK38 "  "0 ,1 "
bitfld.long 0 10. " DMACLK38SRC "  "0 ,1 "
bitfld.long 0 11. " DMACLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_B2R2CLK_MGT"
base ad:0x80157078
group 0--3
line.long 0 "PRCM_B2R2CLK_MGT"
bitfld.long 0 0.--4. " B2R2CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " B2R2CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 9. " B2R2CLK38 "  "0 ,1 "
bitfld.long 0 10. " B2R2CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " B2R2CLK38DIV "  "0 ,1 "
bitfld.long 0 12. " B2R2CLKDIV_BY_2_5_EN "  "0 ,1 "
;tree.end

;tree "PRCM_TVCLK_MGT"
base ad:0x8015707c
group 0--3
line.long 0 "PRCM_TVCLK_MGT"
bitfld.long 0 0.--4. " TVCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " TVCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " TVCLKEN "  "0 ,1 "
bitfld.long 0 9. " TVCLK38 "  "0 ,1 "
bitfld.long 0 10. " TVCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " TVCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_PLLSOC0_FREQ"
base ad:0x80157080
group 0--3
line.long 0 "PRCM_PLLSOC0_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
bitfld.long 0 25. " DIV2EN "  "0 ,1 "
;tree.end

;tree "PRCM_PLLSOC1_FREQ"
base ad:0x80157084
group 0--3
line.long 0 "PRCM_PLLSOC1_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
bitfld.long 0 25. " DIV2EN "  "0 ,1 "
;tree.end

;tree "PRCM_PLLARM_FREQ"
base ad:0x80157088
group 0--3
line.long 0 "PRCM_PLLARM_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
;tree.end

;tree "PRCM_PLLDDR_FREQ"
base ad:0x8015708c
group 0--3
line.long 0 "PRCM_PLLDDR_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
bitfld.long 0 25. " DIV2EN "  "0 ,1 "
;tree.end

;tree "PRCM_PLLSOC0_ENABLE"
base ad:0x80157090
group 0--3
line.long 0 "PRCM_PLLSOC0_ENABLE"
bitfld.long 0 0. " PRCM_PLLSOC0_ENABLE "  "0 ,1 "
;tree.end

;tree "PRCM_PLLSOC1_ENABLE"
base ad:0x80157094
group 0--3
line.long 0 "PRCM_PLLSOC1_ENABLE"
bitfld.long 0 0. " PRCM_PLLSOC1_ENABLE "  "0 ,1 "
;tree.end

;tree "PRCM_PLLARM_ENABLE"
base ad:0x80157098
group 0--3
line.long 0 "PRCM_PLLARM_ENABLE"
bitfld.long 0 0. " PRCM_PLLARM_ENABLE "  "0 ,1 "
bitfld.long 0 8. " PRCM_PLLARM_COUNTON "  "0 ,1 "
;tree.end

;tree "PRCM_PLLDDR_ENABLE"
base ad:0x8015709c
group 0--3
line.long 0 "PRCM_PLLDDR_ENABLE"
bitfld.long 0 0. " PRCM_PLLDDR_ENABLE "  "0 ,1 "
;tree.end

;tree "PRCM_PLLSOC0_LOCKP"
base ad:0x801570a0
rgroup 0--3
line.long 0 "PRCM_PLLSOC0_LOCKP"
bitfld.long 0 0. " PRCM_PLLSOC0_LOCK10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLSOC0_LOCK3 "  "0 ,1 "
;tree.end

;tree "PRCM_PLLSOC1_LOCKP"
base ad:0x801570a4
rgroup 0--3
line.long 0 "PRCM_PLLSOC1_LOCKP"
bitfld.long 0 0. " PRCM_PLLSOC1_LOCK10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLSOC1_LOCK3 "  "0 ,1 "
;tree.end

;tree "PRCM_PLLARM_LOCKP"
base ad:0x801570a8
rgroup 0--3
line.long 0 "PRCM_PLLARM_LOCKP"
bitfld.long 0 0. " PRCM_PLLARM_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLARM_LOCKP3 "  "0 ,1 "
;tree.end

;tree "PRCM_PLLDDR_LOCKP"
base ad:0x801570ac
rgroup 0--3
line.long 0 "PRCM_PLLDDR_LOCKP"
bitfld.long 0 0. " PRCM_PLLDDR_LOCKP "  "0 ,1 "
;tree.end

;tree "PRCM_XP70CLK_MGT"
base ad:0x801570b0
group 0--3
line.long 0 "PRCM_XP70CLK_MGT"
bitfld.long 0 1. " PMBCLK_DIV4_SEL "  "0 ,1 "
bitfld.long 0 3. " P4PRCM_CLK_L2_SW "  "0 ,1 "
bitfld.long 0 4. " CLK38M2CLKGEN_SW "  "0 ,1 "
bitfld.long 0 5.--7. " CLK38M_DDRPLL_SW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--14. " FREERUNNINGOSC_DIV "  " "
bitfld.long 0 15.--16. " SPARE_P4SUBCLK_EN "  "0 ,1 ,2 ,3 "
bitfld.long 0 17.--19. " P4SUBCLK_EN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 22. " EVT_FORCESFREERUNNING_CLK "  "0 ,1 "
bitfld.long 0 23.--25. " CLK38M_SOC1PLL_SW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 26. " CLK38MDSI_SW "  "0 ,1 "
bitfld.long 0 27. " PCLK_DBG_EN "  "0 ,1 "
bitfld.long 0 28. " CLK38M2CLKGEN_EN "  "0 ,1 "
bitfld.long 0 29. " CLK38M2DSI_EN "  "0 ,1 "
bitfld.long 0 30. " PMB_THSENS_CLK_EN "  "0 ,1 "
bitfld.long 0 31. " VOLT_SENS_CLK_EN "  "0 ,1 "
;tree.end

;tree "PRCM_TIMER_0_REF"
base ad:0x801570b4
group 0--3
line.long 0 "PRCM_TIMER_0_REF"
hexfld.long 0 " PRCM_TIMER_0_REF "
;tree.end

;tree "PRCM_TIMER_0_DOWNCOUNT"
base ad:0x801570b8
group 0--3
line.long 0 "PRCM_TIMER_0_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_0_DOWNCOUNT "
;tree.end

;tree "PRCM_TIMER_0_MODE"
base ad:0x801570bc
group 0--3
line.long 0 "PRCM_TIMER_0_MODE"
bitfld.long 0 0. " PRCM_TIMER_0_MODE "  "0 ,1 "
;tree.end

;tree "PRCM_TIMER_1_REF"
base ad:0x801570c0
group 0--3
line.long 0 "PRCM_TIMER_1_REF"
hexfld.long 0 " PRCM_TIMER_1_REF "
;tree.end

;tree "PRCM_TIMER_1_DOWNCOUNT"
base ad:0x801570c4
group 0--3
line.long 0 "PRCM_TIMER_1_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_1_DOWNCOUNT "
;tree.end

;tree "PRCM_TIMER_1_MODE"
base ad:0x801570c8
group 0--3
line.long 0 "PRCM_TIMER_1_MODE"
bitfld.long 0 0. " PRCM_TIMER_1_MODE "  "0 ,1 "
;tree.end

;tree "PRCM_TIMER_2_REF"
base ad:0x801570cc
group 0--3
line.long 0 "PRCM_TIMER_2_REF"
hexfld.long 0 " PRCM_TIMER_2_REF "
;tree.end

;tree "PRCM_TIMER_2_DOWNCOUNT"
base ad:0x801570d0
group 0--3
line.long 0 "PRCM_TIMER_2_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_2_DOWNCOUNT "
;tree.end

;tree "PRCM_TIMER_2_MODE"
base ad:0x801570d4
group 0--3
line.long 0 "PRCM_TIMER_2_MODE"
bitfld.long 0 0. " PRCM_TIMER_2_MODE "  "0 ,1 "
;tree.end

;tree "PRCM_CLK009_MGT"
base ad:0x801570e4
group 0--3
line.long 0 "PRCM_CLK009_MGT"
bitfld.long 0 0.--2. " CLK009DIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3. " CLK009CLK38SRC "  "0 ,1 "
;tree.end

;tree "PRCM_MODECLK"
base ad:0x801570e8
group 0--3
line.long 0 "PRCM_MODECLK"
bitfld.long 0 0.--2. " PRCM_MODECLK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PRCM_ARM_IT_SET"
base ad:0x801570f0
group 0--3
line.long 0 "PRCM_ARM_IT_SET"
bitfld.long 0 0. " PRCM_ARM_IT_SET "  "0 ,1 "
;tree.end

;tree "PRCM_ARM_IT_CLR"
base ad:0x801570f4
group 0--3
line.long 0 "PRCM_ARM_IT_CLR"
bitfld.long 0 0. " PRCM_ARM_IT_CLR "  "0 ,1 "
;tree.end

;tree "PRCM_4500_CLK_REQ"
base ad:0x801570f8
group 0--3
line.long 0 "PRCM_4500_CLK_REQ"
bitfld.long 0 0. " PRCM_4500_CLK_REQ "  "0 ,1 "
bitfld.long 0 16. " PRCM_MODSYSCLKREQ_EN "  "0 ,1 "
;tree.end

;tree "PRCM_MBOX_CPU_VAL"
base ad:0x801570fc
rgroup 0--3
line.long 0 "PRCM_MBOX_CPU_VAL"
bitfld.long 0 0. " XP70_IT_EVENT_10 "  "0 ,1 "
bitfld.long 0 1. " XP70_IT_EVENT_11 "  "0 ,1 "
bitfld.long 0 2. " XP70_IT_EVENT_12 "  "0 ,1 "
bitfld.long 0 3. " XP70_IT_EVENT_13 "  "0 ,1 "
bitfld.long 0 4. " XP70_IT_EVENT_16 "  "0 ,1 "
bitfld.long 0 5. " XP70_IT_EVENT_17 "  "0 ,1 "
bitfld.long 0 6. " XP70_IT_EVENT_18 "  "0 ,1 "
bitfld.long 0 7. " XP70_IT_EVENT_19 "  "0 ,1 "
;tree.end

;tree "PRCM_MBOX_CPU_SET"
base ad:0x80157100
wgroup 0--3
line.long 0 "PRCM_MBOX_CPU_SET"
bitfld.long 0 0. " XP70_IT_EVENT_10 "  "0 ,1 "
bitfld.long 0 1. " XP70_IT_EVENT_11 "  "0 ,1 "
bitfld.long 0 2. " XP70_IT_EVENT_12 "  "0 ,1 "
bitfld.long 0 3. " XP70_IT_EVENT_13 "  "0 ,1 "
bitfld.long 0 4. " XP70_IT_EVENT_16 "  "0 ,1 "
bitfld.long 0 5. " XP70_IT_EVENT_17 "  "0 ,1 "
bitfld.long 0 6. " XP70_IT_EVENT_18 "  "0 ,1 "
bitfld.long 0 7. " XP70_IT_EVENT_19 "  "0 ,1 "
;tree.end

;tree "PRCM_MBOX_CPU_CLR"
base ad:0x80157104
wgroup 0--3
line.long 0 "PRCM_MBOX_CPU_CLR"
bitfld.long 0 0. " XP70_IT_EVENT_10 "  "0 ,1 "
bitfld.long 0 1. " XP70_IT_EVENT_11 "  "0 ,1 "
bitfld.long 0 2. " XP70_IT_EVENT_12 "  "0 ,1 "
bitfld.long 0 3. " XP70_IT_EVENT_13 "  "0 ,1 "
bitfld.long 0 4. " XP70_IT_EVENT_16 "  "0 ,1 "
bitfld.long 0 5. " XP70_IT_EVENT_17 "  "0 ,1 "
bitfld.long 0 6. " XP70_IT_EVENT_18 "  "0 ,1 "
bitfld.long 0 7. " XP70_IT_EVENT_19 "  "0 ,1 "
;tree.end

;tree "PRCM_C2CCLK_MGT"
base ad:0x80157108
group 0--3
line.long 0 "PRCM_C2CCLK_MGT"
bitfld.long 0 0.--4. " C2CCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " C2CCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " C2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " C2CCLK38 "  "0 ,1 "
bitfld.long 0 10. " C2CCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " C2CCLK38DIV "  "0 ,1 "
bitfld.long 0 12. " C2C_PLLDDR_CLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " C2C_PLLDDR_PLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 24.--26. " C2CCLKSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 28. " C2C_PLLSOC1_CLKEN "  "0 ,1 "
;tree.end

;tree "PRCM_PLL32K_ENABLE"
base ad:0x8015710c
group 0--3
line.long 0 "PRCM_PLL32K_ENABLE"
bitfld.long 0 0. " PRCM_PLL32K_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLL32K_BIDIR_OEN "  "0 ,1 "
bitfld.long 0 2. " PRCM_PLL32K_GATE_EN "  "0 ,1 "
;tree.end

;tree "PRCM_PLL32K_LOCKP"
base ad:0x80157110
rgroup 0--3
line.long 0 "PRCM_PLL32K_LOCKP"
bitfld.long 0 0. " PRCM_PLL32K_LOCKP "  "0 ,1 "
;tree.end

;tree "PRCM_ARM_CHGCLKREQ"
base ad:0x80157114
group 0--3
line.long 0 "PRCM_ARM_CHGCLKREQ"
bitfld.long 0 0.--1. " PRCM_ARM_CHGCLKREQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 16. " PRCM_ARM_DIVSEL "  "0 ,1 "
;tree.end

;tree "PRCM_ARM_PLLDIVPS"
base ad:0x80157118
group 0--3
line.long 0 "PRCM_ARM_PLLDIVPS"
bitfld.long 0 0.--5. " ARM_BRM_RATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8.--9. " ARM_BRM_IDLEDIV "  "0 ,1 ,2 ,3 "
bitfld.long 0 12. " ARM_BRM_IDLEEN "  "0 ,1 "
bitfld.long 0 16.--17. " ARM_PLL_OBSDIV "  "0 ,1 ,2 ,3 "
bitfld.long 0 20. " ARM_PLL_OBSEN "  "0 ,1 "
;tree.end

;tree "PRCM_ARMITMSK31TO0"
base ad:0x8015711c
group 0--3
line.long 0 "PRCM_ARMITMSK31TO0"
hexfld.long 0 " PRCM_ARMITMSK31TO0 "
;tree.end

;tree "PRCM_ARMITMSK63TO32"
base ad:0x80157120
group 0--3
line.long 0 "PRCM_ARMITMSK63TO32"
hexfld.long 0 " PRCM_ARMITMSK63TO32 "
;tree.end

;tree "PRCM_ARMITMSK95TO64"
base ad:0x80157124
group 0--3
line.long 0 "PRCM_ARMITMSK95TO64"
hexfld.long 0 " PRCM_ARMITMSK95TO64 "
;tree.end

;tree "PRCM_ARMITMSK127TO96"
base ad:0x80157128
group 0--3
line.long 0 "PRCM_ARMITMSK127TO96"
hexfld.long 0 " PRCM_ARMITMSK127TO96 "
;tree.end

;tree "PRCM_ARMSTANDBY_STATUS"
base ad:0x80157130
rgroup 0--3
line.long 0 "PRCM_ARMSTANDBY_STATUS"
bitfld.long 0 0. " PL320_IDLE "  "0 ,1 "
bitfld.long 0 1. " STANDBYWFE_0 "  "0 ,1 "
bitfld.long 0 2. " STANDBYWFE_1 "  "0 ,1 "
bitfld.long 0 3. " STANDBYWFI_0 "  "0 ,1 "
bitfld.long 0 4. " STANDBYWFI_1 "  "0 ,1 "
bitfld.long 0 5. " STANDBYWFI_WFE "  "0 ,1 "
bitfld.long 0 6. " EVENT_O "  "0 ,1 "
;tree.end

;tree "PRCM_CGATING_BYPASS"
base ad:0x80157134
group 0--3
line.long 0 "PRCM_CGATING_BYPASS"
bitfld.long 0 0. " PRCMCKGEN_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 1. " APECKGEN_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 2. " DSS_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 3. " DMA_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 4. " ICN0_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 5. " ICN1_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 6. " ICN2_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 7. " ICN3_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 8. " SPARE0_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 9. " SPARE1_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 10. " SPARE2_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 11. " SPARE3_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 12. " SPARE4_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 13. " SPARE5_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 14. " SPARE6_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 15. " SPARE7_CGATING_BYPASS "  "0 ,1 "
;tree.end

;tree "PRCM_GPIOCR"
base ad:0x80157138
group 0--3
line.long 0 "PRCM_GPIOCR"
bitfld.long 0 0. " DBG_UARTMOD_CMD0 "  "0 ,1 "
bitfld.long 0 1. " DBG_UARTMOD_CMD1 "  "0 ,1 "
bitfld.long 0 2. " DBG_ETM_R4_CMD0 "  "0 ,1 "
bitfld.long 0 4. " DBG_NEXUS_CMD "  "0 ,1 "
bitfld.long 0 5. " DBG_PTM_A9_CMD0 "  "0 ,1 "
bitfld.long 0 6. " DBG_PTM_A9_CMD1 "  "0 ,1 "
bitfld.long 0 7. " DBG_SBAG_CMD0 "  "0 ,1 "
bitfld.long 0 8. " DBG_SBAG_CMD1 "  "0 ,1 "
bitfld.long 0 9. " DBG_STM_APE_CMD "  "0 ,1 "
bitfld.long 0 10. " DBG_STM_MOD_CMD0 "  "0 ,1 "
bitfld.long 0 11. " DBG_STM_MOD_CMD1 "  "0 ,1 "
bitfld.long 0 12. " DBG_KBD_CMD "  "0 ,1 "
bitfld.long 0 13. " DBG_STM_MOD_CMD2 "  "0 ,1 "
bitfld.long 0 14. " DBG_PTM_A9_CMD2 "  "0 ,1 "
bitfld.long 0 15. " DBG_ETM_R4_CMD1 "  "0 ,1 "
bitfld.long 0 16. " DBG_UARTMOD_CMD2 "  "0 ,1 "
bitfld.long 0 17. " TRIGGER_SELECT "  "0 ,1 "
bitfld.long 0 18. " REMAP_SELECT_ON "  "0 ,1 "
bitfld.long 0 19. " DBG_ETM_R4_CMD2 "  "0 ,1 "
bitfld.long 0 20. " DBG_PTM_A9_CMD3 "  "0 ,1 "
bitfld.long 0 21. " DBG_PTM_A9_CMD4 "  "0 ,1 "
bitfld.long 0 22. " DBG_PTM_A9_CMD5 "  "0 ,1 "
bitfld.long 0 23. " SPI2_SELECT "  "0 ,1 "
bitfld.long 0 24. " DBG_HW_OBS_CMD1 "  "0 ,1 "
bitfld.long 0 25. " DBG_HW_OBS_CMD2 "  "0 ,1 "
bitfld.long 0 27. " MSPBYP01AEN "  "0 ,1 "
bitfld.long 0 28. " MSPBYP01CK10 "  "0 ,1 "
bitfld.long 0 29. " MSPBYP01CK01 "  "0 ,1 "
bitfld.long 0 30. " MSPBYP01FS10 "  "0 ,1 "
bitfld.long 0 31. " MSPBYP01FS01 "  "0 ,1 "
;tree.end

;tree "PRCM_LEMI"
base ad:0x8015713c
group 0--3
line.long 0 "PRCM_LEMI"
bitfld.long 0 0. " APECLK "  "0 ,1 "
bitfld.long 0 1. " APEINT "  "0 ,1 "
bitfld.long 0 2. " I2CAPE "  "0 ,1 "
bitfld.long 0 3. " I2CMOD "  "0 ,1 "
bitfld.long 0 4. " GPS "  "0 ,1 "
bitfld.long 0 5. " UICC "  "0 ,1 "
bitfld.long 0 6. " LINKO "  "0 ,1 "
bitfld.long 0 7. " MOD4500 "  "0 ,1 "
bitfld.long 0 8. " RST4500 "  "0 ,1 "
bitfld.long 0 9. " RTCK "  "0 ,1 "
bitfld.long 0 10. " CLKREQ "  "0 ,1 "
bitfld.long 0 11. " JTAG "  "0 ,1 "
;tree.end

;tree "PRCM_COMPCR"
base ad:0x80157140
group 0--3
line.long 0 "PRCM_COMPCR"
bitfld.long 0 0. " C1V2COMPTYP "  "0 ,1 "
bitfld.long 0 1. " C1V2COMPFRZ "  "0 ,1 "
bitfld.long 0 2. " C1V2COMPN "  "0 ,1 "
bitfld.long 0 3. " C1V8COMPTQ "  "0 ,1 "
bitfld.long 0 4. " C1V8COMPFRZ "  "0 ,1 "
bitfld.long 0 5. " C1V8COMPN "  "0 ,1 "
bitfld.long 0 6. " C1V8COMPACCURATE "  "0 ,1 "
bitfld.long 0 7. " C1V8COMPFASTFRZ "  "0 ,1 "
bitfld.long 0 16.--22. " C1V8NASRCR "  " "
bitfld.long 0 23.--29. " C1V8PASRCR "  " "
;tree.end

;tree "PRCM_COMPSTA"
base ad:0x80157144
rgroup 0--3
line.long 0 "PRCM_COMPSTA"
bitfld.long 0 0. " C1V2COMPOK "  "0 ,1 "
bitfld.long 0 2.--8. " C1V2NASRC "  " "
bitfld.long 0 9.--15. " C1V2PASRC "  " "
bitfld.long 0 16. " C1V8COMPOK "  "0 ,1 "
bitfld.long 0 18.--24. " C1V8NASRC "  " "
bitfld.long 0 25.--31. " C1V8PASRC "  " "
;tree.end

;tree "PRCM_ITSTATUS0"
base ad:0x80157148
rgroup 0--3
line.long 0 "PRCM_ITSTATUS0"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " HSI_CAWAKE0 "  "0 ,1 "
bitfld.long 0 4. " HSI_CAWAKE1 "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " ape4500it "  "0 ,1 "
;tree.end

;tree "PRCM_ITCLR0"
base ad:0x8015714c
wgroup 0--3
line.long 0 "PRCM_ITCLR0"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " HSI_CAWAKE0 "  "0 ,1 "
bitfld.long 0 4. " HSI_CAWAKE1 "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " ape4500it "  "0 ,1 "
;tree.end

;tree "PRCM_ITSTATUS1"
base ad:0x80157150
rgroup 0--3
line.long 0 "PRCM_ITSTATUS1"
bitfld.long 0 0. " FIFO4500IT "  "0 ,1 "
;tree.end

;tree "PRCM_ITCLR1"
base ad:0x80157154
wgroup 0--3
line.long 0 "PRCM_ITCLR1"
bitfld.long 0 0. " FIFO4500IT "  "0 ,1 "
;tree.end

;tree "PRCM_ITSTATUS2"
base ad:0x80157158
rgroup 0--3
line.long 0 "PRCM_ITSTATUS2"
bitfld.long 0 0. " c2c_ddr_req "  "0 ,1 "
bitfld.long 0 1. " c2c_ddr_latency "  "0 ,1 "
bitfld.long 0 2. " reservedreserved "  "0 ,1 "
bitfld.long 0 3. " c2c_mem_ack "  "0 ,1 "
;tree.end

;tree "PRCM_ITCLR2"
base ad:0x8015715c
wgroup 0--3
line.long 0 "PRCM_ITCLR2"
bitfld.long 0 0. " c2c_ddr_req "  "0 ,1 "
bitfld.long 0 1. " c2c_ddr_latency "  "0 ,1 "
bitfld.long 0 3. " c2c_mem_ack "  "0 ,1 "
;tree.end

;tree "PRCM_ITSTATUS3"
base ad:0x80157160
rgroup 0--3
line.long 0 "PRCM_ITSTATUS3"
bitfld.long 0 0. " c2c_wuapp "  "0 ,1 "
bitfld.long 0 1. " c2c_pwrctrl0 "  "0 ,1 "
;tree.end

;tree "PRCM_ITCLR3"
base ad:0x80157164
wgroup 0--3
line.long 0 "PRCM_ITCLR3"
bitfld.long 0 0. " c2c_wuapp "  "0 ,1 "
bitfld.long 0 1. " c2c_pwrctrl0 "  "0 ,1 "
;tree.end

;tree "PRCM_ITSTATUS4"
base ad:0x80157168
rgroup 0--3
line.long 0 "PRCM_ITSTATUS4"
bitfld.long 0 0. " ape_softrst "  "0 ,1 "
bitfld.long 0 1. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 2. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 3. " c2c_reset_req "  "0 ,1 "
bitfld.long 0 4. " HSEM_INT_SVA_MMDSP "  "0 ,1 "
bitfld.long 0 5. " HSEM_INT_SIA_MMDSP "  "0 ,1 "
;tree.end

;tree "PRCM_ITCLR4"
base ad:0x8015716c
wgroup 0--3
line.long 0 "PRCM_ITCLR4"
bitfld.long 0 0. " ape_softrst "  "0 ,1 "
bitfld.long 0 1. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 2. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 3. " c2c_reset_req "  "0 ,1 "
bitfld.long 0 4. " HSEM_INT_SVA_MMDSP "  "0 ,1 "
bitfld.long 0 5. " HSEM_INT_SIA_MMDSP "  "0 ,1 "
;tree.end

;tree "PRCM_LINE_VALUE"
base ad:0x80157170
rgroup 0--3
line.long 0 "PRCM_LINE_VALUE"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " HSI_CAWAKE0 "  "0 ,1 "
bitfld.long 0 4. " HSI_CAWAKE1 "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " ape4500it "  "0 ,1 "
bitfld.long 0 8. " FIFO4500IT "  "0 ,1 "
bitfld.long 0 9. " c2c_ddr_req "  "0 ,1 "
bitfld.long 0 10. " c2c_ddr_latency "  "0 ,1 "
bitfld.long 0 12. " c2c_mem_ack "  "0 ,1 "
bitfld.long 0 13. " c2c_wuapp "  "0 ,1 "
bitfld.long 0 14. " c2c_pwrctrl0 "  "0 ,1 "
bitfld.long 0 17. " ape_softrst "  "0 ,1 "
bitfld.long 0 18. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 19. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 20. " c2c_reset_req "  "0 ,1 "
bitfld.long 0 21. " HSEM_INT_SVA_MMDSP "  "0 ,1 "
bitfld.long 0 22. " HSEM_INT_SIA_MMDSP "  "0 ,1 "
bitfld.long 0 23.--31. " GPIOWKUP "  " "
;tree.end

;tree "PRCM_HOLD_EVT"
base ad:0x80157174
group 0--3
line.long 0 "PRCM_HOLD_EVT"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " HSI_CAWAKE0 "  "0 ,1 "
bitfld.long 0 4. " HSI_CAWAKE1 "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " ape4500it "  "0 ,1 "
bitfld.long 0 8. " FIFO4500IT "  "0 ,1 "
bitfld.long 0 9. " c2c_ddr_req "  "0 ,1 "
bitfld.long 0 10. " c2c_ddr_latency "  "0 ,1 "
bitfld.long 0 12. " c2c_mem_ack "  "0 ,1 "
bitfld.long 0 13. " c2c_wuapp "  "0 ,1 "
bitfld.long 0 14. " c2c_pwrctrl0 "  "0 ,1 "
bitfld.long 0 17. " ape_softrst "  "0 ,1 "
bitfld.long 0 18. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 19. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 20. " c2c_reset_req "  "0 ,1 "
bitfld.long 0 21. " HSEM_INT_SVA_MMDSP "  "0 ,1 "
bitfld.long 0 22. " HSEM_INT_SIA_MMDSP "  "0 ,1 "
bitfld.long 0 23.--31. " GPIOWKUP "  " "
;tree.end

;tree "PRCM_EDGE_SENS_L"
base ad:0x80157178
group 0--3
line.long 0 "PRCM_EDGE_SENS_L"
bitfld.long 0 0.--1. " RTCWKUP "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " RTT0WKUP "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " RTT1WKUP "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " HSI_CAWAKE0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " HSI_CAWAKE1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " USB_WKUP "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " ape4500it "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " FIFO4500IT "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " c2c_ddr_req "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " c2c_ddr_latency "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " c2c_mem_ack "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " c2c_wuapp "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " c2c_pwrctrl0 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_EDGE_SENS_H"
base ad:0x8015717c
group 0--3
line.long 0 "PRCM_EDGE_SENS_H"
bitfld.long 0 2.--3. " ape_softrst "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " A9_WDRSTREQ_INT_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " A9_WDRSTREQ_INT_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " c2c_reset_req "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " HSEM_INT_SVA_MMDSP "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " HSEM_INT_SIA_MMDSP "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " GPIOWKUP_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " GPIOWKUP_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " GPIOWKUP_2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " GPIOWKUP_3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " GPIOWKUP_4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " GPIOWKUP_5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " GPIOWKUP_6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " GPIOWKUP_7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " GPIOWKUP_8 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_ARMITMSK159TO128"
base ad:0x80157184
group 0--3
line.long 0 "PRCM_ARMITMSK159TO128"
hexfld.long 0 " PRCM_ARMITMSK159TO128 "
;tree.end

;tree "PRCM_ARMITMSK191TO160"
base ad:0x80157188
group 0--3
line.long 0 "PRCM_ARMITMSK191TO160"
hexfld.long 0 " PRCM_ARMITMSK191TO160 "
;tree.end

;tree "PRCM_ARMITMSK223TO192"
base ad:0x8015718c
group 0--3
line.long 0 "PRCM_ARMITMSK223TO192"
hexfld.long 0 " PRCM_ARMITMSK223TO192 "
;tree.end

;tree "PRCM_DEBUG_CTRL_VAL"
base ad:0x80157190
rgroup 0--3
line.long 0 "PRCM_DEBUG_CTRL_VAL"
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
;tree.end

;tree "PRCM_DEBUG_NOPWRDOWN_VAL"
base ad:0x80157194
rgroup 0--3
line.long 0 "PRCM_DEBUG_NOPWRDOWN_VAL"
bitfld.long 0 0. " ARM_DEBUG_NOPOWER_DOWN_REQ "  "0 ,1 "
bitfld.long 0 1. " SVA_DEBUG_NOPOWER_DOWN_REQ "  "0 ,1 "
bitfld.long 0 2. " SIA_DEBUG_NOPOWER_DOWN_REQ "  "0 ,1 "
bitfld.long 0 3. " A9_DEBUG_POWER_DOWN_0 "  "0 ,1 "
bitfld.long 0 4. " A9_DEBUG_POWER_DOWN_1 "  "0 ,1 "
;tree.end

;tree "PRCM_DEBUG_CTRL_ACK"
base ad:0x80157198
group 0--3
line.long 0 "PRCM_DEBUG_CTRL_ACK"
bitfld.long 0 0. " SIA_PWRUP_ACK "  "0 ,1 "
bitfld.long 0 1. " SVA_PWRUP_ACK "  "0 ,1 "
bitfld.long 0 2. " MOD_PWRUPREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_CSYSPWRUPACK "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_CDBGRSTACK "  "0 ,1 "
bitfld.long 0 8. " CSYSPWRUP_SWT "  "0 ,1 "
;tree.end

;tree "PRCM_A9PL_FORCE_CLKEN"
base ad:0x8015719c
group 0--3
line.long 0 "PRCM_A9PL_FORCE_CLKEN"
bitfld.long 0 0. " PRCM_A9PL_FORCE_CLKEN "  "0 ,1 "
bitfld.long 0 1. " PRCM_A9AXI_FORCE_CLKEN "  "0 ,1 "
;tree.end

;tree "PRCM_TPIU_FLUSHIN_REQ"
base ad:0x801571a0
group 0--3
line.long 0 "PRCM_TPIU_FLUSHIN_REQ"
bitfld.long 0 0. " PRCM_TPIU_FLUSHIN_REQ "  "0 ,1 "
;tree.end

;tree "PRCM_TPIU_FLUSHIN_ACK"
base ad:0x801571a4
rgroup 0--3
line.long 0 "PRCM_TPIU_FLUSHIN_ACK"
bitfld.long 0 0. " PRCM_TPIU_FLUSHIN_ACK "  "0 ,1 "
;tree.end

;tree "PRCM_STP_FLUSHIN_REQ"
base ad:0x801571a8
group 0--3
line.long 0 "PRCM_STP_FLUSHIN_REQ"
bitfld.long 0 0. " PRCM_STP_FLUSHIN_REQ "  "0 ,1 "
;tree.end

;tree "PRCM_STP_FLUSHIN_ACK"
base ad:0x801571ac
rgroup 0--3
line.long 0 "PRCM_STP_FLUSHIN_ACK"
bitfld.long 0 0. " PRCM_STP_FLUSHIN_ACK "  "0 ,1 "
;tree.end

;tree "PRCM_HWI2C_DIV"
base ad:0x801571b0
group 0--3
line.long 0 "PRCM_HWI2C_DIV"
bitfld.long 0 0.--1. " PRCM_HWI2C_DIV "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_HWI2C_GO"
base ad:0x801571b4
group 0--3
line.long 0 "PRCM_HWI2C_GO"
bitfld.long 0 0. " PRCM_HWI2C_GO "  "0 ,1 "
;tree.end

;tree "PRCM_HWI2C_CMD"
base ad:0x801571b8
group 0--3
line.long 0 "PRCM_HWI2C_CMD"
bitfld.long 0 0. " RWB "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--9. " TSIZE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " HWGCEN "  "0 ,1 "
bitfld.long 0 11. " STOPEN "  "0 ,1 "
hexfld.byte 2 " REG_ADD "
hexfld.byte 3 " REG_DATA "
;tree.end

;tree "PRCM_HWI2C_DATA123"
base ad:0x801571bc
group 0--3
line.long 0 "PRCM_HWI2C_DATA123"
hexfld.byte 0 " DATA1 "
hexfld.byte 1 " DATA2 "
hexfld.byte 2 " DATA3 "
;tree.end

;tree "PRCM_HWI2C_SR"
base ad:0x801571c0
rgroup 0--3
line.long 0 "PRCM_HWI2C_SR"
bitfld.long 0 0.--1. " STATUS "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " CAUSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PRCM_REMAPCR"
base ad:0x801571c4
group 0--3
line.long 0 "PRCM_REMAPCR"
bitfld.long 0 0. " REMAPCLR "  "0 ,1 "
bitfld.long 0 1. " REMAPSTAT "  "0 ,1 "
;tree.end

;tree "PRCM_TCR"
base ad:0x801571c8
group 0--3
line.long 0 "PRCM_TCR"
bitfld.long 0 0. " TENSEL0 "  "0 ,1 "
bitfld.long 0 1. " TENSEL1 "  "0 ,1 "
bitfld.long 0 2. " TENSEL2 "  "0 ,1 "
bitfld.long 0 3. " TENSEL3 "  "0 ,1 "
bitfld.long 0 4. " TENSEL4 "  "0 ,1 "
bitfld.long 0 5. " TENSEL5 "  "0 ,1 "
bitfld.long 0 6. " TENSEL6 "  "0 ,1 "
bitfld.long 0 7. " TENSEL7 "  "0 ,1 "
bitfld.long 0 16. " STOP_TIMERS "  "0 ,1 "
bitfld.long 0 17. " DOZE_MODE "  "0 ,1 "
;tree.end

;tree "PRCM_CLKOCR"
base ad:0x801571cc
group 0--3
line.long 0 "PRCM_CLKOCR"
bitfld.long 0 0.--5. " CLKODIV0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--8. " CLKOSEL0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--21. " CLKODIV1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--24. " CLKOSEL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 28. " CLK1TYPE "  "0 ,1 "
;tree.end

;tree "PRCM_ITSTATUS_DBG"
base ad:0x801571d0
rgroup 0--3
line.long 0 "PRCM_ITSTATUS_DBG"
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
;tree.end

;tree "PRCM_ITCLR_DBG"
base ad:0x801571d4
wgroup 0--3
line.long 0 "PRCM_ITCLR_DBG"
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
;tree.end

;tree "PRCM_LINE_VALUE_DBG"
base ad:0x801571d8
rgroup 0--3
line.long 0 "PRCM_LINE_VALUE_DBG"
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
;tree.end

;tree "PRCM_DBG_HOLD"
base ad:0x801571dc
group 0--3
line.long 0 "PRCM_DBG_HOLD"
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
;tree.end

;tree "PRCM_EDGE_SENS_DBG"
base ad:0x801571e0
group 0--3
line.long 0 "PRCM_EDGE_SENS_DBG"
bitfld.long 0 2.--3. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " DAP_APE_CDBGRSTREQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_APE_RESETN_SET"
base ad:0x801571e4
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "
bitfld.long 0 1. " SGA_M_INITN "  "0 ,1 "
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " DSS_M_INITN "  "0 ,1 "
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 11. " SIA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 14. " DSIPLLTV_RESETN "  "0 ,1 "
bitfld.long 0 15. " DSIPLLLCD_RESETN "  "0 ,1 "
bitfld.long 0 16. " DDR1_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 17. " DDR_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 18. " DDR_MOD_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 19. " DDR_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 20. " DDR_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 21. " DDR1_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 22. " SIA_PIPE_M_RAD_RESETN "  "0 ,1 "
bitfld.long 0 23. " DDR1_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 24. " ESRAM1_INITN "  "0 ,1 "
bitfld.long 0 25. " ESRAM2_INITN "  "0 ,1 "
bitfld.long 0 26. " ESRAM3_INITN "  "0 ,1 "
bitfld.long 0 27. " ESRAM4_INITN "  "0 ,1 "
bitfld.long 0 28. " ESRAM5_INITN "  "0 ,1 "
bitfld.long 0 29. " APE_MEM_INITN "  "0 ,1 "
bitfld.long 0 30. " APE_PWRON_RESETN "  "0 ,1 "
bitfld.long 0 31. " APE_RESETN "  "0 ,1 "
;tree.end

;tree "PRCM_APE_RESETN_CLR"
base ad:0x801571e8
group 0--3
line.long 0 "PRCM_APE_RESETN_CLR"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "
bitfld.long 0 1. " SGA_M_INITN "  "0 ,1 "
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " DSS_M_INITN "  "0 ,1 "
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 11. " SIA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 14. " DSIPLLTV_RESETN "  "0 ,1 "
bitfld.long 0 15. " DSIPLLLCD_RESETN "  "0 ,1 "
bitfld.long 0 16. " DDR1_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 17. " DDR_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 18. " DDR_MOD_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 19. " DDR_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 20. " DDR_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 21. " DDR1_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 22. " SIA_PIPE_M_RAD_RESETN "  "0 ,1 "
bitfld.long 0 23. " DDR1_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 24. " ESRAM1_INITN "  "0 ,1 "
bitfld.long 0 25. " ESRAM2_INITN "  "0 ,1 "
bitfld.long 0 26. " ESRAM3_INITN "  "0 ,1 "
bitfld.long 0 27. " ESRAM4_INITN "  "0 ,1 "
bitfld.long 0 28. " ESRAM5_INITN "  "0 ,1 "
bitfld.long 0 29. " APE_MEM_INITN "  "0 ,1 "
bitfld.long 0 30. " APE_PWRON_RESETN "  "0 ,1 "
bitfld.long 0 31. " APE_RESETN "  "0 ,1 "
;tree.end

;tree "PRCM_APE_RESETN_VAL"
base ad:0x801571ec
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "
bitfld.long 0 1. " SGA_M_INITN "  "0 ,1 "
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " DSS_M_INITN "  "0 ,1 "
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 11. " SIA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 14. " DSIPLLTV_RESETN "  "0 ,1 "
bitfld.long 0 15. " DSIPLLLCD_RESETN "  "0 ,1 "
bitfld.long 0 16. " DDR1_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 17. " DDR_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 18. " DDR_MOD_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 19. " DDR_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 20. " DDR_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 21. " DDR1_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 22. " SIA_PIPE_M_RAD_RESETN "  "0 ,1 "
bitfld.long 0 23. " DDR1_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 24. " ESRAM1_INITN "  "0 ,1 "
bitfld.long 0 25. " ESRAM2_INITN "  "0 ,1 "
bitfld.long 0 26. " ESRAM3_INITN "  "0 ,1 "
bitfld.long 0 27. " ESRAM4_INITN "  "0 ,1 "
bitfld.long 0 28. " ESRAM5_INITN "  "0 ,1 "
bitfld.long 0 29. " APE_MEM_INITN "  "0 ,1 "
bitfld.long 0 30. " APE_PWRON_RESETN "  "0 ,1 "
bitfld.long 0 31. " APE_RESETN "  "0 ,1 "
;tree.end

;tree "PRCM_A9_RESETN_SET"
base ad:0x801571f0
group 0--3
line.long 0 "PRCM_A9_RESETN_SET"
bitfld.long 0 0. " A9_NPORESET "  "0 ,1 "
bitfld.long 0 1. " A9_NRESET_SLICE_FCT "  "0 ,1 "
bitfld.long 0 2. " APE_NRESET "  "0 ,1 "
bitfld.long 0 3. " A9_NRESET_DBG "  "0 ,1 "
bitfld.long 0 4. " A9_NRESET_0 "  "0 ,1 "
bitfld.long 0 5. " A9_NRESET_1 "  "0 ,1 "
bitfld.long 0 6. " A9_WD_REQ_RESETN "  "0 ,1 "
bitfld.long 0 7. " A9_NRESET_SWPLL_FF "  "0 ,1 "
bitfld.long 0 8. " A9_NRESET_SLICE_DBG "  "0 ,1 "
bitfld.long 0 9. " A9_OPP_NRESET "  "0 ,1 "
;tree.end

;tree "PRCM_A9_RESETN_CLR"
base ad:0x801571f4
group 0--3
line.long 0 "PRCM_A9_RESETN_CLR"
bitfld.long 0 0. " A9_NPORESET "  "0 ,1 "
bitfld.long 0 1. " A9_NRESET_SLICE_FCT "  "0 ,1 "
bitfld.long 0 2. " APE_NRESET "  "0 ,1 "
bitfld.long 0 3. " A9_NRESET_DBG "  "0 ,1 "
bitfld.long 0 4. " A9_NRESET_0 "  "0 ,1 "
bitfld.long 0 5. " A9_NRESET_1 "  "0 ,1 "
bitfld.long 0 6. " A9_WD_REQ_RESETN "  "0 ,1 "
bitfld.long 0 7. " A9_NRESET_SWPLL_FF "  "0 ,1 "
bitfld.long 0 8. " A9_NRESET_SLICE_DBG "  "0 ,1 "
bitfld.long 0 9. " A9_OPP_NRESET "  "0 ,1 "
;tree.end

;tree "PRCM_A9_RESETN_VAL"
base ad:0x801571f8
rgroup 0--3
line.long 0 "PRCM_A9_RESETN_VAL"
bitfld.long 0 0. " A9_NPORESET "  "0 ,1 "
bitfld.long 0 1. " A9_NRESET_SLICE_FCT "  "0 ,1 "
bitfld.long 0 2. " APE_NRESET "  "0 ,1 "
bitfld.long 0 3. " A9_NRESET_DBG "  "0 ,1 "
bitfld.long 0 4. " A9_NRESET_0 "  "0 ,1 "
bitfld.long 0 5. " A9_NRESET_1 "  "0 ,1 "
bitfld.long 0 6. " A9_WD_REQ_RESETN "  "0 ,1 "
bitfld.long 0 7. " A9_NRESET_SWPLL_FF "  "0 ,1 "
bitfld.long 0 8. " A9_NRESET_SLICE_DBG "  "0 ,1 "
bitfld.long 0 9. " A9_OPP_NRESET "  "0 ,1 "
;tree.end

;tree "PRCM_MOD_RESETN_SET"
base ad:0x801571fc
group 0--3
line.long 0 "PRCM_MOD_RESETN_SET"
bitfld.long 0 0. " NPURESET "  "0 ,1 "
bitfld.long 0 1. " NSWRESET "  "0 ,1 "
;tree.end

;tree "PRCM_MOD_RESETN_CLR"
base ad:0x80157200
group 0--3
line.long 0 "PRCM_MOD_RESETN_CLR"
bitfld.long 0 0. " NPURESET "  "0 ,1 "
bitfld.long 0 1. " NSWRESET "  "0 ,1 "
;tree.end

;tree "PRCM_MOD_RESETN_VAL"
base ad:0x80157204
rgroup 0--3
line.long 0 "PRCM_MOD_RESETN_VAL"
bitfld.long 0 0. " NPURESET "  "0 ,1 "
bitfld.long 0 1. " NSWRESET "  "0 ,1 "
;tree.end

;tree "PRCM_GPIO_RESETN_SET"
base ad:0x80157208
group 0--3
line.long 0 "PRCM_GPIO_RESETN_SET"
bitfld.long 0 0. " GPIO_RESETN_GRP0 "  "0 ,1 "
bitfld.long 0 1. " GPIO_RESETN_GRP0_MX "  "0 ,1 "
bitfld.long 0 2. " GPIO_RESETN_GRP1 "  "0 ,1 "
bitfld.long 0 3. " GPIO_RESETN_GRP1_MX "  "0 ,1 "
bitfld.long 0 4. " GPIO_RESETN_GRP2 "  "0 ,1 "
bitfld.long 0 5. " GPIO_RESETN_GRP2_MX "  "0 ,1 "
bitfld.long 0 6. " GPIO_RESETN_GRP3 "  "0 ,1 "
bitfld.long 0 7. " GPIO_RESETN_GRP3_MX "  "0 ,1 "
bitfld.long 0 8. " GPIO_RESETN_GRP4 "  "0 ,1 "
bitfld.long 0 9. " GPIO_RESETN_GRP4_MX "  "0 ,1 "
bitfld.long 0 10. " GPIO_RESETN_GRP5 "  "0 ,1 "
bitfld.long 0 11. " GPIO_RESETN_GRP5_MX "  "0 ,1 "
bitfld.long 0 12. " GPIO_RESETN_GRP6 "  "0 ,1 "
bitfld.long 0 13. " GPIO_RESETN_GRP6_MX "  "0 ,1 "
bitfld.long 0 14. " GPIO_RESETN_GRP7 "  "0 ,1 "
bitfld.long 0 15. " GPIO_RESETN_GRP7_MX "  "0 ,1 "
bitfld.long 0 16. " GPIO_RESETN_GRP8 "  "0 ,1 "
bitfld.long 0 17. " GPIO_RESETN_GRP8_MX "  "0 ,1 "
;tree.end

;tree "PRCM_GPIO_RESETN_CLR"
base ad:0x8015720c
group 0--3
line.long 0 "PRCM_GPIO_RESETN_CLR"
bitfld.long 0 0. " GPIO_RESETN_GRP0 "  "0 ,1 "
bitfld.long 0 1. " GPIO_RESETN_GRP0_MX "  "0 ,1 "
bitfld.long 0 2. " GPIO_RESETN_GRP1 "  "0 ,1 "
bitfld.long 0 3. " GPIO_RESETN_GRP1_MX "  "0 ,1 "
bitfld.long 0 4. " GPIO_RESETN_GRP2 "  "0 ,1 "
bitfld.long 0 5. " GPIO_RESETN_GRP2_MX "  "0 ,1 "
bitfld.long 0 6. " GPIO_RESETN_GRP3 "  "0 ,1 "
bitfld.long 0 7. " GPIO_RESETN_GRP3_MX "  "0 ,1 "
bitfld.long 0 8. " GPIO_RESETN_GRP4 "  "0 ,1 "
bitfld.long 0 9. " GPIO_RESETN_GRP4_MX "  "0 ,1 "
bitfld.long 0 10. " GPIO_RESETN_GRP5 "  "0 ,1 "
bitfld.long 0 11. " GPIO_RESETN_GRP5_MX "  "0 ,1 "
bitfld.long 0 12. " GPIO_RESETN_GRP6 "  "0 ,1 "
bitfld.long 0 13. " GPIO_RESETN_GRP6_MX "  "0 ,1 "
bitfld.long 0 14. " GPIO_RESETN_GRP7 "  "0 ,1 "
bitfld.long 0 15. " GPIO_RESETN_GRP7_MX "  "0 ,1 "
bitfld.long 0 16. " GPIO_RESETN_GRP8 "  "0 ,1 "
bitfld.long 0 17. " GPIO_RESETN_GRP8_MX "  "0 ,1 "
;tree.end

;tree "PRCM_GPIO_RESETN_VAL"
base ad:0x80157210
rgroup 0--3
line.long 0 "PRCM_GPIO_RESETN_VAL"
bitfld.long 0 0. " GPIO_RESETN_GRP0 "  "0 ,1 "
bitfld.long 0 1. " GPIO_RESETN_GRP0_MX "  "0 ,1 "
bitfld.long 0 2. " GPIO_RESETN_GRP1 "  "0 ,1 "
bitfld.long 0 3. " GPIO_RESETN_GRP1_MX "  "0 ,1 "
bitfld.long 0 4. " GPIO_RESETN_GRP2 "  "0 ,1 "
bitfld.long 0 5. " GPIO_RESETN_GRP2_MX "  "0 ,1 "
bitfld.long 0 6. " GPIO_RESETN_GRP3 "  "0 ,1 "
bitfld.long 0 7. " GPIO_RESETN_GRP3_MX "  "0 ,1 "
bitfld.long 0 8. " GPIO_RESETN_GRP4 "  "0 ,1 "
bitfld.long 0 9. " GPIO_RESETN_GRP4_MX "  "0 ,1 "
bitfld.long 0 10. " GPIO_RESETN_GRP5 "  "0 ,1 "
bitfld.long 0 11. " GPIO_RESETN_GRP5_MX "  "0 ,1 "
bitfld.long 0 12. " GPIO_RESETN_GRP6 "  "0 ,1 "
bitfld.long 0 13. " GPIO_RESETN_GRP6_MX "  "0 ,1 "
bitfld.long 0 14. " GPIO_RESETN_GRP7 "  "0 ,1 "
bitfld.long 0 15. " GPIO_RESETN_GRP7_MX "  "0 ,1 "
bitfld.long 0 16. " GPIO_RESETN_GRP8 "  "0 ,1 "
bitfld.long 0 17. " GPIO_RESETN_GRP8_MX "  "0 ,1 "
;tree.end

;tree "PRCM_4500_RESETN_SET"
base ad:0x80157214
group 0--3
line.long 0 "PRCM_4500_RESETN_SET"
bitfld.long 0 0. " STN4500_RESETN "  "0 ,1 "
;tree.end

;tree "PRCM_4500_RESETN_CLR"
base ad:0x80157218
group 0--3
line.long 0 "PRCM_4500_RESETN_CLR"
bitfld.long 0 0. " STN4500_RESETN "  "0 ,1 "
;tree.end

;tree "PRCM_4500_RESETN_VAL"
base ad:0x8015721c
rgroup 0--3
line.long 0 "PRCM_4500_RESETN_VAL"
bitfld.long 0 0. " STN4500_RESETN "  "0 ,1 "
;tree.end

;tree "PRCM_HSI_SOFTRST"
base ad:0x80157224
wgroup 0--3
line.long 0 "PRCM_HSI_SOFTRST"
bitfld.long 0 0. " HSITX_SOFTRST "  "0 ,1 "
bitfld.long 0 1. " HSIRX_SOFTRST "  "0 ,1 "
;tree.end

;tree "PRCM_APE_SOFTRST"
base ad:0x80157228
wgroup 0--3
line.long 0 "PRCM_APE_SOFTRST"
bitfld.long 0 0. " PRCM_APE_SOFTRST "  "0 ,1 "
;tree.end

;tree "PRCM_SWD_RST_TEMPO"
base ad:0x80157238
group 0--3
line.long 0 "PRCM_SWD_RST_TEMPO"
bitfld.long 0 0.--9. " PRCM_SWD_RST_TEMPO "  " "
;tree.end

;tree "PRCM_RST_4500_TEMPO"
base ad:0x8015723c
group 0--3
line.long 0 "PRCM_RST_4500_TEMPO"
bitfld.long 0 0.--9. " PRCM_RST_4500_TEMPO "  " "
;tree.end

;tree "PRCM_SVAMMDSP_IT"
base ad:0x80157240
group 0--3
line.long 0 "PRCM_SVAMMDSP_IT"
hexfld.byte 0 " PRCM_SVAMMDSP_IT "
;tree.end

;tree "PRCM_SVAMMDSP_IT_CLR"
base ad:0x80157244
group 0--3
line.long 0 "PRCM_SVAMMDSP_IT_CLR"
bitfld.long 0 0. " PRCM_SVAMMDSP_IT_CLR "  "0 ,1 "
;tree.end

;tree "PRCM_SIAMMDSP_IT"
base ad:0x80157248
group 0--3
line.long 0 "PRCM_SIAMMDSP_IT"
hexfld.byte 0 " PRCM_SIAMMDSP_IT "
;tree.end

;tree "PRCM_SIAMMDSP_IT_CLR"
base ad:0x8015724c
group 0--3
line.long 0 "PRCM_SIAMMDSP_IT_CLR"
bitfld.long 0 0. " PRCM_SIAMMDSP_IT_CLR "  "0 ,1 "
;tree.end

;tree "PRCM_STM_DATA"
base ad:0x80157250
wgroup 0--3
line.long 0 "PRCM_STM_DATA"
hexfld.byte 0 " PRCM_STM_DATA "
;tree.end

;tree "PRCM_POWER_STATE_SET"
base ad:0x80157254
group 0--3
line.long 0 "PRCM_POWER_STATE_SET"
bitfld.long 0 0.--3. " VAPE_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " DDR_CONTROLLER "  "0 ,1 "
bitfld.long 0 5.--6. " SIA_MMDSP_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SIA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 8.--9. " SVA_MMDSP_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " SVA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 11. " DSS_STATE "  "0 ,1 "
bitfld.long 0 12. " SGA_STATE "  "0 ,1 "
bitfld.long 0 13. " DDR1_CONTROLLER "  "0 ,1 "
bitfld.long 0 15. " CSI_DSI "  "0 ,1 "
bitfld.long 0 16.--17. " ESRAM0_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " ESRAM1_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " ESRAM2_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " ESRAM3_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " ESRAM4_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--30. " VARM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 31. " C2C_STATE "  "0 ,1 "
;tree.end

;tree "PRCM_POWER_STATE_CLR"
base ad:0x80157258
group 0--3
line.long 0 "PRCM_POWER_STATE_CLR"
bitfld.long 0 0.--3. " VAPE_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " DDR_CONTROLLER "  "0 ,1 "
bitfld.long 0 5.--6. " SIA_MMDSP_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SIA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 8.--9. " SVA_MMDSP_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " SVA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 11. " DSS_STATE "  "0 ,1 "
bitfld.long 0 12. " SGA_STATE "  "0 ,1 "
bitfld.long 0 13. " DDR1_CONTROLLER "  "0 ,1 "
bitfld.long 0 15. " CSI_DSI "  "0 ,1 "
bitfld.long 0 16.--17. " ESRAM0_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " ESRAM1_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " ESRAM2_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " ESRAM3_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " ESRAM4_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--30. " VARM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 31. " C2C_STATE "  "0 ,1 "
;tree.end

;tree "PRCM_POWER_STATE_VAL"
base ad:0x8015725c
group 0--3
line.long 0 "PRCM_POWER_STATE_VAL"
bitfld.long 0 0.--3. " VAPE_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " DDR_CONTROLLER "  "0 ,1 "
bitfld.long 0 5.--6. " SIA_MMDSP_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SIA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 8.--9. " SVA_MMDSP_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " SVA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 11. " DSS_STATE "  "0 ,1 "
bitfld.long 0 12. " SGA_STATE "  "0 ,1 "
bitfld.long 0 13. " DDR1_CONTROLLER "  "0 ,1 "
bitfld.long 0 15. " CSI_DSI "  "0 ,1 "
bitfld.long 0 16.--17. " ESRAM0_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " ESRAM1_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " ESRAM2_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " ESRAM3_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " ESRAM4_STATE "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--30. " VARM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 31. " C2C_STATE "  "0 ,1 "
;tree.end

;tree "PRCM_ARMITVALUE31TO0"
base ad:0x80157260
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE31TO0"
hexfld.long 0 " PRCM_ARMITVALUE31TO0 "
;tree.end

;tree "PRCM_ARMITVALUE63TO32"
base ad:0x80157264
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE63TO32"
hexfld.long 0 " PRCM_ARMITVALUE63TO32 "
;tree.end

;tree "PRCM_ARMITVALUE95TO64"
base ad:0x80157268
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE95TO64"
hexfld.long 0 " PRCM_ARMITVALUE95TO64 "
;tree.end

;tree "PRCM_ARMITVALUE127TO96"
base ad:0x8015726c
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE127TO96"
hexfld.long 0 " PRCM_ARMITVALUE127TO96 "
;tree.end

;tree "PRCM_REDUN_LOAD"
base ad:0x80157270
group 0--3
line.long 0 "PRCM_REDUN_LOAD"
bitfld.long 0 0. " PRCM_REDUN_GO_ARM "  "0 ,1 "
bitfld.long 0 1. " PRCM_REDUN_GO_SIA "  "0 ,1 "
;tree.end

;tree "PRCM_REDUN_STATUS"
base ad:0x80157274
rgroup 0--3
line.long 0 "PRCM_REDUN_STATUS"
bitfld.long 0 0. " PRCM_REDUN_OK_ARM "  "0 ,1 "
bitfld.long 0 1. " PRCM_REDUN_OK_SIA "  "0 ,1 "
bitfld.long 0 2. " PRCM_REDUN_OK_ESRAM "  "0 ,1 "
;tree.end

;tree "PRCM_UNIPROCLK_MGT"
base ad:0x80157278
group 0--3
line.long 0 "PRCM_UNIPROCLK_MGT"
bitfld.long 0 0.--11. " SPARE "  " "
;tree.end

;tree "PRCM_UICCCLK_MGT"
base ad:0x8015727c
group 0--3
line.long 0 "PRCM_UICCCLK_MGT"
bitfld.long 0 0.--4. " UICCCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " UICCCLKEN "  "0 ,1 "
bitfld.long 0 9. " UICCCLK38 "  "0 ,1 "
bitfld.long 0 10. " UICCCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " UICCCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_SSPCLK_MGT"
base ad:0x80157280
group 0--3
line.long 0 "PRCM_SSPCLK_MGT"
bitfld.long 0 0.--4. " SSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " SSPCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " SSPCLKEN "  "0 ,1 "
bitfld.long 0 9. " SSPCLK38 "  "0 ,1 "
bitfld.long 0 10. " SSPCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SSPCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_RNGCLK_MGT"
base ad:0x80157284
group 0--3
line.long 0 "PRCM_RNGCLK_MGT"
bitfld.long 0 0.--4. " RNGCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " RNGCLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 9. " RNGCLK38 "  "0 ,1 "
bitfld.long 0 10. " RNGCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " RNGCLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_MSP1CLK_MGT"
base ad:0x80157288
group 0--3
line.long 0 "PRCM_MSP1CLK_MGT"
bitfld.long 0 0.--4. " MSP1CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " MSP1CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " MSP1CLKEN "  "0 ,1 "
bitfld.long 0 9. " MSP1CLK38 "  "0 ,1 "
bitfld.long 0 10. " MSP1CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " MSP1CLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_PLLDSILCD_FREQ"
base ad:0x80157290
group 0--3
line.long 0 "PRCM_PLLDSILCD_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
;tree.end

;tree "PRCM_PLLDSILCD_ENABLE"
base ad:0x80157294
group 0--3
line.long 0 "PRCM_PLLDSILCD_ENABLE"
bitfld.long 0 0. " PRCM_PLLDSILCD_ENABLE "  "0 ,1 "
;tree.end

;tree "PRCM_PLLDSILCD_LOCKP"
base ad:0x80157298
rgroup 0--3
line.long 0 "PRCM_PLLDSILCD_LOCKP"
bitfld.long 0 0. " PRCM_PLLDSILCD_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLDSILCD_LOCKP3 "  "0 ,1 "
;tree.end

;tree "PRCM_DAP_RESETN_SET"
base ad:0x801572a0
group 0--3
line.long 0 "PRCM_DAP_RESETN_SET"
bitfld.long 0 0. " DAP_RESETN "  "0 ,1 "
bitfld.long 0 1. " ncpudbgreset0 "  "0 ,1 "
bitfld.long 0 2. " ncpudbgreset1 "  "0 ,1 "
;tree.end

;tree "PRCM_DAP_RESETN_CLR"
base ad:0x801572a4
group 0--3
line.long 0 "PRCM_DAP_RESETN_CLR"
bitfld.long 0 0. " DAP_RESETN "  "0 ,1 "
bitfld.long 0 1. " ncpudbgreset0 "  "0 ,1 "
bitfld.long 0 2. " ncpudbgreset1 "  "0 ,1 "
;tree.end

;tree "PRCM_DAP_RESETN_VAL"
base ad:0x801572a8
rgroup 0--3
line.long 0 "PRCM_DAP_RESETN_VAL"
bitfld.long 0 0. " DAP_RESETN "  "0 ,1 "
bitfld.long 0 1. " ncpudbgreset0 "  "0 ,1 "
bitfld.long 0 2. " ncpudbgreset1 "  "0 ,1 "
;tree.end

;tree "PRCM_C2C_RESETN_SET"
base ad:0x801572b0
group 0--3
line.long 0 "PRCM_C2C_RESETN_SET"
bitfld.long 0 0. " C2C_WRAPPER_RESETN "  "0 ,1 "
bitfld.long 0 1. " C2C_RESETN "  "0 ,1 "
bitfld.long 0 2. " HVA_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " HVA_M_INITN "  "0 ,1 "
bitfld.long 0 4. " G1_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " G1_M_INITN "  "0 ,1 "
bitfld.long 0 6.--31. " SPARE_RESETN "  " "
;tree.end

;tree "PRCM_C2C_RESETN_CLR"
base ad:0x801572b4
group 0--3
line.long 0 "PRCM_C2C_RESETN_CLR"
bitfld.long 0 0. " C2C_WRAPPER_RESETN "  "0 ,1 "
bitfld.long 0 1. " C2C_RESETN "  "0 ,1 "
bitfld.long 0 2. " HVA_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " HVA_M_INITN "  "0 ,1 "
bitfld.long 0 4. " G1_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " G1_M_INITN "  "0 ,1 "
bitfld.long 0 6.--31. " SPARE_RESETN "  " "
;tree.end

;tree "PRCM_C2C_RESETN_VAL"
base ad:0x801572b8
group 0--3
line.long 0 "PRCM_C2C_RESETN_VAL"
bitfld.long 0 0. " C2C_WRAPPER_RESETN "  "0 ,1 "
bitfld.long 0 1. " C2C_RESETN "  "0 ,1 "
bitfld.long 0 2. " HVA_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " HVA_M_INITN "  "0 ,1 "
bitfld.long 0 4. " G1_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " G1_M_INITN "  "0 ,1 "
bitfld.long 0 6.--31. " SPARE_RESETN "  " "
;tree.end

;tree "PRCM_SRAM_DEDCSTOV"
base ad:0x80157300
group 0--3
line.long 0 "PRCM_SRAM_DEDCSTOV"
bitfld.long 0 0.--5. " DC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " DE "  "0 ,1 "
bitfld.long 0 7. " STOV "  "0 ,1 "
;tree.end

;tree "PRCM_SRAM_LS_SLEEP"
base ad:0x80157304
group 0--3
line.long 0 "PRCM_SRAM_LS_SLEEP"
bitfld.long 0 0. " SGA_SLEEP "  "0 ,1 "
bitfld.long 0 1. " SGA_LS "  "0 ,1 "
bitfld.long 0 2. " SVA_PIPE_SLEEP "  "0 ,1 "
bitfld.long 0 3. " SVA_PIPE_LS "  "0 ,1 "
bitfld.long 0 4. " SVA_MMDSP_SLEEP "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_LS "  "0 ,1 "
bitfld.long 0 6. " SIA_PIPE_SLEEP "  "0 ,1 "
bitfld.long 0 7. " SIA_PIPE_LS "  "0 ,1 "
bitfld.long 0 8. " SIA_MMDSP_SLEEP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_LS "  "0 ,1 "
bitfld.long 0 10. " DSS_SLEEP "  "0 ,1 "
bitfld.long 0 11. " DSS_LS "  "0 ,1 "
bitfld.long 0 14. " APE_SLEEP "  "0 ,1 "
bitfld.long 0 15. " APE_LS "  "0 ,1 "
bitfld.long 0 18. " ESRAM1_SLEEP "  "0 ,1 "
bitfld.long 0 19. " ESRAM1_LS "  "0 ,1 "
bitfld.long 0 20. " ESRAM2_SLEEP "  "0 ,1 "
bitfld.long 0 21. " ESRAM2_LS "  "0 ,1 "
bitfld.long 0 22. " ESRAM3_SLEEP "  "0 ,1 "
bitfld.long 0 23. " ESRAM3_LS "  "0 ,1 "
bitfld.long 0 24. " ESRAM4_SLEEP "  "0 ,1 "
bitfld.long 0 25. " ESRAM4_LS "  "0 ,1 "
bitfld.long 0 26. " ESRAM5_SLEEP "  "0 ,1 "
bitfld.long 0 27. " ESRAM5_LS "  "0 ,1 "
bitfld.long 0 28. " SPARE "  "0 ,1 "
bitfld.long 0 29. " SVAROM_PDN "  "0 ,1 "
;tree.end

;tree "PRCM_SRAM_A9"
base ad:0x80157308
group 0--3
line.long 0 "PRCM_SRAM_A9"
bitfld.long 0 0.--5. " A9_DC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " A9_DE "  "0 ,1 "
bitfld.long 0 7. " A9_STOV "  "0 ,1 "
bitfld.long 0 9. " A9_LS "  "0 ,1 "
bitfld.long 0 10. " A9_0_SRAM_SLEEP "  "0 ,1 "
bitfld.long 0 11. " A9_1_SRAM_SLEEP "  "0 ,1 "
bitfld.long 0 12. " SCU_L2_SRAM_SLEEP "  "0 ,1 "
bitfld.long 0 16.--18. " A9_RM_L1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19.--20. " A9_WM_L1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 21.--23. " A9_RM_L2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--25. " A9_WM_L2 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_ARM_LS_CLAMP"
base ad:0x8015730c
group 0--3
line.long 0 "PRCM_ARM_LS_CLAMP"
bitfld.long 0 0. " INCLAMP_I "  "0 ,1 "
bitfld.long 0 1. " OUTCLAMP_I "  "0 ,1 "
bitfld.long 0 2. " PLL_INLATCH_I "  "0 ,1 "
bitfld.long 0 3. " TST_CLK_INLATCH_I "  "0 ,1 "
bitfld.long 0 4. " TST_FCT_INLATCH_I "  "0 ,1 "
bitfld.long 0 5. " TST_OUTCLAMP_I "  "0 ,1 "
bitfld.long 0 6. " CPU0_INCLAMP "  "0 ,1 "
bitfld.long 0 7. " CPU1_INCLAMP "  "0 ,1 "
bitfld.long 0 8.--9. " CPUCLAMP "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--15. " CPU_SPARE_CLAMP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "PRCM_IOCR"
base ad:0x80157310
group 0--3
line.long 0 "PRCM_IOCR"
bitfld.long 0 0. " IOFORCE "  "0 ,1 "
;tree.end

;tree "PRCM_MODEM_SYSCLKOK"
base ad:0x80157314
group 0--3
line.long 0 "PRCM_MODEM_SYSCLKOK"
bitfld.long 0 0.--1. " PRCM_MODEM_SYSCLKOK "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_SYSCLKOK_DELAY"
base ad:0x80157318
group 0--3
line.long 0 "PRCM_SYSCLKOK_DELAY"
hexfld.byte 0 " PRCM_SYSCLKOK_DELAY "
;tree.end

;tree "PRCM_SYSCLKSTATUS"
base ad:0x8015731c
rgroup 0--3
line.long 0 "PRCM_SYSCLKSTATUS"
bitfld.long 0 0. " SYSCLKIND_SYNC "  "0 ,1 "
bitfld.long 0 1. " SYSCLKLOCKED "  "0 ,1 "
;tree.end

;tree "PRCM_DSI_SW_RESET"
base ad:0x80157324
group 0--3
line.long 0 "PRCM_DSI_SW_RESET"
bitfld.long 0 0. " DSI0_SW_RESETN "  "0 ,1 "
bitfld.long 0 1. " DSI1_SW_RESETN "  "0 ,1 "
bitfld.long 0 2. " DSI2_SW_RESETN "  "0 ,1 "
;tree.end

;tree "PRCM_A9_MASK_REQ"
base ad:0x80157328
group 0--3
line.long 0 "PRCM_A9_MASK_REQ"
bitfld.long 0 0. " PRCM_A9_MASK_REQ "  "0 ,1 "
;tree.end

;tree "PRCM_A9_MASK_ACK"
base ad:0x8015732c
rgroup 0--3
line.long 0 "PRCM_A9_MASK_ACK"
bitfld.long 0 0. " PRCM_A9_MASK_ACK "  "0 ,1 "
;tree.end

;tree "PRCM_HOSTACCESS_REQ"
base ad:0x80157334
group 0--3
line.long 0 "PRCM_HOSTACCESS_REQ"
bitfld.long 0 0. " HOSTACCESS_REQ "  "0 ,1 "
bitfld.long 0 1.--2. " HOSTACCESS_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 16. " WAKE_REQ "  "0 ,1 "
;tree.end

;tree "PRCM_TIMER_3_REF"
base ad:0x80157338
group 0--3
line.long 0 "PRCM_TIMER_3_REF"
hexfld.long 0 " PRCM_TIMER_3_REF "
;tree.end

;tree "PRCM_TIMER_3_DOWNCOUNT"
base ad:0x8015733c
group 0--3
line.long 0 "PRCM_TIMER_3_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_3_DOWNCOUNT "
;tree.end

;tree "PRCM_TIMER_3_MODE"
base ad:0x80157340
group 0--3
line.long 0 "PRCM_TIMER_3_MODE"
bitfld.long 0 0. " PRCM_TIMER_3_MODE "  "0 ,1 "
;tree.end

;tree "PRCM_PMB_SENS_CTRL"
base ad:0x80157344
group 0--3
line.long 0 "PRCM_PMB_SENS_CTRL"
bitfld.long 0 0.--5. " SEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--7. " DIV_SPEED "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " DIV_LEAK "  "0 ,1 ,2 ,3 "
bitfld.long 0 10. " SENS_RUN "  "0 ,1 "
bitfld.long 0 11.--13. " SMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 14. " ALL_SENS "  "0 ,1 "
bitfld.long 0 15. " PD_SENS "  "0 ,1 "
;tree.end

;tree "PRCM_PMB_REF_COUNTER"
base ad:0x80157348
group 0--3
line.long 0 "PRCM_PMB_REF_COUNTER"
hexfld.word 0 " REF_COUNTER_LSB "
hexfld.word 2 " REF_COUNTER_MSB "
;tree.end

;tree "PRCM_PMB_SENSOR_STATUS"
base ad:0x8015734c
group 0--3
line.long 0 "PRCM_PMB_SENSOR_STATUS"
hexfld.word 0 " SENSOR_STATUS_LSB "
hexfld.word 2 " SENSOR_STATUS_MSB "
;tree.end

;tree "PRCM_SEM"
base ad:0x80157400
group 0--3
line.long 0 "PRCM_SEM"
bitfld.long 0 0. " PRCM_SEM "  "0 ,1 "
;tree.end

;tree "PRCM_APE_EPOD_CFG"
base ad:0x80157404
group 0--3
line.long 0 "PRCM_APE_EPOD_CFG"
bitfld.long 0 0.--1. " VDDI_WAKEUP_CUR_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " VDDI_WAKEUP_CUR_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--6. " VDDI_BIAS_VOLT_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--9. " VDDI_BIAS_VOLT_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--11. " VDDI_BIAS_CUR_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " BIAS_BOOST_VDDI_ESRAM "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " VDDI_BIAS_CUR_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16. " BIAS_BOOST_VDDI_MMDSP "  "0 ,1 "
;tree.end

;tree "PRCM_DDR_EPOD_CFG"
base ad:0x80157408
group 0--3
line.long 0 "PRCM_DDR_EPOD_CFG"
bitfld.long 0 0.--1. " GNDI_WAKEUP_CUR "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " VDDI_WAKEUP_CUR "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " GNDI_BIAS_VOLT "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--8. " VDDI_BIAS_VOLT_CTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9.--11. " VDDI_BIAS_VOLT_PHY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--13. " BIAS_CUR_CTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 14. " BIAS_BOOST_GNDI_CTRL "  "0 ,1 "
bitfld.long 0 15.--17. " BIAS_BOOST_VDDI_CTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PRCM_EPOD_C_SET"
base ad:0x80157410
group 0--3
line.long 0 "PRCM_EPOD_C_SET"
bitfld.long 0 0. " ESRAM1_2_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM1_2_RET "  "0 ,1 "
bitfld.long 0 2. " ESRAM3_4_5_ON "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_4_5_RET "  "0 ,1 "
bitfld.long 0 8. " SGA_L_ON "  "0 ,1 "
bitfld.long 0 9. " SGA_M_ON "  "0 ,1 "
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 11. " SVA_M_ON "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_ON "  "0 ,1 "
bitfld.long 0 13. " SVA_MM_M_ON "  "0 ,1 "
bitfld.long 0 14. " SVA_MM_M_RET "  "0 ,1 "
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 16. " SIA_M_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "
bitfld.long 0 18. " SIA_MM_M_ON "  "0 ,1 "
bitfld.long 0 19. " SIA_MM_M_RET "  "0 ,1 "
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "
bitfld.long 0 21. " DSS_M_ON "  "0 ,1 "
bitfld.long 0 22. " APERAMS_ON "  "0 ,1 "
bitfld.long 0 23. " C2C_ON "  "0 ,1 "
;tree.end

;tree "PRCM_EPOD_C_CLR"
base ad:0x80157414
group 0--3
line.long 0 "PRCM_EPOD_C_CLR"
bitfld.long 0 0. " ESRAM1_2_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM1_2_RET "  "0 ,1 "
bitfld.long 0 2. " ESRAM3_4_5_ON "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_4_5_RET "  "0 ,1 "
bitfld.long 0 8. " SGA_L_ON "  "0 ,1 "
bitfld.long 0 9. " SGA_M_ON "  "0 ,1 "
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 11. " SVA_M_ON "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_ON "  "0 ,1 "
bitfld.long 0 13. " SVA_MM_M_ON "  "0 ,1 "
bitfld.long 0 14. " SVA_MM_M_RET "  "0 ,1 "
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 16. " SIA_M_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "
bitfld.long 0 18. " SIA_MM_M_ON "  "0 ,1 "
bitfld.long 0 19. " SIA_MM_M_RET "  "0 ,1 "
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "
bitfld.long 0 21. " DSS_M_ON "  "0 ,1 "
bitfld.long 0 22. " APERAMS_ON "  "0 ,1 "
bitfld.long 0 23. " C2C_ON "  "0 ,1 "
;tree.end

;tree "PRCM_EPOD_C_VAL"
base ad:0x80157418
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 0. " ESRAM1_2_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM1_2_RET "  "0 ,1 "
bitfld.long 0 2. " ESRAM3_4_5_ON "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_4_5_RET "  "0 ,1 "
bitfld.long 0 8. " SGA_L_ON "  "0 ,1 "
bitfld.long 0 9. " SGA_M_ON "  "0 ,1 "
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 11. " SVA_M_ON "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_ON "  "0 ,1 "
bitfld.long 0 13. " SVA_MM_M_ON "  "0 ,1 "
bitfld.long 0 14. " SVA_MM_M_RET "  "0 ,1 "
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 16. " SIA_M_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "
bitfld.long 0 18. " SIA_MM_M_ON "  "0 ,1 "
bitfld.long 0 19. " SIA_MM_M_RET "  "0 ,1 "
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "
bitfld.long 0 21. " DSS_M_ON "  "0 ,1 "
bitfld.long 0 22. " APERAMS_ON "  "0 ,1 "
bitfld.long 0 23. " C2C_ON "  "0 ,1 "
;tree.end

;tree "PRCM_EPOD_VOK"
base ad:0x8015741c
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 0. " ESRAM1_2_VOK "  "0 ,1 "
bitfld.long 0 1. " ESRAM3_4_5_VOK "  "0 ,1 "
bitfld.long 0 8. " SGA_L_VOK "  "0 ,1 "
bitfld.long 0 9. " SGA_M_VOK "  "0 ,1 "
bitfld.long 0 10. " SVA_L_VOK "  "0 ,1 "
bitfld.long 0 11. " SVA_M_VOK "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_VOK "  "0 ,1 "
bitfld.long 0 13. " SVA_MM_M_VOK "  "0 ,1 "
bitfld.long 0 14. " SVA_MM_MRET_VOK "  "0 ,1 "
bitfld.long 0 15. " SIA_L_VOK "  "0 ,1 "
bitfld.long 0 16. " SIA_M_VOK "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_VOK "  "0 ,1 "
bitfld.long 0 18. " SIA_MM_M_VOK "  "0 ,1 "
bitfld.long 0 19. " SIA_MM_MRET_VOK "  "0 ,1 "
bitfld.long 0 20. " DSS_L_VOK "  "0 ,1 "
bitfld.long 0 21. " DSS_M_VOK "  "0 ,1 "
bitfld.long 0 22. " APERAMS_M_VOK "  "0 ,1 "
bitfld.long 0 23. " C2C_L_VOK "  "0 ,1 "
;tree.end

;tree "PRCM_MMIP_LS_CLAMP_SET"
base ad:0x80157420
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_SET"
bitfld.long 0 0. " SIA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 1. " SVA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 2. " ESRAM2_CLAMP "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_CLAMP "  "0 ,1 "
bitfld.long 0 4. " ESRAM4_CLAMP "  "0 ,1 "
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "
bitfld.long 0 11. " DSIPLL_CLAMP "  "0 ,1 "
bitfld.long 0 12. " ESRAM5_CLAMP "  "0 ,1 "
bitfld.long 0 16. " SGA_CLAMPI "  "0 ,1 "
bitfld.long 0 17. " SVA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 18. " SVA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 19. " SIA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 20. " SIA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 21. " DSS_CLAMPI "  "0 ,1 "
bitfld.long 0 22. " DSIPLL_CLAMPI "  "0 ,1 "
;tree.end

;tree "PRCM_MMIP_LS_CLAMP_CLR"
base ad:0x80157424
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 0. " SIA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 1. " SVA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 2. " ESRAM2_CLAMP "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_CLAMP "  "0 ,1 "
bitfld.long 0 4. " ESRAM4_CLAMP "  "0 ,1 "
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "
bitfld.long 0 11. " DSIPLL_CLAMP "  "0 ,1 "
bitfld.long 0 12. " ESRAM5_CLAMP "  "0 ,1 "
bitfld.long 0 16. " SGA_CLAMPI "  "0 ,1 "
bitfld.long 0 17. " SVA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 18. " SVA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 19. " SIA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 20. " SIA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 21. " DSS_CLAMPI "  "0 ,1 "
bitfld.long 0 22. " DSIPLL_CLAMPI "  "0 ,1 "
;tree.end

;tree "PRCM_MMIP_LS_CLAMP_VAL"
base ad:0x80157428
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 0. " SIA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 1. " SVA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 2. " ESRAM2_CLAMP "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_CLAMP "  "0 ,1 "
bitfld.long 0 4. " ESRAM4_CLAMP "  "0 ,1 "
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "
bitfld.long 0 11. " DSIPLL_CLAMP "  "0 ,1 "
bitfld.long 0 12. " ESRAM5_CLAMP "  "0 ,1 "
bitfld.long 0 16. " SGA_CLAMPI "  "0 ,1 "
bitfld.long 0 17. " SVA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 18. " SVA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 19. " SIA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 20. " SIA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 21. " DSS_CLAMPI "  "0 ,1 "
bitfld.long 0 22. " DSIPLL_CLAMPI "  "0 ,1 "
;tree.end

;tree "PRCM_VSAFE_LS_CLAMP_SET"
base ad:0x8015742c
group 0--3
line.long 0 "PRCM_VSAFE_LS_CLAMP_SET"
bitfld.long 0 0. " VAPE_VSAFE_FIFOCLAMP "  "0 ,1 "
bitfld.long 0 1. " VAPE_VSAFE_HOLD_0 "  "0 ,1 "
bitfld.long 0 2. " VAPE_VSAFE_CLAMP_0 "  "0 ,1 "
bitfld.long 0 3. " VAPE_VSAFE_HOLD_1 "  "0 ,1 "
bitfld.long 0 4. " VAPE_VSAFE_CLAMP_1 "  "0 ,1 "
bitfld.long 0 5. " VAPE_VSAFE_HOLD_2 "  "0 ,1 "
bitfld.long 0 6. " VAPE_VSAFE_CSI_CLAMP "  "0 ,1 "
bitfld.long 0 7. " VAPE_VSAFE_HOLD_3 "  "0 ,1 "
bitfld.long 0 8. " VAPE_VSAFE_CLAMP_3 "  "0 ,1 "
bitfld.long 0 16. " PMB_CLAMP_VARM "  "0 ,1 "
bitfld.long 0 17. " PMB_CLAMP_VAPE "  "0 ,1 "
bitfld.long 0 18. " PMB_CLAMP_VMODEM "  "0 ,1 "
bitfld.long 0 24. " C2C_CLAMP "  "0 ,1 "
;tree.end

;tree "PRCM_VSAFE_LS_CLAMP_CLR"
base ad:0x80157430
group 0--3
line.long 0 "PRCM_VSAFE_LS_CLAMP_CLR"
bitfld.long 0 0. " VAPE_VSAFE_FIFOCLAMP "  "0 ,1 "
bitfld.long 0 1. " VAPE_VSAFE_HOLD_0 "  "0 ,1 "
bitfld.long 0 2. " VAPE_VSAFE_CLAMP_0 "  "0 ,1 "
bitfld.long 0 3. " VAPE_VSAFE_HOLD_1 "  "0 ,1 "
bitfld.long 0 4. " VAPE_VSAFE_CLAMP_1 "  "0 ,1 "
bitfld.long 0 5. " VAPE_VSAFE_HOLD_2 "  "0 ,1 "
bitfld.long 0 6. " VAPE_VSAFE_CSI_CLAMP "  "0 ,1 "
bitfld.long 0 7. " VAPE_VSAFE_HOLD_3 "  "0 ,1 "
bitfld.long 0 8. " VAPE_VSAFE_CLAMP_3 "  "0 ,1 "
bitfld.long 0 16. " PMB_CLAMP_VARM "  "0 ,1 "
bitfld.long 0 17. " PMB_CLAMP_VAPE "  "0 ,1 "
bitfld.long 0 18. " PMB_CLAMP_VMODEM "  "0 ,1 "
bitfld.long 0 24. " C2C_CLAMP "  "0 ,1 "
;tree.end

;tree "PRCM_VSAFE_LS_CLAMP_VAL"
base ad:0x80157434
group 0--3
line.long 0 "PRCM_VSAFE_LS_CLAMP_VAL"
bitfld.long 0 0. " VAPE_VSAFE_FIFOCLAMP "  "0 ,1 "
bitfld.long 0 1. " VAPE_VSAFE_HOLD_0 "  "0 ,1 "
bitfld.long 0 2. " VAPE_VSAFE_CLAMP_0 "  "0 ,1 "
bitfld.long 0 3. " VAPE_VSAFE_HOLD_1 "  "0 ,1 "
bitfld.long 0 4. " VAPE_VSAFE_CLAMP_1 "  "0 ,1 "
bitfld.long 0 5. " VAPE_VSAFE_HOLD_2 "  "0 ,1 "
bitfld.long 0 6. " VAPE_VSAFE_CSI_CLAMP "  "0 ,1 "
bitfld.long 0 7. " VAPE_VSAFE_HOLD_3 "  "0 ,1 "
bitfld.long 0 8. " VAPE_VSAFE_CLAMP_3 "  "0 ,1 "
bitfld.long 0 16. " PMB_CLAMP_VARM "  "0 ,1 "
bitfld.long 0 17. " PMB_CLAMP_VAPE "  "0 ,1 "
bitfld.long 0 18. " PMB_CLAMP_VMODEM "  "0 ,1 "
bitfld.long 0 24. " C2C_CLAMP "  "0 ,1 "
;tree.end

;tree "PRCM_DDRSUBSYS_APE_MINBW"
base ad:0x80157438
group 0--3
line.long 0 "PRCM_DDRSUBSYS_APE_MINBW"
bitfld.long 0 0.--1. " APE_MIN_BW "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_DDRSUBSYS_STATUS"
base ad:0x8015743c
rgroup 0--3
line.long 0 "PRCM_DDRSUBSYS_STATUS"
bitfld.long 0 0.--4. " MAIN_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " EFFECTIVE_MIN_BW "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " CORE_VDDIOK "  "0 ,1 "
bitfld.long 0 8. " CORE_GNDIOK "  "0 ,1 "
bitfld.long 0 9. " PHY_VDDIOK "  "0 ,1 "
bitfld.long 0 10.--13. " CORE_DOMAIN_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14.--16. " PHY_DOMAIN_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17.--19. " PLL_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--31. " SPARE "  " "
;tree.end

;tree "PRCM_DDRSUBSYS_CONTROL"
base ad:0x80157440
group 0--3
line.long 0 "PRCM_DDRSUBSYS_CONTROL"
bitfld.long 0 0. " CORE_BIAS_DISABLE "  "0 ,1 "
bitfld.long 0 1. " CORE_OFF_DISABLE "  "0 ,1 "
bitfld.long 0 2. " PHY_OFF_DISABLE "  "0 ,1 "
bitfld.long 0 3. " MODEM_ON_CLK_REDUCE_ENABLE "  "0 ,1 "
bitfld.long 0 4. " SPARE_1 "  "0 ,1 "
bitfld.long 0 5. " FREQDIV_BY4_DISABLE "  "0 ,1 "
bitfld.long 0 6. " CORE_ISOLATION_RESYNCH_DISABLE "  "0 ,1 "
bitfld.long 0 7. " FORCE_CORE_ISOLATION "  "0 ,1 "
bitfld.long 0 8. " FORCE_PHY_IO_ISOLATION "  "0 ,1 "
bitfld.long 0 9. " VREF_IO_SET_WITH_EXTERNAL_VREF "  "0 ,1 "
bitfld.long 0 10. " MIN_BW_REMAP "  "0 ,1 "
bitfld.long 0 11. " MODEM_MEM_REQ_STRECH_DISABLE "  "0 ,1 "
bitfld.long 0 12. " C2C_MEM_REQ_STRECH_DISABLE "  "0 ,1 "
bitfld.long 0 13. " C2C_ENABLE "  "0 ,1 "
bitfld.long 0 14.--23. " SPARE_2 "  " "
;tree.end

;tree "PRCM_DDRSUBSYS_HIGH_LEAK_COND"
base ad:0x80157444
group 0--3
line.long 0 "PRCM_DDRSUBSYS_HIGH_LEAK_COND"
bitfld.long 0 0. " HIGH_LEAK "  "0 ,1 "
;tree.end

;tree "PRCM_DDRSUBSYS_CONFIG"
base ad:0x80157448
rgroup 0--3
line.long 0 "PRCM_DDRSUBSYS_CONFIG"
bitfld.long 0 0.--1. " DDRCONFIG_REQ "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_DDRSUBSYS_CONFIG_ACK"
base ad:0x8015744c
group 0--3
line.long 0 "PRCM_DDRSUBSYS_CONFIG_ACK"
bitfld.long 0 0.--1. " DDRCONFIG_ACK "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_TIMER_4_REF"
base ad:0x80157450
group 0--3
line.long 0 "PRCM_TIMER_4_REF"
hexfld.long 0 " PRCM_TIMER_4_REF "
;tree.end

;tree "PRCM_TIMER_4_DOWNCOUNT"
base ad:0x80157454
group 0--3
line.long 0 "PRCM_TIMER_4_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_4_DOWNCOUNT "
;tree.end

;tree "PRCM_TIMER_4_MODE"
base ad:0x80157458
group 0--3
line.long 0 "PRCM_TIMER_4_MODE"
bitfld.long 0 0. " PRCM_TIMER_4_MODE "  "0 ,1 "
;tree.end

;tree "PRCM_TIMER_5_REF"
base ad:0x8015745c
group 0--3
line.long 0 "PRCM_TIMER_5_REF"
hexfld.long 0 " PRCM_TIMER_5_REF "
;tree.end

;tree "PRCM_TIMER_5_DOWNCOUNT"
base ad:0x80157460
group 0--3
line.long 0 "PRCM_TIMER_5_DOWNCOUNT"
hexfld.long 0 " PRCM_TIMER_5_DOWNCOUNT "
;tree.end

;tree "PRCM_TIMER_5_MODE"
base ad:0x80157464
group 0--3
line.long 0 "PRCM_TIMER_5_MODE"
bitfld.long 0 0. " PRCM_TIMER_5_MODE "  "0 ,1 "
;tree.end

;tree "PRCM_SEM_A9_IT_CLR"
base ad:0x8015746c
group 0--3
line.long 0 "PRCM_SEM_A9_IT_CLR"
bitfld.long 0 0. " PRCM_SEM_A9_IT_CLR "  "0 ,1 "
;tree.end

;tree "PRCM_APE_MEM_REQ"
base ad:0x80157470
group 0--3
line.long 0 "PRCM_APE_MEM_REQ"
bitfld.long 0 0. " APE_MEM_REQ "  "0 ,1 "
;tree.end

;tree "PRCM_DBG_FORCES_APE_MEM_REQ"
base ad:0x80157474
group 0--3
line.long 0 "PRCM_DBG_FORCES_APE_MEM_REQ"
bitfld.long 0 0. " DBG_FORCES_APE_MEM_REQ "  "0 ,1 "
;tree.end

;tree "PRCM_APE_MEM_WFX_EN"
base ad:0x80157478
group 0--3
line.long 0 "PRCM_APE_MEM_WFX_EN"
bitfld.long 0 0. " PL310_IDLE_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WFI_0_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WFI_1_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WFE_0_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WFE_1_ENABLE "  "0 ,1 "
;tree.end

;tree "PRCM_APE_MEM_LATENCY"
base ad:0x8015747c
group 0--3
line.long 0 "PRCM_APE_MEM_LATENCY"
bitfld.long 0 0. " APE_MEM_LATENCY "  "0 ,1 "
;tree.end

;tree "PRCM_APE_MEM_ACK"
base ad:0x80157480
rgroup 0--3
line.long 0 "PRCM_APE_MEM_ACK"
bitfld.long 0 0. " APE_MEM_ACK "  "0 ,1 "
;tree.end

;tree "PRCM_ITSTATUS5"
base ad:0x80157484
rgroup 0--3
line.long 0 "PRCM_ITSTATUS5"
bitfld.long 0 0.--8. " GPIOWKUP "  " "
;tree.end

;tree "PRCM_ITCLR5"
base ad:0x80157488
wgroup 0--3
line.long 0 "PRCM_ITCLR5"
bitfld.long 0 0.--8. " GPIOWKUP "  " "
;tree.end

;tree "PRCM_ARM_IT1_CLR"
base ad:0x8015748c
group 0--3
line.long 0 "PRCM_ARM_IT1_CLR"
hexfld.byte 0 " PRCM_ARM_IT1_CLR "
;tree.end

;tree "PRCM_ARM_IT1_SET"
base ad:0x80157490
group 0--3
line.long 0 "PRCM_ARM_IT1_SET"
hexfld.byte 0 " PRCM_ARM_IT1_SET "
;tree.end

;tree "PRCM_ARM_IT1_VAL"
base ad:0x80157494
group 0--3
line.long 0 "PRCM_ARM_IT1_VAL"
hexfld.byte 0 " PRCM_ARM_IT1_VAL "
;tree.end

;tree "PRCM_MOD_PWR_OK"
base ad:0x80157498
group 0--3
line.long 0 "PRCM_MOD_PWR_OK"
bitfld.long 0 0. " PRCM_MOD_PWR_OK "  "0 ,1 "
;tree.end

;tree "PRCM_MOD_AUXCLKOK"
base ad:0x8015749c
group 0--3
line.long 0 "PRCM_MOD_AUXCLKOK"
bitfld.long 0 0. " PRCM_MOD_AUXCLKOK "  "0 ,1 "
;tree.end

;tree "PRCM_MOD_AWAKE_STATUS"
base ad:0x801574a0
rgroup 0--3
line.long 0 "PRCM_MOD_AWAKE_STATUS"
bitfld.long 0 0. " PRCM_MOD_COREPD_AWAKE "  "0 ,1 "
bitfld.long 0 1. " PRCM_MOD_AAPD_AWAKE "  "0 ,1 "
bitfld.long 0 2. " PRCM_MOD_VMODEM_OFF_ISO "  "0 ,1 "
;tree.end

;tree "PRCM_MOD_SWRESET_IRQ_ACK"
base ad:0x801574a4
group 0--3
line.long 0 "PRCM_MOD_SWRESET_IRQ_ACK"
bitfld.long 0 0. " PRCM_MOD_SWRESET_IRQ_ACK "  "0 ,1 "
;tree.end

;tree "PRCM_MOD_SWRESET_ACK"
base ad:0x801574a8
rgroup 0--3
line.long 0 "PRCM_MOD_SWRESET_ACK"
bitfld.long 0 0. " PRCM_MOD_SWRESET_ACK "  "0 ,1 "
;tree.end

;tree "PRCM_DBG_PWRCTL"
base ad:0x801574ac
group 0--3
line.long 0 "PRCM_DBG_PWRCTL"
bitfld.long 0 0. " A9PWRUPEN "  "0 ,1 "
bitfld.long 0 1. " MODPWRUPEN "  "0 ,1 "
bitfld.long 0 2. " MODNOPWRDN "  "0 ,1 "
;tree.end

;tree "PRCM_HWOBS_H"
base ad:0x801574b0
group 0--3
line.long 0 "PRCM_HWOBS_H"
bitfld.long 0 0.--1. " HW_OBS_SEL_16 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " HW_OBS_SEL_17 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " HW_OBS_EN "  "0 ,1 "
bitfld.long 0 8. " DDR1_notDDR0 "  "0 ,1 "
;tree.end

;tree "PRCM_HWOBS_L"
base ad:0x801574b4
group 0--3
line.long 0 "PRCM_HWOBS_L"
bitfld.long 0 0.--1. " HW_OBS_SEL_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " HW_OBS_SEL_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " HW_OBS_SEL_2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " HW_OBS_SEL_3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " HW_OBS_SEL_4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " HW_OBS_SEL_5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " HW_OBS_SEL_6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " HW_OBS_SEL_7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " HW_OBS_SEL_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " HW_OBS_SEL_9 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " HW_OBS_SEL_10 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " HW_OBS_SEL_11 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " HW_OBS_SEL_12 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " HW_OBS_SEL_13 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " HW_OBS_SEL_14 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " HW_OBS_SEL_15 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_C2C_CTL_SET"
base ad:0x801574f4
group 0--3
line.long 0 "PRCM_C2C_CTL_SET"
bitfld.long 0 0. " C2C_MODE "  "0 ,1 "
bitfld.long 0 1. " C2C_WAKEREQIN_MASK "  "0 ,1 "
bitfld.long 0 2. " C2C_SELECT "  "0 ,1 "
;tree.end

;tree "PRCM_C2C_CTL_CLR"
base ad:0x801574f8
group 0--3
line.long 0 "PRCM_C2C_CTL_CLR"
bitfld.long 0 0. " C2C_MODE "  "0 ,1 "
bitfld.long 0 1. " C2C_WAKEREQIN_MASK "  "0 ,1 "
bitfld.long 0 2. " C2C_SELECT "  "0 ,1 "
;tree.end

;tree "PRCM_C2C_CTL_VAL"
base ad:0x801574fc
group 0--3
line.long 0 "PRCM_C2C_CTL_VAL"
bitfld.long 0 0. " C2C_MODE "  "0 ,1 "
bitfld.long 0 1. " C2C_WAKEREQIN_MASK "  "0 ,1 "
bitfld.long 0 2. " C2C_SELECT "  "0 ,1 "
;tree.end

;tree "PRCM_PLLDSITV_FREQ"
base ad:0x80157500
group 0--3
line.long 0 "PRCM_PLLDSITV_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
;tree.end

;tree "PRCM_PLLDSITV_ENABLE"
base ad:0x80157504
group 0--3
line.long 0 "PRCM_PLLDSITV_ENABLE"
bitfld.long 0 0. " PRCM_PLLDSITV_ENABLE "  "0 ,1 "
;tree.end

;tree "PRCM_PLLDSITV_LOCKP"
base ad:0x80157508
rgroup 0--3
line.long 0 "PRCM_PLLDSITV_LOCKP"
bitfld.long 0 0. " PRCM_PLLDSITV_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLDSITV_LOCKP3 "  "0 ,1 "
;tree.end

;tree "PRCM_RNG_ENABLE"
base ad:0x8015750c
group 0--3
line.long 0 "PRCM_RNG_ENABLE"
bitfld.long 0 0. " PRCM_RNG_ENABLE "  "0 ,1 "
;tree.end

;tree "PRCM_YYCLKEN0_MGT_SET"
base ad:0x80157510
group 0--3
line.long 0 "PRCM_YYCLKEN0_MGT_SET"
bitfld.long 0 0. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 1. " ACLKEN "  "0 ,1 "
bitfld.long 0 2. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 3. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 4. " SGACLKEN "  "0 ,1 "
bitfld.long 0 5. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 6. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 7. " MSP1CLKEN "  "0 ,1 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 10. " SLIMCLKEN "  "0 ,1 "
bitfld.long 0 11. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 12. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 13. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 14. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 15. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 16. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 17. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 18. " BMLCLKEN "  "0 ,1 "
bitfld.long 0 19. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 20. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 21. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 22. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 23. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 24. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 25. " IPI2CCLKEN "  "0 ,1 "
bitfld.long 0 26. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 27. " DMACLKEN "  "0 ,1 "
bitfld.long 0 28. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 29. " TVCLKEN "  "0 ,1 "
bitfld.long 0 30. " SPARE_UNIPROCLKEN "  "0 ,1 "
bitfld.long 0 31. " SSPCLKEN "  "0 ,1 "
;tree.end

;tree "PRCM_YYCLKEN1_MGT_SET"
base ad:0x80157514
group 0--3
line.long 0 "PRCM_YYCLKEN1_MGT_SET"
bitfld.long 0 0. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 1. " UICCCLKEN "  "0 ,1 "
bitfld.long 0 2. " C2CCLKEN "  "0 ,1 "
bitfld.long 0 3. " G1CLKEN "  "0 ,1 "
bitfld.long 0 4. " HVACLKEN "  "0 ,1 "
bitfld.long 0 5. " DPICLKEN "  "0 ,1 "
bitfld.long 0 8. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE2CLKEN "  "0 ,1 "
;tree.end

;tree "PRCM_YYCLKEN0_MGT_CLR"
base ad:0x80157518
group 0--3
line.long 0 "PRCM_YYCLKEN0_MGT_CLR"
bitfld.long 0 0. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 1. " ACLKEN "  "0 ,1 "
bitfld.long 0 2. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 3. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 4. " SGACLKEN "  "0 ,1 "
bitfld.long 0 5. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 6. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 7. " MSP1CLKEN "  "0 ,1 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 10. " SLIMCLKEN "  "0 ,1 "
bitfld.long 0 11. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 12. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 13. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 14. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 15. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 16. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 17. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 18. " BMLCLKEN "  "0 ,1 "
bitfld.long 0 19. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 20. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 21. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 22. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 23. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 24. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 25. " IPI2CCLKEN "  "0 ,1 "
bitfld.long 0 26. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 27. " DMACLKEN "  "0 ,1 "
bitfld.long 0 28. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 29. " TVCLKEN "  "0 ,1 "
bitfld.long 0 30. " SPARE_UNIPROCLKEN "  "0 ,1 "
bitfld.long 0 31. " SSPCLKEN "  "0 ,1 "
;tree.end

;tree "PRCM_YYCLKEN1_MGT_CLR"
base ad:0x8015751c
group 0--3
line.long 0 "PRCM_YYCLKEN1_MGT_CLR"
bitfld.long 0 0. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 1. " UICCCLKEN "  "0 ,1 "
bitfld.long 0 2. " C2CCLKEN "  "0 ,1 "
bitfld.long 0 3. " G1CLKEN "  "0 ,1 "
bitfld.long 0 4. " HVACLKEN "  "0 ,1 "
bitfld.long 0 5. " DPICLKEN "  "0 ,1 "
bitfld.long 0 8. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE2CLKEN "  "0 ,1 "
;tree.end

;tree "PRCM_YYCLKEN0_MGT_VAL"
base ad:0x80157520
group 0--3
line.long 0 "PRCM_YYCLKEN0_MGT_VAL"
bitfld.long 0 0. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 1. " ACLKEN "  "0 ,1 "
bitfld.long 0 2. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 3. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 4. " SGACLKEN "  "0 ,1 "
bitfld.long 0 5. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 6. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 7. " MSP1CLKEN "  "0 ,1 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 10. " SLIMCLKEN "  "0 ,1 "
bitfld.long 0 11. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 12. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 13. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 14. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 15. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 16. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 17. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 18. " BMLCLKEN "  "0 ,1 "
bitfld.long 0 19. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 20. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 21. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 22. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 23. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 24. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 25. " IPI2CCLKEN "  "0 ,1 "
bitfld.long 0 26. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 27. " DMACLKEN "  "0 ,1 "
bitfld.long 0 28. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 29. " TVCLKEN "  "0 ,1 "
bitfld.long 0 30. " SPARE_UNIPROCLKEN "  "0 ,1 "
bitfld.long 0 31. " SSPCLKEN "  "0 ,1 "
;tree.end

;tree "PRCM_YYCLKEN1_MGT_VAL"
base ad:0x80157524
group 0--3
line.long 0 "PRCM_YYCLKEN1_MGT_VAL"
bitfld.long 0 0. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 1. " UICCCLKEN "  "0 ,1 "
bitfld.long 0 2. " C2CCLKEN "  "0 ,1 "
bitfld.long 0 3. " G1CLKEN "  "0 ,1 "
bitfld.long 0 4. " HVACLKEN "  "0 ,1 "
bitfld.long 0 5. " DPICLKEN "  "0 ,1 "
bitfld.long 0 8. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE2CLKEN "  "0 ,1 "
;tree.end

;tree "PRCM_XP70CLK_MGT2"
base ad:0x80157528
group 0--3
line.long 0 "PRCM_XP70CLK_MGT2"
bitfld.long 0 0.--2. " PLL_SOC0_MX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " XP70_CLK_L2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--8. " XP70_CLK_L1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9.--11. " CLK38M_ARMPLL_SW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " CLK38M_ARMVFCGPLL_SW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " CLK38M_DDR1PLL_SW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PRCM_DSITVCLK_DIV"
base ad:0x8015752c
group 0--3
line.long 0 "PRCM_DSITVCLK_DIV"
hexfld.byte 0 " DSI0_ESC_CLK_DIV "
hexfld.byte 1 " DSI1_ESC_CLK_DIV "
hexfld.byte 2 " DSI2_ESC_CLK_DIV "
bitfld.long 0 24. " DSI0_ESC_CLK_EN "  "0 ,1 "
bitfld.long 0 25. " DSI1_ESC_CLK_EN "  "0 ,1 "
bitfld.long 0 26. " DSI2_ESC_CLK_EN "  "0 ,1 "
;tree.end

;tree "PRCM_DSI_PLLOUT_SEL"
base ad:0x80157530
group 0--3
line.long 0 "PRCM_DSI_PLLOUT_SEL"
bitfld.long 0 0.--3. " DSI0_PLLOUT_DIVSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " DSI1_PLLOUT_DIVSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCM_DSI_GLITCHFREE_EN"
base ad:0x80157534
group 0--3
line.long 0 "PRCM_DSI_GLITCHFREE_EN"
bitfld.long 0 0. " DSI0_BYPASS_BYTE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 1. " DSI0_BYPASS_MCDE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 8. " DSI1_BYPASS_BYTE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 9. " DSI1_BYPASS_MCDE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 16. " DSI2_BYPASS_BYTE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 17. " DSI2_BYPASS_MCDE_CLK_SYNC "  "0 ,1 "
;tree.end

;tree "PRCM_CLKACTIV"
base ad:0x80157538
group 0--3
line.long 0 "PRCM_CLKACTIV"
bitfld.long 0 0. " CLK32_RUNNING "  "0 ,1 "
bitfld.long 0 1. " SYSCLK_RUNNING "  "0 ,1 "
bitfld.long 0 2. " PLLSOC0_RUNNING "  "0 ,1 "
bitfld.long 0 3. " PLLSOC1_RUNNING "  "0 ,1 "
bitfld.long 0 4. " PLLDDR_RUNNING "  "0 ,1 "
bitfld.long 0 5. " ABB_ULPCLK_RUNNING "  "0 ,1 "
bitfld.long 0 6. " DB8500_ULPCLK_RUNNING "  "0 ,1 "
bitfld.long 0 7. " MSP0SCK_RUNNING "  "0 ,1 "
bitfld.long 0 8. " MSP2SCK_RUNNING "  "0 ,1 "
bitfld.long 0 16. " PLLSOC1_DIV12_EN "  "0 ,1 "
bitfld.long 0 17. " PLLSOC1_EN "  "0 ,1 "
bitfld.long 0 18. " PLLDDR_DIV12_EN "  "0 ,1 "
bitfld.long 0 19. " PLLDDR_DIV2_EN "  "0 ,1 "
bitfld.long 0 20. " PLLSOC0_DIV12_EN "  "0 ,1 "
bitfld.long 0 21. " PLLSOC0_DIV2_EN "  "0 ,1 "
bitfld.long 0 22. " PLLDDR1_OUT_EN "  "0 ,1 "
bitfld.long 0 23. " PLLDDR1_RUNNING "  "0 ,1 "
bitfld.long 0 24. " C2CCLK_PLLSOC0_RUNNING "  "0 ,1 "
bitfld.long 0 25. " C2CCLK_PLLSOC1_RUNNING "  "0 ,1 "
bitfld.long 0 26. " C2CCLK_PLLDDR_RUNNING "  "0 ,1 "
;tree.end

;tree "PRCM_SIA_MMDSP_MEM_MGT"
base ad:0x8015753c
group 0--3
line.long 0 "PRCM_SIA_MMDSP_MEM_MGT"
bitfld.long 0 0. " MEM_REQ "  "0 ,1 "
bitfld.long 0 1. " MEM_LATENCY "  "0 ,1 "
;tree.end

;tree "PRCM_SVA_MMDSP_MEM_MGT"
base ad:0x80157540
group 0--3
line.long 0 "PRCM_SVA_MMDSP_MEM_MGT"
bitfld.long 0 0. " MEM_REQ "  "0 ,1 "
bitfld.long 0 1. " MEM_LATENCY "  "0 ,1 "
;tree.end

;tree "PRCM_SXAMMDSP_FORCE_CLKEN"
base ad:0x80157544
group 0--3
line.long 0 "PRCM_SXAMMDSP_FORCE_CLKEN"
bitfld.long 0 0. " SIA "  "0 ,1 "
bitfld.long 0 1. " SVA "  "0 ,1 "
;tree.end

;tree "PRCM_G1CLK_MGT"
base ad:0x80157548
group 0--3
line.long 0 "PRCM_G1CLK_MGT"
bitfld.long 0 0.--4. " G1CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " G1CLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " G1CLKEN "  "0 ,1 "
bitfld.long 0 9. " G1CLK38 "  "0 ,1 "
bitfld.long 0 10. " G1CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " G1CLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_HVACLK_MGT"
base ad:0x8015754c
group 0--3
line.long 0 "PRCM_HVACLK_MGT"
bitfld.long 0 0.--4. " HVACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " HVACLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " HVACLKEN "  "0 ,1 "
bitfld.long 0 9. " HVACLK38 "  "0 ,1 "
bitfld.long 0 10. " HVACLK38SRC "  "0 ,1 "
bitfld.long 0 11. " HVACLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_DPICLK_MGT"
base ad:0x80157550
group 0--3
line.long 0 "PRCM_DPICLK_MGT"
bitfld.long 0 0.--4. " DPICLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--7. " DPICLKPLLSW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8. " DPICLKEN "  "0 ,1 "
bitfld.long 0 9. " DPICLK38 "  "0 ,1 "
bitfld.long 0 10. " DPICLK38SRC "  "0 ,1 "
bitfld.long 0 11. " DPICLK38DIV "  "0 ,1 "
;tree.end

;tree "PRCM_UICC_NANDTREE"
base ad:0x80157570
group 0--3
line.long 0 "PRCM_UICC_NANDTREE"
bitfld.long 0 0. " UICC_NAND_I "  "0 ,1 "
bitfld.long 0 1. " UICC_NAND_O "  "0 ,1 "
;tree.end

;tree "PRCM_GPIOCR2"
base ad:0x80157574
group 0--3
line.long 0 "PRCM_GPIOCR2"
bitfld.long 0 0. " DBG_MODEMRF_CTRL_CMD1 "  "0 ,1 "
bitfld.long 0 1. " DBG_MODEMRF_CTRL_CMD0 "  "0 ,1 "
bitfld.long 0 2. " DBG_MODEMRF_INT_CMD1 "  "0 ,1 "
bitfld.long 0 3. " DBG_MODEMRF_INT_CMD0 "  "0 ,1 "
bitfld.long 0 4.--5. " MOD_DDR_SPACE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--15. " MOD_GPIOCR_SPARE "  " "
;tree.end

;tree "PRCM_MDM_ACWAKE"
base ad:0x80157578
group 0--3
line.long 0 "PRCM_MDM_ACWAKE"
bitfld.long 0 0. " MDM_ACWAKE "  "0 ,1 "
;tree.end

;tree "PRCM_ARM_OPP_SET"
base ad:0x8015757c
group 0--3
line.long 0 "PRCM_ARM_OPP_SET"
bitfld.long 0 0. " HS "  "0 ,1 "
bitfld.long 0 1. " LS "  "0 ,1 "
bitfld.long 0 2. " SPLITMEM "  "0 ,1 "
bitfld.long 0 3. " SPLITMEM_L2 "  "0 ,1 "
bitfld.long 0 4.--6. " SYNC_RATIO_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--9. " SYNC_RATIO_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " SYNC_RATIO_2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--15. " BBSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16. " PRCM_RTAEN "  "0 ,1 "
bitfld.long 0 17.--20. " PRCM_L2RTA_TIMEOUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 21.--25. " PLMTEMPO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PRCM_ARM_OPP_CLR"
base ad:0x80157580
group 0--3
line.long 0 "PRCM_ARM_OPP_CLR"
bitfld.long 0 0. " HS "  "0 ,1 "
bitfld.long 0 1. " LS "  "0 ,1 "
bitfld.long 0 2. " SPLITMEM "  "0 ,1 "
bitfld.long 0 3. " SPLITMEM_L2 "  "0 ,1 "
bitfld.long 0 4.--6. " SYNC_RATIO_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--9. " SYNC_RATIO_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " SYNC_RATIO_2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--15. " BBSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16. " PRCM_RTAEN "  "0 ,1 "
bitfld.long 0 17.--20. " PRCM_L2RTA_TIMEOUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 21.--25. " PLMTEMPO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PRCM_ARM_OPP_VAL"
base ad:0x80157584
rgroup 0--3
line.long 0 "PRCM_ARM_OPP_VAL"
bitfld.long 0 0. " HS "  "0 ,1 "
bitfld.long 0 1. " LS "  "0 ,1 "
bitfld.long 0 2. " SPLITMEM "  "0 ,1 "
bitfld.long 0 3. " SPLITMEM_L2 "  "0 ,1 "
bitfld.long 0 4.--6. " SYNC_RATIO_0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 7.--9. " SYNC_RATIO_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " SYNC_RATIO_2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 13.--15. " BBSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16. " PRCM_RTAEN "  "0 ,1 "
bitfld.long 0 17.--20. " PRCM_L2RTA_TIMEOUT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 21.--25. " PLMTEMPO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PRCM_ARM_OPP_REQ"
base ad:0x80157588
group 0--3
line.long 0 "PRCM_ARM_OPP_REQ"
bitfld.long 0 0. " OPP_REQ "  "0 ,1 "
bitfld.long 0 16. " OPP_ACK "  "0 ,1 "
;tree.end

;tree "PRCM_ARM_EPOD_C_SET"
base ad:0x8015758c
group 0--3
line.long 0 "PRCM_ARM_EPOD_C_SET"
bitfld.long 0 0. " A9_0_L_ON "  "0 ,1 "
bitfld.long 0 1. " A9_0_M_ON "  "0 ,1 "
bitfld.long 0 2. " A9_1_L_ON "  "0 ,1 "
bitfld.long 0 3. " A9_1_M_ON "  "0 ,1 "
bitfld.long 0 4. " A9_SCUL2_L_ON "  "0 ,1 "
bitfld.long 0 5. " A9_SCUL2_M_ON "  "0 ,1 "
;tree.end

;tree "PRCM_ARM_EPOD_C_CLR"
base ad:0x80157590
group 0--3
line.long 0 "PRCM_ARM_EPOD_C_CLR"
bitfld.long 0 0. " A9_0_L_ON "  "0 ,1 "
bitfld.long 0 1. " A9_0_M_ON "  "0 ,1 "
bitfld.long 0 2. " A9_1_L_ON "  "0 ,1 "
bitfld.long 0 3. " A9_1_M_ON "  "0 ,1 "
bitfld.long 0 4. " A9_SCUL2_L_ON "  "0 ,1 "
bitfld.long 0 5. " A9_SCUL2_M_ON "  "0 ,1 "
;tree.end

;tree "PRCM_ARM_EPOD_C_VAL"
base ad:0x80157594
rgroup 0--3
line.long 0 "PRCM_ARM_EPOD_C_VAL"
bitfld.long 0 0. " A9_0_L_ON "  "0 ,1 "
bitfld.long 0 1. " A9_0_M_ON "  "0 ,1 "
bitfld.long 0 2. " A9_1_L_ON "  "0 ,1 "
bitfld.long 0 3. " A9_1_M_ON "  "0 ,1 "
bitfld.long 0 4. " A9_SCUL2_L_ON "  "0 ,1 "
bitfld.long 0 5. " A9_SCUL2_M_ON "  "0 ,1 "
;tree.end

;tree "PRCM_ARM_EPOD_VOK"
base ad:0x80157598
rgroup 0--3
line.long 0 "PRCM_ARM_EPOD_VOK"
bitfld.long 0 0. " A9_0_L_VOK "  "0 ,1 "
bitfld.long 0 1. " A9_0_M_VOK "  "0 ,1 "
bitfld.long 0 2. " A9_1_L_VOK "  "0 ,1 "
bitfld.long 0 3. " A9_1_M_VOK "  "0 ,1 "
bitfld.long 0 4. " A9_SCUL2_L_VOK "  "0 ,1 "
bitfld.long 0 5. " A9_SCUL2_M_VOK "  "0 ,1 "
;tree.end

;tree "PRCM_ARM_EPOD_CFG"
base ad:0x8015759c
group 0--3
line.long 0 "PRCM_ARM_EPOD_CFG"
bitfld.long 0 0.--1. " VDDI_WAKEUP_CUR_L "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " VDDI_WAKEUP_CUR_M_VARM "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " VDDI_WAKEUP_CUR_M_VSAFE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--9. " KEEPERCTRL_CPU "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10.--13. " KEEPERCTRL_SCU "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCM_SPARE_GPIO_MUX"
base ad:0x801575a0
group 0--3
line.long 0 "PRCM_SPARE_GPIO_MUX"
hexfld.word 0 " SPARE_GPIO_MUX "
;tree.end

;tree "PRCM_MOD_MEM_REQ"
base ad:0x801575a4
group 0--3
line.long 0 "PRCM_MOD_MEM_REQ"
bitfld.long 0 0. " MOD_MEM_REQ_EN "  "0 ,1 "
bitfld.long 0 1. " MOD_MEM_REQ_FORCE "  "0 ,1 "
bitfld.long 0 8. " MOD_MEM_REQ_VAL "  "0 ,1 "
;tree.end

;tree "PRCM_MOD_MEM_ACK"
base ad:0x801575a8
group 0--3
line.long 0 "PRCM_MOD_MEM_ACK"
bitfld.long 0 0. " MOD_MEM_ACK_EN "  "0 ,1 "
bitfld.long 0 1. " MOD_MEM_ACK_FORCE "  "0 ,1 "
bitfld.long 0 8. " MOD_MEM_ACK_VAL "  "0 ,1 "
;tree.end

;tree "PRCM_MOD_MEM_LAT"
base ad:0x801575ac
group 0--3
line.long 0 "PRCM_MOD_MEM_LAT"
bitfld.long 0 0. " MOD_MEM_LAT_EN "  "0 ,1 "
bitfld.long 0 1. " MOD_MEM_LAT_FORCE "  "0 ,1 "
bitfld.long 0 8. " MOD_MEM_LAT_VAL "  "0 ,1 "
;tree.end

;tree "PRCM_ARM_PLLDIVPS_REQ"
base ad:0x801575b0
group 0--3
line.long 0 "PRCM_ARM_PLLDIVPS_REQ"
bitfld.long 0 0. " ARM_BRM_RATEVAL "  "0 ,1 "
bitfld.long 0 4. " ARM_PLL_OBSVAL "  "0 ,1 "
;tree.end

;tree "PRCM_ARM_PLLDIVPS_ACK"
base ad:0x801575b4
rgroup 0--3
line.long 0 "PRCM_ARM_PLLDIVPS_ACK"
bitfld.long 0 0. " ARM_BRM_RATEACK "  "0 ,1 "
bitfld.long 0 4. " ARM_PLL_OBSACK "  "0 ,1 "
;tree.end

;tree "PRCM_MOD_MEM_MIN_BW"
base ad:0x801575b8
group 0--3
line.long 0 "PRCM_MOD_MEM_MIN_BW"
bitfld.long 0 0. " MOD_MEM_MIN_BW_EN "  "0 ,1 "
bitfld.long 0 1.--2. " MOD_MEM_MIN_BW_FORCE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " MOD_DDR_MIN_BW "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_SRPTIMER_VAL"
base ad:0x801575d0
group 0--3
line.long 0 "PRCM_SRPTIMER_VAL"
hexfld.byte 0 " SRPTIMER_VAL "
;tree.end

;tree "PRCM_SRPTIMER_A9_IT_CLR"
base ad:0x801575d4
group 0--3
line.long 0 "PRCM_SRPTIMER_A9_IT_CLR"
bitfld.long 0 0. " PRCM_SRPTIMER_A9_IT_CLR "  "0 ,1 "
;tree.end

;tree "PRCM_HWI2C_A9_IT_CLR"
base ad:0x801575d8
group 0--3
line.long 0 "PRCM_HWI2C_A9_IT_CLR"
bitfld.long 0 0. " PRCM_HWI2C_A9_IT_CLR "  "0 ,1 "
;tree.end

;tree "PRCM_ARMITVALUE159TO128"
base ad:0x801575dc
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE159TO128"
hexfld.long 0 " PRCM_ARMITVALUE159TO128 "
;tree.end

;tree "PRCM_ARMITVALUE191TO160"
base ad:0x801575e0
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE191TO160"
hexfld.long 0 " PRCM_ARMITVALUE191TO160 "
;tree.end

;tree "PRCM_ARMITVALUE223TO192"
base ad:0x801575e4
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE223TO192"
hexfld.long 0 " PRCM_ARMITVALUE223TO192 "
;tree.end

;tree "PRCM_SECNONSEWM"
base ad:0x80158000
group 0--3
line.long 0 "PRCM_SECNONSEWM"
hexfld.word 0 " SECNONSECWM "
;tree.end

;tree "PRCM_ESRAM0_INITN"
base ad:0x80158004
group 0--3
line.long 0 "PRCM_ESRAM0_INITN"
bitfld.long 0 0. " PRCM_ESRAM0_INITN "  "0 ,1 "
;tree.end

;tree "PRCM_ARMITMSKSEC_31TO0"
base ad:0x80158008
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_31TO0"
hexfld.long 0 " PRCM_ARMITMSKSEC_31TO0 "
;tree.end

;tree "PRCM_ARMITMSKSEC_63TO32"
base ad:0x8015800c
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_63TO32"
hexfld.long 0 " PRCM_ARMITMSKSEC_63TO32 "
;tree.end

;tree "PRCM_ARMITMSKSEC_95TO64"
base ad:0x80158010
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_95TO64"
hexfld.long 0 " PRCM_ARMITMSKSEC_95TO64 "
;tree.end

;tree "PRCM_ARMITMSKSEC_127TO96"
base ad:0x80158014
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_127TO96"
hexfld.long 0 " PRCM_ARMITMSKSEC_127TO96 "
;tree.end

;tree "PRCM_ARMIT_MASKXP70_IT"
base ad:0x80158018
group 0--3
line.long 0 "PRCM_ARMIT_MASKXP70_IT"
bitfld.long 0 0. " PRCM_ARMIT_MASKXP70_IT "  "0 ,1 "
;tree.end

;tree "PRCM_ESRAM0_EPOD_CFG"
base ad:0x8015801c
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_CFG"
bitfld.long 0 0.--1. " VDDI_WAKEUP_CUR "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " VDDI_BIAS_VOLT_CTRL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--6. " BIAS_CUR_CTRL "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " BOOST "  "0 ,1 "
;tree.end

;tree "PRCM_ESRAM0_EPOD_C_VAL"
base ad:0x80158020
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_C_VAL"
bitfld.long 0 0. " ESRAM0_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_RET "  "0 ,1 "
;tree.end

;tree "PRCM_ESRAM0_EPOD_C_SET"
base ad:0x80158024
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_C_SET"
bitfld.long 0 0. " ESRAM0_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_RET "  "0 ,1 "
;tree.end

;tree "PRCM_ESRAM0_EPOD_C_CLR"
base ad:0x80158028
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_C_CLR"
bitfld.long 0 0. " ESRAM0_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_RET "  "0 ,1 "
;tree.end

;tree "PRCM_ESRAM0_EPOD_VOK"
base ad:0x8015802c
rgroup 0--3
line.long 0 "PRCM_ESRAM0_EPOD_VOK"
bitfld.long 0 0. " ESRAM0_VOK "  "0 ,1 "
;tree.end

;tree "PRCM_ESRAM0_LS_SLEEP"
base ad:0x80158030
group 0--3
line.long 0 "PRCM_ESRAM0_LS_SLEEP"
bitfld.long 0 0. " ESRAM0_SLEEP "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_LS "  "0 ,1 "
;tree.end

;tree "PRCM_SECURE_ONGOING"
base ad:0x80158034
group 0--3
line.long 0 "PRCM_SECURE_ONGOING"
bitfld.long 0 0. " SECURE_ONGOING "  "0 ,1 "
;tree.end

;tree "PRCM_I2C_SECURE"
base ad:0x80158038
group 0--3
line.long 0 "PRCM_I2C_SECURE"
bitfld.long 0 0. " I2C_SECURE "  "0 ,1 "
;tree.end

;tree "PRCM_RESET_STATUS"
base ad:0x8015803c
group 0--3
line.long 0 "PRCM_RESET_STATUS"
bitfld.long 0 0. " A9_CPU0_WATCHDOG_RESET "  "0 ,1 "
bitfld.long 0 1. " A9_CPU1_WATCHDOG_RESET "  "0 ,1 "
bitfld.long 0 2. " APE_SOFTWARE_RESET "  "0 ,1 "
bitfld.long 0 3. " APE_RESET "  "0 ,1 "
bitfld.long 0 4. " SECURE_WATCHDOG "  "0 ,1 "
bitfld.long 0 5. " POWER_ON_RESET "  "0 ,1 "
bitfld.long 0 6. " A9_RESTART "  "0 ,1 "
bitfld.long 0 7. " APE_RESTART "  "0 ,1 "
bitfld.long 0 8. " MODEM_SOFTWARE_RESET "  "0 ,1 "
bitfld.long 0 16. " BOOT_ENGI "  "0 ,1 "
;tree.end

;tree "PRCM_PERIPH4_RESETN_SET"
base ad:0x80158040
group 0--3
line.long 0 "PRCM_PERIPH4_RESETN_SET"
bitfld.long 0 0. " RTC_RESETN "  "0 ,1 "
bitfld.long 0 1. " RTT0_RESETN "  "0 ,1 "
bitfld.long 0 2. " RTT1_RESETN "  "0 ,1 "
bitfld.long 0 3. " BACKUP_RAM_RESETN "  "0 ,1 "
bitfld.long 0 4. " SEC_REG_RESETN "  "0 ,1 "
bitfld.long 0 5. " CLK_PLL_CONF_RESETN "  "0 ,1 "
bitfld.long 0 6. " HWI2C_RESETN "  "0 ,1 "
;tree.end

;tree "PRCM_PERIPH4_RESETN_CLR"
base ad:0x80158044
group 0--3
line.long 0 "PRCM_PERIPH4_RESETN_CLR"
bitfld.long 0 0. " RTC_RESETN "  "0 ,1 "
bitfld.long 0 1. " RTT0_RESETN "  "0 ,1 "
bitfld.long 0 2. " RTT1_RESETN "  "0 ,1 "
bitfld.long 0 3. " BACKUP_RAM_RESETN "  "0 ,1 "
bitfld.long 0 4. " SEC_REG_RESETN "  "0 ,1 "
bitfld.long 0 5. " CLK_PLL_CONF_RESETN "  "0 ,1 "
bitfld.long 0 6. " HWI2C_RESETN "  "0 ,1 "
;tree.end

;tree "PRCM_PERIPH4_RESETN_VAL"
base ad:0x80158048
rgroup 0--3
line.long 0 "PRCM_PERIPH4_RESETN_VAL"
bitfld.long 0 0. " RTC_RESETN "  "0 ,1 "
bitfld.long 0 1. " RTT0_RESETN "  "0 ,1 "
bitfld.long 0 2. " RTT1_RESETN "  "0 ,1 "
bitfld.long 0 3. " BACKUP_RAM_RESETN "  "0 ,1 "
bitfld.long 0 4. " SEC_REG_RESETN "  "0 ,1 "
bitfld.long 0 5. " CLK_PLL_CONF_RESETN "  "0 ,1 "
bitfld.long 0 6. " HWI2C_RESETN "  "0 ,1 "
;tree.end

;tree "PRCM_SPAREOUT_SEC"
base ad:0x8015804c
group 0--3
line.long 0 "PRCM_SPAREOUT_SEC"
bitfld.long 0 0. " BOOT_ROM_PDN "  "0 ,1 "
bitfld.long 0 1.--3. " SPAREOUT_SEC_3_1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4. " PCLK_RTT0_EN "  "0 ,1 "
bitfld.long 0 5. " PCLK_RTT1_EN "  "0 ,1 "
bitfld.long 0 6.--7. " SPAREOUT_SEC_7_6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--10. " FREERUNNINGOSC_COMP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11. " HVACLKEN_SEC "  "0 ,1 "
bitfld.long 0 12. " SVACLKEN_SEC "  "0 ,1 "
bitfld.long 0 13.--15. " SPAREOUT_SEC_15_13 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PRCM_PIPELINEDCR"
base ad:0x801580d8
group 0--3
line.long 0 "PRCM_PIPELINEDCR"
hexfld.long 0 " PRCM_PIPELINEDCR "
;tree.end

;tree "PRCM_VOLATILEIOCR"
base ad:0x801580dc
group 0--3
line.long 0 "PRCM_VOLATILEIOCR"
hexfld.long 0 " PRCM_VOLATILEIOCR "
;tree.end

;tree "PRCM_XP70CFGCR"
base ad:0x801580e0
group 0--3
line.long 0 "PRCM_XP70CFGCR"
bitfld.long 0 0. " XP70_P_FETCH_EN "  "0 ,1 "
bitfld.long 0 1. " XP70_WAKE_UP "  "0 ,1 "
bitfld.long 0 2. " XP70_EXCEPT_VB "  "0 ,1 "
bitfld.long 0 3. " XP70_IDLE_ACK "  "0 ,1 "
;tree.end

;tree "PRCM_TCPM_PAGING"
base ad:0x801580f0
group 0--3
line.long 0 "PRCM_TCPM_PAGING"
bitfld.long 0 0. " PRCM_TCPM_PAGING "  "0 ,1 "
;tree.end

;tree "PRCM_ARMITMSKSEC_159TO128"
base ad:0x80158550
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_159TO128"
hexfld.long 0 " PRCM_ARMITMSKSEC_159TO128 "
;tree.end

;tree "PRCM_ARMITMSKSEC_191TO160"
base ad:0x80158554
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_191TO160"
hexfld.long 0 " PRCM_ARMITMSKSEC_191TO160 "
;tree.end

;tree "PRCM_ARMITMSKSEC_223TO192"
base ad:0x8015855c
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_223TO192"
hexfld.long 0 " PRCM_ARMITMSKSEC_223TO192 "
;tree.end

;tree "PRCM_PLLVFCGARM_FREQ"
base ad:0x80159000
group 0--3
line.long 0 "PRCM_PLLVFCGARM_FREQ"
bitfld.long 0 0.--6. " D "  " "
bitfld.long 0 7.--8. " N "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--11. " FRANGE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12. " STROBE_ODF "  "0 ,1 "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PRCM_PLLVFCGARM_CTRL_SET"
base ad:0x80159004
group 0--3
line.long 0 "PRCM_PLLVFCGARM_CTRL_SET"
bitfld.long 0 0. " MASTER_ENABLE "  "0 ,1 "
bitfld.long 0 1. " VFCENABLE "  "0 ,1 "
bitfld.long 0 2. " CALIB_MODE "  "0 ,1 "
bitfld.long 0 3. " CALIB_START "  "0 ,1 "
bitfld.long 0 4. " HWRITE_MODE "  "0 ,1 "
bitfld.long 0 5. " SWRITE_MODE "  "0 ,1 "
bitfld.long 0 6. " VADJUST_MODE "  "0 ,1 "
bitfld.long 0 7. " STROBE "  "0 ,1 "
bitfld.long 0 8. " COUNTON "  "0 ,1 "
bitfld.long 0 16.--21. " WAIT_CYCLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--23. " FREQ_INCR "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--26. " TRIP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PRCM_PLLVFCGARM_CTRL_CLR"
base ad:0x80159008
group 0--3
line.long 0 "PRCM_PLLVFCGARM_CTRL_CLR"
bitfld.long 0 0. " MASTER_ENABLE "  "0 ,1 "
bitfld.long 0 1. " VFCENABLE "  "0 ,1 "
bitfld.long 0 2. " CALIB_MODE "  "0 ,1 "
bitfld.long 0 3. " CALIB_START "  "0 ,1 "
bitfld.long 0 4. " HWRITE_MODE "  "0 ,1 "
bitfld.long 0 5. " SWRITE_MODE "  "0 ,1 "
bitfld.long 0 6. " VADJUST_MODE "  "0 ,1 "
bitfld.long 0 7. " STROBE "  "0 ,1 "
bitfld.long 0 8. " COUNTON "  "0 ,1 "
bitfld.long 0 16.--21. " WAIT_CYCLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--23. " FREQ_INCR "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--26. " TRIP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PRCM_PLLVFCGARM_CTRL_VAL"
base ad:0x8015900c
rgroup 0--3
line.long 0 "PRCM_PLLVFCGARM_CTRL_VAL"
bitfld.long 0 0. " MASTER_ENABLE "  "0 ,1 "
bitfld.long 0 1. " VFCENABLE "  "0 ,1 "
bitfld.long 0 2. " CALIB_MODE "  "0 ,1 "
bitfld.long 0 3. " CALIB_START "  "0 ,1 "
bitfld.long 0 4. " HWRITE_MODE "  "0 ,1 "
bitfld.long 0 5. " SWRITE_MODE "  "0 ,1 "
bitfld.long 0 6. " VADJUST_MODE "  "0 ,1 "
bitfld.long 0 7. " STROBE "  "0 ,1 "
bitfld.long 0 8. " COUNTON "  "0 ,1 "
bitfld.long 0 16.--21. " WAIT_CYCLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--23. " FREQ_INCR "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--26. " TRIP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PRCM_PLLVFCGARM_COMPENSATION"
base ad:0x80159010
group 0--3
line.long 0 "PRCM_PLLVFCGARM_COMPENSATION"
bitfld.long 0 0.--19. " CODE_IN "  " "
;tree.end

;tree "PRCM_PLLVFCGARM_CALIBRATION"
base ad:0x80159014
rgroup 0--3
line.long 0 "PRCM_PLLVFCGARM_CALIBRATION"
bitfld.long 0 0.--19. " CODE_OUT "  " "
;tree.end

;tree "PRCM_PLLVFCGARM_STATUS"
base ad:0x80159018
rgroup 0--3
line.long 0 "PRCM_PLLVFCGARM_STATUS"
bitfld.long 0 0. " VFC_CLKGOOD "  "0 ,1 "
bitfld.long 0 1. " MODE_DONE "  "0 ,1 "
bitfld.long 0 2. " READY_VDDSENSE "  "0 ,1 "
bitfld.long 0 3. " FULLSPEED "  "0 ,1 "
bitfld.long 0 4. " COARSE_RANGE_OUT "  "0 ,1 "
bitfld.long 0 5. " CODE_SPREAD_ERROR "  "0 ,1 "
bitfld.long 0 6. " MODE_ERROR "  "0 ,1 "
bitfld.long 0 7. " CODE_OVERFLOW "  "0 ,1 "
bitfld.long 0 16.--20. " CODE_SPREAD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PRCM_PLLVFCGARM_LOCKP"
base ad:0x8015901c
rgroup 0--3
line.long 0 "PRCM_PLLVFCGARM_LOCKP"
bitfld.long 0 0. " PRCM_VFCGARM_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_VFCGARM_LOCKP3 "  "0 ,1 "
bitfld.long 0 2. " DVFS_CLKGOOD "  "0 ,1 "
;tree.end

;tree "PRCM_A9_MEMORIES_CTL"
base ad:0x80159020
group 0--3
line.long 0 "PRCM_A9_MEMORIES_CTL"
bitfld.long 0 0. " A9_IG_SPREG "  "0 ,1 "
bitfld.long 0 1. " A9_IG_ETB "  "0 ,1 "
bitfld.long 0 2. " A9_STDBY_SPREG "  "0 ,1 "
bitfld.long 0 3. " A9_STDBY_SPHD "  "0 ,1 "
bitfld.long 0 4. " A9_STDBY_ETB "  "0 ,1 "
;tree.end

;tree "PRCM_C2CSUBSYS_STATUS"
base ad:0x80159024
rgroup 0--3
line.long 0 "PRCM_C2CSUBSYS_STATUS"
hexfld.byte 0 " C2C_STATUS "
;tree.end

;tree "PRCM_C2C_IO_CTL_SET"
base ad:0x8015902c
group 0--3
line.long 0 "PRCM_C2C_IO_CTL_SET"
bitfld.long 0 0. " C2C_IO_PDN "  "0 ,1 "
bitfld.long 0 1. " C2C_IO_PUN "  "0 ,1 "
bitfld.long 0 2. " C2C_MIRROR_INTLOOP "  "0 ,1 "
bitfld.long 0 3. " C2C_PSW "  "0 ,1 "
bitfld.long 0 4. " C2C_MODE3_LOWEMI "  "0 ,1 "
;tree.end

;tree "PRCM_C2C_IO_CTL_CLR"
base ad:0x80159030
group 0--3
line.long 0 "PRCM_C2C_IO_CTL_CLR"
bitfld.long 0 0. " C2C_IO_PDN "  "0 ,1 "
bitfld.long 0 1. " C2C_IO_PUN "  "0 ,1 "
bitfld.long 0 2. " C2C_MIRROR_INTLOOP "  "0 ,1 "
bitfld.long 0 3. " C2C_PSW "  "0 ,1 "
bitfld.long 0 4. " C2C_MODE3_LOWEMI "  "0 ,1 "
;tree.end

;tree "PRCM_C2C_IO_CTL_VAL"
base ad:0x80159034
group 0--3
line.long 0 "PRCM_C2C_IO_CTL_VAL"
bitfld.long 0 0. " C2C_IO_PDN "  "0 ,1 "
bitfld.long 0 1. " C2C_IO_PUN "  "0 ,1 "
bitfld.long 0 2. " C2C_IO_MIRROR_INTLOOP "  "0 ,1 "
bitfld.long 0 3. " C2C_IO_PSW "  "0 ,1 "
bitfld.long 0 4. " C2C_IO_MODE3_LOWEMI "  "0 ,1 "
;tree.end

;tree "PRCM_C2C_MEM_REQ"
base ad:0x80159038
group 0--3
line.long 0 "PRCM_C2C_MEM_REQ"
bitfld.long 0 0. " C2C_MEM_REQ_EN "  "0 ,1 "
bitfld.long 0 1. " C2C_MEM_REQ_FORCE "  "0 ,1 "
bitfld.long 0 8. " C2C_DDR_REQ_VAL "  "0 ,1 "
;tree.end

;tree "PRCM_C2C_MEM_ACK"
base ad:0x8015903c
group 0--3
line.long 0 "PRCM_C2C_MEM_ACK"
bitfld.long 0 0. " C2C_MEM_ACK_EN "  "0 ,1 "
bitfld.long 0 1. " C2C_MEM_ACK_FORCE "  "0 ,1 "
bitfld.long 0 8. " C2C_MEM_ACK_VAL "  "0 ,1 "
;tree.end

;tree "PRCM_C2C_MEM_LAT"
base ad:0x80159040
group 0--3
line.long 0 "PRCM_C2C_MEM_LAT"
bitfld.long 0 0. " C2C_MEM_LAT_EN "  "0 ,1 "
bitfld.long 0 1. " C2C_MEM_LAT_FORCE "  "0 ,1 "
bitfld.long 0 8. " C2C_DDR_LAT_VAL "  "0 ,1 "
;tree.end

;tree "PRCM_C2C_MEM_MIN_BW"
base ad:0x80159044
group 0--3
line.long 0 "PRCM_C2C_MEM_MIN_BW"
bitfld.long 0 0. " C2C_MEM_MIN_BW_EN "  "0 ,1 "
bitfld.long 0 1.--2. " C2C_MEM_MIN_BW_FORCE "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " C2C_DDR_MIN_BW "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_C2CSUBSYS_CONTROL_SET"
base ad:0x80159048
group 0--3
line.long 0 "PRCM_C2CSUBSYS_CONTROL_SET"
hexfld.long 0 " C2C_CONTROL "
;tree.end

;tree "PRCM_C2CSUBSYS_CONTROL_CLR"
base ad:0x8015904c
group 0--3
line.long 0 "PRCM_C2CSUBSYS_CONTROL_CLR"
hexfld.long 0 " C2C_CONTROL "
;tree.end

;tree "PRCM_C2CSUBSYS_CONTROL_VAL"
base ad:0x80159050
group 0--3
line.long 0 "PRCM_C2CSUBSYS_CONTROL_VAL"
hexfld.long 0 " C2C_CONTROL "
;tree.end

;tree "PRCM_C2C_SSCM_GENI_SET"
base ad:0x80159054
group 0--3
line.long 0 "PRCM_C2C_SSCM_GENI_SET"
hexfld.long 0 " C2C_SSCM_GENI "
;tree.end

;tree "PRCM_C2C_SSCM_GENI_CLR"
base ad:0x80159058
group 0--3
line.long 0 "PRCM_C2C_SSCM_GENI_CLR"
hexfld.long 0 " C2C_SSCM_GENI "
;tree.end

;tree "PRCM_C2C_SSCM_GENI_VAL"
base ad:0x8015905c
group 0--3
line.long 0 "PRCM_C2C_SSCM_GENI_VAL"
hexfld.long 0 " C2C_SSCM_GENI "
;tree.end

;tree "PRCM_C2C_SSCM_GENO"
base ad:0x80159060
rgroup 0--3
line.long 0 "PRCM_C2C_SSCM_GENO"
hexfld.long 0 " C2C_SSCM_GENO "
;tree.end

;tree "PRCM_C2C_COMPCR"
base ad:0x80159064
group 0--3
line.long 0 "PRCM_C2C_COMPCR"
bitfld.long 0 0. " IO_TQ "  "0 ,1 "
bitfld.long 0 1. " IO_COMPFRZ "  "0 ,1 "
bitfld.long 0 2. " IO_COMPEN "  "0 ,1 "
bitfld.long 0 3. " IO_COMPTQ "  "0 ,1 "
bitfld.long 0 4. " IO_COMPFASTFRZ "  "0 ,1 "
bitfld.long 0 5. " IO_ACCURATE "  "0 ,1 "
bitfld.long 0 6. " IO_ISO "  "0 ,1 "
bitfld.long 0 8.--11. " IO_NASRCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " IO_PASRCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCM_C2C_COMPSTA"
base ad:0x80159068
rgroup 0--3
line.long 0 "PRCM_C2C_COMPSTA"
bitfld.long 0 0. " IO_COMPOK "  "0 ,1 "
bitfld.long 0 8.--11. " IO_NASRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " IO_PASRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PRCM_PLLVFCGARM_F_DIV2_CNT"
base ad:0x8015906c
rgroup 0--3
line.long 0 "PRCM_PLLVFCGARM_F_DIV2_CNT"
bitfld.long 0 0.--9. " CNT_VAL "  " "
;tree.end

;tree "PRCM_REG_SPARE_OUT"
base ad:0x80159070
group 0--3
line.long 0 "PRCM_REG_SPARE_OUT"
bitfld.long 0 0. " APE_EROM_LS "  "0 ,1 "
bitfld.long 0 1. " SVACORE_EROM_LS "  "0 ,1 "
bitfld.long 0 2.--15. " REG_SPARE_OUT_15_2 "  " "
bitfld.long 0 16. " CPU0_INITN "  "0 ,1 "
bitfld.long 0 17. " CPU1_INITN "  "0 ,1 "
bitfld.long 0 18. " L2_CACHE_INITN "  "0 ,1 "
bitfld.long 0 19. " GFX_FORCE_CLKEN "  "0 ,1 "
bitfld.long 0 20.--31. " REG_SPARE_OUT_31_20 "  " "
;tree.end

;tree "PRCM_REG_SPARE_IN"
base ad:0x80159074
rgroup 0--3
line.long 0 "PRCM_REG_SPARE_IN"
hexfld.long 0 " REG_SPARE_IN "
;tree.end

;tree "PRCM_A9_C2C_GENO_MASK_SET"
base ad:0x80159078
group 0--3
line.long 0 "PRCM_A9_C2C_GENO_MASK_SET"
hexfld.long 0 " A9_C2C_GENO_MASK "
;tree.end

;tree "PRCM_A9_C2C_GENO_MASK_CLR"
base ad:0x8015907c
group 0--3
line.long 0 "PRCM_A9_C2C_GENO_MASK_CLR"
hexfld.long 0 " A9_C2C_GENO_MASK "
;tree.end

;tree "PRCM_A9_C2C_GENO_MASK_VAL"
base ad:0x80159080
group 0--3
line.long 0 "PRCM_A9_C2C_GENO_MASK_VAL"
hexfld.long 0 " A9_C2C_GENO_MASK "
;tree.end

;tree "PRCM_PLLDDR1_FREQ"
base ad:0x8015908c
group 0--3
line.long 0 "PRCM_PLLDDR1_FREQ"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
bitfld.long 0 25. " DIV2EN "  "0 ,1 "
;tree.end

;tree "PRCM_PLLDDR1_ENABLE"
base ad:0x8015909c
group 0--3
line.long 0 "PRCM_PLLDDR1_ENABLE"
bitfld.long 0 0. " PRCM_PLLDDR1_ENABLE "  "0 ,1 "
;tree.end

;tree "PRCM_PLLDDR1_LOCKP"
base ad:0x801590ac
rgroup 0--3
line.long 0 "PRCM_PLLDDR1_LOCKP"
bitfld.long 0 0. " PRCM_PLLDDR1_LOCKP "  "0 ,1 "
;tree.end

;tree "PRCM_POWER_STATE1_SET"
base ad:0x80159254
group 0--3
line.long 0 "PRCM_POWER_STATE1_SET"
bitfld.long 0 0.--1. " ESRAM5_STATE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_POWER_STATE1_CLR"
base ad:0x80159258
group 0--3
line.long 0 "PRCM_POWER_STATE1_CLR"
bitfld.long 0 0.--1. " ESRAM5_STATE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_POWER_STATE1_VAL"
base ad:0x8015925c
group 0--3
line.long 0 "PRCM_POWER_STATE1_VAL"
bitfld.long 0 0.--1. " ESRAM5_STATE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_DDR1SUBSYS_APE_MINBW"
base ad:0x80159438
group 0--3
line.long 0 "PRCM_DDR1SUBSYS_APE_MINBW"
bitfld.long 0 0.--1. " APE1_MIN_BW "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_DDR1SUBSYS_STATUS"
base ad:0x8015943c
rgroup 0--3
line.long 0 "PRCM_DDR1SUBSYS_STATUS"
bitfld.long 0 0.--4. " MAIN_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " EFFECTIVE_MIN_BW "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " CORE_VDDIOK "  "0 ,1 "
bitfld.long 0 8. " CORE_GNDIOK "  "0 ,1 "
bitfld.long 0 9. " PHY_VDDIOK "  "0 ,1 "
bitfld.long 0 10.--13. " CORE_DOMAIN_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14.--16. " PHY_DOMAIN_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17.--19. " PLL_FSM_STATE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--31. " SPARE "  " "
;tree.end

;tree "PRCM_DDR1SUBSYS_CONTROL"
base ad:0x80159440
group 0--3
line.long 0 "PRCM_DDR1SUBSYS_CONTROL"
bitfld.long 0 0. " CORE_BIAS_DISABLE "  "0 ,1 "
bitfld.long 0 1. " CORE_OFF_DISABLE "  "0 ,1 "
bitfld.long 0 2. " PHY_OFF_DISABLE "  "0 ,1 "
bitfld.long 0 3. " MODEM_ON_CLK_REDUCE_ENABLE "  "0 ,1 "
bitfld.long 0 4. " SPARE_1 "  "0 ,1 "
bitfld.long 0 5. " FREQDIV_BY4_DISABLE "  "0 ,1 "
bitfld.long 0 6. " CORE_ISOLATION_RESYNCH_DISABLE "  "0 ,1 "
bitfld.long 0 7. " FORCE_CORE_ISOLATION "  "0 ,1 "
bitfld.long 0 8. " FORCE_PHY_IO_ISOLATION "  "0 ,1 "
bitfld.long 0 9. " VREF_IO_SET_WITH_EXTERNAL_VREF "  "0 ,1 "
bitfld.long 0 10. " MIN_BW_REMAP "  "0 ,1 "
bitfld.long 0 11. " MODEM_MEM_REQ_STRECH_DISABLE "  "0 ,1 "
bitfld.long 0 12. " C2C_MEM_REQ_STRECH_DISABLE "  "0 ,1 "
bitfld.long 0 13. " C2C_ENABLE "  "0 ,1 "
bitfld.long 0 14.--23. " SPARE_2 "  " "
;tree.end

;tree "PRCM_DDR1SUBSYS_HIGH_LEAK_COND"
base ad:0x80159444
group 0--3
line.long 0 "PRCM_DDR1SUBSYS_HIGH_LEAK_COND"
bitfld.long 0 0. " DDR1_HIGH_LEAK "  "0 ,1 "
;tree.end

;tree "PRCM_DDR1SUBSYS_CONFIG"
base ad:0x80159448
rgroup 0--3
line.long 0 "PRCM_DDR1SUBSYS_CONFIG"
bitfld.long 0 0.--1. " DDR1_CONFIG_REQ "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_DDR1SUBSYS_CONFIG_ACK"
base ad:0x8015944c
group 0--3
line.long 0 "PRCM_DDR1SUBSYS_CONFIG_ACK"
bitfld.long 0 0.--1. " DDR1_CONFIG_ACK "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_DDR1SUBSYS_GFX_MINBW"
base ad:0x80159450
group 0--3
line.long 0 "PRCM_DDR1SUBSYS_GFX_MINBW"
bitfld.long 0 0.--1. " GFX_MIN_BW "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_APE_MEM1_REQ"
base ad:0x80159470
group 0--3
line.long 0 "PRCM_APE_MEM1_REQ"
bitfld.long 0 0. " APE_MEM1_REQ "  "0 ,1 "
;tree.end

;tree "PRCM_DBG_FORCES_APE_MEM1_REQ"
base ad:0x80159474
group 0--3
line.long 0 "PRCM_DBG_FORCES_APE_MEM1_REQ"
bitfld.long 0 0. " DBG_FORCES_APE_MEM1_REQ "  "0 ,1 "
;tree.end

;tree "PRCM_APE_MEM1_WFX_EN"
base ad:0x80159478
group 0--3
line.long 0 "PRCM_APE_MEM1_WFX_EN"
bitfld.long 0 0. " PL310_IDLE_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WFI_0_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WFI_1_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WFE_0_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WFE_1_ENABLE "  "0 ,1 "
;tree.end

;tree "PRCM_APE_MEM1_LATENCY"
base ad:0x8015947c
group 0--3
line.long 0 "PRCM_APE_MEM1_LATENCY"
bitfld.long 0 0. " APE_MEM1_LATENCY "  "0 ,1 "
;tree.end

;tree "PRCM_APE_MEM1_ACK"
base ad:0x80159480
rgroup 0--3
line.long 0 "PRCM_APE_MEM1_ACK"
bitfld.long 0 0. " APE_MEM1_ACK "  "0 ,1 "
;tree.end

;tree "PRCM_ITSTATUS7"
base ad:0x801594b8
rgroup 0--3
line.long 0 "PRCM_ITSTATUS7"
bitfld.long 0 1. " c2c_mstandby "  "0 ,1 "
bitfld.long 0 3. " c2c_irq_0 "  "0 ,1 "
bitfld.long 0 4. " c2c_irq_1 "  "0 ,1 "
bitfld.long 0 10.--17. " c2c_lp_interrupt "  " "
bitfld.long 0 18. " temp_sensor_it "  "0 ,1 "
bitfld.long 0 19. " voltage_sensor_it "  "0 ,1 "
bitfld.long 0 20.--31. " SPARE "  " "
;tree.end

;tree "PRCM_ITCLR7"
base ad:0x801594bc
group 0--3
line.long 0 "PRCM_ITCLR7"
bitfld.long 0 1. " c2c_mstandby "  "0 ,1 "
bitfld.long 0 3. " c2c_irq_0 "  "0 ,1 "
bitfld.long 0 4. " c2c_irq_1 "  "0 ,1 "
bitfld.long 0 10.--17. " c2c_lp_interrupt "  " "
bitfld.long 0 18. " temp_sensor_it "  "0 ,1 "
bitfld.long 0 19. " voltage_sensor_it "  "0 ,1 "
bitfld.long 0 20.--31. " SPARE "  " "
;tree.end

;tree "PRCM_LINE_VALUE7"
base ad:0x801594c0
rgroup 0--3
line.long 0 "PRCM_LINE_VALUE7"
bitfld.long 0 1. " c2c_mstandby "  "0 ,1 "
bitfld.long 0 3. " c2c_irq_0 "  "0 ,1 "
bitfld.long 0 4. " c2c_irq_1 "  "0 ,1 "
bitfld.long 0 10.--17. " c2c_lp_interrupt "  " "
bitfld.long 0 18. " temp_sensor_it "  "0 ,1 "
bitfld.long 0 19. " voltage_sensor_it "  "0 ,1 "
bitfld.long 0 20.--31. " SPARE "  " "
;tree.end

;tree "PRCM_HOLD_EVT7"
base ad:0x801594c4
group 0--3
line.long 0 "PRCM_HOLD_EVT7"
bitfld.long 0 1. " c2c_mstandby "  "0 ,1 "
bitfld.long 0 3. " c2c_irq_0 "  "0 ,1 "
bitfld.long 0 4. " c2c_irq_1 "  "0 ,1 "
bitfld.long 0 10.--17. " c2c_lp_interrupt "  " "
bitfld.long 0 18. " temp_sensor_it "  "0 ,1 "
bitfld.long 0 19. " voltage_sensor_it "  "0 ,1 "
bitfld.long 0 20.--31. " SPARE "  " "
;tree.end

;tree "PRCM_EDGE_SENS_L7"
base ad:0x801594c8
group 0--3
line.long 0 "PRCM_EDGE_SENS_L7"
bitfld.long 0 2.--3. " c2c_mstandby "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " c2c_irq_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " c2c_irq_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " c2c_lp_interrupt_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " c2c_lp_interrupt_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " c2c_lp_interrupt_2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " c2c_lp_interrupt_3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " c2c_lp_interrupt_4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " c2c_lp_interrupt_5 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_EDGE_SENS_H7"
base ad:0x801594cc
group 0--3
line.long 0 "PRCM_EDGE_SENS_H7"
bitfld.long 0 0.--1. " c2c_lp_interrupt_6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " c2c_lp_interrupt_7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " temp_sensor_it "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " voltage_sensor_it "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--31. " SPARE "  " "
;tree.end

;tree "PRCM_ITSTATUS8"
base ad:0x801594d0
rgroup 0--3
line.long 0 "PRCM_ITSTATUS8"
hexfld.long 0 " c2c_prcmu_irq "
;tree.end

;tree "PRCM_ITCLR8"
base ad:0x801594d4
group 0--3
line.long 0 "PRCM_ITCLR8"
hexfld.long 0 " c2c_prcmu_irq "
;tree.end

;tree "PRCM_LINE_VALUE8"
base ad:0x801594d8
rgroup 0--3
line.long 0 "PRCM_LINE_VALUE8"
hexfld.long 0 " c2c_prcmu_irq "
;tree.end

;tree "PRCM_HOLD_EVT8"
base ad:0x801594dc
group 0--3
line.long 0 "PRCM_HOLD_EVT8"
hexfld.long 0 " c2c_prcmu_irq "
;tree.end

;tree "PRCM_EDGE_SENS_L8"
base ad:0x801594e0
group 0--3
line.long 0 "PRCM_EDGE_SENS_L8"
bitfld.long 0 0.--1. " C2C_PRCMU_IRQ_0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " C2C_PRCMU_IRQ_1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " C2C_PRCMU_IRQ_2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " C2C_PRCMU_IRQ_3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " C2C_PRCMU_IRQ_4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " C2C_PRCMU_IRQ_5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " C2C_PRCMU_IRQ_6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " C2C_PRCMU_IRQ_7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " C2C_PRCMU_IRQ_8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " C2C_PRCMU_IRQ_9 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " C2C_PRCMU_IRQ_10 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " C2C_PRCMU_IRQ_11 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " C2C_PRCMU_IRQ_12 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " C2C_PRCMU_IRQ_13 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " C2C_PRCMU_IRQ_14 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " C2C_PRCMU_IRQ_15 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_EDGE_SENS_H8"
base ad:0x801594e4
group 0--3
line.long 0 "PRCM_EDGE_SENS_H8"
bitfld.long 0 0.--1. " C2C_PRCMU_IRQ_16 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " C2C_PRCMU_IRQ_17 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " C2C_PRCMU_IRQ_18 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " C2C_PRCMU_IRQ_19 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " C2C_PRCMU_IRQ_20 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " C2C_PRCMU_IRQ_21 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " C2C_PRCMU_IRQ_22 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " C2C_PRCMU_IRQ_23 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " C2C_PRCMU_IRQ_24 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " C2C_PRCMU_IRQ_25 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " C2C_PRCMU_IRQ_26 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " C2C_PRCMU_IRQ_27 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " C2C_PRCMU_IRQ_28 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " C2C_PRCMU_IRQ_29 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " C2C_PRCMU_IRQ_30 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " C2C_PRCMU_IRQ_31 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_ITSTATUS9"
base ad:0x801594e8
rgroup 0--3
line.long 0 "PRCM_ITSTATUS9"
bitfld.long 0 0. " ddr0_config_it "  "0 ,1 "
bitfld.long 0 1. " ddr1_config_it "  "0 ,1 "
bitfld.long 0 2.--31. " SPARE "  " "
;tree.end

;tree "PRCM_ITCLR9"
base ad:0x801594ec
group 0--3
line.long 0 "PRCM_ITCLR9"
bitfld.long 0 0. " ddr0_config_it "  "0 ,1 "
bitfld.long 0 1. " ddr1_config_it "  "0 ,1 "
bitfld.long 0 2.--31. " SPARE "  " "
;tree.end

;tree "PRCM_LINE_VALUE9"
base ad:0x801594f0
rgroup 0--3
line.long 0 "PRCM_LINE_VALUE9"
bitfld.long 0 0. " ddr0_config_it "  "0 ,1 "
bitfld.long 0 1. " ddr1_config_it "  "0 ,1 "
bitfld.long 0 2.--31. " SPARE "  " "
;tree.end

;tree "PRCM_HOLD_EVT9"
base ad:0x801594f4
group 0--3
line.long 0 "PRCM_HOLD_EVT9"
bitfld.long 0 0. " ddr0_config_it "  "0 ,1 "
bitfld.long 0 1. " ddr1_config_it "  "0 ,1 "
bitfld.long 0 2.--31. " SPARE "  " "
;tree.end

;tree "PRCM_EDGE_SENS_L9"
base ad:0x801594f8
group 0--3
line.long 0 "PRCM_EDGE_SENS_L9"
bitfld.long 0 0.--1. " ddr0_config_it "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " ddr1_config_it "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--31. " spare "  " "
;tree.end

;tree "PRCM_EDGE_SENS_H9"
base ad:0x801594fc
group 0--3
line.long 0 "PRCM_EDGE_SENS_H9"
hexfld.long 0 " SPARE "
;tree.end

;tree "PRCM_ITSTATUS10"
base ad:0x80159500
rgroup 0--3
line.long 0 "PRCM_ITSTATUS10"
bitfld.long 0 0. " ddr0_status_it "  "0 ,1 "
bitfld.long 0 1. " ddr1_status_it "  "0 ,1 "
bitfld.long 0 2.--31. " SPARE "  " "
;tree.end

;tree "PRCM_ITCLR10"
base ad:0x80159504
group 0--3
line.long 0 "PRCM_ITCLR10"
bitfld.long 0 0. " ddr0_status_it "  "0 ,1 "
bitfld.long 0 1. " ddr1_status_it "  "0 ,1 "
bitfld.long 0 2.--31. " SPARE "  " "
;tree.end

;tree "PRCM_LINE_VALUE10"
base ad:0x80159508
rgroup 0--3
line.long 0 "PRCM_LINE_VALUE10"
bitfld.long 0 0. " ddr0_status_it "  "0 ,1 "
bitfld.long 0 1. " ddr1_status_it "  "0 ,1 "
bitfld.long 0 2.--31. " SPARE "  " "
;tree.end

;tree "PRCM_HOLD_EVT10"
base ad:0x8015950c
group 0--3
line.long 0 "PRCM_HOLD_EVT10"
bitfld.long 0 0. " ddr0_status_it "  "0 ,1 "
bitfld.long 0 1. " ddr1_status_it "  "0 ,1 "
bitfld.long 0 2.--31. " SPARE "  " "
;tree.end

;tree "PRCM_EDGE_SENS_L10"
base ad:0x80159510
group 0--3
line.long 0 "PRCM_EDGE_SENS_L10"
bitfld.long 0 0.--1. " ddr0_status_it "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " ddr1_status_it "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--31. " spare "  " "
;tree.end

;tree "PRCM_EDGE_SENS_H10"
base ad:0x80159514
group 0--3
line.long 0 "PRCM_EDGE_SENS_H10"
hexfld.long 0 " SPARE "
;tree.end

;tree "PRCM_ITSTATUS11"
base ad:0x80159518
rgroup 0--3
line.long 0 "PRCM_ITSTATUS11"
bitfld.long 0 0. " ape_mem0_ack_it "  "0 ,1 "
bitfld.long 0 1. " ape_mem1_ack_it "  "0 ,1 "
bitfld.long 0 2.--31. " SPARE "  " "
;tree.end

;tree "PRCM_ITCLR11"
base ad:0x8015951c
group 0--3
line.long 0 "PRCM_ITCLR11"
bitfld.long 0 0. " ape_mem0_ack_it "  "0 ,1 "
bitfld.long 0 1. " ape_mem1_ack_it "  "0 ,1 "
bitfld.long 0 2.--31. " SPARE "  " "
;tree.end

;tree "PRCM_LINE_VALUE11"
base ad:0x80159520
rgroup 0--3
line.long 0 "PRCM_LINE_VALUE11"
bitfld.long 0 0. " ape_mem0_ack_it "  "0 ,1 "
bitfld.long 0 1. " ape_mem1_ack_it "  "0 ,1 "
bitfld.long 0 2.--31. " SPARE "  " "
;tree.end

;tree "PRCM_HOLD_EVT11"
base ad:0x80159524
group 0--3
line.long 0 "PRCM_HOLD_EVT11"
bitfld.long 0 0. " ape_mem0_ack_it "  "0 ,1 "
bitfld.long 0 1. " ape_mem1_ack_it "  "0 ,1 "
bitfld.long 0 2.--31. " SPARE "  " "
;tree.end

;tree "PRCM_EDGE_SENS_L11"
base ad:0x80159528
group 0--3
line.long 0 "PRCM_EDGE_SENS_L11"
bitfld.long 0 0.--1. " ape_mem0_ack_it "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " ape_mem1_ack_it "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--31. " spare "  " "
;tree.end

;tree "PRCM_EDGE_SENS_H11"
base ad:0x8015952c
group 0--3
line.long 0 "PRCM_EDGE_SENS_H11"
hexfld.long 0 " SPARE "
;tree.end

;tree "PRCM_SIA_MMDSP_MEM1_MGT"
base ad:0x8015953c
group 0--3
line.long 0 "PRCM_SIA_MMDSP_MEM1_MGT"
bitfld.long 0 0. " MEM1_REQ "  "0 ,1 "
bitfld.long 0 1. " MEM1_LATENCY "  "0 ,1 "
;tree.end

;tree "PRCM_SVA_MMDSP_MEM1_MGT"
base ad:0x80159540
group 0--3
line.long 0 "PRCM_SVA_MMDSP_MEM1_MGT"
bitfld.long 0 0. " MEM1_REQ "  "0 ,1 "
bitfld.long 0 1. " MEM1_LATENCY "  "0 ,1 "
;tree.end

;tree "PRCM_VSENS_CTRL"
base ad:0x80159600
group 0--3
line.long 0 "PRCM_VSENS_CTRL"
bitfld.long 0 0. " START "  "0 ,1 "
bitfld.long 0 16.--17. " CALMODE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_VSENS_STATUS"
base ad:0x80159604
rgroup 0--3
line.long 0 "PRCM_VSENS_STATUS"
bitfld.long 0 0.--3. " DATA_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " OVERFLOW "  "0 ,1 "
bitfld.long 0 5. " IT_STATUS "  "0 ,1 "
bitfld.long 0 6. " RUN "  "0 ,1 "
bitfld.long 0 7. " CALDONE "  "0 ,1 "
;tree.end

;tree "PRCM_VSENS_IT_CLR"
base ad:0x80159608
wgroup 0--3
line.long 0 "PRCM_VSENS_IT_CLR"
bitfld.long 0 0. " IT_CLR "  "0 ,1 "
;tree.end

;tree "PRCM_VSENS_CLKDIV"
base ad:0x8015960c
group 0--3
line.long 0 "PRCM_VSENS_CLKDIV"
hexfld.byte 0 " CLKDIV "
;tree.end

;tree "PRCM_VSENS_MEANFILTER"
base ad:0x80159610
group 0--3
line.long 0 "PRCM_VSENS_MEANFILTER"
bitfld.long 0 0.--1. " MEANFILTER "  "0 ,1 ,2 ,3 "
;tree.end

;tree "PRCM_VSENS_TRIM"
base ad:0x80159614
group 0--3
line.long 0 "PRCM_VSENS_TRIM"
bitfld.long 0 0.--5. " TRIM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--10. " TRIM_DAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " ADC_OFFSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PRCM_VSENS_VOLTAGE"
base ad:0x80159618
rgroup 0--3
line.long 0 "PRCM_VSENS_VOLTAGE"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " OVERFLOW "  "0 ,1 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "PWL"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CR"
base ad:0x80113000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PWLEN "  "0 ,1 "
;tree.end

;tree "LR"
base ad:0x80113004
group 0--3
line.long 0 "LR"
hexfld.byte 0 " PWLVL "
;tree.end

;tree "ITCR"
base ad:0x80113080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITOP"
base ad:0x80113088
rgroup 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " PWLOUT "  "0 ,1 "
;tree.end

;tree "PeriphID0"
base ad:0x80113fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PeriphID1"
base ad:0x80113fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0x80113fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0x80113fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0x80113ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

;tree "PCellID1"
base ad:0x80113ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

;tree "PCellID2"
base ad:0x80113ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

;tree "PCellID3"
base ad:0x80113ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "REGBANKTB"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "OUT_REG0"
base ad:0x63f80000
group 0--3
line.long 0 "OUT_REG0"
bitfld.long 0 0. " MSP_external_direct_loopback "  "0 ,1 "
bitfld.long 0 1. " MSP0toMSP1_MSP2toMSP3_MSP4toMSP5_MSP6toMSP7 "  "0 ,1 "
bitfld.long 0 2. " MSP0toMSP2_MSP1toMSP3_MSP4toMSP6_MSP5toMSP7 "  "0 ,1 "
bitfld.long 0 3. " MSP1toMSP2_MSP0toMSP3_MSP4toMSP7_MSP5toMSP6 "  "0 ,1 "
bitfld.long 0 4. " MSP0toMSP4_MSP1toMSP5_MSP2toMSP6_MSP3toMSP7 "  "0 ,1 "
bitfld.long 0 5. " MSP0toMSP5_MSP1toMSP4_MSP2toMSP7_MSP3toMSP6 "  "0 ,1 "
bitfld.long 0 6. " MSP0toMSP6_MSP1toMSP7_MSP2toMSP4_MSP3toMSP5 "  "0 ,1 "
bitfld.long 0 7. " MSP0toMSP7_MSP1toMSP6_MSP2toMSP5_MSP3toMSP4 "  "0 ,1 "
bitfld.long 0 8. " MSP0_SCK_en "  "0 ,1 "
bitfld.long 0 9. " MSP1_SCK_en "  "0 ,1 "
bitfld.long 0 10. " MSP2_SCK_en "  "0 ,1 "
bitfld.long 0 11. " MSP3_SCK_en "  "0 ,1 "
bitfld.long 0 12. " MSP4_SCK_en "  "0 ,1 "
bitfld.long 0 13. " MSP5_SCK_en "  "0 ,1 "
bitfld.long 0 14. " MSP6_SCK_en "  "0 ,1 "
bitfld.long 0 15. " MSP7_SCK_en "  "0 ,1 "
bitfld.long 0 16. " bypass_start "  "0 ,1 "
bitfld.long 0 17. " TFSDIR "  "0 ,1 "
bitfld.long 0 18. " TCKDIR "  "0 ,1 "
bitfld.long 0 19. " soft_reset_msp "  "0 ,1 "
bitfld.long 0 20. " BYPASS01 "  "0 ,1 "
bitfld.long 0 21. " BYPASS03 "  "0 ,1 "
bitfld.long 0 22. " BYPASS13 "  "0 ,1 "
bitfld.long 0 23. " MSP_INTERCO_ENABLE "  "0 ,1 "
bitfld.long 0 24. " MSP_WRMODE_ENABLE "  "0 ,1 "
bitfld.long 0 25. " MSP0_TX "  "0 ,1 "
bitfld.long 0 26. " MSP0_RX "  "0 ,1 "
bitfld.long 0 27. " DDR_PRELOAD "  "0 ,1 "
bitfld.long 0 28. " ulpi_write "  "0 ,1 "
bitfld.long 0 29. " MSP4ACTIVE "  "0 ,1 "
;tree.end

;tree "OUT_REG1"
base ad:0x63f80004
group 0--3
line.long 0 "OUT_REG1"
bitfld.long 0 0. " I2C0toI2C1_I2C2toI2C3 "  "0 ,1 "
bitfld.long 0 1. " I2C0toI2C2_I2C1toI2C3 "  "0 ,1 "
bitfld.long 0 2. " I2C0toI2C3_I2C1toI2C2 "  "0 ,1 "
bitfld.long 0 3. " MSHC_gpio_out_select "  "0 ,1 "
bitfld.long 0 4. " MSHC_insertion_card_emulation "  "0 ,1 "
bitfld.long 0 5. " I2CMODEMtoI2C1 "  "0 ,1 "
bitfld.long 0 6. " I2C0toI2C4_I2C1toI2C2 "  "0 ,1 "
;tree.end

;tree "OUT_REG2"
base ad:0x63f80008
group 0--3
line.long 0 "OUT_REG2"
bitfld.long 0 0. " START_WAKEUP "  "0 ,1 "
bitfld.long 0 1. " WAKE_UP_MODE "  "0 ,1 "
bitfld.long 0 2.--5. " GPIO_BANK "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--10. " GPIO_NUMBER "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "OUT_REG3"
base ad:0x63f8000c
group 0--3
line.long 0 "OUT_REG3"
bitfld.long 0 0. " TAIMODE "  "0 ,1 "
bitfld.long 0 1. " SSP0_to_TAI_or_SSP0Trickbox "  "0 ,1 "
bitfld.long 0 2. " SimCard_StartToSend "  "0 ,1 "
bitfld.long 0 3.--4. " Slim_am_cmd "  "0 ,1 ,2 ,3 "
bitfld.long 0 5.--6. " Slim_af_cmd "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " sig_force_rst "  "0 ,1 "
;tree.end

;tree "OUT_REG4"
base ad:0x63f80010
group 0--3
line.long 0 "OUT_REG4"
bitfld.long 0 0.--12. " USB_CTRL "  " "
bitfld.long 0 13. " SEL_DSI1 "  "0 ,1 "
bitfld.long 0 15. " HDMI_Conf_34 "  "0 ,1 "
bitfld.long 0 16. " HDMI_en "  "0 ,1 "
bitfld.long 0 17.--19. " DBI2_READ_sel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--21. " CS_path "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--24. " TE_path "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 25. " TV_CKB_en "  "0 ,1 "
bitfld.long 0 26. " TV_CKA_en "  "0 ,1 "
bitfld.long 0 27. " DPI2_flow_en "  "0 ,1 "
bitfld.long 0 28. " WAITn_sel "  "0 ,1 "
bitfld.long 0 29. " FSMC_TEST "  "0 ,1 "
bitfld.long 0 30. " RAM_EN "  "0 ,1 "
bitfld.long 0 31. " NOR_DIS "  "0 ,1 "
;tree.end

;tree "OUT_REG5"
base ad:0x63f80014
group 0--3
line.long 0 "OUT_REG5"
bitfld.long 0 0. " hsitb_select "  "0 ,1 "
bitfld.long 0 1. " hsitb_frame_mode "  "0 ,1 "
bitfld.long 0 2. " hsitb_break_send "  "0 ,1 "
bitfld.long 0 3. " dsi_clk_div4_en "  "0 ,1 "
bitfld.long 0 4. " dsi_clk_div2_en "  "0 ,1 "
bitfld.long 0 5. " dsi_clk_en "  "0 ,1 "
bitfld.long 0 6. " dsi_esc_mcdeclk "  "0 ,1 "
bitfld.long 0 7. " dsi_esc_clk27 "  "0 ,1 "
bitfld.long 0 8. " CKA_27M_INT "  "0 ,1 "
;tree.end

;tree "OUT_REG6"
base ad:0x63f80018
group 0--3
line.long 0 "OUT_REG6"
bitfld.long 0 0. " SD_MMCARD_SEL0 "  "0 ,1 "
bitfld.long 0 1. " SD_MMCARD_SEL1 "  "0 ,1 "
bitfld.long 0 2. " SD_MMCARD_SEL2 "  "0 ,1 "
bitfld.long 0 3. " SD_MMCARD_SEL3 "  "0 ,1 "
bitfld.long 0 4. " SD_MMCARD_SEL4 "  "0 ,1 "
bitfld.long 0 5. " SD_MMCARD_SEL5 "  "0 ,1 "
bitfld.long 0 6. " MMCI0_LEVEL_SHIFTER_EN "  "0 ,1 "
bitfld.long 0 7. " MMCI1_LEVEL_SHIFTER_EN "  "0 ,1 "
bitfld.long 0 8. " MMCI2_LEVEL_SHIFTER_EN "  "0 ,1 "
bitfld.long 0 9. " MMCI3_LEVEL_SHIFTER_EN "  "0 ,1 "
bitfld.long 0 10. " MMCI4_LEVEL_SHIFTER_EN "  "0 ,1 "
bitfld.long 0 11. " MMCI5_LEVEL_SHIFTER_EN "  "0 ,1 "
bitfld.long 0 12. " eMMCARD_SEL0 "  "0 ,1 "
bitfld.long 0 13. " eMMCARD_SEL1 "  "0 ,1 "
bitfld.long 0 14. " eMMCARD_SEL2 "  "0 ,1 "
bitfld.long 0 15. " eMMCARD_SEL3 "  "0 ,1 "
bitfld.long 0 16. " eMMCARD_SEL4 "  "0 ,1 "
bitfld.long 0 17. " eMMCARD_SEL5 "  "0 ,1 "
bitfld.long 0 18.--19. " Boot_strap_test "  "0 ,1 ,2 ,3 "
;tree.end

;tree "OUT_REG7"
base ad:0x63f8001c
group 0--3
line.long 0 "OUT_REG7"
hexfld.long 0 " OUT_REG8 "
;tree.end

;tree "OUT_REG8"
base ad:0x63f80020
group 0--3
line.long 0 "OUT_REG8"
bitfld.long 0 0. " fsmc_wprot_test "  "0 ,1 "
bitfld.long 0 1. " Onenand_CS0_en "  "0 ,1 "
bitfld.long 0 26. " SK_en_n "  "0 ,1 "
bitfld.long 0 27. " SK_0_2 "  "0 ,1 "
bitfld.long 0 28. " SK_1_2 "  "0 ,1 "
bitfld.long 0 29. " KBETM_SK_b "  "0 ,1 "
bitfld.long 0 30. " KBETM_I_74 "  "0 ,1 "
bitfld.long 0 31. " KBETM_I_c "  "0 ,1 "
;tree.end

;tree "OUT_REG9"
base ad:0x63f80024
group 0--3
line.long 0 "OUT_REG9"
bitfld.long 0 0. " hamaca_jtag "  "0 ,1 "
bitfld.long 0 1. " hamaca_i2c "  "0 ,1 "
bitfld.long 0 2. " hamaca_nexus "  "0 ,1 "
bitfld.long 0 3. " GPIO0_i_nexus_tb "  "0 ,1 "
bitfld.long 0 4. " GPIO1_i_nexus_tb "  "0 ,1 "
bitfld.long 0 5. " GPIO2_i_nexus_tb "  "0 ,1 "
bitfld.long 0 6. " GPIO3_i_nexus_tb "  "0 ,1 "
bitfld.long 0 7. " GPIO4_i_nexus_tb "  "0 ,1 "
bitfld.long 0 8. " GPIO5_i_nexus_tb "  "0 ,1 "
bitfld.long 0 9. " GPIO6_i_nexus_tb "  "0 ,1 "
bitfld.long 0 10. " GPIO7_i_nexus_tb "  "0 ,1 "
bitfld.long 0 11.--14. " power_mode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 15. " start_jtag "  "0 ,1 "
;tree.end

;tree "OUT_REG10"
base ad:0x63f80028
group 0--3
line.long 0 "OUT_REG10"
bitfld.long 0 0. " I2C_touareg_select "  "0 ,1 "
bitfld.long 0 1. " VSC_touareg_select "  "0 ,1 "
bitfld.long 0 2. " SPI_touareg_select "  "0 ,1 "
bitfld.long 0 3. " AUDIO_touareg_select "  "0 ,1 "
bitfld.long 0 4. " USB_touareg_select "  "0 ,1 "
;tree.end

;tree "OUT_REG11"
base ad:0x63f8002c
group 0--3
line.long 0 "OUT_REG11"
bitfld.long 0 0. " DbgAck_force "  "0 ,1 "
;tree.end

;tree "OUT_REG12"
base ad:0x63f80030
group 0--3
line.long 0 "OUT_REG12"
bitfld.long 0 0. " CCx_start "  "0 ,1 "
bitfld.long 0 1. " CCP_enable "  "0 ,1 "
bitfld.long 0 2. " CCx_mode "  "0 ,1 "
bitfld.long 0 3. " CCx_ds "  "0 ,1 "
bitfld.long 0 4. " CCx_ext_type "  "0 ,1 "
bitfld.long 0 5. " CCx_ext_sync_en "  "0 ,1 "
bitfld.long 0 6. " CCx_ext_camera_format "  "0 ,1 "
bitfld.long 0 7. " CCP0_select "  "0 ,1 "
bitfld.long 0 8. " CCP1_select "  "0 ,1 "
bitfld.long 0 9. " CCIR_10BITS "  "0 ,1 "
bitfld.long 0 10. " CCIR_enable "  "0 ,1 "
bitfld.long 0 11. " CSI_enable "  "0 ,1 "
bitfld.long 0 12. " CSI_start "  "0 ,1 "
bitfld.long 0 13. " CSI_double_lane "  "0 ,1 "
bitfld.long 0 14.--16. " CSI_rate "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17. " CSI_multiple_frames "  "0 ,1 "
bitfld.long 0 18. " S850_XSHUTDOWN "  "0 ,1 "
bitfld.long 0 19. " S850_select "  "0 ,1 "
bitfld.long 0 20. " CCIR_12BITS_enable "  "0 ,1 "
bitfld.long 0 21. " CCIR_12BITS_start "  "0 ,1 "
bitfld.long 0 22. " CCIR_connection "  "0 ,1 "
bitfld.long 0 23. " CCIR_12BITS_clock_enable "  "0 ,1 "
;tree.end

;tree "OUT_REG13"
base ad:0x63f80034
group 0--3
line.long 0 "OUT_REG13"
bitfld.long 0 0. " tbjtag_tapsel "  "0 ,1 "
bitfld.long 0 1. " tbjtag_dbgcfg "  "0 ,1 "
bitfld.long 0 2. " tbjtag_pmu_swsr4 "  "0 ,1 "
bitfld.long 0 3. " tbjtag_arm_not_mmdsp "  "0 ,1 "
bitfld.long 0 4. " MainJtagPort_Sel "  "0 ,1 "
;tree.end

;tree "OUT_REG14"
base ad:0x63f80038
group 0--3
line.long 0 "OUT_REG14"
hexfld.long 0 " OUT_REG14 "
;tree.end

;tree "OUT_REG15"
base ad:0x63f8003c
group 0--3
line.long 0 "OUT_REG15"
bitfld.long 0 0.--3. " REG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "OUT_REG16"
base ad:0x63f80040
group 0--3
line.long 0 "OUT_REG16"
bitfld.long 0 0. " I2C_HILLMAN_select "  "0 ,1 "
bitfld.long 0 1. " Register0_HILLMAN "  "0 ,1 "
;tree.end

;tree "OUT_REG17"
base ad:0x63f80044
group 0--3
line.long 0 "OUT_REG17"
bitfld.long 0 0.--2. " KPO_89_70 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " KPI_SKAx_SKBx "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6. " KPO_89 "  "0 ,1 "
bitfld.long 0 7. " SK_xx "  "0 ,1 "
bitfld.long 0 8. " MS_LEVEL_SHIFTER_EN "  "0 ,1 "
bitfld.long 0 9. " CLOCKS_MONITOR_EN "  "0 ,1 "
bitfld.long 0 10. " CM_WDG_CLK_32K_S0 "  "0 ,1 "
bitfld.long 0 11. " CM_WDG_CLK_32K_S1 "  "0 ,1 "
bitfld.long 0 12. " CM_WDG_CLK_10hz "  "0 ,1 "
bitfld.long 0 13. " CM_DDR_CLK_532M "  "0 ,1 "
bitfld.long 0 14. " CM_DDR_CLK_266M "  "0 ,1 "
bitfld.long 0 15. " CM_DDR_CLK_133M "  "0 ,1 "
bitfld.long 0 16. " CM_DDR1_CLK_532M "  "0 ,1 "
bitfld.long 0 17. " CM_DDR1_CLK_266M "  "0 ,1 "
bitfld.long 0 18. " CM_DDR1_CLK_133M "  "0 ,1 "
;tree.end

;tree "OUT_REG18"
base ad:0x63f80048
group 0--3
line.long 0 "OUT_REG18"
bitfld.long 0 0. " bfm_csi20_en "  "0 ,1 "
bitfld.long 0 1. " bfm_csi21_en "  "0 ,1 "
bitfld.long 0 2. " bfm_csi20_select "  "0 ,1 "
bitfld.long 0 3. " bfm_csi21_select "  "0 ,1 "
;tree.end

;tree "OUT_REG19"
base ad:0x63f8004c
group 0--3
line.long 0 "OUT_REG19"
bitfld.long 0 0. " jtag_dap_Start "  "0 ,1 "
bitfld.long 0 1. " XTI_STM_Enable "  "0 ,1 "
bitfld.long 0 2. " StartToSend "  "0 ,1 "
bitfld.long 0 3. " PwrCtrl0 "  "0 ,1 "
bitfld.long 0 4. " Mux_Linko_Rx_Pin "  "0 ,1 "
bitfld.long 0 5. " Rf_Strobe_en "  "0 ,1 "
bitfld.long 0 6. " APECLK_dis "  "0 ,1 "
bitfld.long 0 7. " SYSCLK_dis "  "0 ,1 "
bitfld.long 0 8. " rf_chipset_sel "  "0 ,1 "
bitfld.long 0 9. " XTI_tb_reset "  "0 ,1 "
bitfld.long 0 10.--13. " XTI_ASR001_select "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14. " SBAG_select "  "0 ,1 "
;tree.end

;tree "OUT_REG20"
base ad:0x63f80050
group 0--3
line.long 0 "OUT_REG20"
bitfld.long 0 0. " dd_c2c_sscm_fsm_enable "  "0 ,1 "
bitfld.long 0 1. " dd_c2c_ddr_req "  "0 ,1 "
bitfld.long 0 2. " dd_c2c_ddr_latency "  "0 ,1 "
bitfld.long 0 3. " c2c_test_mode "  "0 ,1 "
bitfld.long 0 4. " gpio_linko_sel "  "0 ,1 "
;tree.end

;tree "IN_REG0"
base ad:0x63f80400
group 0--3
line.long 0 "IN_REG0"
hexfld.long 0 " PWL_STATISTIC "
;tree.end

;tree "IN_REG1"
base ad:0x63f80404
group 0--3
line.long 0 "IN_REG1"
hexfld.long 0 " GPIO_SLEEP "
;tree.end

;tree "IN_REG2"
base ad:0x63f80408
group 0--3
line.long 0 "IN_REG2"
hexfld.long 0 " IN_REG2 "
;tree.end

;tree "IN_REG3"
base ad:0x63f8040c
group 0--3
line.long 0 "IN_REG3"
bitfld.long 0 0. " comp_status "  "0 ,1 "
;tree.end

;tree "IN_REG4"
base ad:0x63f80410
group 0--3
line.long 0 "IN_REG4"
hexfld.long 0 " IN_REG4 "
;tree.end

;tree "IN_REG5"
base ad:0x63f80414
group 0--3
line.long 0 "IN_REG5"
hexfld.long 0 " IN_REG5 "
;tree.end

;tree "IN_REG6"
base ad:0x63f80418
group 0--3
line.long 0 "IN_REG6"
hexfld.long 0 " IN_REG6 "
;tree.end

;tree "IN_REG7"
base ad:0x63f8041c
group 0--3
line.long 0 "IN_REG7"
hexfld.long 0 " IN_REG8 "
;tree.end

;tree "IN_REG8"
base ad:0x63f80420
group 0--3
line.long 0 "IN_REG8"
hexfld.long 0 " IN_REG8 "
;tree.end

;tree "IN_REG9"
base ad:0x63f80424
group 0--3
line.long 0 "IN_REG9"
hexfld.long 0 " IN_REG9 "
;tree.end

;tree "IN_REG10"
base ad:0x63f80428
group 0--3
line.long 0 "IN_REG10"
hexfld.long 0 " IN_REG10 "
;tree.end

;tree "IN_REG11"
base ad:0x63f8042c
group 0--3
line.long 0 "IN_REG11"
hexfld.long 0 " IN_REG11 "
;tree.end

;tree "IN_REG12"
base ad:0x63f80430
group 0--3
line.long 0 "IN_REG12"
hexfld.long 0 " IN_REG12 "
;tree.end

;tree "IN_REG13"
base ad:0x63f80434
group 0--3
line.long 0 "IN_REG13"
hexfld.long 0 " IN_REG13 "
;tree.end

;tree "IN_REG14"
base ad:0x63f80438
group 0--3
line.long 0 "IN_REG14"
hexfld.long 0 " IN_REG14 "
;tree.end

;tree "IN_REG15"
base ad:0x63f8043c
group 0--3
line.long 0 "IN_REG15"
bitfld.long 0 5. " OUT "  "0 ,1 "
bitfld.long 0 6. " ENOUT "  "0 ,1 "
;tree.end

;tree "IN_REG16"
base ad:0x63f80440
group 0--3
line.long 0 "IN_REG16"
hexfld.long 0 " IN_REG16 "
;tree.end

;tree "IN_REG17"
base ad:0x63f80444
group 0--3
line.long 0 "IN_REG17"
hexfld.long 0 " IN_REG17 "
;tree.end

;tree "IN_REG18"
base ad:0x63f80448
group 0--3
line.long 0 "IN_REG18"
hexfld.long 0 " IN_REG18 "
;tree.end

;tree "IN_REG19"
base ad:0x63f8044c
group 0--3
line.long 0 "IN_REG19"
hexfld.long 0 " IN_REG19 "
;tree.end

;tree "IN_REG20"
base ad:0x63f80450
group 0--3
line.long 0 "IN_REG20"
hexfld.long 0 " IN_REG20 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "RNG"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CR"
base ad:0xa03c0000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SEC "  "0 ,1 "
bitfld.long 0 1. " PRIV "  "0 ,1 "
bitfld.long 0 2. " RNGDIS "  "0 ,1 "
bitfld.long 0 3. " TSTCLK "  "0 ,1 "
;tree.end

;tree "SR"
base ad:0xa03c0004
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RNGRDY "  "0 ,1 "
bitfld.long 0 1. " REVCLK "  "0 ,1 "
bitfld.long 0 2. " FAULT "  "0 ,1 "
;tree.end

;tree "VAL"
base ad:0xa03c0008
group 0--3
line.long 0 "VAL"
bitfld.long 0 0. " 16 "  "0 ,1 "
;tree.end

;tree "ITCR"
base ad:0xa03c0080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITIP"
base ad:0xa03c0084
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
;tree.end

;tree "PeriphID0"
base ad:0xa03c0fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PeriphID1"
base ad:0xa03c0fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0xa03c0fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0xa03c0fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0xa03c0ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

;tree "PCellID1"
base ad:0xa03c0ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

;tree "PCellID2"
base ad:0xa03c0ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

;tree "PCellID3"
base ad:0xa03c0ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "RTC"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "DR"
base ad:0x80154000
rgroup 0--3
line.long 0 "DR"
bitfld.long 0 0.--5. " CWSEC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " WMIN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--16. " CWHOUR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 17.--19. " CWDAYW "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--24. " CWDAYM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--28. " CWMONTH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "MR"
base ad:0x80154004
group 0--3
line.long 0 "MR"
bitfld.long 0 0.--5. " CWSECM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " WMINM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--16. " CWHOURM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 17.--19. " CWDAYWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--24. " CWDAYMM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--28. " CWMONTHM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "LR"
base ad:0x80154008
group 0--3
line.long 0 "LR"
bitfld.long 0 0.--5. " CWSECL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--11. " WMINL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--16. " CWHOURL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 17.--19. " CWDAYWL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--24. " CWDAYML "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 25.--28. " CWMONTHL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "TCR"
base ad:0x8015400c
group 0--3
line.long 0 "TCR"
hexfld.word 0 " CKDIV "
bitfld.long 0 16.--25. " CKDEL "  " "
bitfld.long 0 26. " RTCEN "  "0 ,1 "
bitfld.long 0 27. " SEC "  "0 ,1 "
;tree.end

;tree "IMSC"
base ad:0x80154010
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTCIMSC "  "0 ,1 "
bitfld.long 0 1. " RTTIMSC "  "0 ,1 "
;tree.end

;tree "RIS"
base ad:0x80154014
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTCRIS "  "0 ,1 "
bitfld.long 0 1. " RTTRIS "  "0 ,1 "
;tree.end

;tree "MIS"
base ad:0x80154018
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTCMIS "  "0 ,1 "
bitfld.long 0 1. " RTTMIS "  "0 ,1 "
;tree.end

;tree "ICR"
base ad:0x8015401c
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTCIC "  "0 ,1 "
bitfld.long 0 1. " RTTIC "  "0 ,1 "
;tree.end

;tree "RTT_DR"
base ad:0x80154020
group 0--3
line.long 0 "RTT_DR"
hexfld.long 0 " Data "
;tree.end

;tree "RTT_LR1"
base ad:0x80154024
group 0--3
line.long 0 "RTT_LR1"
hexfld.long 0 " Load "
;tree.end

;tree "RTT_LR2"
base ad:0x8015402c
group 0--3
line.long 0 "RTT_LR2"
hexfld.long 0 " Load "
;tree.end

;tree "RTT_PR1"
base ad:0x8015403c
group 0--3
line.long 0 "RTT_PR1"
hexfld.long 0 " Load "
;tree.end

;tree "RTT_PR2"
base ad:0x80154040
group 0--3
line.long 0 "RTT_PR2"
hexfld.long 0 " Load "
;tree.end

;tree "RTT_PR3"
base ad:0x80154044
group 0--3
line.long 0 "RTT_PR3"
hexfld.long 0 " Load "
;tree.end

;tree "RTT_PR4"
base ad:0x80154048
group 0--3
line.long 0 "RTT_PR4"
hexfld.long 0 " Load "
;tree.end

;tree "IN"
base ad:0x8015404c
rgroup 0--3
line.long 0 "IN"
hexfld.long 0 " TINTERRUPT "
;tree.end

;tree "WK"
base ad:0x80154050
group 0--3
line.long 0 "WK"
hexfld.long 0 " TINTERRUPT "
;tree.end

;tree "SMIN"
base ad:0x80154054
rgroup 0--3
line.long 0 "SMIN"
hexfld.long 0 " SINTERRUPT "
;tree.end

;tree "RTT_CR"
base ad:0x80154028
group 0--3
line.long 0 "RTT_CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
bitfld.long 0 2. " RTTSS "  "0 ,1 "
bitfld.long 0 3. " RTTSM "  "0 ,1 "
bitfld.long 0 4.--10. " RTTPS "  " "
bitfld.long 0 11. " RTTCLK "  "0 ,1 "
;tree.end

;tree "YR"
base ad:0x80154030
rgroup 0--3
line.long 0 "YR"
bitfld.long 0 0.--13. " CWYEAR "  " "
;tree.end

;tree "YMR"
base ad:0x80154034
group 0--3
line.long 0 "YMR"
bitfld.long 0 0.--13. " CWYEARM "  " "
;tree.end

;tree "YLR"
base ad:0x80154038
group 0--3
line.long 0 "YLR"
bitfld.long 0 0.--13. " CWYEARL "  " "
;tree.end

;tree "ITCR"
base ad:0x80154080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTCNT "  "0 ,1 "
;tree.end

;tree "ITIP"
base ad:0x80154084
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
;tree.end

;tree "ITOP"
base ad:0x80154088
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTCINTR "  "0 ,1 "
bitfld.long 0 1. " RTCWKUP "  "0 ,1 "
bitfld.long 0 2. " PWLOUT "  "0 ,1 "
bitfld.long 0 3. " RTTINTR "  "0 ,1 "
bitfld.long 0 4. " RTTWKUP "  "0 ,1 "
;tree.end

;tree "PeriphID0"
base ad:0x80154fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PeriphID1"
base ad:0x80154fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0x80154fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0x80154fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0x80154ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " RTCPCellID0 "
;tree.end

;tree "PCellID1"
base ad:0x80154ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " RTCPCellID1 "
;tree.end

;tree "PCellID2"
base ad:0x80154ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " RTCPCellID2 "
;tree.end

;tree "PCellID3"
base ad:0x80154ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " RTCPCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "RTT0"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CTCR"
base ad:0x80152000
group 0--3
line.long 0 "CTCR"
hexfld.word 0 " CKDIV "
;tree.end

;tree "IMSC"
base ad:0x80152004
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTTIMSC "  "0 ,1 "
;tree.end

;tree "RIS"
base ad:0x80152008
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTTRIS "  "0 ,1 "
;tree.end

;tree "MIS"
base ad:0x8015200c
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTTMIS "  "0 ,1 "
;tree.end

;tree "ICR"
base ad:0x80152010
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTTIC "  "0 ,1 "
;tree.end

;tree "DR"
base ad:0x80152014
group 0--3
line.long 0 "DR"
hexfld.long 0 " Data "
;tree.end

;tree "LR"
base ad:0x80152018
group 0--3
line.long 0 "LR"
hexfld.long 0 " Load "
;tree.end

;tree "CR"
base ad:0x8015201c
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
bitfld.long 0 2. " RTTENS "  "0 ,1 "
;tree.end

;tree "ITCR"
base ad:0x80152080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITOP"
base ad:0x80152084
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTTINTR "  "0 ,1 "
bitfld.long 0 1. " RTTWKUP "  "0 ,1 "
;tree.end

;tree "PeriphID0"
base ad:0x80152fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PeriphID1"
base ad:0x80152fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0x80152fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0x80152fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0x80152ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " RTCPCellID0 "
;tree.end

;tree "PCellID1"
base ad:0x80152ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " RTCPCellID1 "
;tree.end

;tree "PCellID2"
base ad:0x80152ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " RTCPCellID2 "
;tree.end

;tree "PCellID3"
base ad:0x80152ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " RTCPCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "RTT1"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CTCR"
base ad:0x80153000
group 0--3
line.long 0 "CTCR"
hexfld.word 0 " CKDIV "
;tree.end

;tree "IMSC"
base ad:0x80153004
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTTIMSC "  "0 ,1 "
;tree.end

;tree "RIS"
base ad:0x80153008
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTTRIS "  "0 ,1 "
;tree.end

;tree "MIS"
base ad:0x8015300c
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTTMIS "  "0 ,1 "
;tree.end

;tree "ICR"
base ad:0x80153010
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTTIC "  "0 ,1 "
;tree.end

;tree "DR"
base ad:0x80153014
group 0--3
line.long 0 "DR"
hexfld.long 0 " Data "
;tree.end

;tree "LR"
base ad:0x80153018
group 0--3
line.long 0 "LR"
hexfld.long 0 " Load "
;tree.end

;tree "CR"
base ad:0x8015301c
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
bitfld.long 0 2. " RTTENS "  "0 ,1 "
;tree.end

;tree "ITCR"
base ad:0x80153080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITOP"
base ad:0x80153084
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTTINTR "  "0 ,1 "
bitfld.long 0 1. " RTTWKUP "  "0 ,1 "
;tree.end

;tree "PeriphID0"
base ad:0x80153fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PeriphID1"
base ad:0x80153fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0x80153fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0x80153fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0x80153ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " RTCPCellID0 "
;tree.end

;tree "PCellID1"
base ad:0x80153ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " RTCPCellID1 "
;tree.end

;tree "PCellID2"
base ad:0x80153ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " RTCPCellID2 "
;tree.end

;tree "PCellID3"
base ad:0x80153ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " RTCPCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "SCR"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CR"
base ad:0x80155000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " APEDBGEN0 "  "0 ,1 "
bitfld.long 0 1. " APENIDEN0 "  "0 ,1 "
bitfld.long 0 2. " APESPNIDEN0 "  "0 ,1 "
bitfld.long 0 3. " APESPIDEN0 "  "0 ,1 "
bitfld.long 0 4. " APEDBGEN1 "  "0 ,1 "
bitfld.long 0 5. " APENIDEN1 "  "0 ,1 "
bitfld.long 0 6. " APESPNIDEN1 "  "0 ,1 "
bitfld.long 0 7. " APESPIDEN1 "  "0 ,1 "
bitfld.long 0 8. " TOPDBGEN "  "0 ,1 "
bitfld.long 0 9. " MCSBAGEN "  "0 ,1 "
bitfld.long 0 10. " APESTRCEN "  "0 ,1 "
bitfld.long 0 11. " APESTMEN "  "0 ,1 "
bitfld.long 0 12. " SIADBGEN "  "0 ,1 "
bitfld.long 0 13. " TOPAPEDBGEN "  "0 ,1 "
bitfld.long 0 14. " SPRSTEN0 "  "0 ,1 "
bitfld.long 0 15. " SPRSTEN1 "  "0 ,1 "
bitfld.long 0 16. " PRCMUDBGEn "  "0 ,1 "
bitfld.long 0 17. " SFRDIS "  "0 ,1 "
bitfld.long 0 18. " CRRSTEN "  "0 ,1 "
bitfld.long 0 23. " MODEMDIS "  "0 ,1 "
bitfld.long 0 24. " FBVALDIS "  "0 ,1 "
bitfld.long 0 25. " SCRDAF "  "0 ,1 "
bitfld.long 0 26. " SWDGCLK "  "0 ,1 "
bitfld.long 0 27. " APECLKSW "  "0 ,1 "
bitfld.long 0 28. " cJTAGEn "  "0 ,1 "
bitfld.long 0 29. " REMAPDIS "  "0 ,1 "
bitfld.long 0 30. " SECMODDIS "  "0 ,1 "
bitfld.long 0 31. " OPENDEVn "  "0 ,1 "
;tree.end

;tree "WDR"
base ad:0x80155004
rgroup 0--3
line.long 0 "WDR"
hexfld.long 0 " SWDTVAL "
;tree.end

;tree "WLR"
base ad:0x80155008
group 0--3
line.long 0 "WLR"
hexfld.long 0 " SWDTLOAD "
;tree.end

;tree "WCR"
base ad:0x8015500c
group 0--3
line.long 0 "WCR"
bitfld.long 0 0. " SWDTDIS "  "0 ,1 "
bitfld.long 0 1. " SWDTLDIS "  "0 ,1 "
;tree.end

;tree "FVR0"
base ad:0x80155010
rgroup 0--3
line.long 0 "FVR0"
hexfld.long 0 " FUSE0_VALUE "
;tree.end

;tree "FVR1"
base ad:0x80155014
rgroup 0--3
line.long 0 "FVR1"
hexfld.long 0 " FUSE1_VALUE "
;tree.end

;tree "FVR2"
base ad:0x80155018
rgroup 0--3
line.long 0 "FVR2"
hexfld.long 0 " FUSE2_VALUE "
;tree.end

;tree "FVR3"
base ad:0x8015501c
rgroup 0--3
line.long 0 "FVR3"
hexfld.long 0 " FUSE3_VALUE "
;tree.end

;tree "FVR4"
base ad:0x80155020
rgroup 0--3
line.long 0 "FVR4"
hexfld.long 0 " FUSE4_VALUE "
;tree.end

;tree "FVR5"
base ad:0x80155024
rgroup 0--3
line.long 0 "FVR5"
hexfld.long 0 " FUSE5_VALUE "
;tree.end

;tree "FVR6"
base ad:0x80155028
rgroup 0--3
line.long 0 "FVR6"
hexfld.long 0 " FUSE6_VALUE "
;tree.end

;tree "FVR7"
base ad:0x8015502c
rgroup 0--3
line.long 0 "FVR7"
hexfld.long 0 " FUSE7_VALUE "
;tree.end

;tree "FVR8"
base ad:0x80155030
rgroup 0--3
line.long 0 "FVR8"
hexfld.long 0 " FUSE8_VALUE "
;tree.end

;tree "FVR9"
base ad:0x80155034
rgroup 0--3
line.long 0 "FVR9"
hexfld.long 0 " FUSE9_VALUE "
;tree.end

;tree "FVR10"
base ad:0x80155038
rgroup 0--3
line.long 0 "FVR10"
hexfld.long 0 " FUSE10_VALUE "
;tree.end

;tree "FVR11"
base ad:0x8015503c
rgroup 0--3
line.long 0 "FVR11"
hexfld.long 0 " FUSE11_VALUE "
;tree.end

;tree "FVR12"
base ad:0x80155040
rgroup 0--3
line.long 0 "FVR12"
hexfld.long 0 " FUSE12_VALUE "
;tree.end

;tree "FVR13"
base ad:0x80155044
rgroup 0--3
line.long 0 "FVR13"
hexfld.long 0 " FUSE13_VALUE "
;tree.end

;tree "FVR14"
base ad:0x80155048
rgroup 0--3
line.long 0 "FVR14"
hexfld.long 0 " FUSE14_VALUE "
;tree.end

;tree "FVR15"
base ad:0x8015504c
rgroup 0--3
line.long 0 "FVR15"
hexfld.long 0 " FUSE15_VALUE "
;tree.end

;tree "FVR16"
base ad:0x80155050
rgroup 0--3
line.long 0 "FVR16"
hexfld.long 0 " FUSE16_VALUE "
;tree.end

;tree "FVR17"
base ad:0x80155054
rgroup 0--3
line.long 0 "FVR17"
hexfld.long 0 " FUSE17_VALUE "
;tree.end

;tree "FVR18"
base ad:0x80155058
rgroup 0--3
line.long 0 "FVR18"
hexfld.long 0 " FUSE18_VALUE "
;tree.end

;tree "FVR19"
base ad:0x8015505c
rgroup 0--3
line.long 0 "FVR19"
hexfld.long 0 " FUSE19_VALUE "
;tree.end

;tree "FVR20"
base ad:0x80155060
rgroup 0--3
line.long 0 "FVR20"
hexfld.long 0 " FUSE20_VALUE "
;tree.end

;tree "FVR21"
base ad:0x80155064
rgroup 0--3
line.long 0 "FVR21"
hexfld.long 0 " FUSE21_VALUE "
;tree.end

;tree "FVR22"
base ad:0x80155068
rgroup 0--3
line.long 0 "FVR22"
hexfld.long 0 " FUSE22_VALUE "
;tree.end

;tree "FVR23"
base ad:0x8015506c
rgroup 0--3
line.long 0 "FVR23"
hexfld.long 0 " FUSE23_VALUE "
;tree.end

;tree "SRAMPROT0"
base ad:0x80155070
group 0--3
line.long 0 "SRAMPROT0"
bitfld.long 0 0.--3. " SRAMPROT0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "SRAMPROT1"
base ad:0x80155074
group 0--3
line.long 0 "SRAMPROT1"
bitfld.long 0 0.--3. " SRAMPROT1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "SPR0"
base ad:0x80155090
group 0--3
line.long 0 "SPR0"
hexfld.long 0 " SSPR0 "
;tree.end

;tree "SPR1"
base ad:0x80155094
group 0--3
line.long 0 "SPR1"
hexfld.long 0 " SSPR1 "
;tree.end

;tree "ROSZ"
base ad:0x80155098
group 0--3
line.long 0 "ROSZ"
bitfld.long 0 0.--9. " ROSZ0 "  " "
bitfld.long 0 12.--21. " R0SZ1 "  " "
;tree.end

;tree "DECPROT"
base ad:0x8015509c
group 0--3
line.long 0 "DECPROT"
bitfld.long 0 0.--25. " DECPROT "  " "
;tree.end

;tree "DDRSECLOW"
base ad:0x801550d0
group 0--3
line.long 0 "DDRSECLOW"
hexfld.long 0 " DDRSECLOW "
;tree.end

;tree "DDRSECHIGH"
base ad:0x801550d4
group 0--3
line.long 0 "DDRSECHIGH"
hexfld.long 0 " DDRSECHIGH "
;tree.end

;tree "DDRA9LOW"
base ad:0x801550d8
group 0--3
line.long 0 "DDRA9LOW"
hexfld.long 0 " DDRA9LOW "
;tree.end

;tree "DDRA9HIGH"
base ad:0x801550dc
group 0--3
line.long 0 "DDRA9HIGH"
hexfld.long 0 " DDRA9HIGH "
;tree.end

;tree "DDRMODLOW"
base ad:0x801550e0
group 0--3
line.long 0 "DDRMODLOW"
hexfld.long 0 " DDRMODLOW "
;tree.end

;tree "DDRMODHIGH"
base ad:0x801550e4
group 0--3
line.long 0 "DDRMODHIGH"
hexfld.long 0 " DDRMODHIGH "
;tree.end

;tree "DDRSHAREHIGH"
base ad:0x801550e8
group 0--3
line.long 0 "DDRSHAREHIGH"
hexfld.long 0 " DDRSHAREHIGH "
;tree.end

;tree "DDRMAXSPACE"
base ad:0x801550ec
group 0--3
line.long 0 "DDRMAXSPACE"
hexfld.long 0 " DDRMAXSPACE "
;tree.end

;tree "FUSECRC"
base ad:0x801550b0
group 0--3
line.long 0 "FUSECRC"
hexfld.byte 0 " CRC0 "
hexfld.byte 1 " CRC1 "
hexfld.byte 2 " CRC2 "
;tree.end

;tree "INTLV"
base ad:0x801550b4
group 0--3
line.long 0 "INTLV"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 1.--5. " PAGESIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6.--11. " ENDADD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 12.--17. " STARTADD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "SCRBCTRL"
base ad:0x801550c0
group 0--3
line.long 0 "SCRBCTRL"
bitfld.long 0 0. " SCRBEN "  "0 ,1 "
;tree.end

;tree "SCRBKEY_L"
base ad:0x801550c4
group 0--3
line.long 0 "SCRBKEY_L"
hexfld.long 0 " SCRAMBLE_KEY "
;tree.end

;tree "SCRBKEY_H"
base ad:0x801550c8
group 0--3
line.long 0 "SCRBKEY_H"
hexfld.long 0 " SCRAMBLE_KEY "
;tree.end

;tree "MODEM_CR"
base ad:0x80155100
group 0--3
line.long 0 "MODEM_CR"
bitfld.long 0 0. " DBGEN "  "0 ,1 "
bitfld.long 0 1. " NIDEN "  "0 ,1 "
bitfld.long 0 2. " SPNIDEN "  "0 ,1 "
bitfld.long 0 3. " SPIDEN "  "0 ,1 "
bitfld.long 0 10. " STRCEN "  "0 ,1 "
bitfld.long 0 11. " STMDIS "  "0 ,1 "
bitfld.long 0 13. " TOPDBGEN "  "0 ,1 "
bitfld.long 0 16. " TXDIS "  "0 ,1 "
;tree.end

;tree "PeriphID0"
base ad:0x80155fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PeriphID1"
base ad:0x80155fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0x80155fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0x80155fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0x80155ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " PCellID0 "
;tree.end

;tree "PCellID1"
base ad:0x80155ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " PCellID1 "
;tree.end

;tree "PCellID2"
base ad:0x80155ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " PCellID2 "
;tree.end

;tree "PCellID3"
base ad:0x80155ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " PCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "SCTL"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CR"
base ad:0x80158000
group 0--3
line.long 0 "CR"
bitfld.long 0 0.--3. " MODECR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " MODESTATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8. " REMAPCLR "  "0 ,1 "
bitfld.long 0 9. " REMAPSTAT "  "0 ,1 "
bitfld.long 0 16. " RST4820SW "  "0 ,1 "
;tree.end

;tree "IMCR"
base ad:0x80158004
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " ITMDEN "  "0 ,1 "
bitfld.long 0 1.--4. " ITMDCR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "IMSR"
base ad:0x80158008
group 0--3
line.long 0 "IMSR"
bitfld.long 0 0. " ITMDSTAT "  "0 ,1 "
;tree.end

;tree "XTALCR"
base ad:0x8015800c
group 0--3
line.long 0 "XTALCR"
hexfld.word 0 " MXTALTIME "
hexfld.byte 2 " RESET_TEMPO "
bitfld.long 0 24. " SYSCLKDIV0 "  "0 ,1 "
bitfld.long 0 25. " SYSCLKDIV1 "  "0 ,1 "
bitfld.long 0 26.--27. " PERULPDIV "  "0 ,1 ,2 ,3 "
bitfld.long 0 28. " LCDULPDIV "  "0 ,1 "
bitfld.long 0 31. " SCRAL "  "0 ,1 "
;tree.end

;tree "PLL1CR"
base ad:0x80158010
group 0--3
line.long 0 "PLL1CR"
bitfld.long 0 0. " PLL1OVER "  "0 ,1 "
bitfld.long 0 1. " PLL1EN "  "0 ,1 "
bitfld.long 0 2. " PLL1STAT "  "0 ,1 "
bitfld.long 0 8. " PLL1CT "  "0 ,1 "
bitfld.long 0 9. " PLL1LCKCNTEN "  "0 ,1 "
bitfld.long 0 15. " GPIORSTCFG "  "0 ,1 "
hexfld.word 2 " PLL1CKINVAL "
;tree.end

;tree "PLLFR"
base ad:0x80158014
group 0--3
line.long 0 "PLLFR"
bitfld.long 0 0.--2. " PLL1PA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--8. " AUDDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 9.--15. " PLL1D "  " "
bitfld.long 0 16.--18. " PLL2PA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " PHIBEN "  "0 ,1 "
bitfld.long 0 21. " MSP4CLK "  "0 ,1 "
bitfld.long 0 22. " MSP3CLK "  "0 ,1 "
bitfld.long 0 23. " MSP1CLK "  "0 ,1 "
bitfld.long 0 24.--30. " PLL2D "  " "
;tree.end

;tree "RSTSR"
base ad:0x80158018
group 0--3
line.long 0 "RSTSR"
bitfld.long 0 0. " PORRST "  "0 ,1 "
bitfld.long 0 1. " SECRST "  "0 ,1 "
bitfld.long 0 2. " WDTRST "  "0 ,1 "
bitfld.long 0 3. " SOFTRST "  "0 ,1 "
bitfld.long 0 4. " SLEEPRST "  "0 ,1 "
;tree.end

;tree "XDBGEN"
base ad:0x8015801c
group 0--3
line.long 0 "XDBGEN"
bitfld.long 0 0. " ICEEXBRKINE "  "0 ,1 "
bitfld.long 0 1. " ICEHABRKOE "  "0 ,1 "
bitfld.long 0 2. " ICEHVBRKOE "  "0 ,1 "
bitfld.long 0 3. " ICEHIBRKOE "  "0 ,1 "
bitfld.long 0 4. " ICESBAGINTOE "  "0 ,1 "
bitfld.long 0 5. " HAEXBRKINE "  "0 ,1 "
bitfld.long 0 6. " HAICEBRKOE "  "0 ,1 "
bitfld.long 0 7. " HAHVBRKOE "  "0 ,1 "
bitfld.long 0 8. " HAHIBRKOE "  "0 ,1 "
bitfld.long 0 9. " HASBAGINTOE "  "0 ,1 "
bitfld.long 0 10. " HVEXBRKINE "  "0 ,1 "
bitfld.long 0 11. " HVICEBRKOE "  "0 ,1 "
bitfld.long 0 12. " HVHABRKOE "  "0 ,1 "
bitfld.long 0 13. " HVHIBRKOE "  "0 ,1 "
bitfld.long 0 14. " HVSBAGINTOE "  "0 ,1 "
bitfld.long 0 15. " HIEXBRKINE "  "0 ,1 "
bitfld.long 0 16. " HIICEBRKOE "  "0 ,1 "
bitfld.long 0 17. " HIHABRKOE "  "0 ,1 "
bitfld.long 0 18. " HIHVBRKOE "  "0 ,1 "
bitfld.long 0 19. " HISBAGINTOE "  "0 ,1 "
;tree.end

;tree "XDBGAO"
base ad:0x80158020
group 0--3
line.long 0 "XDBGAO"
bitfld.long 0 0. " ICEEXBRKAO "  "0 ,1 "
bitfld.long 0 1. " ICEHABRKAO "  "0 ,1 "
bitfld.long 0 2. " ICEHVBRKAO "  "0 ,1 "
bitfld.long 0 3. " ICEHIBRKAO "  "0 ,1 "
bitfld.long 0 4. " ICESBAGINTAO "  "0 ,1 "
bitfld.long 0 5. " HAEXBRKAO "  "0 ,1 "
bitfld.long 0 6. " HAICEBRKAO "  "0 ,1 "
bitfld.long 0 7. " HAHVBRKAO "  "0 ,1 "
bitfld.long 0 8. " HAHIBRKAO "  "0 ,1 "
bitfld.long 0 9. " HASBAGINTAO "  "0 ,1 "
bitfld.long 0 10. " HVEXBRKAO "  "0 ,1 "
bitfld.long 0 11. " HVICEBRKAO "  "0 ,1 "
bitfld.long 0 12. " HVHABRKAO "  "0 ,1 "
bitfld.long 0 13. " HVHIBRKAO "  "0 ,1 "
bitfld.long 0 14. " HVSBAGINTAO "  "0 ,1 "
bitfld.long 0 15. " HIEXBRKAO "  "0 ,1 "
bitfld.long 0 16. " HIICEBRKAO "  "0 ,1 "
bitfld.long 0 17. " HIHABRKAO "  "0 ,1 "
bitfld.long 0 18. " HIHVBRKAO "  "0 ,1 "
bitfld.long 0 19. " HISBAGINTAO "  "0 ,1 "
;tree.end

;tree "PCKEN0"
base ad:0x80158024
group 0--3
line.long 0 "PCKEN0"
hexfld.long 0 " PCKEN0 "
;tree.end

;tree "PCKDIS0"
base ad:0x80158028
group 0--3
line.long 0 "PCKDIS0"
hexfld.long 0 " PERDIS "
;tree.end

;tree "PCKENSR0"
base ad:0x8015802c
rgroup 0--3
line.long 0 "PCKENSR0"
hexfld.long 0 " PCKENSR0 "
;tree.end

;tree "PCKSR0"
base ad:0x80158030
rgroup 0--3
line.long 0 "PCKSR0"
hexfld.long 0 " PCKSR0 "
;tree.end

;tree "PCKEN1"
base ad:0x80158034
group 0--3
line.long 0 "PCKEN1"
hexfld.long 0 " PCKEN1 "
;tree.end

;tree "PCKDIS1"
base ad:0x80158038
group 0--3
line.long 0 "PCKDIS1"
hexfld.long 0 " PERDIS1 "
;tree.end

;tree "PCKENSR1"
base ad:0x8015803c
rgroup 0--3
line.long 0 "PCKENSR1"
hexfld.long 0 " PCKENSR1 "
;tree.end

;tree "PCKSR1"
base ad:0x80158040
rgroup 0--3
line.long 0 "PCKSR1"
hexfld.long 0 " PCKSR1 "
;tree.end

;tree "CLKOCR"
base ad:0x80158044
group 0--3
line.long 0 "CLKOCR"
bitfld.long 0 0.--5. " CLKODIV0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--8. " CLKOSEL0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--21. " CLKODIV1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--24. " CLKOSEL1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 28. " OSRV_GRP1ORGRP2 "  "0 ,1 "
;tree.end

;tree "PLL2CR"
base ad:0x80158048
group 0--3
line.long 0 "PLL2CR"
bitfld.long 0 0. " PLL2OVER "  "0 ,1 "
bitfld.long 0 1. " PLL2EN "  "0 ,1 "
bitfld.long 0 2. " PLL2STAT "  "0 ,1 "
bitfld.long 0 3.--27. " PLLTIME "  " "
bitfld.long 0 28. " AP1CLKDIVSEL "  "0 ,1 "
bitfld.long 0 29. " AP2CLKDIVSEL "  "0 ,1 "
bitfld.long 0 30. " AP3CLKDIVSEL "  "0 ,1 "
bitfld.long 0 31. " AP4CLKDIVSEL "  "0 ,1 "
;tree.end

;tree "CLKCR"
base ad:0x8015804c
group 0--3
line.long 0 "CLKCR"
bitfld.long 0 0.--4. " LCDDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--9. " PERDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 10.--13. " HSITDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 14.--17. " SYSDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 18.--23. " TVODIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 26.--29. " HSIRDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 30. " TVOSEL "  "0 ,1 "
bitfld.long 0 31. " SYSSEL "  "0 ,1 "
;tree.end

;tree "TCR"
base ad:0x80158050
group 0--3
line.long 0 "TCR"
bitfld.long 0 0. " TENSEL0 "  "0 ,1 "
bitfld.long 0 1. " TENSEL1 "  "0 ,1 "
bitfld.long 0 2. " TENSEL2 "  "0 ,1 "
bitfld.long 0 3. " TENSEL3 "  "0 ,1 "
bitfld.long 0 4. " TENSEL4 "  "0 ,1 "
bitfld.long 0 5. " TENSEL5 "  "0 ,1 "
bitfld.long 0 6. " TENSEL6 "  "0 ,1 "
bitfld.long 0 7. " TENSEL7 "  "0 ,1 "
bitfld.long 0 8. " TENSEL8 "  "0 ,1 "
bitfld.long 0 9. " TENSEL9 "  "0 ,1 "
bitfld.long 0 10. " TENSEL10 "  "0 ,1 "
bitfld.long 0 11. " TENSEL11 "  "0 ,1 "
bitfld.long 0 12. " TENSEL12 "  "0 ,1 "
bitfld.long 0 13. " TENSEL13 "  "0 ,1 "
bitfld.long 0 14. " TENSEL14 "  "0 ,1 "
bitfld.long 0 15. " TENSEL15 "  "0 ,1 "
;tree.end

;tree "PCKEN2"
base ad:0x80158054
group 0--3
line.long 0 "PCKEN2"
hexfld.long 0 " PCKEN2 "
;tree.end

;tree "PCKDIS2"
base ad:0x80158058
group 0--3
line.long 0 "PCKDIS2"
hexfld.long 0 " PCKDIS2 "
;tree.end

;tree "PCKENSR2"
base ad:0x8015805c
rgroup 0--3
line.long 0 "PCKENSR2"
hexfld.long 0 " PCKENSR2 "
;tree.end

;tree "PCKSR2"
base ad:0x80158060
rgroup 0--3
line.long 0 "PCKSR2"
hexfld.long 0 " PCKSR2 "
;tree.end

;tree "DBGCR"
base ad:0x80158064
group 0--3
line.long 0 "DBGCR"
bitfld.long 0 0. " nETMRU "  "0 ,1 "
bitfld.long 0 1. " ETMENE "  "0 ,1 "
bitfld.long 0 2. " ETBSWREN "  "0 ,1 "
bitfld.long 0 3. " SGADBGEN "  "0 ,1 "
bitfld.long 0 4. " SGADBGM "  "0 ,1 "
bitfld.long 0 5.--6. " SGADBGSEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--13. " VLIM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 14. " SYSCLKDIV24 "  "0 ,1 "
bitfld.long 0 15. " DSPCLKDIV12 "  "0 ,1 "
hexfld.word 2 " SGADBGGPIO "
;tree.end

;tree "TGTFV"
base ad:0x80158100
group 0--3
line.long 0 "TGTFV"
bitfld.long 0 0.--2. " P "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--14. " D "  " "
bitfld.long 0 16.--21. " V "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "CRTFV"
base ad:0x80158104
rgroup 0--3
line.long 0 "CRTFV"
bitfld.long 0 0.--2. " P "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--14. " D "  " "
bitfld.long 0 16.--21. " V "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "CLOCKCR1"
base ad:0x80158108
group 0--3
line.long 0 "CLOCKCR1"
bitfld.long 0 0.--4. " ARMCLKFIXPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " ARMCLKFIXPLLSW "  "0 ,1 "
bitfld.long 0 6. " ARMCLKFIX38M_ON "  "0 ,1 "
bitfld.long 0 7. " ARMCLKFIXEN "  "0 ,1 "
bitfld.long 0 8.--12. " ACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " ACLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " ACLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " ACLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " SVAMMDSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " SVAMMDSPCLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " SVAMMDSPCLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " SIAMMDSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " SIAMMDSPCLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " SIAMMDSPCLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " SIAMMDSPCLKEN "  "0 ,1 "
;tree.end

;tree "CLOCKCR2"
base ad:0x8015810c
group 0--3
line.long 0 "CLOCKCR2"
bitfld.long 0 0.--4. " SAAMMDSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " SAAMMDSPCLKPLLSW "  "0 ,1 "
bitfld.long 0 6. " SAAMMDSPCLK38M_ON "  "0 ,1 "
bitfld.long 0 7. " SAAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 8.--12. " SGACLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " SGACLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " SGACLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " SGACLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " UARTCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " UARTCLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " UARTCLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " MSPCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " MSPCLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " MSPCLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " MSPCLKEN "  "0 ,1 "
;tree.end

;tree "CLOCKCR3"
base ad:0x80158110
group 0--3
line.long 0 "CLOCKCR3"
bitfld.long 0 0.--4. " I2CCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " I2CCLKPLLSW "  "0 ,1 "
bitfld.long 0 6. " I2CCLK38M_ON "  "0 ,1 "
bitfld.long 0 7. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 8.--12. " SDMMCCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " SDMMCCLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " SDMMCCLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " SLIMBUSCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " SLIMBUSCLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " SLIMBUSCLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " SLIMBUSCLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " PER1CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " PER1CLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " PER1CLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " PER1CLKEN "  "0 ,1 "
;tree.end

;tree "CLOCKCR4"
base ad:0x80158114
group 0--3
line.long 0 "CLOCKCR4"
bitfld.long 0 0.--4. " PER2CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " PER2CLKPLLSW "  "0 ,1 "
bitfld.long 0 6. " PER2CLK38M_ON "  "0 ,1 "
bitfld.long 0 7. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 8.--12. " PER3CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " PER3CLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " PER3CLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " PER5CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " PER5CLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " PER5CLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " PER6CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " PER6CLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " PER6CLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " PER6CLKEN "  "0 ,1 "
;tree.end

;tree "CLOCKCR5"
base ad:0x80158118
group 0--3
line.long 0 "CLOCKCR5"
bitfld.long 0 0.--4. " PER7CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " PER7CLKPLLSW "  "0 ,1 "
bitfld.long 0 6. " PER7CLK38M_ON "  "0 ,1 "
bitfld.long 0 7. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 8.--12. " LCDCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " LCDCLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " LCDCLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " DSICLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " DSICLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " DSICLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " DSICLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " BMLCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " BMLCLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " BMLCLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " BMLCLKEN "  "0 ,1 "
;tree.end

;tree "CLOCKCR6"
base ad:0x8015811c
group 0--3
line.long 0 "CLOCKCR6"
bitfld.long 0 0.--4. " HSITXCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " HSITXCLKPLLSW "  "0 ,1 "
bitfld.long 0 6. " HSITXCLK38M_ON "  "0 ,1 "
bitfld.long 0 7. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 8.--12. " HSIRXCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " HSIRXCLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " HSIRXCLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " HDMICLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " HDMICLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " HDMICLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " APEATCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " APEATCLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " APEATCLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " APEATCLKEN "  "0 ,1 "
;tree.end

;tree "CLOCKCR7"
base ad:0x80158120
group 0--3
line.long 0 "CLOCKCR7"
bitfld.long 0 0.--4. " GxDEBUGCLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " GxDEBUGCLKPLLSW "  "0 ,1 "
bitfld.long 0 6. " GxDEBUGCLK38M_ON "  "0 ,1 "
bitfld.long 0 7. " GxDEBUGCLKEN "  "0 ,1 "
bitfld.long 0 8.--12. " SPARE1CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 13. " SPARE1CLKPLLSW "  "0 ,1 "
bitfld.long 0 14. " SPARE1CLK38M_ON "  "0 ,1 "
bitfld.long 0 15. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 16.--20. " SPARE2CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21. " SPARE2CLKPLLSW "  "0 ,1 "
bitfld.long 0 22. " SPARE2CLK38M_ON "  "0 ,1 "
bitfld.long 0 23. " SPARE2CLKEN "  "0 ,1 "
bitfld.long 0 24.--28. " SPARE3CLKPLLDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 29. " SPARE3CLKPLLSW "  "0 ,1 "
bitfld.long 0 30. " SPARE3CLK38M_ON "  "0 ,1 "
bitfld.long 0 31. " SPARE3CLKEN "  "0 ,1 "
;tree.end

;tree "PLLSOC0FR"
base ad:0x80158124
group 0--3
line.long 0 "PLLSOC0FR"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " SELDIV2 "  "0 ,1 "
;tree.end

;tree "PLLSOC1FR"
base ad:0x80158128
group 0--3
line.long 0 "PLLSOC1FR"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " SELDIV2 "  "0 ,1 "
;tree.end

;tree "PLLARMFR"
base ad:0x8015812c
group 0--3
line.long 0 "PLLARMFR"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " SELDIV2 "  "0 ,1 "
;tree.end

;tree "PLLDDRFR"
base ad:0x80158130
group 0--3
line.long 0 "PLLDDRFR"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " SELDIV2 "  "0 ,1 "
;tree.end

;tree "PLLDSIFR"
base ad:0x80158134
group 0--3
line.long 0 "PLLDSIFR"
hexfld.byte 0 " D "
bitfld.long 0 8.--13. " N "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--18. " R "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " SELDIV2 "  "0 ,1 "
;tree.end

;tree "SRC_PLLSOC0SR"
base ad:0x80158138
rgroup 0--3
line.long 0 "SRC_PLLSOC0SR"
bitfld.long 0 0. " PLLSOC0_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PLLSOC0_LOCKP3 "  "0 ,1 "
;tree.end

;tree "SRC_PLLSOC1SR"
base ad:0x8015813c
rgroup 0--3
line.long 0 "SRC_PLLSOC1SR"
bitfld.long 0 0. " PLLSOC1_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PLLSOC1_LOCKP3 "  "0 ,1 "
;tree.end

;tree "SRC_PLLARMSR"
base ad:0x80158140
rgroup 0--3
line.long 0 "SRC_PLLARMSR"
bitfld.long 0 0. " PLLARM_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PLLARM_LOCKP3 "  "0 ,1 "
;tree.end

;tree "SRC_PLLDDRSR"
base ad:0x80158144
rgroup 0--3
line.long 0 "SRC_PLLDDRSR"
bitfld.long 0 0. " PLLDDR_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PLLDDR_LOCKP3 "  "0 ,1 "
;tree.end

;tree "SRC_PLLDSISR"
base ad:0x80158148
rgroup 0--3
line.long 0 "SRC_PLLDSISR"
bitfld.long 0 0. " PLLDSI_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PLLDSI_LOCKP3 "  "0 ,1 "
;tree.end

;tree "ITCR"
base ad:0x80158f00
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "ITIP"
base ad:0x80158f04
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RemapStat "  "0 ,1 "
bitfld.long 0 1. " nIRQ "  "0 ,1 "
bitfld.long 0 2. " nFIQ "  "0 ,1 "
bitfld.long 0 3. " PLL1ON "  "0 ,1 "
bitfld.long 0 5. " SoftResStat "  "0 ,1 "
bitfld.long 0 7. " ExtResStat "  "0 ,1 "
bitfld.long 0 8. " PORESStat "  "0 ,1 "
bitfld.long 0 9. " PLLSW "  "0 ,1 "
bitfld.long 0 10. " PLLTimeEn "  "0 ,1 "
bitfld.long 0 12. " XtalTimeEn "  "0 ,1 "
bitfld.long 0 13. " MPMCnSMC "  "0 ,1 "
bitfld.long 0 15. " DOZECLK "  "0 ,1 "
bitfld.long 0 16. " REFCLK "  "0 ,1 "
bitfld.long 0 17. " WDEN "  "0 ,1 "
bitfld.long 0 18. " SLEEPRESSTAT "  "0 ,1 "
bitfld.long 0 19. " PLL2ON "  "0 ,1 "
;tree.end

;tree "ITOP"
base ad:0x80158f08
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " SoftResReq "  "0 ,1 "
bitfld.long 0 1. " RemapClear "  "0 ,1 "
bitfld.long 0 2. " PLL1En "  "0 ,1 "
bitfld.long 0 4.--7. " SYSMODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10. " PLLRQSW "  "0 ,1 "
bitfld.long 0 11. " SLEEPMODE "  "0 ,1 "
bitfld.long 0 17. " PLL2EN "  "0 ,1 "
bitfld.long 0 19. " SLOWDIV8CLKEN "  "0 ,1 "
bitfld.long 0 20.--21. " CLK1HZCLKEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 22. " EXTCLKEN "  "0 ,1 "
;tree.end

;tree "PeriphID0"
base ad:0x80158fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "PeriphID1"
base ad:0x80158fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0x80158fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0x80158fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0x80158ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SCPCellID0 "
;tree.end

;tree "PCellID1"
base ad:0x80158ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SCPCellID1 "
;tree.end

;tree "PCellID2"
base ad:0x80158ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SCPCellID2 "
;tree.end

;tree "PCellID3"
base ad:0x80158ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SCPCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "SCTLTB"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "STMISCSTAT"
base ad:0x63200000
group 0--3
line.long 0 "STMISCSTAT"
bitfld.long 0 0. " SLEEPMODE "  "0 ,1 "
bitfld.long 0 1. " XTALRQSW "  "0 ,1 "
bitfld.long 0 2. " PLLRQSW "  "0 ,1 "
bitfld.long 0 3.--4. " HCLKDIVSEL "  "0 ,1 ,2 ,3 "
;tree.end

;tree "SYSMODE"
base ad:0x63200004
group 0--3
line.long 0 "SYSMODE"
bitfld.long 0 0.--3. " SysMode "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "XTALEN"
base ad:0x63200008
group 0--3
line.long 0 "XTALEN"
bitfld.long 0 0. " XtalEn "  "0 ,1 "
;tree.end

;tree "PAUSE"
base ad:0x6320000c
group 0--3
line.long 0 "PAUSE"
bitfld.long 0 0. " Pause "  "0 ,1 "
;tree.end

;tree "REMAPCLEAR"
base ad:0x63200010
group 0--3
line.long 0 "REMAPCLEAR"
bitfld.long 0 0. " RemapClear "  "0 ,1 "
;tree.end

;tree "SOFTRESREQ"
base ad:0x63200014
group 0--3
line.long 0 "SOFTRESREQ"
bitfld.long 0 0. " SoftResReq "  "0 ,1 "
;tree.end

;tree "REMAPSTAT"
base ad:0x63200018
group 0--3
line.long 0 "REMAPSTAT"
bitfld.long 0 0. " RemapStat "  "0 ,1 "
;tree.end

;tree "STBATOK"
base ad:0x6320001c
group 0--3
line.long 0 "STBATOK"
bitfld.long 0 0. " BATOK "  "0 ,1 "
;tree.end

;tree "NFIQ"
base ad:0x63200020
group 0--3
line.long 0 "NFIQ"
bitfld.long 0 0. " nFiq "  "0 ,1 "
;tree.end

;tree "PLLON"
base ad:0x63200024
group 0--3
line.long 0 "PLLON"
bitfld.long 0 0. " PllOn "  "0 ,1 "
;tree.end

;tree "XTALON"
base ad:0x63200028
group 0--3
line.long 0 "XTALON"
bitfld.long 0 0. " XtalOn "  "0 ,1 "
;tree.end

;tree "SOFTRESSTAT"
base ad:0x6320002c
group 0--3
line.long 0 "SOFTRESSTAT"
bitfld.long 0 0. " SoftResStat "  "0 ,1 "
;tree.end

;tree "WATRESSTAT"
base ad:0x63200030
group 0--3
line.long 0 "WATRESSTAT"
bitfld.long 0 0. " WatResStat "  "0 ,1 "
;tree.end

;tree "EXTRESSTAT"
base ad:0x63200034
group 0--3
line.long 0 "EXTRESSTAT"
bitfld.long 0 0. " ExtResStat "  "0 ,1 "
;tree.end

;tree "PORESSTAT"
base ad:0x63200038
group 0--3
line.long 0 "PORESSTAT"
bitfld.long 0 0. " PoResStat "  "0 ,1 "
;tree.end

;tree "PLLEN"
base ad:0x6320003c
group 0--3
line.long 0 "PLLEN"
bitfld.long 0 0. " PllEn "  "0 ,1 "
;tree.end

;tree "PLLFREQCTRL"
base ad:0x63200040
group 0--3
line.long 0 "PLLFREQCTRL"
hexfld.long 0 " PllFreqCtrl "
;tree.end

;tree "PERIPHCTRL1"
base ad:0x63200044
group 0--3
line.long 0 "PERIPHCTRL1"
hexfld.long 0 " PeriphCtrl1 "
;tree.end

;tree "PERIPHCTRL2"
base ad:0x63200048
group 0--3
line.long 0 "PERIPHCTRL2"
hexfld.long 0 " PeriphCtrl2 "
;tree.end

;tree "NPOR"
base ad:0x6320004c
group 0--3
line.long 0 "NPOR"
bitfld.long 0 0. " nPor "  "0 ,1 "
;tree.end

;tree "PLLSW"
base ad:0x63200050
group 0--3
line.long 0 "PLLSW"
bitfld.long 0 0. " PllSw "  "0 ,1 "
;tree.end

;tree "PLLTIMEEN"
base ad:0x63200054
group 0--3
line.long 0 "PLLTIMEEN"
bitfld.long 0 0. " PllTimeEn "  "0 ,1 "
;tree.end

;tree "XTALSW"
base ad:0x63200058
group 0--3
line.long 0 "XTALSW"
bitfld.long 0 0. " XtalSw "  "0 ,1 "
;tree.end

;tree "XTALTIMEEN"
base ad:0x6320005c
group 0--3
line.long 0 "XTALTIMEEN"
bitfld.long 0 0. " XtalTimeEn "  "0 ,1 "
;tree.end

;tree "COUNTER"
base ad:0x63200060
group 0--3
line.long 0 "COUNTER"
bitfld.long 0 0.--24. " Counter "  " "
;tree.end

;tree "INVSTAT"
base ad:0x63200064
group 0--3
line.long 0 "INVSTAT"
bitfld.long 0 0. " InvStat "  "0 ,1 "
;tree.end

;tree "SYSSETUP"
base ad:0x63200068
group 0--3
line.long 0 "SYSSETUP"
bitfld.long 0 0. " BIGENDIAN "  "0 ,1 "
bitfld.long 0 1. " BIGENDINIT "  "0 ,1 "
bitfld.long 0 2. " VINITHI "  "0 ,1 "
;tree.end

;tree "STVDDCOK"
base ad:0x6320006c
group 0--3
line.long 0 "STVDDCOK"
bitfld.long 0 0. " VDDCOK "  "0 ,1 "
;tree.end

;tree "DUMMYVAL"
base ad:0x63200070
group 0--3
line.long 0 "DUMMYVAL"
bitfld.long 0 0. " VAL "  "0 ,1 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "SCU"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "SCU_CR"
base ad:0xa0410000
group 0--3
line.long 0 "SCU_CR"
bitfld.long 0 0. " SCUCREN "  "0 ,1 "
bitfld.long 0 1. " SCUCRAFEN "  "0 ,1 "
bitfld.long 0 2. " SCUCRRPE "  "0 ,1 "
;tree.end

;tree "SCU_CONFR"
base ad:0xa0410004
group 0--3
line.long 0 "SCU_CONFR"
bitfld.long 0 0.--1. " SCUCONFRCPUN "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " SCUCONFRCPUSMP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.byte 1 " SCUCONFRTRS "
;tree.end

;tree "SCU_CPUPSR"
base ad:0xa0410008
group 0--3
line.long 0 "SCU_CPUPSR"
bitfld.long 0 0.--1. " SCUCPUPSRCPU0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " SCUCPUPSRCPU1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " SCUCPUPSRCPU2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " SCUCPUPSRCPU3 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "SCU_IA"
base ad:0xa041000c
wgroup 0--3
line.long 0 "SCU_IA"
bitfld.long 0 0.--3. " SCUIACPU0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " SCUIACPU1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " SCUIACPU2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " SCUIACPU3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "SCU_FSAR"
base ad:0xa0410040
group 0--3
line.long 0 "SCU_FSAR"
bitfld.long 0 20.--31. " SCUFSARFSA "  " "
;tree.end

;tree "SCU_FEAR"
base ad:0xa0410044
group 0--3
line.long 0 "SCU_FEAR"
bitfld.long 0 20.--31. " SCUFEARFEA "  " "
;tree.end

;tree "SCU_ACR"
base ad:0xa0410050
group 0--3
line.long 0 "SCU_ACR"
bitfld.long 0 0. " SCUACRCPU0 "  "0 ,1 "
bitfld.long 0 1. " SCUACRCPU1 "  "0 ,1 "
bitfld.long 0 2. " SCUACRCPU2 "  "0 ,1 "
bitfld.long 0 3. " SCUACRCPU3 "  "0 ,1 "
;tree.end

;tree "SCU_SACR"
base ad:0xa0410054
group 0--3
line.long 0 "SCU_SACR"
bitfld.long 0 0. " SCUSACRCPU0 "  "0 ,1 "
bitfld.long 0 1. " SCUSACRCPU1 "  "0 ,1 "
bitfld.long 0 2. " SCUSACRCPU2 "  "0 ,1 "
bitfld.long 0 3. " SCUSACRCPU3 "  "0 ,1 "
bitfld.long 0 4. " SCUSACRTCPU0 "  "0 ,1 "
bitfld.long 0 5. " SCUSACRTCPU1 "  "0 ,1 "
bitfld.long 0 6. " SCUSACRTCPU2 "  "0 ,1 "
bitfld.long 0 7. " SCUSACRTCPU3 "  "0 ,1 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "SGA"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
if (((data.long(ad:0x80157014)&0x100)!=0x100)||((data.long(ad:0x8015741c)&0x100)!=0x100)||((data.long(ad:0x801571ec)&0x1)!=0x1)||((data.long(ad:0x80157428)&0x20)!=0x0))
base ad:0x0
hgroup 0--3
TEXTLINE "SGA is not acessible. Please activate its clock or release its reset"
else
;tree "GP2_VSCL_START_ADDR"
base ad:0xa0300000
group 0--3
line.long 0 "GP2_VSCL_START_ADDR"
bitfld.long 0 3.--31. " VSCL_START "  " "
;tree.end

;tree "GP2_VSCL_END_ADDR"
base ad:0xa0300004
group 0--3
line.long 0 "GP2_VSCL_END_ADDR"
bitfld.long 0 3.--31. " VSCL_END "  " "
;tree.end

;tree "GP2_PLBCL_START_ADDR"
base ad:0xa0300008
group 0--3
line.long 0 "GP2_PLBCL_START_ADDR"
bitfld.long 0 3.--31. " PLBCL_START "  " "
;tree.end

;tree "GP2_PLBCL_END_ADDR"
base ad:0xa030000c
group 0--3
line.long 0 "GP2_PLBCL_END_ADDR"
bitfld.long 0 3.--31. " PLBCL_END "  " "
;tree.end

;tree "GP2_PLB_ALLOC_START_ADDR"
base ad:0xa0300010
group 0--3
line.long 0 "GP2_PLB_ALLOC_START_ADDR"
bitfld.long 0 7.--31. " PLB_ALLOC_START_ADDR "  " "
;tree.end

;tree "GP2_PLB_ALLOC_END_ADDR"
base ad:0xa0300014
group 0--3
line.long 0 "GP2_PLB_ALLOC_END_ADDR"
bitfld.long 0 7.--31. " PLB_ALLOC_END_ADDR "  " "
;tree.end

;tree "GP2_CMD"
base ad:0xa0300020
group 0--3
line.long 0 "GP2_CMD"
bitfld.long 0 0. " START_VS "  "0 ,1 "
bitfld.long 0 1. " START_PLB "  "0 ,1 "
bitfld.long 0 4. " UPDATE_PLB_ALLOC "  "0 ,1 "
bitfld.long 0 5. " RESET "  "0 ,1 "
bitfld.long 0 6. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 7. " FLUSH_CACHE "  "0 ,1 "
bitfld.long 0 8. " START_BUS "  "0 ,1 "
bitfld.long 0 9. " STOP_BUS "  "0 ,1 "
bitfld.long 0 10. " SOFT_RESET "  "0 ,1 "
bitfld.long 0 11. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

;tree "GP2_INT_RAWSTAT"
base ad:0xa0300024
group 0--3
line.long 0 "GP2_INT_RAWSTAT"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
bitfld.long 0 12. " AXI_BUS_STOPPED "  "0 ,1 "
bitfld.long 0 13. " VS_INVALID_CMD "  "0 ,1 "
bitfld.long 0 14. " PLB_INVALID_CMD "  "0 ,1 "
bitfld.long 0 19. " RESET_COMPLETED "  "0 ,1 "
bitfld.long 0 20. " SEMAPHORE_UNDERFLOW "  "0 ,1 "
bitfld.long 0 21. " SEMAPHORE_OVERFLOW "  "0 ,1 "
bitfld.long 0 22. " PTR_OUT_OF_BOUNDS "  "0 ,1 "
;tree.end

;tree "GP2_INT_CLEAR"
base ad:0xa0300028
wgroup 0--3
line.long 0 "GP2_INT_CLEAR"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
bitfld.long 0 12. " AXI_BUS_STOPPED "  "0 ,1 "
bitfld.long 0 13. " VS_INVALID_CMD "  "0 ,1 "
bitfld.long 0 14. " PLB_INVALID_CMD "  "0 ,1 "
bitfld.long 0 19. " RESET_COMPLETED "  "0 ,1 "
bitfld.long 0 20. " SEMAPHORE_UNDERFLOW "  "0 ,1 "
bitfld.long 0 21. " SEMAPHORE_OVERFLOW "  "0 ,1 "
bitfld.long 0 22. " PTR_OUT_OF_BOUNDS "  "0 ,1 "
;tree.end

;tree "GP2_INT_MASK"
base ad:0xa030002c
group 0--3
line.long 0 "GP2_INT_MASK"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
bitfld.long 0 12. " AXI_BUS_STOPPED "  "0 ,1 "
bitfld.long 0 13. " VS_INVALID_CMD "  "0 ,1 "
bitfld.long 0 14. " PLB_INVALID_CMD "  "0 ,1 "
bitfld.long 0 19. " RESET_COMPLETED "  "0 ,1 "
bitfld.long 0 20. " SEMAPHORE_UNDERFLOW "  "0 ,1 "
bitfld.long 0 21. " SEMAPHORE_OVERFLOW "  "0 ,1 "
bitfld.long 0 22. " PTR_OUT_OF_BOUNDS "  "0 ,1 "
;tree.end

;tree "GP2_INT_STAT"
base ad:0xa0300030
rgroup 0--3
line.long 0 "GP2_INT_STAT"
bitfld.long 0 0. " VS_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 1. " PLB_END_CMD_LIST "  "0 ,1 "
bitfld.long 0 2. " PLB_OUT_OF_MEM "  "0 ,1 "
bitfld.long 0 3. " VS_SEM "  "0 ,1 "
bitfld.long 0 4. " PLB_SEM "  "0 ,1 "
bitfld.long 0 5. " HANG "  "0 ,1 "
bitfld.long 0 6. " FORCED_HANG "  "0 ,1 "
bitfld.long 0 7. " PERF_CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 8. " PERF_CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 9. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 11. " AXI_BUS_ERROR "  "0 ,1 "
bitfld.long 0 12. " AXI_BUS_STOPPED "  "0 ,1 "
bitfld.long 0 13. " VS_INVALID_CMD "  "0 ,1 "
bitfld.long 0 14. " PLB_INVALID_CMD "  "0 ,1 "
bitfld.long 0 19. " RESET_COMPLETED "  "0 ,1 "
bitfld.long 0 20. " SEMAPHORE_UNDERFLOW "  "0 ,1 "
bitfld.long 0 21. " SEMAPHORE_OVERFLOW "  "0 ,1 "
bitfld.long 0 22. " PTR_OUT_OF_BOUNDS "  "0 ,1 "
;tree.end

;tree "GP2_WRITE_BOUNDARY_LOW"
base ad:0xa0300034
group 0--3
line.long 0 "GP2_WRITE_BOUNDARY_LOW"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_LOW "  " "
;tree.end

;tree "GP2_WRITE_BOUNDARY_HIGH"
base ad:0xa0300038
group 0--3
line.long 0 "GP2_WRITE_BOUNDARY_HIGH"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_HIGH "  " "
;tree.end

;tree "GP2_PERF_CNT_0_ENABLE"
base ad:0xa030003c
group 0--3
line.long 0 "GP2_PERF_CNT_0_ENABLE"
bitfld.long 0 0. " PERF_CNT_0_ENABLE "  "0 ,1 "
;tree.end

;tree "GP2_PERF_CNT_1_ENABLE"
base ad:0xa0300040
group 0--3
line.long 0 "GP2_PERF_CNT_1_ENABLE"
bitfld.long 0 0. " PERF_CNT_1_ENABLE "  "0 ,1 "
;tree.end

;tree "GP2_PERF_CNT_0_SRC"
base ad:0xa0300044
group 0--3
line.long 0 "GP2_PERF_CNT_0_SRC"
bitfld.long 0 0.--4. " PERF_CNT_0_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GP2_PERF_CNT_1_SRC"
base ad:0xa0300048
group 0--3
line.long 0 "GP2_PERF_CNT_1_SRC"
bitfld.long 0 0.--4. " PERF_CNT_1_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GP2_PERF_CNT_0_VAL"
base ad:0xa030004c
rgroup 0--3
line.long 0 "GP2_PERF_CNT_0_VAL"
hexfld.long 0 " PERF_CNT_0_VAL "
;tree.end

;tree "GP2_PERF_CNT_1_VAL"
base ad:0xa0300050
rgroup 0--3
line.long 0 "GP2_PERF_CNT_1_VAL"
hexfld.long 0 " PERF_CNT_1_VAL "
;tree.end

;tree "GP2_PERF_CNT_0_LIMIT"
base ad:0xa0300054
group 0--3
line.long 0 "GP2_PERF_CNT_0_LIMIT"
hexfld.long 0 " PERF_CNT_0_LIMIT "
;tree.end

;tree "GP2_PERF_CNT_1_LIMIT"
base ad:0xa0300058
group 0--3
line.long 0 "GP2_PERF_CNT_1_LIMIT"
hexfld.long 0 " PERF_CNT_1_LIMIT "
;tree.end

;tree "GP2_STATUS"
base ad:0xa0300068
rgroup 0--3
line.long 0 "GP2_STATUS"
bitfld.long 0 0. " IRQ "  "0 ,1 "
bitfld.long 0 1. " VS_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " BUS_STOPPED "  "0 ,1 "
bitfld.long 0 3. " PLB_ACTIVE "  "0 ,1 "
bitfld.long 0 5. " PLB_STALLED "  "0 ,1 "
bitfld.long 0 6. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 7. " HANG "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUND_ERR "  "0 ,1 "
bitfld.long 0 9. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

;tree "GP2_VERSION"
base ad:0xa030006c
rgroup 0--3
line.long 0 "GP2_VERSION"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 2 " PRODUCT_ID "
;tree.end

;tree "GP2_VSCL_INITIAL_ADDR"
base ad:0xa0300080
rgroup 0--3
line.long 0 "GP2_VSCL_INITIAL_ADDR"
bitfld.long 0 3.--31. " VSCL_INITIAL_ADDR "  " "
;tree.end

;tree "GP2_PLBCL_INITIAL_ADDR"
base ad:0xa0300084
rgroup 0--3
line.long 0 "GP2_PLBCL_INITIAL_ADDR"
bitfld.long 0 3.--31. " PLBCL_INITIAL_ADDR "  " "
;tree.end

;tree "GP2_WRITE_BOUNDARY_ERROR_ADDR"
base ad:0xa0300088
rgroup 0--3
line.long 0 "GP2_WRITE_BOUNDARY_ERROR_ADDR"
bitfld.long 0 0. " WRITE_BOUNDARY_ERROR_ADDR "  "0 ,1 "
;tree.end

;tree "GP2_AXI_BUS_ERROR_STAT"
base ad:0xa0300094
rgroup 0--3
line.long 0 "GP2_AXI_BUS_ERROR_STAT"
bitfld.long 0 0. " READ_ERROR "  "0 ,1 "
bitfld.long 0 1. " WRITE_ERROR "  "0 ,1 "
bitfld.long 0 2.--5. " READ_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--9. " WRITE_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "GP2_WATCHDOG_DISABLE"
base ad:0xa03000a0
group 0--3
line.long 0 "GP2_WATCHDOG_DISABLE"
bitfld.long 0 0. " WATCHDOG_DISABLE "  "0 ,1 "
;tree.end

;tree "GP2_WATCHDOG_TIMEOUT"
base ad:0xa03000a4
group 0--3
line.long 0 "GP2_WATCHDOG_TIMEOUT"
hexfld.long 0 " WATCHDOG_TIMEOUT "
;tree.end

;tree "L2_VERSION"
base ad:0xa0301000
rgroup 0--3
line.long 0 "L2_VERSION"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 2 " PRODUCT_ID "
;tree.end

;tree "L2_SIZE"
base ad:0xa0301004
rgroup 0--3
line.long 0 "L2_SIZE"
hexfld.byte 0 " LINE_SIZE "
hexfld.byte 1 " ASSOCIATIVITY "
hexfld.byte 2 " CACHE8SIZE "
hexfld.byte 3 " EXTERNAL_BUS_WIDTH "
;tree.end

;tree "L2_STATUS"
base ad:0xa0301008
rgroup 0--3
line.long 0 "L2_STATUS"
bitfld.long 0 0. " COMMAND_BUSY "  "0 ,1 "
bitfld.long 0 1. " DATA_BUSY "  "0 ,1 "
;tree.end

;tree "L2_COMMAND"
base ad:0xa0301010
group 0--3
line.long 0 "L2_COMMAND"
bitfld.long 0 0.--2. " COMMAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "L2_CLEAR_PAGE"
base ad:0xa0301014
group 0--3
line.long 0 "L2_CLEAR_PAGE"
hexfld.long 0 " CLEAR_PAGE "
;tree.end

;tree "L2_MAX_READS"
base ad:0xa0301018
group 0--3
line.long 0 "L2_MAX_READS"
bitfld.long 0 0.--4. " MAX_READS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "L2_ENABLE"
base ad:0xa030101c
group 0--3
line.long 0 "L2_ENABLE"
bitfld.long 0 0. " PERMIT_CACHEABLE_ACCESSES "  "0 ,1 "
bitfld.long 0 1. " PERMIT_CACHE_READ_ALLOCATE "  "0 ,1 "
;tree.end

;tree "L2_PERFCNT_SRC0"
base ad:0xa0301020
group 0--3
line.long 0 "L2_PERFCNT_SRC0"
bitfld.long 0 0.--6. " PERFCNT_SRC0 "  " "
;tree.end

;tree "L2_PERFCNT_VAL0"
base ad:0xa0301024
group 0--3
line.long 0 "L2_PERFCNT_VAL0"
hexfld.long 0 " PERFCNT_VAL0 "
;tree.end

;tree "L2_PERFCNT_SRC1"
base ad:0xa0301028
group 0--3
line.long 0 "L2_PERFCNT_SRC1"
bitfld.long 0 0.--6. " PERFCNT_SRC1 "  " "
;tree.end

;tree "L2_PERFCNT_VAL1"
base ad:0xa030102c
group 0--3
line.long 0 "L2_PERFCNT_VAL1"
hexfld.long 0 " PERFCNT_VAL1 "
;tree.end

;tree "GP_MMU_DTE_ADDR"
base ad:0xa0303000
group 0--3
line.long 0 "GP_MMU_DTE_ADDR"
bitfld.long 0 0.--19. " DTE_ADDR "  " "
;tree.end

;tree "GP_MMU_STATUS"
base ad:0xa0303004
rgroup 0--3
line.long 0 "GP_MMU_STATUS"
bitfld.long 0 0. " PAGING_ENABLED "  "0 ,1 "
bitfld.long 0 1. " PAGE_FAULT_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " STALL_ACTIVE "  "0 ,1 "
bitfld.long 0 3. " IDLE "  "0 ,1 "
bitfld.long 0 4. " REPLAY_BUFFER_EMPTY "  "0 ,1 "
bitfld.long 0 5. " PAGE_FAULT_IS_WRITE "  "0 ,1 "
bitfld.long 0 6.--10. " PAGE_FAULT_BUS_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "GP_MMU_COMMAND"
base ad:0xa0303008
group 0--3
line.long 0 "GP_MMU_COMMAND"
bitfld.long 0 0.--2. " COMMAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "GP_MMU_PAGE_FAULT_ADDR"
base ad:0xa030300c
rgroup 0--3
line.long 0 "GP_MMU_PAGE_FAULT_ADDR"
bitfld.long 0 0. " PAGE_FAULT_ADDR "  "0 ,1 "
;tree.end

;tree "GP_MMU_ZAPE_ONE_LINE"
base ad:0xa0303010
group 0--3
line.long 0 "GP_MMU_ZAPE_ONE_LINE"
bitfld.long 0 0. " ZAPE_ONE_LINE "  "0 ,1 "
;tree.end

;tree "GP_MMU_INT_RAWSTAT"
base ad:0xa0303014
group 0--3
line.long 0 "GP_MMU_INT_RAWSTAT"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

;tree "GP_MMU_INT_CLEAR"
base ad:0xa0303018
wgroup 0--3
line.long 0 "GP_MMU_INT_CLEAR"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

;tree "GP_MMU_INT_MASK"
base ad:0xa030301c
group 0--3
line.long 0 "GP_MMU_INT_MASK"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

;tree "GP_MMU_INT_STATUS"
base ad:0xa0303020
rgroup 0--3
line.long 0 "GP_MMU_INT_STATUS"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

;tree "PP0_MMU_DTE_ADDR"
base ad:0xa0304000
group 0--3
line.long 0 "PP0_MMU_DTE_ADDR"
bitfld.long 0 0.--19. " DTE_ADDR "  " "
;tree.end

;tree "PP0_MMU_STATUS"
base ad:0xa0304004
rgroup 0--3
line.long 0 "PP0_MMU_STATUS"
bitfld.long 0 0. " PAGING_ENABLED "  "0 ,1 "
bitfld.long 0 1. " PAGE_FAULT_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " STALL_ACTIVE "  "0 ,1 "
bitfld.long 0 3. " IDLE "  "0 ,1 "
bitfld.long 0 4. " REPLAY_BUFFER_EMPTY "  "0 ,1 "
bitfld.long 0 5. " PAGE_FAULT_IS_WRITE "  "0 ,1 "
bitfld.long 0 6.--10. " PAGE_FAULT_BUS_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PP0_MMU_COMMAND"
base ad:0xa0304008
group 0--3
line.long 0 "PP0_MMU_COMMAND"
bitfld.long 0 0.--2. " COMMAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PP0_MMU_PAGE_FAULT_ADDR"
base ad:0xa030400c
rgroup 0--3
line.long 0 "PP0_MMU_PAGE_FAULT_ADDR"
bitfld.long 0 0. " PAGE_FAULT_ADDR "  "0 ,1 "
;tree.end

;tree "PP0_MMU_ZAPE_ONE_LINE"
base ad:0xa0304010
group 0--3
line.long 0 "PP0_MMU_ZAPE_ONE_LINE"
bitfld.long 0 0. " ZAPE_ONE_LINE "  "0 ,1 "
;tree.end

;tree "PP0_MMU_INT_RAWSTAT"
base ad:0xa0304014
group 0--3
line.long 0 "PP0_MMU_INT_RAWSTAT"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

;tree "PP0_MMU_INT_CLEAR"
base ad:0xa0304018
wgroup 0--3
line.long 0 "PP0_MMU_INT_CLEAR"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

;tree "PP0_MMU_INT_MASK"
base ad:0xa030401c
group 0--3
line.long 0 "PP0_MMU_INT_MASK"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

;tree "PP0_MMU_INT_STATUS"
base ad:0xa0304020
rgroup 0--3
line.long 0 "PP0_MMU_INT_STATUS"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

;tree "PP1_MMU_DTE_ADDR"
base ad:0xa0305000
group 0--3
line.long 0 "PP1_MMU_DTE_ADDR"
bitfld.long 0 0.--19. " DTE_ADDR "  " "
;tree.end

;tree "PP1_MMU_STATUS"
base ad:0xa0305004
rgroup 0--3
line.long 0 "PP1_MMU_STATUS"
bitfld.long 0 0. " PAGING_ENABLED "  "0 ,1 "
bitfld.long 0 1. " PAGE_FAULT_ACTIVE "  "0 ,1 "
bitfld.long 0 2. " STALL_ACTIVE "  "0 ,1 "
bitfld.long 0 3. " IDLE "  "0 ,1 "
bitfld.long 0 4. " REPLAY_BUFFER_EMPTY "  "0 ,1 "
bitfld.long 0 5. " PAGE_FAULT_IS_WRITE "  "0 ,1 "
bitfld.long 0 6.--10. " PAGE_FAULT_BUS_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PP1_MMU_COMMAND"
base ad:0xa0305008
group 0--3
line.long 0 "PP1_MMU_COMMAND"
bitfld.long 0 0.--2. " COMMAND "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PP1_MMU_PAGE_FAULT_ADDR"
base ad:0xa030500c
rgroup 0--3
line.long 0 "PP1_MMU_PAGE_FAULT_ADDR"
bitfld.long 0 0. " PAGE_FAULT_ADDR "  "0 ,1 "
;tree.end

;tree "PP1_MMU_ZAPE_ONE_LINE"
base ad:0xa0305010
group 0--3
line.long 0 "PP1_MMU_ZAPE_ONE_LINE"
bitfld.long 0 0. " ZAPE_ONE_LINE "  "0 ,1 "
;tree.end

;tree "PP1_MMU_INT_RAWSTAT"
base ad:0xa0305014
group 0--3
line.long 0 "PP1_MMU_INT_RAWSTAT"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

;tree "PP1_MMU_INT_CLEAR"
base ad:0xa0305018
wgroup 0--3
line.long 0 "PP1_MMU_INT_CLEAR"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

;tree "PP1_MMU_INT_MASK"
base ad:0xa030501c
group 0--3
line.long 0 "PP1_MMU_INT_MASK"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

;tree "PP1_MMU_INT_STATUS"
base ad:0xa0305020
rgroup 0--3
line.long 0 "PP1_MMU_INT_STATUS"
bitfld.long 0 0. " PAGE_FAULT "  "0 ,1 "
bitfld.long 0 1. " READ_BUS_ERROR "  "0 ,1 "
;tree.end

;tree "REND_LIST_ADDR"
base ad:0xa0308000
group 0--3
line.long 0 "REND_LIST_ADDR"
bitfld.long 0 3.--31. " REND_LIST_ADDR "  " "
;tree.end

;tree "REND_RSW_BASE"
base ad:0xa0308004
group 0--3
line.long 0 "REND_RSW_BASE"
bitfld.long 0 6.--31. " REND_RSW_BASE "  " "
;tree.end

;tree "REND_VERTEX_BASE"
base ad:0xa0308008
group 0--3
line.long 0 "REND_VERTEX_BASE"
bitfld.long 0 6.--31. " REND_VERTEX_BASE "  " "
;tree.end

;tree "FEATURE_ENABLE"
base ad:0xa030800c
group 0--3
line.long 0 "FEATURE_ENABLE"
bitfld.long 0 0. " FP_TILEBUF_ENABLE "  "0 ,1 "
bitfld.long 0 1. " EARLYZ_ENABLE "  "0 ,1 "
bitfld.long 0 3. " EARLYZ_DISABLE1 "  "0 ,1 "
bitfld.long 0 4. " EARLYZ_DISABLE2 "  "0 ,1 "
bitfld.long 0 5. " ORIGIN_LOWER_LEFT "  "0 ,1 "
bitfld.long 0 6. " SUMMATE_QUAD_COVER "  "0 ,1 "
;tree.end

;tree "Z_CLEAR_VALUE"
base ad:0xa0308010
group 0--3
line.long 0 "Z_CLEAR_VALUE"
bitfld.long 0 0.--23. " Z_CLEAR_VALUE "  " "
;tree.end

;tree "STENCIL_CLEAR_VALUE"
base ad:0xa0308014
group 0--3
line.long 0 "STENCIL_CLEAR_VALUE"
hexfld.byte 0 " STENCIL_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_0"
base ad:0xa0308018
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_0"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_1"
base ad:0xa030801c
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_1"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_2"
base ad:0xa0308020
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_2"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_3"
base ad:0xa0308024
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_3"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "BOUNDING_BOX_LEFT_RIGHT"
base ad:0xa0308028
group 0--3
line.long 0 "BOUNDING_BOX_LEFT_RIGHT"
bitfld.long 0 0.--13. " BOUNDING_BOX_RIGHT "  " "
bitfld.long 0 16.--19. " BOUNDING_BOX_LEFT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "BOUNDING_BOX_BOTTOM"
base ad:0xa030802c
group 0--3
line.long 0 "BOUNDING_BOX_BOTTOM"
bitfld.long 0 0.--13. " BOUNDING_BOX_BOTTOM "  " "
;tree.end

;tree "FS_STACK_ADDR"
base ad:0xa0308030
group 0--3
line.long 0 "FS_STACK_ADDR"
bitfld.long 0 3.--31. " FS_STACK_ADDR "  " "
;tree.end

;tree "FS_STACK_SIZE_AND_INIT_VAL"
base ad:0xa0308034
group 0--3
line.long 0 "FS_STACK_SIZE_AND_INIT_VAL"
hexfld.word 0 " FP_STACK_SIZE "
hexfld.word 2 " FS_STACK_INIT_VAL "
;tree.end

;tree "ORIGIN_OFFSET_X"
base ad:0xa0308040
group 0--3
line.long 0 "ORIGIN_OFFSET_X"
hexfld.word 0 " ORIGIN_OFFSET_X "
;tree.end

;tree "ORIGIN_OFFSET_Y"
base ad:0xa0308044
group 0--3
line.long 0 "ORIGIN_OFFSET_Y"
hexfld.word 0 " ORIGIN_OFFSET_Y "
;tree.end

;tree "SUBPIXEL_SPECIFIER"
base ad:0xa0308048
group 0--3
line.long 0 "SUBPIXEL_SPECIFIER"
hexfld.byte 0 " SUBPIXEL_SPECIFIER "
;tree.end

;tree "TIEBREAK_MODE"
base ad:0xa030804c
group 0--3
line.long 0 "TIEBREAK_MODE"
bitfld.long 0 0.--2. " TIEBREAK_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLIST_CONFIG"
base ad:0xa0308050
group 0--3
line.long 0 "PLIST_CONFIG"
bitfld.long 0 0.--5. " SCALE_X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--21. " SCALE_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 28.--29. " LIST_FORMAT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "SCALING_CONFIG"
base ad:0xa0308054
group 0--3
line.long 0 "SCALING_CONFIG"
bitfld.long 0 0. " POINT_AND_LINE_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 1. " DITHERING_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 2. " FRAGCOORD_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " DERIVATIVE_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 8. " FLIP_POINT_SPRITES "  "0 ,1 "
bitfld.long 0 9. " FLIP_DITHERING_MATRIX "  "0 ,1 "
bitfld.long 0 10. " FLIP_FRAGCOORD "  "0 ,1 "
bitfld.long 0 11. " FLIP_DERIVATIVE_Y "  "0 ,1 "
bitfld.long 0 16.--18. " SCALE_X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " SCALE_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "TILEBUFFER_BITS"
base ad:0xa0308058
group 0--3
line.long 0 "TILEBUFFER_BITS"
bitfld.long 0 0.--3. " TILEBUFFER_R_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " TILEBUFFER_G_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TILEBUFFER_B_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " TILEBUFFER_A_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB0_SOURCE_SELECT"
base ad:0xa0308100
group 0--3
line.long 0 "WB0_SOURCE_SELECT"
bitfld.long 0 0.--1. " WB0_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB0_TARGET_ADDR"
base ad:0xa0308104
group 0--3
line.long 0 "WB0_TARGET_ADDR"
bitfld.long 0 3.--31. " WB0_TARGET_ADDR "  " "
;tree.end

;tree "WB0_TARGET_PIXEL_FORMAT"
base ad:0xa0308108
group 0--3
line.long 0 "WB0_TARGET_PIXEL_FORMAT"
bitfld.long 0 0.--3. " WB0_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB0_TARGET_AA_FORMAT"
base ad:0xa030810c
group 0--3
line.long 0 "WB0_TARGET_AA_FORMAT"
bitfld.long 0 0.--2. " WB0_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB0_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB0_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB0_TARGET_LAYOUT"
base ad:0xa0308110
group 0--3
line.long 0 "WB0_TARGET_LAYOUT"
bitfld.long 0 0.--1. " WB0_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB0_TARGET_SCANLINE_LENGTH"
base ad:0xa0308114
group 0--3
line.long 0 "WB0_TARGET_SCANLINE_LENGTH"
hexfld.word 0 " WB0_TARGET_SCANLINE_LENGTH "
;tree.end

;tree "WB0_TARGET_FLAGS"
base ad:0xa0308118
group 0--3
line.long 0 "WB0_TARGET_FLAGS"
bitfld.long 0 0. " WB0_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB0_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB0_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB0_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB0_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB0_BIG_ENDIAN "  "0 ,1 "
;tree.end

;tree "WB0_MRT_ENABLE"
base ad:0xa030811c
group 0--3
line.long 0 "WB0_MRT_ENABLE"
bitfld.long 0 0.--3. " WB0_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB0_MRT_OFFSET"
base ad:0xa0308120
group 0--3
line.long 0 "WB0_MRT_OFFSET"
bitfld.long 0 3.--31. " WB0_MRT_OFFSET "  " "
;tree.end

;tree "WB0_GLOBAL_TEST_ENABLE"
base ad:0xa0308124
group 0--3
line.long 0 "WB0_GLOBAL_TEST_ENABLE"
bitfld.long 0 0. " WB0_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

;tree "WB0_GLOBAL_TEST_REF_VALUE"
base ad:0xa0308128
group 0--3
line.long 0 "WB0_GLOBAL_TEST_REF_VALUE"
hexfld.word 0 " WB0_GLOBAL_TEST_REF_VALUE "
;tree.end

;tree "WB0_GLOBAL_TEST_CMP_FUNC"
base ad:0xa030812c
group 0--3
line.long 0 "WB0_GLOBAL_TEST_CMP_FUNC"
bitfld.long 0 0.--2. " WB0_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB1_SOURCE_SELECT"
base ad:0xa0308200
group 0--3
line.long 0 "WB1_SOURCE_SELECT"
bitfld.long 0 0.--1. " WB1_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB1_TARGET_ADDR"
base ad:0xa0308204
group 0--3
line.long 0 "WB1_TARGET_ADDR"
bitfld.long 0 3.--31. " WB1_TARGET_ADDR "  " "
;tree.end

;tree "WB1_TARGET_PIXEL_FORMAT"
base ad:0xa0308208
group 0--3
line.long 0 "WB1_TARGET_PIXEL_FORMAT"
bitfld.long 0 0.--3. " WB1_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB1_TARGET_AA_FORMAT"
base ad:0xa030820c
group 0--3
line.long 0 "WB1_TARGET_AA_FORMAT"
bitfld.long 0 0.--2. " WB1_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB1_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB1_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB1_TARGET_LAYOUT"
base ad:0xa0308210
group 0--3
line.long 0 "WB1_TARGET_LAYOUT"
bitfld.long 0 0.--1. " WB1_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB1_TARGET_SCANLINE_LENGTH"
base ad:0xa0308214
group 0--3
line.long 0 "WB1_TARGET_SCANLINE_LENGTH"
hexfld.word 0 " WB1_TARGET_SCANLINE_LENGTH "
;tree.end

;tree "WB1_TARGET_FLAGS"
base ad:0xa0308218
group 0--3
line.long 0 "WB1_TARGET_FLAGS"
bitfld.long 0 0. " WB1_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB1_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB1_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB1_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB1_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB1_BIG_ENDIAN "  "0 ,1 "
;tree.end

;tree "WB1_MRT_ENABLE"
base ad:0xa030821c
group 0--3
line.long 0 "WB1_MRT_ENABLE"
bitfld.long 0 0.--3. " WB1_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB1_MRT_OFFSET"
base ad:0xa0308220
group 0--3
line.long 0 "WB1_MRT_OFFSET"
bitfld.long 0 3.--31. " WB1_MRT_OFFSET "  " "
;tree.end

;tree "WB1_GLOBAL_TEST_ENABLE"
base ad:0xa0308224
group 0--3
line.long 0 "WB1_GLOBAL_TEST_ENABLE"
bitfld.long 0 0. " WB1_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

;tree "WB1_GLOBAL_TEST_REF_VALUE"
base ad:0xa0308228
group 0--3
line.long 0 "WB1_GLOBAL_TEST_REF_VALUE"
hexfld.word 0 " WB1_GLOBAL_TEST_REF_VALUE "
;tree.end

;tree "WB1_GLOBAL_TEST_CMP_FUNC"
base ad:0xa030822c
group 0--3
line.long 0 "WB1_GLOBAL_TEST_CMP_FUNC"
bitfld.long 0 0.--2. " WB1_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB2_SOURCE_SELECT"
base ad:0xa0308300
group 0--3
line.long 0 "WB2_SOURCE_SELECT"
bitfld.long 0 0.--1. " WB2_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB2_TARGET_ADDR"
base ad:0xa0308304
group 0--3
line.long 0 "WB2_TARGET_ADDR"
bitfld.long 0 3.--31. " WB2_TARGET_ADDR "  " "
;tree.end

;tree "WB2_TARGET_PIXEL_FORMAT"
base ad:0xa0308308
group 0--3
line.long 0 "WB2_TARGET_PIXEL_FORMAT"
bitfld.long 0 0.--3. " WB2_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB2_TARGET_AA_FORMAT"
base ad:0xa030830c
group 0--3
line.long 0 "WB2_TARGET_AA_FORMAT"
bitfld.long 0 0.--2. " WB2_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB2_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB2_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB2_TARGET_LAYOUT"
base ad:0xa0308310
group 0--3
line.long 0 "WB2_TARGET_LAYOUT"
bitfld.long 0 0.--1. " WB2_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB2_TARGET_SCANLINE_LENGTH"
base ad:0xa0308314
group 0--3
line.long 0 "WB2_TARGET_SCANLINE_LENGTH"
hexfld.word 0 " WB2_TARGET_SCANLINE_LENGTH "
;tree.end

;tree "WB2_TARGET_FLAGS"
base ad:0xa0308318
group 0--3
line.long 0 "WB2_TARGET_FLAGS"
bitfld.long 0 0. " WB2_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB2_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB2_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB2_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB2_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB2_BIG_ENDIAN "  "0 ,1 "
;tree.end

;tree "WB2_MRT_ENABLE"
base ad:0xa030831c
group 0--3
line.long 0 "WB2_MRT_ENABLE"
bitfld.long 0 0.--3. " WB2_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB2_MRT_OFFSET"
base ad:0xa0308320
group 0--3
line.long 0 "WB2_MRT_OFFSET"
bitfld.long 0 3.--31. " WB2_MRT_OFFSET "  " "
;tree.end

;tree "WB2_GLOBAL_TEST_ENABLE"
base ad:0xa0308324
group 0--3
line.long 0 "WB2_GLOBAL_TEST_ENABLE"
bitfld.long 0 0. " WB2_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

;tree "WB2_GLOBAL_TEST_REF_VALUE"
base ad:0xa0308328
group 0--3
line.long 0 "WB2_GLOBAL_TEST_REF_VALUE"
hexfld.word 0 " WB2_GLOBAL_TEST_REF_VALUE "
;tree.end

;tree "WB2_GLOBAL_TEST_CMP_FUNC"
base ad:0xa030832c
group 0--3
line.long 0 "WB2_GLOBAL_TEST_CMP_FUNC"
bitfld.long 0 0.--2. " WB2_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "MGMT_VERSION"
base ad:0xa0309000
rgroup 0--3
line.long 0 "MGMT_VERSION"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 2 " PRODUCT_ID "
;tree.end

;tree "MGMT_CURRENT_REND_LIST_ADDR"
base ad:0xa0309004
group 0--3
line.long 0 "MGMT_CURRENT_REND_LIST_ADDR"
bitfld.long 0 5.--31. " CURRENT_REND_LIST_ADDR "  " "
;tree.end

;tree "MGMT_STATUS"
base ad:0xa0309008
group 0--3
line.long 0 "MGMT_STATUS"
bitfld.long 0 0. " RENDERING_ACTIVE "  "0 ,1 "
bitfld.long 0 1. " TILE_STOPPED "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 4. " BUS_STOPPED "  "0 ,1 "
bitfld.long 0 5. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 6. " INTERRUPT_ASSERTED "  "0 ,1 "
bitfld.long 0 7. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

;tree "MGMT_CTRL"
base ad:0xa030900c
group 0--3
line.long 0 "MGMT_CTRL"
bitfld.long 0 0. " STOP_BUS "  "0 ,1 "
bitfld.long 0 1. " START_BUS "  "0 ,1 "
bitfld.long 0 2. " END_AFTER_TILE "  "0 ,1 "
bitfld.long 0 3. " FLUSH_CACHES "  "0 ,1 "
bitfld.long 0 4. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 5. " FORCE_RESET "  "0 ,1 "
bitfld.long 0 6. " START_RENDERING "  "0 ,1 "
bitfld.long 0 7. " SOFT_RESET "  "0 ,1 "
bitfld.long 0 8. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

;tree "MGMT_LAST_TILE_POS_START"
base ad:0xa0309010
rgroup 0--3
line.long 0 "MGMT_LAST_TILE_POS_START"
hexfld.byte 0 " TILEX_START "
hexfld.byte 2 " TILEY_START "
;tree.end

;tree "MGMT_LAST_TILE_POS_END"
base ad:0xa0309014
rgroup 0--3
line.long 0 "MGMT_LAST_TILE_POS_END"
hexfld.byte 0 " TILEX_END "
hexfld.byte 2 " TILEY_END "
;tree.end

;tree "MGMT_INT_RAWSTAT"
base ad:0xa0309020
group 0--3
line.long 0 "MGMT_INT_RAWSTAT"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_INT_CLEAR"
base ad:0xa0309024
group 0--3
line.long 0 "MGMT_INT_CLEAR"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_INT_MASK"
base ad:0xa0309028
group 0--3
line.long 0 "MGMT_INT_MASK"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_INT_STATUS"
base ad:0xa030902c
rgroup 0--3
line.long 0 "MGMT_INT_STATUS"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_ENABLE"
base ad:0xa0309040
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ENABLE"
bitfld.long 0 0. " WRITE_BOUNDARY_ENABLE "  "0 ,1 "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_LOW"
base ad:0xa0309044
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_LOW"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_LOW "  " "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_HIGH"
base ad:0xa0309048
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_HIGH"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_HIGH "  " "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_ADDRESS"
base ad:0xa030904c
rgroup 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ADDRESS"
bitfld.long 0 2.--31. " WRITE_BOUNDARY_ADDRESS "  " "
;tree.end

;tree "MGMT_BUS_ERROR_STATUS"
base ad:0xa0309050
rgroup 0--3
line.long 0 "MGMT_BUS_ERROR_STATUS"
bitfld.long 0 0. " WRITE_ERROR "  "0 ,1 "
bitfld.long 0 1. " READ_ERROR "  "0 ,1 "
bitfld.long 0 2.--5. " WRITE_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--9. " READ_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "MGMT_WATCHDOG_DISABLE"
base ad:0xa0309060
group 0--3
line.long 0 "MGMT_WATCHDOG_DISABLE"
bitfld.long 0 0. " WATCHDOG_DISABLE "  "0 ,1 "
;tree.end

;tree "MGMT_WATCHDOG_TIMEOUT"
base ad:0xa0309064
group 0--3
line.long 0 "MGMT_WATCHDOG_TIMEOUT"
hexfld.long 0 " WATCHDOG_TIMEOUT "
;tree.end

;tree "MGMT_PERF_CNT_0_ENABLE"
base ad:0xa0309080
group 0--3
line.long 0 "MGMT_PERF_CNT_0_ENABLE"
bitfld.long 0 0. " PERF_CNT_0_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_0_LIM_EN "  "0 ,1 "
;tree.end

;tree "MGMT_PERF_CNT_0_SRC"
base ad:0xa0309084
group 0--3
line.long 0 "MGMT_PERF_CNT_0_SRC"
bitfld.long 0 0.--5. " PERF_CNT_0_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "MGMT_PERF_CNT_0_LIMIT"
base ad:0xa0309088
group 0--3
line.long 0 "MGMT_PERF_CNT_0_LIMIT"
hexfld.long 0 " PERF_CNT_0_LIMIT "
;tree.end

;tree "MGMT_PERF_CNT_0_VALUE"
base ad:0xa030908c
group 0--3
line.long 0 "MGMT_PERF_CNT_0_VALUE"
hexfld.long 0 " PERF_CNT_0_VALUE "
;tree.end

;tree "MGMT_PERF_CNT_1_ENABLE"
base ad:0xa03090a0
group 0--3
line.long 0 "MGMT_PERF_CNT_1_ENABLE"
bitfld.long 0 0. " PERF_CNT_1_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_1_LIM_EN "  "0 ,1 "
;tree.end

;tree "MGMT_PERF_CNT_1_SRC"
base ad:0xa03090a4
group 0--3
line.long 0 "MGMT_PERF_CNT_1_SRC"
bitfld.long 0 0.--5. " PERF_CNT_1_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "MGMT_PERF_CNT_1_LIMIT"
base ad:0xa03090a8
group 0--3
line.long 0 "MGMT_PERF_CNT_1_LIMIT"
hexfld.long 0 " PERF_CNT_1_LIMIT "
;tree.end

;tree "MGMT_PERF_CNT_1_VALUE"
base ad:0xa03090ac
group 0--3
line.long 0 "MGMT_PERF_CNT_1_VALUE"
hexfld.long 0 " PERF_CNT_1_VALUE "
;tree.end

;tree "MGMT_PERFMON_CONTR"
base ad:0xa03090b0
group 0--3
line.long 0 "MGMT_PERFMON_CONTR"
bitfld.long 0 0. " PERFMON_ENABLE "  "0 ,1 "
bitfld.long 0 16.--25. " NUMBER_OF_TILEX "  " "
;tree.end

;tree "MGMT_PERFMON_BASE"
base ad:0xa03090b4
group 0--3
line.long 0 "MGMT_PERFMON_BASE"
bitfld.long 0 3.--31. " PERFMON_BASE_ADDR "  " "
;tree.end

;tree "REND_LIST_ADDR_PP1"
base ad:0xa030a000
group 0--3
line.long 0 "REND_LIST_ADDR_PP1"
bitfld.long 0 3.--31. " REND_LIST_ADDR "  " "
;tree.end

;tree "REND_RSW_BASE_PP1"
base ad:0xa030a004
group 0--3
line.long 0 "REND_RSW_BASE_PP1"
bitfld.long 0 6.--31. " REND_RSW_BASE "  " "
;tree.end

;tree "REND_VERTEX_BASE_PP1"
base ad:0xa030a008
group 0--3
line.long 0 "REND_VERTEX_BASE_PP1"
bitfld.long 0 6.--31. " REND_VERTEX_BASE "  " "
;tree.end

;tree "FEATURE_ENABLE_PP1"
base ad:0xa030a00c
group 0--3
line.long 0 "FEATURE_ENABLE_PP1"
bitfld.long 0 0. " FP_TILEBUF_ENABLE "  "0 ,1 "
bitfld.long 0 1. " EARLYZ_ENABLE "  "0 ,1 "
bitfld.long 0 3. " EARLYZ_DISABLE1 "  "0 ,1 "
bitfld.long 0 4. " EARLYZ_DISABLE2 "  "0 ,1 "
bitfld.long 0 5. " ORIGIN_LOWER_LEFT "  "0 ,1 "
bitfld.long 0 6. " SUMMATE_QUAD_COVER "  "0 ,1 "
;tree.end

;tree "Z_CLEAR_VALUE_PP1"
base ad:0xa030a010
group 0--3
line.long 0 "Z_CLEAR_VALUE_PP1"
bitfld.long 0 0.--23. " Z_CLEAR_VALUE "  " "
;tree.end

;tree "STENCIL_CLEAR_VALUE_PP1"
base ad:0xa030a014
group 0--3
line.long 0 "STENCIL_CLEAR_VALUE_PP1"
hexfld.byte 0 " STENCIL_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_0_PP1"
base ad:0xa030a018
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_0_PP1"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_1_PP1"
base ad:0xa030a01c
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_1_PP1"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_2_PP1"
base ad:0xa030a020
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_2_PP1"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_3_PP1"
base ad:0xa030a024
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_3_PP1"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "BOUNDING_BOX_LEFT_RIGHT_PP1"
base ad:0xa030a028
group 0--3
line.long 0 "BOUNDING_BOX_LEFT_RIGHT_PP1"
bitfld.long 0 0.--13. " BOUNDING_BOX_RIGHT "  " "
bitfld.long 0 16.--19. " BOUNDING_BOX_LEFT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "BOUNDING_BOX_BOTTOM_PP1"
base ad:0xa030a02c
group 0--3
line.long 0 "BOUNDING_BOX_BOTTOM_PP1"
bitfld.long 0 0.--13. " BOUNDING_BOX_BOTTOM "  " "
;tree.end

;tree "FS_STACK_ADDR_PP1"
base ad:0xa030a030
group 0--3
line.long 0 "FS_STACK_ADDR_PP1"
bitfld.long 0 3.--31. " FS_STACK_ADDR "  " "
;tree.end

;tree "FS_STACK_SIZE_AND_INIT_VAL_PP1"
base ad:0xa030a034
group 0--3
line.long 0 "FS_STACK_SIZE_AND_INIT_VAL_PP1"
hexfld.word 0 " FP_STACK_SIZE "
hexfld.word 2 " FS_STACK_INIT_VAL "
;tree.end

;tree "ORIGIN_OFFSET_X_PP1"
base ad:0xa030a040
group 0--3
line.long 0 "ORIGIN_OFFSET_X_PP1"
hexfld.word 0 " ORIGIN_OFFSET_X "
;tree.end

;tree "ORIGIN_OFFSET_Y_PP1"
base ad:0xa030a044
group 0--3
line.long 0 "ORIGIN_OFFSET_Y_PP1"
hexfld.word 0 " ORIGIN_OFFSET_Y "
;tree.end

;tree "SUBPIXEL_SPECIFIER_PP1"
base ad:0xa030a048
group 0--3
line.long 0 "SUBPIXEL_SPECIFIER_PP1"
hexfld.byte 0 " SUBPIXEL_SPECIFIER "
;tree.end

;tree "TIEBREAK_MODE_PP1"
base ad:0xa030a04c
group 0--3
line.long 0 "TIEBREAK_MODE_PP1"
bitfld.long 0 0.--2. " TIEBREAK_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLIST_CONFIG_PP1"
base ad:0xa030a050
group 0--3
line.long 0 "PLIST_CONFIG_PP1"
bitfld.long 0 0.--5. " SCALE_X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--21. " SCALE_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 28.--29. " LIST_FORMAT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "SCALING_CONFIG_PP1"
base ad:0xa030a054
group 0--3
line.long 0 "SCALING_CONFIG_PP1"
bitfld.long 0 0. " POINT_AND_LINE_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 1. " DITHERING_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 2. " FRAGCOORD_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " DERIVATIVE_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 8. " FLIP_POINT_SPRITES "  "0 ,1 "
bitfld.long 0 9. " FLIP_DITHERING_MATRIX "  "0 ,1 "
bitfld.long 0 10. " FLIP_FRAGCOORD "  "0 ,1 "
bitfld.long 0 11. " FLIP_DERIVATIVE_Y "  "0 ,1 "
bitfld.long 0 16.--18. " SCALE_X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " SCALE_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "TILEBUFFER_BITS_PP1"
base ad:0xa030a058
group 0--3
line.long 0 "TILEBUFFER_BITS_PP1"
bitfld.long 0 0.--3. " TILEBUFFER_R_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " TILEBUFFER_G_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TILEBUFFER_B_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " TILEBUFFER_A_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB0_SOURCE_SELECT_PP1"
base ad:0xa030a100
group 0--3
line.long 0 "WB0_SOURCE_SELECT_PP1"
bitfld.long 0 0.--1. " WB0_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB0_TARGET_ADDR_PP1"
base ad:0xa030a104
group 0--3
line.long 0 "WB0_TARGET_ADDR_PP1"
bitfld.long 0 3.--31. " WB0_TARGET_ADDR "  " "
;tree.end

;tree "WB0_TARGET_PIXEL_FORMAT_PP1"
base ad:0xa030a108
group 0--3
line.long 0 "WB0_TARGET_PIXEL_FORMAT_PP1"
bitfld.long 0 0.--3. " WB0_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB0_TARGET_AA_FORMAT_PP1"
base ad:0xa030a10c
group 0--3
line.long 0 "WB0_TARGET_AA_FORMAT_PP1"
bitfld.long 0 0.--2. " WB0_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB0_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB0_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB0_TARGET_LAYOUT_PP1"
base ad:0xa030a110
group 0--3
line.long 0 "WB0_TARGET_LAYOUT_PP1"
bitfld.long 0 0.--1. " WB0_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB0_TARGET_SCANLINE_LENGTH_PP1"
base ad:0xa030a114
group 0--3
line.long 0 "WB0_TARGET_SCANLINE_LENGTH_PP1"
hexfld.word 0 " WB0_TARGET_SCANLINE_LENGTH "
;tree.end

;tree "WB0_TARGET_FLAGS_PP1"
base ad:0xa030a118
group 0--3
line.long 0 "WB0_TARGET_FLAGS_PP1"
bitfld.long 0 0. " WB0_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB0_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB0_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB0_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB0_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB0_BIG_ENDIAN "  "0 ,1 "
;tree.end

;tree "WB0_MRT_ENABLE_PP1"
base ad:0xa030a11c
group 0--3
line.long 0 "WB0_MRT_ENABLE_PP1"
bitfld.long 0 0.--3. " WB0_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB0_MRT_OFFSET_PP1"
base ad:0xa030a120
group 0--3
line.long 0 "WB0_MRT_OFFSET_PP1"
bitfld.long 0 3.--31. " WB0_MRT_OFFSET "  " "
;tree.end

;tree "WB0_GLOBAL_TEST_ENABLE_PP1"
base ad:0xa030a124
group 0--3
line.long 0 "WB0_GLOBAL_TEST_ENABLE_PP1"
bitfld.long 0 0. " WB0_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

;tree "WB0_GLOBAL_TEST_REF_VALUE_PP1"
base ad:0xa030a128
group 0--3
line.long 0 "WB0_GLOBAL_TEST_REF_VALUE_PP1"
hexfld.word 0 " WB0_GLOBAL_TEST_REF_VALUE "
;tree.end

;tree "WB0_GLOBAL_TEST_CMP_FUNC_PP1"
base ad:0xa030a12c
group 0--3
line.long 0 "WB0_GLOBAL_TEST_CMP_FUNC_PP1"
bitfld.long 0 0.--2. " WB0_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB1_SOURCE_SELECT_PP1"
base ad:0xa030a200
group 0--3
line.long 0 "WB1_SOURCE_SELECT_PP1"
bitfld.long 0 0.--1. " WB1_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB1_TARGET_ADDR_PP1"
base ad:0xa030a204
group 0--3
line.long 0 "WB1_TARGET_ADDR_PP1"
bitfld.long 0 3.--31. " WB1_TARGET_ADDR "  " "
;tree.end

;tree "WB1_TARGET_PIXEL_FORMAT_PP1"
base ad:0xa030a208
group 0--3
line.long 0 "WB1_TARGET_PIXEL_FORMAT_PP1"
bitfld.long 0 0.--3. " WB1_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB1_TARGET_AA_FORMAT_PP1"
base ad:0xa030a20c
group 0--3
line.long 0 "WB1_TARGET_AA_FORMAT_PP1"
bitfld.long 0 0.--2. " WB1_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB1_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB1_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB1_TARGET_LAYOUT_PP1"
base ad:0xa030a210
group 0--3
line.long 0 "WB1_TARGET_LAYOUT_PP1"
bitfld.long 0 0.--1. " WB1_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB1_TARGET_SCANLINE_LENGTH_PP1"
base ad:0xa030a214
group 0--3
line.long 0 "WB1_TARGET_SCANLINE_LENGTH_PP1"
hexfld.word 0 " WB1_TARGET_SCANLINE_LENGTH "
;tree.end

;tree "WB1_TARGET_FLAGS_PP1"
base ad:0xa030a218
group 0--3
line.long 0 "WB1_TARGET_FLAGS_PP1"
bitfld.long 0 0. " WB1_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB1_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB1_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB1_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB1_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB1_BIG_ENDIAN "  "0 ,1 "
;tree.end

;tree "WB1_MRT_ENABLE_PP1"
base ad:0xa030a21c
group 0--3
line.long 0 "WB1_MRT_ENABLE_PP1"
bitfld.long 0 0.--3. " WB1_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB1_MRT_OFFSET_PP1"
base ad:0xa030a220
group 0--3
line.long 0 "WB1_MRT_OFFSET_PP1"
bitfld.long 0 3.--31. " WB1_MRT_OFFSET "  " "
;tree.end

;tree "WB1_GLOBAL_TEST_ENABLE_PP1"
base ad:0xa030a224
group 0--3
line.long 0 "WB1_GLOBAL_TEST_ENABLE_PP1"
bitfld.long 0 0. " WB1_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

;tree "WB1_GLOBAL_TEST_REF_VALUE_PP1"
base ad:0xa030a228
group 0--3
line.long 0 "WB1_GLOBAL_TEST_REF_VALUE_PP1"
hexfld.word 0 " WB1_GLOBAL_TEST_REF_VALUE "
;tree.end

;tree "WB1_GLOBAL_TEST_CMP_FUNC_PP1"
base ad:0xa030a22c
group 0--3
line.long 0 "WB1_GLOBAL_TEST_CMP_FUNC_PP1"
bitfld.long 0 0.--2. " WB1_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB2_SOURCE_SELECT_PP1"
base ad:0xa030a300
group 0--3
line.long 0 "WB2_SOURCE_SELECT_PP1"
bitfld.long 0 0.--1. " WB2_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB2_TARGET_ADDR_PP1"
base ad:0xa030a304
group 0--3
line.long 0 "WB2_TARGET_ADDR_PP1"
bitfld.long 0 3.--31. " WB2_TARGET_ADDR "  " "
;tree.end

;tree "WB2_TARGET_PIXEL_FORMAT_PP1"
base ad:0xa030a308
group 0--3
line.long 0 "WB2_TARGET_PIXEL_FORMAT_PP1"
bitfld.long 0 0.--3. " WB2_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB2_TARGET_AA_FORMAT_PP1"
base ad:0xa030a30c
group 0--3
line.long 0 "WB2_TARGET_AA_FORMAT_PP1"
bitfld.long 0 0.--2. " WB2_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB2_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB2_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB2_TARGET_LAYOUT_PP1"
base ad:0xa030a310
group 0--3
line.long 0 "WB2_TARGET_LAYOUT_PP1"
bitfld.long 0 0.--1. " WB2_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB2_TARGET_SCANLINE_LENGTH_PP1"
base ad:0xa030a314
group 0--3
line.long 0 "WB2_TARGET_SCANLINE_LENGTH_PP1"
hexfld.word 0 " WB2_TARGET_SCANLINE_LENGTH "
;tree.end

;tree "WB2_TARGET_FLAGS_PP1"
base ad:0xa030a318
group 0--3
line.long 0 "WB2_TARGET_FLAGS_PP1"
bitfld.long 0 0. " WB2_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB2_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB2_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB2_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB2_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB2_BIG_ENDIAN "  "0 ,1 "
;tree.end

;tree "WB2_MRT_ENABLE_PP1"
base ad:0xa030a31c
group 0--3
line.long 0 "WB2_MRT_ENABLE_PP1"
bitfld.long 0 0.--3. " WB2_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB2_MRT_OFFSET_PP1"
base ad:0xa030a320
group 0--3
line.long 0 "WB2_MRT_OFFSET_PP1"
bitfld.long 0 3.--31. " WB2_MRT_OFFSET "  " "
;tree.end

;tree "WB2_GLOBAL_TEST_ENABLE_PP1"
base ad:0xa030a324
group 0--3
line.long 0 "WB2_GLOBAL_TEST_ENABLE_PP1"
bitfld.long 0 0. " WB2_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

;tree "WB2_GLOBAL_TEST_REF_VALUE_PP1"
base ad:0xa030a328
group 0--3
line.long 0 "WB2_GLOBAL_TEST_REF_VALUE_PP1"
hexfld.word 0 " WB2_GLOBAL_TEST_REF_VALUE "
;tree.end

;tree "WB2_GLOBAL_TEST_CMP_FUNC_PP1"
base ad:0xa030a32c
group 0--3
line.long 0 "WB2_GLOBAL_TEST_CMP_FUNC_PP1"
bitfld.long 0 0.--2. " WB2_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "MGMT_VERSION_PP1"
base ad:0xa030b000
rgroup 0--3
line.long 0 "MGMT_VERSION_PP1"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 2 " PRODUCT_ID "
;tree.end

;tree "MGMT_CURRENT_REND_LIST_ADDR_PP1"
base ad:0xa030b004
group 0--3
line.long 0 "MGMT_CURRENT_REND_LIST_ADDR_PP1"
bitfld.long 0 5.--31. " CURRENT_REND_LIST_ADDR "  " "
;tree.end

;tree "MGMT_STATUS_PP1"
base ad:0xa030b008
group 0--3
line.long 0 "MGMT_STATUS_PP1"
bitfld.long 0 0. " RENDERING_ACTIVE "  "0 ,1 "
bitfld.long 0 1. " TILE_STOPPED "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 4. " BUS_STOPPED "  "0 ,1 "
bitfld.long 0 5. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 6. " INTERRUPT_ASSERTED "  "0 ,1 "
bitfld.long 0 7. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

;tree "MGMT_CTRL_PP1"
base ad:0xa030b00c
group 0--3
line.long 0 "MGMT_CTRL_PP1"
bitfld.long 0 0. " STOP_BUS "  "0 ,1 "
bitfld.long 0 1. " START_BUS "  "0 ,1 "
bitfld.long 0 2. " END_AFTER_TILE "  "0 ,1 "
bitfld.long 0 3. " FLUSH_CACHES "  "0 ,1 "
bitfld.long 0 4. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 5. " FORCE_RESET "  "0 ,1 "
bitfld.long 0 6. " START_RENDERING "  "0 ,1 "
bitfld.long 0 7. " SOFT_RESET "  "0 ,1 "
bitfld.long 0 8. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

;tree "MGMT_LAST_TILE_POS_START_PP1"
base ad:0xa030b010
rgroup 0--3
line.long 0 "MGMT_LAST_TILE_POS_START_PP1"
hexfld.byte 0 " TILEX_START "
hexfld.byte 2 " TILEY_START "
;tree.end

;tree "MGMT_LAST_TILE_POS_END_PP1"
base ad:0xa030b014
rgroup 0--3
line.long 0 "MGMT_LAST_TILE_POS_END_PP1"
hexfld.byte 0 " TILEX_END "
hexfld.byte 2 " TILEY_END "
;tree.end

;tree "MGMT_INT_RAWSTAT_PP1"
base ad:0xa030b020
group 0--3
line.long 0 "MGMT_INT_RAWSTAT_PP1"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_INT_CLEAR_PP1"
base ad:0xa030b024
group 0--3
line.long 0 "MGMT_INT_CLEAR_PP1"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_INT_MASK_PP1"
base ad:0xa030b028
group 0--3
line.long 0 "MGMT_INT_MASK_PP1"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_INT_STATUS_PP1"
base ad:0xa030b02c
rgroup 0--3
line.long 0 "MGMT_INT_STATUS_PP1"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_ENABLE_PP1"
base ad:0xa030b040
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ENABLE_PP1"
bitfld.long 0 0. " WRITE_BOUNDARY_ENABLE "  "0 ,1 "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_LOW_PP1"
base ad:0xa030b044
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_LOW_PP1"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_LOW "  " "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_HIGH_PP1"
base ad:0xa030b048
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_HIGH_PP1"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_HIGH "  " "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_ADDRESS_PP1"
base ad:0xa030b04c
rgroup 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ADDRESS_PP1"
bitfld.long 0 2.--31. " WRITE_BOUNDARY_ADDRESS "  " "
;tree.end

;tree "MGMT_BUS_ERROR_STATUS_PP1"
base ad:0xa030b050
rgroup 0--3
line.long 0 "MGMT_BUS_ERROR_STATUS_PP1"
bitfld.long 0 0. " WRITE_ERROR "  "0 ,1 "
bitfld.long 0 1. " READ_ERROR "  "0 ,1 "
bitfld.long 0 2.--5. " WRITE_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--9. " READ_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "MGMT_WATCHDOG_DISABLE_PP1"
base ad:0xa030b060
group 0--3
line.long 0 "MGMT_WATCHDOG_DISABLE_PP1"
bitfld.long 0 0. " WATCHDOG_DISABLE "  "0 ,1 "
;tree.end

;tree "MGMT_WATCHDOG_TIMEOUT_PP1"
base ad:0xa030b064
group 0--3
line.long 0 "MGMT_WATCHDOG_TIMEOUT_PP1"
hexfld.long 0 " WATCHDOG_TIMEOUT "
;tree.end

;tree "MGMT_PERF_CNT_0_ENABLE_PP1"
base ad:0xa030b080
group 0--3
line.long 0 "MGMT_PERF_CNT_0_ENABLE_PP1"
bitfld.long 0 0. " PERF_CNT_0_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_0_LIM_EN "  "0 ,1 "
;tree.end

;tree "MGMT_PERF_CNT_0_SRC_PP1"
base ad:0xa030b084
group 0--3
line.long 0 "MGMT_PERF_CNT_0_SRC_PP1"
bitfld.long 0 0.--5. " PERF_CNT_0_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "MGMT_PERF_CNT_0_LIMIT_PP1"
base ad:0xa030b088
group 0--3
line.long 0 "MGMT_PERF_CNT_0_LIMIT_PP1"
hexfld.long 0 " PERF_CNT_0_LIMIT "
;tree.end

;tree "MGMT_PERF_CNT_0_VALUE_PP1"
base ad:0xa030b08c
group 0--3
line.long 0 "MGMT_PERF_CNT_0_VALUE_PP1"
hexfld.long 0 " PERF_CNT_0_VALUE "
;tree.end

;tree "MGMT_PERF_CNT_1_ENABLE_PP1"
base ad:0xa030b0a0
group 0--3
line.long 0 "MGMT_PERF_CNT_1_ENABLE_PP1"
bitfld.long 0 0. " PERF_CNT_1_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_1_LIM_EN "  "0 ,1 "
;tree.end

;tree "MGMT_PERF_CNT_1_SRC_PP1"
base ad:0xa030b0a4
group 0--3
line.long 0 "MGMT_PERF_CNT_1_SRC_PP1"
bitfld.long 0 0.--5. " PERF_CNT_1_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "MGMT_PERF_CNT_1_LIMIT_PP1"
base ad:0xa030b0a8
group 0--3
line.long 0 "MGMT_PERF_CNT_1_LIMIT_PP1"
hexfld.long 0 " PERF_CNT_1_LIMIT "
;tree.end

;tree "MGMT_PERF_CNT_1_VALUE_PP1"
base ad:0xa030b0ac
group 0--3
line.long 0 "MGMT_PERF_CNT_1_VALUE_PP1"
hexfld.long 0 " PERF_CNT_1_VALUE "
;tree.end

;tree "MGMT_PERFMON_CONTR_PP1"
base ad:0xa030b0b0
group 0--3
line.long 0 "MGMT_PERFMON_CONTR_PP1"
bitfld.long 0 0. " PERFMON_ENABLE "  "0 ,1 "
bitfld.long 0 16.--25. " NUMBER_OF_TILEX "  " "
;tree.end

;tree "MGMT_PERFMON_BASE_PP1"
base ad:0xa030b0b4
group 0--3
line.long 0 "MGMT_PERFMON_BASE_PP1"
bitfld.long 0 3.--31. " PERFMON_BASE_ADDR "  " "
;tree.end

;tree "REND_LIST_ADDR_PP2"
base ad:0xa030c000
group 0--3
line.long 0 "REND_LIST_ADDR_PP2"
bitfld.long 0 3.--31. " REND_LIST_ADDR "  " "
;tree.end

;tree "REND_RSW_BASE_PP2"
base ad:0xa030c004
group 0--3
line.long 0 "REND_RSW_BASE_PP2"
bitfld.long 0 6.--31. " REND_RSW_BASE "  " "
;tree.end

;tree "REND_VERTEX_BASE_PP2"
base ad:0xa030c008
group 0--3
line.long 0 "REND_VERTEX_BASE_PP2"
bitfld.long 0 6.--31. " REND_VERTEX_BASE "  " "
;tree.end

;tree "FEATURE_ENABLE_PP2"
base ad:0xa030c00c
group 0--3
line.long 0 "FEATURE_ENABLE_PP2"
bitfld.long 0 0. " FP_TILEBUF_ENABLE "  "0 ,1 "
bitfld.long 0 1. " EARLYZ_ENABLE "  "0 ,1 "
bitfld.long 0 3. " EARLYZ_DISABLE1 "  "0 ,1 "
bitfld.long 0 4. " EARLYZ_DISABLE2 "  "0 ,1 "
bitfld.long 0 5. " ORIGIN_LOWER_LEFT "  "0 ,1 "
bitfld.long 0 6. " SUMMATE_QUAD_COVER "  "0 ,1 "
;tree.end

;tree "Z_CLEAR_VALUE_PP2"
base ad:0xa030c010
group 0--3
line.long 0 "Z_CLEAR_VALUE_PP2"
bitfld.long 0 0.--23. " Z_CLEAR_VALUE "  " "
;tree.end

;tree "STENCIL_CLEAR_VALUE_PP2"
base ad:0xa030c014
group 0--3
line.long 0 "STENCIL_CLEAR_VALUE_PP2"
hexfld.byte 0 " STENCIL_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_0_PP2"
base ad:0xa030c018
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_0_PP2"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_1_PP2"
base ad:0xa030c01c
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_1_PP2"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_2_PP2"
base ad:0xa030c020
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_2_PP2"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_3_PP2"
base ad:0xa030c024
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_3_PP2"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "BOUNDING_BOX_LEFT_RIGHT_PP2"
base ad:0xa030c028
group 0--3
line.long 0 "BOUNDING_BOX_LEFT_RIGHT_PP2"
bitfld.long 0 0.--13. " BOUNDING_BOX_RIGHT "  " "
bitfld.long 0 16.--19. " BOUNDING_BOX_LEFT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "BOUNDING_BOX_BOTTOM_PP2"
base ad:0xa030c02c
group 0--3
line.long 0 "BOUNDING_BOX_BOTTOM_PP2"
bitfld.long 0 0.--13. " BOUNDING_BOX_BOTTOM "  " "
;tree.end

;tree "FS_STACK_ADDR_PP2"
base ad:0xa030c030
group 0--3
line.long 0 "FS_STACK_ADDR_PP2"
bitfld.long 0 3.--31. " FS_STACK_ADDR "  " "
;tree.end

;tree "FS_STACK_SIZE_AND_INIT_VAL_PP2"
base ad:0xa030c034
group 0--3
line.long 0 "FS_STACK_SIZE_AND_INIT_VAL_PP2"
hexfld.word 0 " FP_STACK_SIZE "
hexfld.word 2 " FS_STACK_INIT_VAL "
;tree.end

;tree "ORIGIN_OFFSET_X_PP2"
base ad:0xa030c040
group 0--3
line.long 0 "ORIGIN_OFFSET_X_PP2"
hexfld.word 0 " ORIGIN_OFFSET_X "
;tree.end

;tree "ORIGIN_OFFSET_Y_PP2"
base ad:0xa030c044
group 0--3
line.long 0 "ORIGIN_OFFSET_Y_PP2"
hexfld.word 0 " ORIGIN_OFFSET_Y "
;tree.end

;tree "SUBPIXEL_SPECIFIER_PP2"
base ad:0xa030c048
group 0--3
line.long 0 "SUBPIXEL_SPECIFIER_PP2"
hexfld.byte 0 " SUBPIXEL_SPECIFIER "
;tree.end

;tree "TIEBREAK_MODE_PP2"
base ad:0xa030c04c
group 0--3
line.long 0 "TIEBREAK_MODE_PP2"
bitfld.long 0 0.--2. " TIEBREAK_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLIST_CONFIG_PP2"
base ad:0xa030c050
group 0--3
line.long 0 "PLIST_CONFIG_PP2"
bitfld.long 0 0.--5. " SCALE_X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--21. " SCALE_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 28.--29. " LIST_FORMAT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "SCALING_CONFIG_PP2"
base ad:0xa030c054
group 0--3
line.long 0 "SCALING_CONFIG_PP2"
bitfld.long 0 0. " POINT_AND_LINE_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 1. " DITHERING_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 2. " FRAGCOORD_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " DERIVATIVE_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 8. " FLIP_POINT_SPRITES "  "0 ,1 "
bitfld.long 0 9. " FLIP_DITHERING_MATRIX "  "0 ,1 "
bitfld.long 0 10. " FLIP_FRAGCOORD "  "0 ,1 "
bitfld.long 0 11. " FLIP_DERIVATIVE_Y "  "0 ,1 "
bitfld.long 0 16.--18. " SCALE_X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " SCALE_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "TILEBUFFER_BITS_PP2"
base ad:0xa030c058
group 0--3
line.long 0 "TILEBUFFER_BITS_PP2"
bitfld.long 0 0.--3. " TILEBUFFER_R_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " TILEBUFFER_G_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TILEBUFFER_B_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " TILEBUFFER_A_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB0_SOURCE_SELECT_PP2"
base ad:0xa030c100
group 0--3
line.long 0 "WB0_SOURCE_SELECT_PP2"
bitfld.long 0 0.--1. " WB0_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB0_TARGET_ADDR_PP2"
base ad:0xa030c104
group 0--3
line.long 0 "WB0_TARGET_ADDR_PP2"
bitfld.long 0 3.--31. " WB0_TARGET_ADDR "  " "
;tree.end

;tree "WB0_TARGET_PIXEL_FORMAT_PP2"
base ad:0xa030c108
group 0--3
line.long 0 "WB0_TARGET_PIXEL_FORMAT_PP2"
bitfld.long 0 0.--3. " WB0_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB0_TARGET_AA_FORMAT_PP2"
base ad:0xa030c10c
group 0--3
line.long 0 "WB0_TARGET_AA_FORMAT_PP2"
bitfld.long 0 0.--2. " WB0_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB0_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB0_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB0_TARGET_LAYOUT_PP2"
base ad:0xa030c110
group 0--3
line.long 0 "WB0_TARGET_LAYOUT_PP2"
bitfld.long 0 0.--1. " WB0_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB0_TARGET_SCANLINE_LENGTH_PP2"
base ad:0xa030c114
group 0--3
line.long 0 "WB0_TARGET_SCANLINE_LENGTH_PP2"
hexfld.word 0 " WB0_TARGET_SCANLINE_LENGTH "
;tree.end

;tree "WB0_TARGET_FLAGS_PP2"
base ad:0xa030c118
group 0--3
line.long 0 "WB0_TARGET_FLAGS_PP2"
bitfld.long 0 0. " WB0_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB0_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB0_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB0_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB0_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB0_BIG_ENDIAN "  "0 ,1 "
;tree.end

;tree "WB0_MRT_ENABLE_PP2"
base ad:0xa030c11c
group 0--3
line.long 0 "WB0_MRT_ENABLE_PP2"
bitfld.long 0 0.--3. " WB0_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB0_MRT_OFFSET_PP2"
base ad:0xa030c120
group 0--3
line.long 0 "WB0_MRT_OFFSET_PP2"
bitfld.long 0 3.--31. " WB0_MRT_OFFSET "  " "
;tree.end

;tree "WB0_GLOBAL_TEST_ENABLE_PP2"
base ad:0xa030c124
group 0--3
line.long 0 "WB0_GLOBAL_TEST_ENABLE_PP2"
bitfld.long 0 0. " WB0_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

;tree "WB0_GLOBAL_TEST_REF_VALUE_PP2"
base ad:0xa030c128
group 0--3
line.long 0 "WB0_GLOBAL_TEST_REF_VALUE_PP2"
hexfld.word 0 " WB0_GLOBAL_TEST_REF_VALUE "
;tree.end

;tree "WB0_GLOBAL_TEST_CMP_FUNC_PP2"
base ad:0xa030c12c
group 0--3
line.long 0 "WB0_GLOBAL_TEST_CMP_FUNC_PP2"
bitfld.long 0 0.--2. " WB0_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB1_SOURCE_SELECT_PP2"
base ad:0xa030c200
group 0--3
line.long 0 "WB1_SOURCE_SELECT_PP2"
bitfld.long 0 0.--1. " WB1_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB1_TARGET_ADDR_PP2"
base ad:0xa030c204
group 0--3
line.long 0 "WB1_TARGET_ADDR_PP2"
bitfld.long 0 3.--31. " WB1_TARGET_ADDR "  " "
;tree.end

;tree "WB1_TARGET_PIXEL_FORMAT_PP2"
base ad:0xa030c208
group 0--3
line.long 0 "WB1_TARGET_PIXEL_FORMAT_PP2"
bitfld.long 0 0.--3. " WB1_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB1_TARGET_AA_FORMAT_PP2"
base ad:0xa030c20c
group 0--3
line.long 0 "WB1_TARGET_AA_FORMAT_PP2"
bitfld.long 0 0.--2. " WB1_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB1_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB1_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB1_TARGET_LAYOUT_PP2"
base ad:0xa030c210
group 0--3
line.long 0 "WB1_TARGET_LAYOUT_PP2"
bitfld.long 0 0.--1. " WB1_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB1_TARGET_SCANLINE_LENGTH_PP2"
base ad:0xa030c214
group 0--3
line.long 0 "WB1_TARGET_SCANLINE_LENGTH_PP2"
hexfld.word 0 " WB1_TARGET_SCANLINE_LENGTH "
;tree.end

;tree "WB1_TARGET_FLAGS_PP2"
base ad:0xa030c218
group 0--3
line.long 0 "WB1_TARGET_FLAGS_PP2"
bitfld.long 0 0. " WB1_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB1_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB1_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB1_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB1_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB1_BIG_ENDIAN "  "0 ,1 "
;tree.end

;tree "WB1_MRT_ENABLE_PP2"
base ad:0xa030c21c
group 0--3
line.long 0 "WB1_MRT_ENABLE_PP2"
bitfld.long 0 0.--3. " WB1_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB1_MRT_OFFSET_PP2"
base ad:0xa030c220
group 0--3
line.long 0 "WB1_MRT_OFFSET_PP2"
bitfld.long 0 3.--31. " WB1_MRT_OFFSET "  " "
;tree.end

;tree "WB1_GLOBAL_TEST_ENABLE_PP2"
base ad:0xa030c224
group 0--3
line.long 0 "WB1_GLOBAL_TEST_ENABLE_PP2"
bitfld.long 0 0. " WB1_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

;tree "WB1_GLOBAL_TEST_REF_VALUE_PP2"
base ad:0xa030c228
group 0--3
line.long 0 "WB1_GLOBAL_TEST_REF_VALUE_PP2"
hexfld.word 0 " WB1_GLOBAL_TEST_REF_VALUE "
;tree.end

;tree "WB1_GLOBAL_TEST_CMP_FUNC_PP2"
base ad:0xa030c22c
group 0--3
line.long 0 "WB1_GLOBAL_TEST_CMP_FUNC_PP2"
bitfld.long 0 0.--2. " WB1_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB2_SOURCE_SELECT_PP2"
base ad:0xa030c300
group 0--3
line.long 0 "WB2_SOURCE_SELECT_PP2"
bitfld.long 0 0.--1. " WB2_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB2_TARGET_ADDR_PP2"
base ad:0xa030c304
group 0--3
line.long 0 "WB2_TARGET_ADDR_PP2"
bitfld.long 0 3.--31. " WB2_TARGET_ADDR "  " "
;tree.end

;tree "WB2_TARGET_PIXEL_FORMAT_PP2"
base ad:0xa030c308
group 0--3
line.long 0 "WB2_TARGET_PIXEL_FORMAT_PP2"
bitfld.long 0 0.--3. " WB2_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB2_TARGET_AA_FORMAT_PP2"
base ad:0xa030c30c
group 0--3
line.long 0 "WB2_TARGET_AA_FORMAT_PP2"
bitfld.long 0 0.--2. " WB2_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB2_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB2_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB2_TARGET_LAYOUT_PP2"
base ad:0xa030c310
group 0--3
line.long 0 "WB2_TARGET_LAYOUT_PP2"
bitfld.long 0 0.--1. " WB2_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB2_TARGET_SCANLINE_LENGTH_PP2"
base ad:0xa030c314
group 0--3
line.long 0 "WB2_TARGET_SCANLINE_LENGTH_PP2"
hexfld.word 0 " WB2_TARGET_SCANLINE_LENGTH "
;tree.end

;tree "WB2_TARGET_FLAGS_PP2"
base ad:0xa030c318
group 0--3
line.long 0 "WB2_TARGET_FLAGS_PP2"
bitfld.long 0 0. " WB2_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB2_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB2_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB2_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB2_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB2_BIG_ENDIAN "  "0 ,1 "
;tree.end

;tree "WB2_MRT_ENABLE_PP2"
base ad:0xa030c31c
group 0--3
line.long 0 "WB2_MRT_ENABLE_PP2"
bitfld.long 0 0.--3. " WB2_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB2_MRT_OFFSET_PP2"
base ad:0xa030c320
group 0--3
line.long 0 "WB2_MRT_OFFSET_PP2"
bitfld.long 0 3.--31. " WB2_MRT_OFFSET "  " "
;tree.end

;tree "WB2_GLOBAL_TEST_ENABLE_PP2"
base ad:0xa030c324
group 0--3
line.long 0 "WB2_GLOBAL_TEST_ENABLE_PP2"
bitfld.long 0 0. " WB2_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

;tree "WB2_GLOBAL_TEST_REF_VALUE_PP2"
base ad:0xa030c328
group 0--3
line.long 0 "WB2_GLOBAL_TEST_REF_VALUE_PP2"
hexfld.word 0 " WB2_GLOBAL_TEST_REF_VALUE "
;tree.end

;tree "WB2_GLOBAL_TEST_CMP_FUNC_PP2"
base ad:0xa030c32c
group 0--3
line.long 0 "WB2_GLOBAL_TEST_CMP_FUNC_PP2"
bitfld.long 0 0.--2. " WB2_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "MGMT_VERSION_PP2"
base ad:0xa030d000
rgroup 0--3
line.long 0 "MGMT_VERSION_PP2"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 2 " PRODUCT_ID "
;tree.end

;tree "MGMT_CURRENT_REND_LIST_ADDR_PP2"
base ad:0xa030d004
group 0--3
line.long 0 "MGMT_CURRENT_REND_LIST_ADDR_PP2"
bitfld.long 0 5.--31. " CURRENT_REND_LIST_ADDR "  " "
;tree.end

;tree "MGMT_STATUS_PP2"
base ad:0xa030d008
group 0--3
line.long 0 "MGMT_STATUS_PP2"
bitfld.long 0 0. " RENDERING_ACTIVE "  "0 ,1 "
bitfld.long 0 1. " TILE_STOPPED "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 4. " BUS_STOPPED "  "0 ,1 "
bitfld.long 0 5. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 6. " INTERRUPT_ASSERTED "  "0 ,1 "
bitfld.long 0 7. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

;tree "MGMT_CTRL_PP2"
base ad:0xa030d00c
group 0--3
line.long 0 "MGMT_CTRL_PP2"
bitfld.long 0 0. " STOP_BUS "  "0 ,1 "
bitfld.long 0 1. " START_BUS "  "0 ,1 "
bitfld.long 0 2. " END_AFTER_TILE "  "0 ,1 "
bitfld.long 0 3. " FLUSH_CACHES "  "0 ,1 "
bitfld.long 0 4. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 5. " FORCE_RESET "  "0 ,1 "
bitfld.long 0 6. " START_RENDERING "  "0 ,1 "
bitfld.long 0 7. " SOFT_RESET "  "0 ,1 "
bitfld.long 0 8. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

;tree "MGMT_LAST_TILE_POS_START_PP2"
base ad:0xa030d010
rgroup 0--3
line.long 0 "MGMT_LAST_TILE_POS_START_PP2"
hexfld.byte 0 " TILEX_START "
hexfld.byte 2 " TILEY_START "
;tree.end

;tree "MGMT_LAST_TILE_POS_END_PP2"
base ad:0xa030d014
rgroup 0--3
line.long 0 "MGMT_LAST_TILE_POS_END_PP2"
hexfld.byte 0 " TILEX_END "
hexfld.byte 2 " TILEY_END "
;tree.end

;tree "MGMT_INT_RAWSTAT_PP2"
base ad:0xa030d020
group 0--3
line.long 0 "MGMT_INT_RAWSTAT_PP2"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_INT_CLEAR_PP2"
base ad:0xa030d024
group 0--3
line.long 0 "MGMT_INT_CLEAR_PP2"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_INT_MASK_PP2"
base ad:0xa030d028
group 0--3
line.long 0 "MGMT_INT_MASK_PP2"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_INT_STATUS_PP2"
base ad:0xa030d02c
rgroup 0--3
line.long 0 "MGMT_INT_STATUS_PP2"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_ENABLE_PP2"
base ad:0xa030d040
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ENABLE_PP2"
bitfld.long 0 0. " WRITE_BOUNDARY_ENABLE "  "0 ,1 "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_LOW_PP2"
base ad:0xa030d044
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_LOW_PP2"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_LOW "  " "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_HIGH_PP2"
base ad:0xa030d048
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_HIGH_PP2"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_HIGH "  " "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_ADDRESS_PP2"
base ad:0xa030d04c
rgroup 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ADDRESS_PP2"
bitfld.long 0 2.--31. " WRITE_BOUNDARY_ADDRESS "  " "
;tree.end

;tree "MGMT_BUS_ERROR_STATUS_PP2"
base ad:0xa030d050
rgroup 0--3
line.long 0 "MGMT_BUS_ERROR_STATUS_PP2"
bitfld.long 0 0. " WRITE_ERROR "  "0 ,1 "
bitfld.long 0 1. " READ_ERROR "  "0 ,1 "
bitfld.long 0 2.--5. " WRITE_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--9. " READ_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "MGMT_WATCHDOG_DISABLE_PP2"
base ad:0xa030d060
group 0--3
line.long 0 "MGMT_WATCHDOG_DISABLE_PP2"
bitfld.long 0 0. " WATCHDOG_DISABLE "  "0 ,1 "
;tree.end

;tree "MGMT_WATCHDOG_TIMEOUT_PP2"
base ad:0xa030d064
group 0--3
line.long 0 "MGMT_WATCHDOG_TIMEOUT_PP2"
hexfld.long 0 " WATCHDOG_TIMEOUT "
;tree.end

;tree "MGMT_PERF_CNT_0_ENABLE_PP2"
base ad:0xa030d080
group 0--3
line.long 0 "MGMT_PERF_CNT_0_ENABLE_PP2"
bitfld.long 0 0. " PERF_CNT_0_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_0_LIM_EN "  "0 ,1 "
;tree.end

;tree "MGMT_PERF_CNT_0_SRC_PP2"
base ad:0xa030d084
group 0--3
line.long 0 "MGMT_PERF_CNT_0_SRC_PP2"
bitfld.long 0 0.--5. " PERF_CNT_0_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "MGMT_PERF_CNT_0_LIMIT_PP2"
base ad:0xa030d088
group 0--3
line.long 0 "MGMT_PERF_CNT_0_LIMIT_PP2"
hexfld.long 0 " PERF_CNT_0_LIMIT "
;tree.end

;tree "MGMT_PERF_CNT_0_VALUE_PP2"
base ad:0xa030d08c
group 0--3
line.long 0 "MGMT_PERF_CNT_0_VALUE_PP2"
hexfld.long 0 " PERF_CNT_0_VALUE "
;tree.end

;tree "MGMT_PERF_CNT_1_ENABLE_PP2"
base ad:0xa030d0a0
group 0--3
line.long 0 "MGMT_PERF_CNT_1_ENABLE_PP2"
bitfld.long 0 0. " PERF_CNT_1_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_1_LIM_EN "  "0 ,1 "
;tree.end

;tree "MGMT_PERF_CNT_1_SRC_PP2"
base ad:0xa030d0a4
group 0--3
line.long 0 "MGMT_PERF_CNT_1_SRC_PP2"
bitfld.long 0 0.--5. " PERF_CNT_1_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "MGMT_PERF_CNT_1_LIMIT_PP2"
base ad:0xa030d0a8
group 0--3
line.long 0 "MGMT_PERF_CNT_1_LIMIT_PP2"
hexfld.long 0 " PERF_CNT_1_LIMIT "
;tree.end

;tree "MGMT_PERF_CNT_1_VALUE_PP2"
base ad:0xa030d0ac
group 0--3
line.long 0 "MGMT_PERF_CNT_1_VALUE_PP2"
hexfld.long 0 " PERF_CNT_1_VALUE "
;tree.end

;tree "MGMT_PERFMON_CONTR_PP2"
base ad:0xa030d0b0
group 0--3
line.long 0 "MGMT_PERFMON_CONTR_PP2"
bitfld.long 0 0. " PERFMON_ENABLE "  "0 ,1 "
bitfld.long 0 16.--25. " NUMBER_OF_TILEX "  " "
;tree.end

;tree "MGMT_PERFMON_BASE_PP2"
base ad:0xa030d0b4
group 0--3
line.long 0 "MGMT_PERFMON_BASE_PP2"
bitfld.long 0 3.--31. " PERFMON_BASE_ADDR "  " "
;tree.end

;tree "REND_LIST_ADDR_PP3"
base ad:0xa030e000
group 0--3
line.long 0 "REND_LIST_ADDR_PP3"
bitfld.long 0 3.--31. " REND_LIST_ADDR "  " "
;tree.end

;tree "REND_RSW_BASE_PP3"
base ad:0xa030e004
group 0--3
line.long 0 "REND_RSW_BASE_PP3"
bitfld.long 0 6.--31. " REND_RSW_BASE "  " "
;tree.end

;tree "REND_VERTEX_BASE_PP3"
base ad:0xa030e008
group 0--3
line.long 0 "REND_VERTEX_BASE_PP3"
bitfld.long 0 6.--31. " REND_VERTEX_BASE "  " "
;tree.end

;tree "FEATURE_ENABLE_PP3"
base ad:0xa030e00c
group 0--3
line.long 0 "FEATURE_ENABLE_PP3"
bitfld.long 0 0. " FP_TILEBUF_ENABLE "  "0 ,1 "
bitfld.long 0 1. " EARLYZ_ENABLE "  "0 ,1 "
bitfld.long 0 3. " EARLYZ_DISABLE1 "  "0 ,1 "
bitfld.long 0 4. " EARLYZ_DISABLE2 "  "0 ,1 "
bitfld.long 0 5. " ORIGIN_LOWER_LEFT "  "0 ,1 "
bitfld.long 0 6. " SUMMATE_QUAD_COVER "  "0 ,1 "
;tree.end

;tree "Z_CLEAR_VALUE_PP3"
base ad:0xa030e010
group 0--3
line.long 0 "Z_CLEAR_VALUE_PP3"
bitfld.long 0 0.--23. " Z_CLEAR_VALUE "  " "
;tree.end

;tree "STENCIL_CLEAR_VALUE_PP3"
base ad:0xa030e014
group 0--3
line.long 0 "STENCIL_CLEAR_VALUE_PP3"
hexfld.byte 0 " STENCIL_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_0_PP3"
base ad:0xa030e018
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_0_PP3"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_1_PP3"
base ad:0xa030e01c
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_1_PP3"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_2_PP3"
base ad:0xa030e020
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_2_PP3"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "ARGB_CLEAR_VALUE_3_PP3"
base ad:0xa030e024
group 0--3
line.long 0 "ARGB_CLEAR_VALUE_3_PP3"
hexfld.byte 0 " RED_CLEAR_VALUE "
hexfld.byte 1 " GREEN_CLEAR_VALUE "
hexfld.byte 2 " BLUE_CLEAR_VALUE "
hexfld.byte 3 " ALPHA_CLEAR_VALUE "
;tree.end

;tree "BOUNDING_BOX_LEFT_RIGHT_PP3"
base ad:0xa030e028
group 0--3
line.long 0 "BOUNDING_BOX_LEFT_RIGHT_PP3"
bitfld.long 0 0.--13. " BOUNDING_BOX_RIGHT "  " "
bitfld.long 0 16.--19. " BOUNDING_BOX_LEFT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "BOUNDING_BOX_BOTTOM_PP3"
base ad:0xa030e02c
group 0--3
line.long 0 "BOUNDING_BOX_BOTTOM_PP3"
bitfld.long 0 0.--13. " BOUNDING_BOX_BOTTOM "  " "
;tree.end

;tree "FS_STACK_ADDR_PP3"
base ad:0xa030e030
group 0--3
line.long 0 "FS_STACK_ADDR_PP3"
bitfld.long 0 3.--31. " FS_STACK_ADDR "  " "
;tree.end

;tree "FS_STACK_SIZE_AND_INIT_VAL_PP3"
base ad:0xa030e034
group 0--3
line.long 0 "FS_STACK_SIZE_AND_INIT_VAL_PP3"
hexfld.word 0 " FP_STACK_SIZE "
hexfld.word 2 " FS_STACK_INIT_VAL "
;tree.end

;tree "ORIGIN_OFFSET_X_PP3"
base ad:0xa030e040
group 0--3
line.long 0 "ORIGIN_OFFSET_X_PP3"
hexfld.word 0 " ORIGIN_OFFSET_X "
;tree.end

;tree "ORIGIN_OFFSET_Y_PP3"
base ad:0xa030e044
group 0--3
line.long 0 "ORIGIN_OFFSET_Y_PP3"
hexfld.word 0 " ORIGIN_OFFSET_Y "
;tree.end

;tree "SUBPIXEL_SPECIFIER_PP3"
base ad:0xa030e048
group 0--3
line.long 0 "SUBPIXEL_SPECIFIER_PP3"
hexfld.byte 0 " SUBPIXEL_SPECIFIER "
;tree.end

;tree "TIEBREAK_MODE_PP3"
base ad:0xa030e04c
group 0--3
line.long 0 "TIEBREAK_MODE_PP3"
bitfld.long 0 0.--2. " TIEBREAK_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "PLIST_CONFIG_PP3"
base ad:0xa030e050
group 0--3
line.long 0 "PLIST_CONFIG_PP3"
bitfld.long 0 0.--5. " SCALE_X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--21. " SCALE_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 28.--29. " LIST_FORMAT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "SCALING_CONFIG_PP3"
base ad:0xa030e054
group 0--3
line.long 0 "SCALING_CONFIG_PP3"
bitfld.long 0 0. " POINT_AND_LINE_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 1. " DITHERING_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 2. " FRAGCOORD_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " DERIVATIVE_SCALE_ENABLE "  "0 ,1 "
bitfld.long 0 8. " FLIP_POINT_SPRITES "  "0 ,1 "
bitfld.long 0 9. " FLIP_DITHERING_MATRIX "  "0 ,1 "
bitfld.long 0 10. " FLIP_FRAGCOORD "  "0 ,1 "
bitfld.long 0 11. " FLIP_DERIVATIVE_Y "  "0 ,1 "
bitfld.long 0 16.--18. " SCALE_X "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20.--22. " SCALE_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "TILEBUFFER_BITS_PP3"
base ad:0xa030e058
group 0--3
line.long 0 "TILEBUFFER_BITS_PP3"
bitfld.long 0 0.--3. " TILEBUFFER_R_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " TILEBUFFER_G_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " TILEBUFFER_B_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " TILEBUFFER_A_BITS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB0_SOURCE_SELECT_PP3"
base ad:0xa030e100
group 0--3
line.long 0 "WB0_SOURCE_SELECT_PP3"
bitfld.long 0 0.--1. " WB0_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB0_TARGET_ADDR_PP3"
base ad:0xa030e104
group 0--3
line.long 0 "WB0_TARGET_ADDR_PP3"
bitfld.long 0 3.--31. " WB0_TARGET_ADDR "  " "
;tree.end

;tree "WB0_TARGET_PIXEL_FORMAT_PP3"
base ad:0xa030e108
group 0--3
line.long 0 "WB0_TARGET_PIXEL_FORMAT_PP3"
bitfld.long 0 0.--3. " WB0_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB0_TARGET_AA_FORMAT_PP3"
base ad:0xa030e10c
group 0--3
line.long 0 "WB0_TARGET_AA_FORMAT_PP3"
bitfld.long 0 0.--2. " WB0_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB0_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB0_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB0_TARGET_LAYOUT_PP3"
base ad:0xa030e110
group 0--3
line.long 0 "WB0_TARGET_LAYOUT_PP3"
bitfld.long 0 0.--1. " WB0_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB0_TARGET_SCANLINE_LENGTH_PP3"
base ad:0xa030e114
group 0--3
line.long 0 "WB0_TARGET_SCANLINE_LENGTH_PP3"
hexfld.word 0 " WB0_TARGET_SCANLINE_LENGTH "
;tree.end

;tree "WB0_TARGET_FLAGS_PP3"
base ad:0xa030e118
group 0--3
line.long 0 "WB0_TARGET_FLAGS_PP3"
bitfld.long 0 0. " WB0_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB0_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB0_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB0_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB0_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB0_BIG_ENDIAN "  "0 ,1 "
;tree.end

;tree "WB0_MRT_ENABLE_PP3"
base ad:0xa030e11c
group 0--3
line.long 0 "WB0_MRT_ENABLE_PP3"
bitfld.long 0 0.--3. " WB0_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB0_MRT_OFFSET_PP3"
base ad:0xa030e120
group 0--3
line.long 0 "WB0_MRT_OFFSET_PP3"
bitfld.long 0 3.--31. " WB0_MRT_OFFSET "  " "
;tree.end

;tree "WB0_GLOBAL_TEST_ENABLE_PP3"
base ad:0xa030e124
group 0--3
line.long 0 "WB0_GLOBAL_TEST_ENABLE_PP3"
bitfld.long 0 0. " WB0_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

;tree "WB0_GLOBAL_TEST_REF_VALUE_PP3"
base ad:0xa030e128
group 0--3
line.long 0 "WB0_GLOBAL_TEST_REF_VALUE_PP3"
hexfld.word 0 " WB0_GLOBAL_TEST_REF_VALUE "
;tree.end

;tree "WB0_GLOBAL_TEST_CMP_FUNC_PP3"
base ad:0xa030e12c
group 0--3
line.long 0 "WB0_GLOBAL_TEST_CMP_FUNC_PP3"
bitfld.long 0 0.--2. " WB0_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB1_SOURCE_SELECT_PP3"
base ad:0xa030e200
group 0--3
line.long 0 "WB1_SOURCE_SELECT_PP3"
bitfld.long 0 0.--1. " WB1_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB1_TARGET_ADDR_PP3"
base ad:0xa030e204
group 0--3
line.long 0 "WB1_TARGET_ADDR_PP3"
bitfld.long 0 3.--31. " WB1_TARGET_ADDR "  " "
;tree.end

;tree "WB1_TARGET_PIXEL_FORMAT_PP3"
base ad:0xa030e208
group 0--3
line.long 0 "WB1_TARGET_PIXEL_FORMAT_PP3"
bitfld.long 0 0.--3. " WB1_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB1_TARGET_AA_FORMAT_PP3"
base ad:0xa030e20c
group 0--3
line.long 0 "WB1_TARGET_AA_FORMAT_PP3"
bitfld.long 0 0.--2. " WB1_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB1_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB1_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB1_TARGET_LAYOUT_PP3"
base ad:0xa030e210
group 0--3
line.long 0 "WB1_TARGET_LAYOUT_PP3"
bitfld.long 0 0.--1. " WB1_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB1_TARGET_SCANLINE_LENGTH_PP3"
base ad:0xa030e214
group 0--3
line.long 0 "WB1_TARGET_SCANLINE_LENGTH_PP3"
hexfld.word 0 " WB1_TARGET_SCANLINE_LENGTH "
;tree.end

;tree "WB1_TARGET_FLAGS_PP3"
base ad:0xa030e218
group 0--3
line.long 0 "WB1_TARGET_FLAGS_PP3"
bitfld.long 0 0. " WB1_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB1_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB1_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB1_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB1_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB1_BIG_ENDIAN "  "0 ,1 "
;tree.end

;tree "WB1_MRT_ENABLE_PP3"
base ad:0xa030e21c
group 0--3
line.long 0 "WB1_MRT_ENABLE_PP3"
bitfld.long 0 0.--3. " WB1_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB1_MRT_OFFSET_PP3"
base ad:0xa030e220
group 0--3
line.long 0 "WB1_MRT_OFFSET_PP3"
bitfld.long 0 3.--31. " WB1_MRT_OFFSET "  " "
;tree.end

;tree "WB1_GLOBAL_TEST_ENABLE_PP3"
base ad:0xa030e224
group 0--3
line.long 0 "WB1_GLOBAL_TEST_ENABLE_PP3"
bitfld.long 0 0. " WB1_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

;tree "WB1_GLOBAL_TEST_REF_VALUE_PP3"
base ad:0xa030e228
group 0--3
line.long 0 "WB1_GLOBAL_TEST_REF_VALUE_PP3"
hexfld.word 0 " WB1_GLOBAL_TEST_REF_VALUE "
;tree.end

;tree "WB1_GLOBAL_TEST_CMP_FUNC_PP3"
base ad:0xa030e22c
group 0--3
line.long 0 "WB1_GLOBAL_TEST_CMP_FUNC_PP3"
bitfld.long 0 0.--2. " WB1_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB2_SOURCE_SELECT_PP3"
base ad:0xa030e300
group 0--3
line.long 0 "WB2_SOURCE_SELECT_PP3"
bitfld.long 0 0.--1. " WB2_SOURCE_SELECT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB2_TARGET_ADDR_PP3"
base ad:0xa030e304
group 0--3
line.long 0 "WB2_TARGET_ADDR_PP3"
bitfld.long 0 3.--31. " WB2_TARGET_ADDR "  " "
;tree.end

;tree "WB2_TARGET_PIXEL_FORMAT_PP3"
base ad:0xa030e308
group 0--3
line.long 0 "WB2_TARGET_PIXEL_FORMAT_PP3"
bitfld.long 0 0.--3. " WB2_TARGET_PIXEL_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB2_TARGET_AA_FORMAT_PP3"
base ad:0xa030e30c
group 0--3
line.long 0 "WB2_TARGET_AA_FORMAT_PP3"
bitfld.long 0 0.--2. " WB2_TARGET_AA_FORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--9. " WB2_TARGET_AA_X "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--14. " WB2_TARGET_AA_Y "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "WB2_TARGET_LAYOUT_PP3"
base ad:0xa030e310
group 0--3
line.long 0 "WB2_TARGET_LAYOUT_PP3"
bitfld.long 0 0.--1. " WB2_TARGET_LAYOUT "  "0 ,1 ,2 ,3 "
;tree.end

;tree "WB2_TARGET_SCANLINE_LENGTH_PP3"
base ad:0xa030e314
group 0--3
line.long 0 "WB2_TARGET_SCANLINE_LENGTH_PP3"
hexfld.word 0 " WB2_TARGET_SCANLINE_LENGTH "
;tree.end

;tree "WB2_TARGET_FLAGS_PP3"
base ad:0xa030e318
group 0--3
line.long 0 "WB2_TARGET_FLAGS_PP3"
bitfld.long 0 0. " WB2_DIRTY_BIT_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WB2_BOUNDING_BOX_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WB2_SWAP_RED_BLUE_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WB2_INV_COMPONENT_ORDER_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WB2_DITHER_ENABLE "  "0 ,1 "
bitfld.long 0 5. " WB2_BIG_ENDIAN "  "0 ,1 "
;tree.end

;tree "WB2_MRT_ENABLE_PP3"
base ad:0xa030e31c
group 0--3
line.long 0 "WB2_MRT_ENABLE_PP3"
bitfld.long 0 0.--3. " WB2_MRT_ENABLE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "WB2_MRT_OFFSET_PP3"
base ad:0xa030e320
group 0--3
line.long 0 "WB2_MRT_OFFSET_PP3"
bitfld.long 0 3.--31. " WB2_MRT_OFFSET "  " "
;tree.end

;tree "WB2_GLOBAL_TEST_ENABLE_PP3"
base ad:0xa030e324
group 0--3
line.long 0 "WB2_GLOBAL_TEST_ENABLE_PP3"
bitfld.long 0 0. " WB2_GLOBAL_TEST_ENABLE "  "0 ,1 "
;tree.end

;tree "WB2_GLOBAL_TEST_REF_VALUE_PP3"
base ad:0xa030e328
group 0--3
line.long 0 "WB2_GLOBAL_TEST_REF_VALUE_PP3"
hexfld.word 0 " WB2_GLOBAL_TEST_REF_VALUE "
;tree.end

;tree "WB2_GLOBAL_TEST_CMP_FUNC_PP3"
base ad:0xa030e32c
group 0--3
line.long 0 "WB2_GLOBAL_TEST_CMP_FUNC_PP3"
bitfld.long 0 0.--2. " WB2_GLOBAL_TEST_CMP_FUNC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "MGMT_VERSION_PP3"
base ad:0xa030f000
rgroup 0--3
line.long 0 "MGMT_VERSION_PP3"
hexfld.byte 0 " VERSION_MINOR "
hexfld.byte 1 " VERSION_MAJOR "
hexfld.word 2 " PRODUCT_ID "
;tree.end

;tree "MGMT_CURRENT_REND_LIST_ADDR_PP3"
base ad:0xa030f004
group 0--3
line.long 0 "MGMT_CURRENT_REND_LIST_ADDR_PP3"
bitfld.long 0 5.--31. " CURRENT_REND_LIST_ADDR "  " "
;tree.end

;tree "MGMT_STATUS_PP3"
base ad:0xa030f008
group 0--3
line.long 0 "MGMT_STATUS_PP3"
bitfld.long 0 0. " RENDERING_ACTIVE "  "0 ,1 "
bitfld.long 0 1. " TILE_STOPPED "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 4. " BUS_STOPPED "  "0 ,1 "
bitfld.long 0 5. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 6. " INTERRUPT_ASSERTED "  "0 ,1 "
bitfld.long 0 7. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

;tree "MGMT_CTRL_PP3"
base ad:0xa030f00c
group 0--3
line.long 0 "MGMT_CTRL_PP3"
bitfld.long 0 0. " STOP_BUS "  "0 ,1 "
bitfld.long 0 1. " START_BUS "  "0 ,1 "
bitfld.long 0 2. " END_AFTER_TILE "  "0 ,1 "
bitfld.long 0 3. " FLUSH_CACHES "  "0 ,1 "
bitfld.long 0 4. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 5. " FORCE_RESET "  "0 ,1 "
bitfld.long 0 6. " START_RENDERING "  "0 ,1 "
bitfld.long 0 7. " SOFT_RESET "  "0 ,1 "
bitfld.long 0 8. " CLK_OVERRIDE "  "0 ,1 "
;tree.end

;tree "MGMT_LAST_TILE_POS_START_PP3"
base ad:0xa030f010
rgroup 0--3
line.long 0 "MGMT_LAST_TILE_POS_START_PP3"
hexfld.byte 0 " TILEX_START "
hexfld.byte 2 " TILEY_START "
;tree.end

;tree "MGMT_LAST_TILE_POS_END_PP3"
base ad:0xa030f014
rgroup 0--3
line.long 0 "MGMT_LAST_TILE_POS_END_PP3"
hexfld.byte 0 " TILEX_END "
hexfld.byte 2 " TILEY_END "
;tree.end

;tree "MGMT_INT_RAWSTAT_PP3"
base ad:0xa030f020
group 0--3
line.long 0 "MGMT_INT_RAWSTAT_PP3"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_INT_CLEAR_PP3"
base ad:0xa030f024
group 0--3
line.long 0 "MGMT_INT_CLEAR_PP3"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_INT_MASK_PP3"
base ad:0xa030f028
group 0--3
line.long 0 "MGMT_INT_MASK_PP3"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_INT_STATUS_PP3"
base ad:0xa030f02c
rgroup 0--3
line.long 0 "MGMT_INT_STATUS_PP3"
bitfld.long 0 0. " END_OF_FRAME "  "0 ,1 "
bitfld.long 0 1. " END_OF_TILE "  "0 ,1 "
bitfld.long 0 2. " HANG "  "0 ,1 "
bitfld.long 0 3. " FORCE_HANG "  "0 ,1 "
bitfld.long 0 4. " BUS_ERROR "  "0 ,1 "
bitfld.long 0 5. " BUS_STOP "  "0 ,1 "
bitfld.long 0 6. " CNT_0_LIMIT "  "0 ,1 "
bitfld.long 0 7. " CNT_1_LIMIT "  "0 ,1 "
bitfld.long 0 8. " WRITE_BOUNDARY_ERROR "  "0 ,1 "
bitfld.long 0 9. " INVALID_PLIST_COMMAND "  "0 ,1 "
bitfld.long 0 10. " CALL_STACK_UNDERFLOW "  "0 ,1 "
bitfld.long 0 11. " CALL_STACK_OVERFLOW "  "0 ,1 "
bitfld.long 0 12. " RESET_COMPLETED "  "0 ,1 "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_ENABLE_PP3"
base ad:0xa030f040
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ENABLE_PP3"
bitfld.long 0 0. " WRITE_BOUNDARY_ENABLE "  "0 ,1 "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_LOW_PP3"
base ad:0xa030f044
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_LOW_PP3"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_LOW "  " "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_HIGH_PP3"
base ad:0xa030f048
group 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_HIGH_PP3"
bitfld.long 0 8.--31. " WRITE_BOUNDARY_HIGH "  " "
;tree.end

;tree "MGMT_WRITE_BOUNDARY_ADDRESS_PP3"
base ad:0xa030f04c
rgroup 0--3
line.long 0 "MGMT_WRITE_BOUNDARY_ADDRESS_PP3"
bitfld.long 0 2.--31. " WRITE_BOUNDARY_ADDRESS "  " "
;tree.end

;tree "MGMT_BUS_ERROR_STATUS_PP3"
base ad:0xa030f050
rgroup 0--3
line.long 0 "MGMT_BUS_ERROR_STATUS_PP3"
bitfld.long 0 0. " WRITE_ERROR "  "0 ,1 "
bitfld.long 0 1. " READ_ERROR "  "0 ,1 "
bitfld.long 0 2.--5. " WRITE_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 6.--9. " READ_ERROR_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "MGMT_WATCHDOG_DISABLE_PP3"
base ad:0xa030f060
group 0--3
line.long 0 "MGMT_WATCHDOG_DISABLE_PP3"
bitfld.long 0 0. " WATCHDOG_DISABLE "  "0 ,1 "
;tree.end

;tree "MGMT_WATCHDOG_TIMEOUT_PP3"
base ad:0xa030f064
group 0--3
line.long 0 "MGMT_WATCHDOG_TIMEOUT_PP3"
hexfld.long 0 " WATCHDOG_TIMEOUT "
;tree.end

;tree "MGMT_PERF_CNT_0_ENABLE_PP3"
base ad:0xa030f080
group 0--3
line.long 0 "MGMT_PERF_CNT_0_ENABLE_PP3"
bitfld.long 0 0. " PERF_CNT_0_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_0_LIM_EN "  "0 ,1 "
;tree.end

;tree "MGMT_PERF_CNT_0_SRC_PP3"
base ad:0xa030f084
group 0--3
line.long 0 "MGMT_PERF_CNT_0_SRC_PP3"
bitfld.long 0 0.--5. " PERF_CNT_0_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "MGMT_PERF_CNT_0_LIMIT_PP3"
base ad:0xa030f088
group 0--3
line.long 0 "MGMT_PERF_CNT_0_LIMIT_PP3"
hexfld.long 0 " PERF_CNT_0_LIMIT "
;tree.end

;tree "MGMT_PERF_CNT_0_VALUE_PP3"
base ad:0xa030f08c
group 0--3
line.long 0 "MGMT_PERF_CNT_0_VALUE_PP3"
hexfld.long 0 " PERF_CNT_0_VALUE "
;tree.end

;tree "MGMT_PERF_CNT_1_ENABLE_PP3"
base ad:0xa030f0a0
group 0--3
line.long 0 "MGMT_PERF_CNT_1_ENABLE_PP3"
bitfld.long 0 0. " PERF_CNT_1_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PERF_CNT_1_LIM_EN "  "0 ,1 "
;tree.end

;tree "MGMT_PERF_CNT_1_SRC_PP3"
base ad:0xa030f0a4
group 0--3
line.long 0 "MGMT_PERF_CNT_1_SRC_PP3"
bitfld.long 0 0.--5. " PERF_CNT_1_SRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "MGMT_PERF_CNT_1_LIMIT_PP3"
base ad:0xa030f0a8
group 0--3
line.long 0 "MGMT_PERF_CNT_1_LIMIT_PP3"
hexfld.long 0 " PERF_CNT_1_LIMIT "
;tree.end

;tree "MGMT_PERF_CNT_1_VALUE_PP3"
base ad:0xa030f0ac
group 0--3
line.long 0 "MGMT_PERF_CNT_1_VALUE_PP3"
hexfld.long 0 " PERF_CNT_1_VALUE "
;tree.end

;tree "MGMT_PERFMON_CONTR_PP3"
base ad:0xa030f0b0
group 0--3
line.long 0 "MGMT_PERFMON_CONTR_PP3"
bitfld.long 0 0. " PERFMON_ENABLE "  "0 ,1 "
bitfld.long 0 16.--25. " NUMBER_OF_TILEX "  " "
;tree.end

;tree "MGMT_PERFMON_BASE_PP3"
base ad:0xa030f0b4
group 0--3
line.long 0 "MGMT_PERFMON_BASE_PP3"
bitfld.long 0 3.--31. " PERFMON_BASE_ADDR "  " "
;tree.end

endif
tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "SGX"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "EUR_CR_ALL_CLKGATESTATUS"
base ad:0xa0300008
group 0--3
line.long 0 "EUR_CR_ALL_CLKGATESTATUS"
bitfld.long 0 0. " ISP_CLKS "  "0 ,1 "
bitfld.long 0 1. " ISP2_CLKS "  "0 ,1 "
bitfld.long 0 2. " TSP_CLKS "  "0 ,1 "
bitfld.long 0 3. " TE_CLKS "  "0 ,1 "
bitfld.long 0 4. " MTE_CLKS "  "0 ,1 "
bitfld.long 0 5. " DPM_CLKS "  "0 ,1 "
bitfld.long 0 6. " VDM_CLKS "  "0 ,1 "
bitfld.long 0 7. " PDS_CLKS "  "0 ,1 "
bitfld.long 0 8. " PBE_CLKS "  "0 ,1 "
bitfld.long 0 9. " TCU_L2_CLKS "  "0 ,1 "
bitfld.long 0 10. " UCACHEL2_CLKS "  "0 ,1 "
bitfld.long 0 11. " USE0_CLKS "  "0 ,1 "
bitfld.long 0 12. " ITR0_CLKS "  "0 ,1 "
bitfld.long 0 13. " TEX0_CLKS "  "0 ,1 "
bitfld.long 0 15. " USE1_CLKS "  "0 ,1 "
bitfld.long 0 16. " ITR1_CLKS "  "0 ,1 "
bitfld.long 0 17. " TEX1_CLKS "  "0 ,1 "
bitfld.long 0 19. " IDXFIFO_CLKS "  "0 ,1 "
bitfld.long 0 20. " TA_CLKS "  "0 ,1 "
bitfld.long 0 21. " DCU_L2_CLKS "  "0 ,1 "
bitfld.long 0 22. " DCU0_L0L1_CLKS "  "0 ,1 "
bitfld.long 0 23. " DCU1_L0L1_CLKS "  "0 ,1 "
bitfld.long 0 24. " BIF_CORE_CLKS "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_CORE_ID"
base ad:0xa0300020
group 0--3
line.long 0 "EUR_CR_ALL_CORE_ID"
bitfld.long 0 0. " CONFIG_MULTI "  "0 ,1 "
bitfld.long 0 1. " CONFIG_BASE "  "0 ,1 "
bitfld.long 0 2.--7. " CONFIG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8.--11. " CONFIG_CORES "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " CONFIG_SLC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 2 " ID "
;tree.end

;tree "EUR_CR_ALL_CORE_REVISION"
base ad:0xa0300024
group 0--3
line.long 0 "EUR_CR_ALL_CORE_REVISION"
hexfld.byte 0 " MAINTENANCE "
hexfld.byte 1 " MINOR "
hexfld.byte 2 " MAJOR "
hexfld.byte 3 " DESIGNER "
;tree.end

;tree "EUR_CR_ALL_DESIGNER_REV_FIELD1"
base ad:0xa0300028
group 0--3
line.long 0 "EUR_CR_ALL_DESIGNER_REV_FIELD1"
hexfld.long 0 " DESIGNER_REV_FIELD1 "
;tree.end

;tree "EUR_CR_ALL_DESIGNER_REV_FIELD2"
base ad:0xa030002c
group 0--3
line.long 0 "EUR_CR_ALL_DESIGNER_REV_FIELD2"
hexfld.long 0 " DESIGNER_REV_FIELD2 "
;tree.end

;tree "EUR_CR_ALL_DEBUG_REG0"
base ad:0xa0300070
group 0--3
line.long 0 "EUR_CR_ALL_DEBUG_REG0"
;tree.end

;tree "EUR_CR_ALL_DEBUG_REG1"
base ad:0xa0300074
group 0--3
line.long 0 "EUR_CR_ALL_DEBUG_REG1"
;tree.end

;tree "EUR_CR_ALL_TIMER"
base ad:0xa0300144
group 0--3
line.long 0 "EUR_CR_ALL_TIMER"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ALL_TE_RGNBBOX_X"
base ad:0xa0300228
group 0--3
line.long 0 "EUR_CR_ALL_TE_RGNBBOX_X"
bitfld.long 0 0.--8. " MIN "  " "
bitfld.long 0 16.--24. " MAX "  " "
;tree.end

;tree "EUR_CR_ALL_TE_RGNBBOX_Y"
base ad:0xa030022c
group 0--3
line.long 0 "EUR_CR_ALL_TE_RGNBBOX_Y"
bitfld.long 0 0.--8. " MIN "  " "
bitfld.long 0 16.--24. " MAX "  " "
;tree.end

;tree "EUR_CR_ALL_VDM_BATCH_NUM_STATUS"
base ad:0xa0300324
group 0--3
line.long 0 "EUR_CR_ALL_VDM_BATCH_NUM_STATUS"
bitfld.long 0 0.--12. " VALUE "  " "
;tree.end

;tree "EUR_CR_ALL_VDM_CONTEXT_STORE_STREAM"
base ad:0xa0300334
group 0--3
line.long 0 "EUR_CR_ALL_VDM_CONTEXT_STORE_STREAM"
bitfld.long 0 2.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_ALL_VDM_CONTEXT_STORE_INDEX_ADDR"
base ad:0xa0300338
group 0--3
line.long 0 "EUR_CR_ALL_VDM_CONTEXT_STORE_INDEX_ADDR"
bitfld.long 0 0.--21. " ADDR "  " "
bitfld.long 0 22. " WINDING_ORDER "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_VDM_CONTEXT_STORE_WRAP_INDEX"
base ad:0xa030034c
group 0--3
line.long 0 "EUR_CR_ALL_VDM_CONTEXT_STORE_WRAP_INDEX"
bitfld.long 0 0.--21. " COUNT "  " "
;tree.end

;tree "EUR_CR_ALL_VDM_CONTEXT_STORE_WRAPPED"
base ad:0xa0300350
group 0--3
line.long 0 "EUR_CR_ALL_VDM_CONTEXT_STORE_WRAPPED"
bitfld.long 0 0.--21. " COUNT "  " "
;tree.end

;tree "EUR_CR_ALL_VDM_CONTEXT_STORE_STATUS"
base ad:0xa030033c
group 0--3
line.long 0 "EUR_CR_ALL_VDM_CONTEXT_STORE_STATUS"
bitfld.long 0 0. " COMPLETE "  "0 ,1 "
bitfld.long 0 4. " PROCESS "  "0 ,1 "
bitfld.long 0 8. " NA "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_VDM_WAIT_FOR_KICK"
base ad:0xa0300348
group 0--3
line.long 0 "EUR_CR_ALL_VDM_WAIT_FOR_KICK"
bitfld.long 0 0. " STATUS "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_VDM_MTE"
base ad:0xa0300378
group 0--3
line.long 0 "EUR_CR_ALL_VDM_MTE"
hexfld.long 0 " SIG "
;tree.end

;tree "EUR_CR_ALL_VDM_FENCE_STATUS"
base ad:0xa0300394
group 0--3
line.long 0 "EUR_CR_ALL_VDM_FENCE_STATUS"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_MTE_FIRST_PAGE"
base ad:0xa0300258
group 0--3
line.long 0 "EUR_CR_ALL_MTE_FIRST_PAGE"
hexfld.word 0 " DATA "
bitfld.long 0 16.--20. " MACROTILE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 31. " VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_MTE_SECOND_PAGE"
base ad:0xa030025c
group 0--3
line.long 0 "EUR_CR_ALL_MTE_SECOND_PAGE"
hexfld.word 0 " DATA "
bitfld.long 0 31. " VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_MTE_ABORT"
base ad:0xa0300260
group 0--3
line.long 0 "EUR_CR_ALL_MTE_ABORT"
bitfld.long 0 0. " SETTLED "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_MTE_SIG1"
base ad:0xa030026c
group 0--3
line.long 0 "EUR_CR_ALL_MTE_SIG1"
hexfld.long 0 " TE_SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_MTE_SIG2"
base ad:0xa0300270
group 0--3
line.long 0 "EUR_CR_ALL_MTE_SIG2"
hexfld.long 0 " MEM_SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_VDM_CONTEXT_LOAD_STATUS"
base ad:0xa0300288
group 0--3
line.long 0 "EUR_CR_ALL_VDM_CONTEXT_LOAD_STATUS"
bitfld.long 0 0. " COMPLETE "  "0 ,1 "
bitfld.long 0 1. " PROCESSING "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_VDM_TASK_KICK_STATUS"
base ad:0xa0300294
group 0--3
line.long 0 "EUR_CR_ALL_VDM_TASK_KICK_STATUS"
bitfld.long 0 0. " COMPLETE "  "0 ,1 "
bitfld.long 0 1. " PROCESSING "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_TE_SAFE"
base ad:0xa030029c
group 0--3
line.long 0 "EUR_CR_ALL_TE_SAFE"
bitfld.long 0 0. " TO_DRAIN "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_CLIP_SIG1"
base ad:0xa0300304
group 0--3
line.long 0 "EUR_CR_ALL_CLIP_SIG1"
hexfld.long 0 " CLIP_SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_PBE_NONPIXEL_CHECKSUM"
base ad:0xa030030c
group 0--3
line.long 0 "EUR_CR_ALL_PBE_NONPIXEL_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ALL_ISP_FPU"
base ad:0xa0300438
group 0--3
line.long 0 "EUR_CR_ALL_ISP_FPU"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_ISP_BREAK_INDEX"
base ad:0xa0300450
group 0--3
line.long 0 "EUR_CR_ALL_ISP_BREAK_INDEX"
bitfld.long 0 0.--25. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_ALL_ISP_STATUS2"
base ad:0xa03004e4
group 0--3
line.long 0 "EUR_CR_ALL_ISP_STATUS2"
hexfld.byte 0 " TILE_X "
hexfld.byte 1 " TILE_Y "
bitfld.long 0 16.--20. " PRIM_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "EUR_CR_ALL_PIXELBE_EMIT"
base ad:0xa03004ec
group 0--3
line.long 0 "EUR_CR_ALL_PIXELBE_EMIT"
bitfld.long 0 0. " STATUS0 "  "0 ,1 "
bitfld.long 0 1. " STATUS1 "  "0 ,1 "
bitfld.long 0 2. " STATUS2 "  "0 ,1 "
bitfld.long 0 3. " STATUS3 "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_ISP_CONTEXT_SWITCH2"
base ad:0xa0300544
group 0--3
line.long 0 "EUR_CR_ALL_ISP_CONTEXT_SWITCH2"
bitfld.long 0 0.--8. " ZLS_BURST "  " "
bitfld.long 0 9. " PT_IN_FLIGHT "  "0 ,1 "
bitfld.long 0 10. " END_OF_RENDER "  "0 ,1 "
bitfld.long 0 11. " END_OF_TILE "  "0 ,1 "
hexfld.byte 2 " TILE_Y "
hexfld.byte 3 " TILE_X "
;tree.end

;tree "EUR_CR_ALL_ISP_CONTEXT_SWITCH3"
base ad:0xa0300548
group 0--3
line.long 0 "EUR_CR_ALL_ISP_CONTEXT_SWITCH3"
bitfld.long 0 2.--25. " ZLS_CMP_BASE "  " "
bitfld.long 0 26. " ZLS_FIRST_TILE_IN_MT "  "0 ,1 "
bitfld.long 0 27.--30. " ZLS_MACROTILE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 31. " ZLS_ZSTORE_CMD "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_ISP_CONTEXT_SWITCH4"
base ad:0xa030054c
group 0--3
line.long 0 "EUR_CR_ALL_ISP_CONTEXT_SWITCH4"
bitfld.long 0 0.--27. " PIM_ID "  " "
;tree.end

;tree "EUR_CR_ALL_ISP_CONTEXT_SWITCH5"
base ad:0xa0300550
group 0--3
line.long 0 "EUR_CR_ALL_ISP_CONTEXT_SWITCH5"
bitfld.long 0 0.--1. " STREAM_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " EMPTY_STATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_ALL_ISP_CONTEXT_SWITCH6"
base ad:0xa0300554
group 0--3
line.long 0 "EUR_CR_ALL_ISP_CONTEXT_SWITCH6"
bitfld.long 0 2.--27. " RGN0_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN0_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_ISP_CONTEXT_SWITCH7"
base ad:0xa0300558
group 0--3
line.long 0 "EUR_CR_ALL_ISP_CONTEXT_SWITCH7"
bitfld.long 0 2.--27. " RGN1_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN1_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_ISP_CONTEXT_SWITCH8"
base ad:0xa030055c
group 0--3
line.long 0 "EUR_CR_ALL_ISP_CONTEXT_SWITCH8"
bitfld.long 0 2.--27. " RGN2_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN2_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_ISP_CONTEXT_SWITCH9"
base ad:0xa0300560
group 0--3
line.long 0 "EUR_CR_ALL_ISP_CONTEXT_SWITCH9"
bitfld.long 0 2.--27. " RGN3_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN3_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_DPM_TA_ALLOC_FREE_LIST_STATUS1"
base ad:0xa0300700
group 0--3
line.long 0 "EUR_CR_ALL_DPM_TA_ALLOC_FREE_LIST_STATUS1"
hexfld.word 0 " HEAD "
hexfld.word 2 " TAIL "
;tree.end

;tree "EUR_CR_ALL_DPM_3D_FREE_LIST_STATUS1"
base ad:0xa030070c
group 0--3
line.long 0 "EUR_CR_ALL_DPM_3D_FREE_LIST_STATUS1"
hexfld.word 0 " HEAD "
hexfld.word 2 " TAIL "
;tree.end

;tree "EUR_CR_ALL_DPM_TA_ALLOC_FREE_LIST_STATUS2"
base ad:0xa0300710
group 0--3
line.long 0 "EUR_CR_ALL_DPM_TA_ALLOC_FREE_LIST_STATUS2"
hexfld.word 0 " PREVIOUS "
;tree.end

;tree "EUR_CR_ALL_DPM_3D_FREE_LIST_STATUS2"
base ad:0xa030071c
group 0--3
line.long 0 "EUR_CR_ALL_DPM_3D_FREE_LIST_STATUS2"
hexfld.word 0 " PREVIOUS "
;tree.end

;tree "EUR_CR_ALL_DPM_PAGE_STATUS"
base ad:0xa0300724
group 0--3
line.long 0 "EUR_CR_ALL_DPM_PAGE_STATUS"
hexfld.word 0 " TOTAL "
hexfld.word 2 " TA "
;tree.end

;tree "EUR_CR_ALL_DPM_PAGE"
base ad:0xa0300728
group 0--3
line.long 0 "EUR_CR_ALL_DPM_PAGE"
hexfld.word 0 " STATUS_3D "
;tree.end

;tree "EUR_CR_ALL_DPM_GLOBAL_PAGE_STATUS"
base ad:0xa030072c
group 0--3
line.long 0 "EUR_CR_ALL_DPM_GLOBAL_PAGE_STATUS"
hexfld.word 0 " TOTAL "
hexfld.word 2 " TA "
;tree.end

;tree "EUR_CR_ALL_DPM_GLOBAL_PAGE"
base ad:0xa0300730
group 0--3
line.long 0 "EUR_CR_ALL_DPM_GLOBAL_PAGE"
hexfld.word 0 " STATUS_3D "
;tree.end

;tree "EUR_CR_ALL_DPM_REQUESTING"
base ad:0xa0300734
group 0--3
line.long 0 "EUR_CR_ALL_DPM_REQUESTING"
bitfld.long 0 0.--1. " SOURCE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_ALL_DPM_RGN_HDR_PARSER"
base ad:0xa0300738
group 0--3
line.long 0 "EUR_CR_ALL_DPM_RGN_HDR_PARSER"
bitfld.long 0 0. " IDLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_DPM_CONTEXT_DRAIN_STATUS"
base ad:0xa0300744
group 0--3
line.long 0 "EUR_CR_ALL_DPM_CONTEXT_DRAIN_STATUS"
bitfld.long 0 0. " DRAINED "  "0 ,1 "
bitfld.long 0 1. " RESUMED "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_TF_SIG00"
base ad:0xa030084c
group 0--3
line.long 0 "EUR_CR_ALL_TF_SIG00"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_TF_SIG01"
base ad:0xa0300850
group 0--3
line.long 0 "EUR_CR_ALL_TF_SIG01"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_TF_SIG02"
base ad:0xa0300854
group 0--3
line.long 0 "EUR_CR_ALL_TF_SIG02"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_TF_SIG03"
base ad:0xa0300858
group 0--3
line.long 0 "EUR_CR_ALL_TF_SIG03"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_ITR_TAG0"
base ad:0xa030085c
group 0--3
line.long 0 "EUR_CR_ALL_ITR_TAG0"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_ITR_TAG1"
base ad:0xa0300860
group 0--3
line.long 0 "EUR_CR_ALL_ITR_TAG1"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_ITR_USE0"
base ad:0xa0300864
group 0--3
line.long 0 "EUR_CR_ALL_ITR_USE0"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_ITR_USE1"
base ad:0xa0300868
group 0--3
line.long 0 "EUR_CR_ALL_ITR_USE1"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_ITR_USE2"
base ad:0xa030086c
group 0--3
line.long 0 "EUR_CR_ALL_ITR_USE2"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_ITR_USE3"
base ad:0xa0300870
group 0--3
line.long 0 "EUR_CR_ALL_ITR_USE3"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_CLIP_CHECKSUM"
base ad:0xa0300900
group 0--3
line.long 0 "EUR_CR_ALL_CLIP_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ALL_MTE_MEM_CHECKSUM"
base ad:0xa0300904
group 0--3
line.long 0 "EUR_CR_ALL_MTE_MEM_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ALL_MTE_TE_CHECKSUM"
base ad:0xa0300908
group 0--3
line.long 0 "EUR_CR_ALL_MTE_TE_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ALL_TE_CHECKSUM"
base ad:0xa030090c
group 0--3
line.long 0 "EUR_CR_ALL_TE_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ALL_ISP_FPU_CHECKSUM"
base ad:0xa0300910
group 0--3
line.long 0 "EUR_CR_ALL_ISP_FPU_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ALL_ISP_PRECALC_CHECKSUM"
base ad:0xa0300914
group 0--3
line.long 0 "EUR_CR_ALL_ISP_PRECALC_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ALL_ISP_EDGE_CHECKSUM"
base ad:0xa0300918
group 0--3
line.long 0 "EUR_CR_ALL_ISP_EDGE_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ALL_ISP_TAGWRITE_CHECKSUM"
base ad:0xa030091c
group 0--3
line.long 0 "EUR_CR_ALL_ISP_TAGWRITE_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ALL_ISP_SPAN_CHECKSUM"
base ad:0xa0300920
group 0--3
line.long 0 "EUR_CR_ALL_ISP_SPAN_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ALL_PBE_PIXEL_CHECKSUM"
base ad:0xa0300924
group 0--3
line.long 0 "EUR_CR_ALL_PBE_PIXEL_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ALL_USE0_DM_SLOT"
base ad:0xa0300aa4
group 0--3
line.long 0 "EUR_CR_ALL_USE0_DM_SLOT"
bitfld.long 0 2.--3. " 1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " 2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " 3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " 4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " 5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " 6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " 7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " 8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " 9 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " 10 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " 11 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " 12 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " 13 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " 14 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " 15 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_ALL_USE1_DM_SLOT"
base ad:0xa0300aa8
group 0--3
line.long 0 "EUR_CR_ALL_USE1_DM_SLOT"
bitfld.long 0 2.--3. " 1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " 2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " 3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " 4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " 5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " 6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " 7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " 8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " 9 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " 10 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " 11 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " 12 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " 13 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " 14 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " 15 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_ALL_LOOPBACK"
base ad:0xa0300b04
group 0--3
line.long 0 "EUR_CR_ALL_LOOPBACK"
bitfld.long 0 0. " STATUS "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_USE0_SERV_PIXEL"
base ad:0xa0300b08
group 0--3
line.long 0 "EUR_CR_ALL_USE0_SERV_PIXEL"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_USE0_SERV_VERTEX"
base ad:0xa0300b0c
group 0--3
line.long 0 "EUR_CR_ALL_USE0_SERV_VERTEX"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_USE0_SERV_EVENT"
base ad:0xa0300b10
group 0--3
line.long 0 "EUR_CR_ALL_USE0_SERV_EVENT"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_USE1_SERV_PIXEL"
base ad:0xa0300b14
group 0--3
line.long 0 "EUR_CR_ALL_USE1_SERV_PIXEL"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_USE1_SERV_VERTEX"
base ad:0xa0300b18
group 0--3
line.long 0 "EUR_CR_ALL_USE1_SERV_VERTEX"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_USE1_SERV_EVENT"
base ad:0xa0300b1c
group 0--3
line.long 0 "EUR_CR_ALL_USE1_SERV_EVENT"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_PDS_EVDM_PC_BASE"
base ad:0xa0300b2c
group 0--3
line.long 0 "EUR_CR_ALL_PDS_EVDM_PC_BASE"
bitfld.long 0 0.--29. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_ALL_PDS_PDM_PC_BASE"
base ad:0xa0300b38
group 0--3
line.long 0 "EUR_CR_ALL_PDS_PDM_PC_BASE"
bitfld.long 0 0.--29. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_ALL_USE2_DM_SLOT"
base ad:0xa0300b80
group 0--3
line.long 0 "EUR_CR_ALL_USE2_DM_SLOT"
bitfld.long 0 2.--3. " 1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " 2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " 3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " 4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " 5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " 6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " 7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " 8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " 9 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " 10 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " 11 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " 12 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " 13 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " 14 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " 15 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_ALL_USE3_DM_SLOT"
base ad:0xa0300b84
group 0--3
line.long 0 "EUR_CR_ALL_USE3_DM_SLOT"
bitfld.long 0 2.--3. " 1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " 2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " 3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " 4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " 5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " 6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " 7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " 8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " 9 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " 10 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " 11 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " 12 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " 13 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " 14 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " 15 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_ALL_USE2_SERV_PIXEL"
base ad:0xa0300b88
group 0--3
line.long 0 "EUR_CR_ALL_USE2_SERV_PIXEL"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_USE2_SERV_VERTEX"
base ad:0xa0300b8c
group 0--3
line.long 0 "EUR_CR_ALL_USE2_SERV_VERTEX"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_USE2_SERV_EVENT"
base ad:0xa0300b90
group 0--3
line.long 0 "EUR_CR_ALL_USE2_SERV_EVENT"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_USE3_SERV_PIXEL"
base ad:0xa0300b94
group 0--3
line.long 0 "EUR_CR_ALL_USE3_SERV_PIXEL"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_USE3_SERV_VERTEX"
base ad:0xa0300b98
group 0--3
line.long 0 "EUR_CR_ALL_USE3_SERV_VERTEX"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_USE3_SERV_EVENT"
base ad:0xa0300b9c
group 0--3
line.long 0 "EUR_CR_ALL_USE3_SERV_EVENT"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_PDS_STATUS"
base ad:0xa0300ba4
group 0--3
line.long 0 "EUR_CR_ALL_PDS_STATUS"
bitfld.long 0 0. " RENDER_IN_PROGRESS "  "0 ,1 "
bitfld.long 0 1. " CSWITCH_STORE_END_RENDER "  "0 ,1 "
bitfld.long 0 2. " RENDER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " CSWITCH_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " IPF_COMPLETED "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_BIF_INT_STAT"
base ad:0xa0300c04
group 0--3
line.long 0 "EUR_CR_ALL_BIF_INT_STAT"
bitfld.long 0 0.--13. " FAULT_REQ "  " "
bitfld.long 0 16.--18. " FAULT_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19. " FLUSH_COMPLETE "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_BIF_FAULT"
base ad:0xa0300c08
group 0--3
line.long 0 "EUR_CR_ALL_BIF_FAULT"
bitfld.long 0 0.--3. " CID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--8. " SB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_REQ_STAT"
base ad:0xa0300ca8
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_REQ_STAT"
hexfld.byte 0 " READS "
;tree.end

;tree "EUR_CR_ALL_BIF_BANK_STATUS"
base ad:0xa0300cb4
group 0--3
line.long 0 "EUR_CR_ALL_BIF_BANK_STATUS"
bitfld.long 0 0. " 3D_CURRENT_BANK "  "0 ,1 "
bitfld.long 0 1. " TA_CURRENT_BANK "  "0 ,1 "
;tree.end

;tree "EUR_CR_ALL_BIF_SIG0"
base ad:0xa0300cc0
group 0--3
line.long 0 "EUR_CR_ALL_BIF_SIG0"
hexfld.long 0 " WDATA_SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_BIF_SIG1"
base ad:0xa0300cc4
group 0--3
line.long 0 "EUR_CR_ALL_BIF_SIG1"
hexfld.long 0 " ADDR_SIGNATURE "
;tree.end

;tree "EUR_CR_ALL_EMU_TA_PHASE"
base ad:0xa0300e84
group 0--3
line.long 0 "EUR_CR_ALL_EMU_TA_PHASE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_EMU_3D_PHASE"
base ad:0xa0300e88
group 0--3
line.long 0 "EUR_CR_ALL_EMU_3D_PHASE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_EMU_TA_CYCLE"
base ad:0xa0300e8c
group 0--3
line.long 0 "EUR_CR_ALL_EMU_TA_CYCLE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_EMU_3D_CYCLE"
base ad:0xa0300e90
group 0--3
line.long 0 "EUR_CR_ALL_EMU_3D_CYCLE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_EMU_MEM_READ"
base ad:0xa0300eb4
group 0--3
line.long 0 "EUR_CR_ALL_EMU_MEM_READ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_EMU_TA_OR_3D_CYCLE"
base ad:0xa0300eb8
group 0--3
line.long 0 "EUR_CR_ALL_EMU_TA_OR_3D_CYCLE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_EMU_MEM_WRITE"
base ad:0xa0300ebc
group 0--3
line.long 0 "EUR_CR_ALL_EMU_MEM_WRITE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_EMU_MEM_BYTE_WRITE"
base ad:0xa0300ec0
group 0--3
line.long 0 "EUR_CR_ALL_EMU_MEM_BYTE_WRITE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_EMU_MEM_STALL"
base ad:0xa0300ec4
group 0--3
line.long 0 "EUR_CR_ALL_EMU_MEM_STALL"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_MMU"
base ad:0xa0300ecc
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_MMU"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_CACHE"
base ad:0xa0300ed0
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_CACHE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_TA"
base ad:0xa0300ed4
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_TA"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_WRITE_TA"
base ad:0xa0300ed8
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_WRITE_TA"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_VDM"
base ad:0xa0300edc
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_VDM"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_PBE"
base ad:0xa0300ee0
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_PBE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_WRITE_PBE"
base ad:0xa0300ee4
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_WRITE_PBE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_TSP"
base ad:0xa0300ee8
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_TSP"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_ISP"
base ad:0xa0300eec
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_ISP"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_ISPZ"
base ad:0xa0300ef0
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_ISPZ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_WRITE_ISPZ"
base ad:0xa0300ef4
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_WRITE_ISPZ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_USE0"
base ad:0xa0300ef8
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_USE0"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_WRITE_USE0"
base ad:0xa0300efc
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_WRITE_USE0"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_USE1"
base ad:0xa0300f08
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_USE1"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_WRITE_USE1"
base ad:0xa0300f0c
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_WRITE_USE1"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_USEC"
base ad:0xa0300f10
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_USEC"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_PDS"
base ad:0xa0300f14
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_PDS"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_USE2"
base ad:0xa0300f18
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_USE2"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_WRITE_USE2"
base ad:0xa0300f1c
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_WRITE_USE2"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_READ_USE3"
base ad:0xa0300f20
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_READ_USE3"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_WRITE_USE3"
base ad:0xa0300f24
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_WRITE_USE3"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_USEC_BIF_VERTEX_READ"
base ad:0xa0300f2c
group 0--3
line.long 0 "EUR_CR_ALL_USEC_BIF_VERTEX_READ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_USEC_BIF_PIXEL_READ"
base ad:0xa0300f30
group 0--3
line.long 0 "EUR_CR_ALL_USEC_BIF_PIXEL_READ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_USEC_BIF_EVENT_READ"
base ad:0xa0300f34
group 0--3
line.long 0 "EUR_CR_ALL_USEC_BIF_EVENT_READ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_THREE_D_COUNT"
base ad:0xa0300f38
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_THREE_D_COUNT"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_OVER_LAPPED_TA_READ_COUNT"
base ad:0xa0300f3c
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_OVER_LAPPED_TA_READ_COUNT"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BIF_MEM_OVER_LAPPED_TA_WRITE_COUNT"
base ad:0xa0300f40
group 0--3
line.long 0 "EUR_CR_ALL_BIF_MEM_OVER_LAPPED_TA_WRITE_COUNT"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_ALL_BREAKPOINT"
base ad:0xa0300f7c
group 0--3
line.long 0 "EUR_CR_ALL_BREAKPOINT"
bitfld.long 0 2. " TRAPPED "  "0 ,1 "
bitfld.long 0 3. " UNTRAPPED "  "0 ,1 "
bitfld.long 0 4.--5. " ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--9. " MODULE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_ALL_BREAKPOINT_TRAP_INFO0"
base ad:0xa0300f80
group 0--3
line.long 0 "EUR_CR_ALL_BREAKPOINT_TRAP_INFO0"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_ALL_BREAKPOINT_TRAP_INFO1"
base ad:0xa0300f84
group 0--3
line.long 0 "EUR_CR_ALL_BREAKPOINT_TRAP_INFO1"
bitfld.long 0 0.--1. " DATA_MASTER "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--6. " TAG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 7.--8. " NUMBER "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--13. " SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "EUR_CR_MASTER_CORE"
base ad:0xa0304000
group 0--3
line.long 0 "EUR_CR_MASTER_CORE"
bitfld.long 0 0.--1. " ENABLE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_MASTER_CLKGATECTL"
base ad:0xa0304004
group 0--3
line.long 0 "EUR_CR_MASTER_CLKGATECTL"
bitfld.long 0 0.--1. " CORE0_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " CORE1_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " CORE2_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " CORE3_CLKG "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_MASTER_CLKGATESTATUS"
base ad:0xa0304008
group 0--3
line.long 0 "EUR_CR_MASTER_CLKGATESTATUS"
bitfld.long 0 0. " CORE0_CLKS "  "0 ,1 "
bitfld.long 0 1. " CORE1_CLKS "  "0 ,1 "
bitfld.long 0 2. " CORE2_CLKS "  "0 ,1 "
bitfld.long 0 3. " CORE3_CLKS "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_CLKGATECTLOVR"
base ad:0xa030400c
group 0--3
line.long 0 "EUR_CR_MASTER_CLKGATECTLOVR"
bitfld.long 0 0.--1. " CORE0_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " CORE1_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " CORE2_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " CORE3_CLKO "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_MASTER_CORE_ID"
base ad:0xa0304010
rgroup 0--3
line.long 0 "EUR_CR_MASTER_CORE_ID"
bitfld.long 0 0. " CONFIG_MULTI "  "0 ,1 "
bitfld.long 0 1. " CONFIG_BASE "  "0 ,1 "
bitfld.long 0 2.--7. " CONFIG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8.--11. " CONFIG_CORES "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " CONFIG_SLC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 2 " ID "
;tree.end

;tree "EUR_CR_MASTER_CORE_REVISION"
base ad:0xa0304014
rgroup 0--3
line.long 0 "EUR_CR_MASTER_CORE_REVISION"
hexfld.byte 0 " MAINTENANCE "
hexfld.byte 1 " MINOR "
hexfld.byte 2 " MAJOR "
hexfld.byte 3 " DESIGNER "
;tree.end

;tree "EUR_CR_MASTER_DESIGNER_REV_FIELD1"
base ad:0xa0304018
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DESIGNER_REV_FIELD1"
hexfld.long 0 " DESIGNER_REV_FIELD1 "
;tree.end

;tree "EUR_CR_MASTER_DESIGNER_REV_FIELD2"
base ad:0xa030401c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DESIGNER_REV_FIELD2"
hexfld.long 0 " DESIGNER_REV_FIELD2 "
;tree.end

;tree "EUR_CR_MASTER_SOFT_RESET"
base ad:0xa0304080
group 0--3
line.long 0 "EUR_CR_MASTER_SOFT_RESET"
bitfld.long 0 0. " CORE_RESET0 "  "0 ,1 "
bitfld.long 0 1. " CORE_RESET1 "  "0 ,1 "
bitfld.long 0 2. " CORE_RESET2 "  "0 ,1 "
bitfld.long 0 3. " CORE_RESET3 "  "0 ,1 "
bitfld.long 0 4. " IPF_RESET "  "0 ,1 "
bitfld.long 0 5. " DPM_RESET "  "0 ,1 "
bitfld.long 0 6. " VDM_RESET "  "0 ,1 "
bitfld.long 0 7. " SLC_RESET "  "0 ,1 "
bitfld.long 0 8. " BIF_RESET "  "0 ,1 "
bitfld.long 0 9. " MCI_RESET "  "0 ,1 "
bitfld.long 0 10. " PTLA_RESET "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DEBUG"
base ad:0xa0304090
group 0--3
line.long 0 "EUR_CR_MASTER_DEBUG"
bitfld.long 0 0. " DUMMY_FIELD "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_EVENT_STATUS"
base ad:0xa030412c
group 0--3
line.long 0 "EUR_CR_MASTER_EVENT_STATUS"
bitfld.long 0 0. " DPM_3D_MEM_FREE "  "0 ,1 "
bitfld.long 0 1. " DPM_OUT_OF_MEMORY_MT "  "0 ,1 "
bitfld.long 0 2. " DPM_OUT_OF_MEMORY_GBL "  "0 ,1 "
bitfld.long 0 3. " DPM_REACHED_MEM_THRESH "  "0 ,1 "
bitfld.long 0 4. " DPM_STATE_STORE "  "0 ,1 "
bitfld.long 0 5. " DPM_STATE_LOAD "  "0 ,1 "
bitfld.long 0 6. " DPM_STATE_CLEAR "  "0 ,1 "
bitfld.long 0 7. " DPM_CONTROL_STORE "  "0 ,1 "
bitfld.long 0 8. " DPM_CONTROL_LOAD "  "0 ,1 "
bitfld.long 0 9. " DPM_CONTROL_CLEAR "  "0 ,1 "
bitfld.long 0 10. " TPC_FLUSH "  "0 ,1 "
bitfld.long 0 11. " TPC_CLEAR "  "0 ,1 "
bitfld.long 0 12. " TA_TERMINATE "  "0 ,1 "
bitfld.long 0 13. " TA_FINISHED "  "0 ,1 "
bitfld.long 0 14. " SW_EVENT "  "0 ,1 "
bitfld.long 0 15. " BREAKPOINT "  "0 ,1 "
bitfld.long 0 16. " ISP_VISIBILITY_FAIL "  "0 ,1 "
bitfld.long 0 17. " ISP_HALT "  "0 ,1 "
bitfld.long 0 18. " PIXELBE_END_RENDER "  "0 ,1 "
bitfld.long 0 19. " OTPM_FLUSHED "  "0 ,1 "
bitfld.long 0 20. " OTPM_INV "  "0 ,1 "
bitfld.long 0 21. " OTPM_LOADED "  "0 ,1 "
bitfld.long 0 22. " DPM_INITEND "  "0 ,1 "
bitfld.long 0 23. " ISP_END_TILE "  "0 ,1 "
bitfld.long 0 24. " DPM_TA_MEM_FREE "  "0 ,1 "
bitfld.long 0 25. " DPM_OUT_OF_MEMORY_ZLS "  "0 ,1 "
bitfld.long 0 26. " TCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 27. " TWOD_COMPLETE "  "0 ,1 "
bitfld.long 0 28. " TA_DPM_FAULT "  "0 ,1 "
bitfld.long 0 29. " TIMER "  "0 ,1 "
bitfld.long 0 30. " PCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 31. " MASTER_INTERRUPT "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_EVENT_STATUS2"
base ad:0xa0304118
group 0--3
line.long 0 "EUR_CR_MASTER_EVENT_STATUS2"
bitfld.long 0 0. " DPM_TA_FREE_LOAD "  "0 ,1 "
bitfld.long 0 1. " DPM_3D_FREE_LOAD "  "0 ,1 "
bitfld.long 0 2. " TRIG_DL "  "0 ,1 "
bitfld.long 0 3. " TRIG_3D "  "0 ,1 "
bitfld.long 0 4. " TRIG_TA "  "0 ,1 "
bitfld.long 0 5. " TE_RGNHDR_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 6. " MTE_STATE_FLUSHED "  "0 ,1 "
bitfld.long 0 7. " DCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 8. " ISP2_ZLS_CSW_FINISHED "  "0 ,1 "
bitfld.long 0 9. " MTE_CONTEXT_DRAINED "  "0 ,1 "
bitfld.long 0 10. " DATA_BREAKPOINT_TRAPPED "  "0 ,1 "
bitfld.long 0 11. " DATA_BREAKPOINT_UNTRAPPED "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_EVENT_HOST_ENABLE"
base ad:0xa0304130
group 0--3
line.long 0 "EUR_CR_MASTER_EVENT_HOST_ENABLE"
bitfld.long 0 0. " DPM_3D_MEM_FREE "  "0 ,1 "
bitfld.long 0 1. " DPM_OUT_OF_MEMORY_MT "  "0 ,1 "
bitfld.long 0 2. " DPM_OUT_OF_MEMORY_GBL "  "0 ,1 "
bitfld.long 0 3. " DPM_REACHED_MEM_THRESH "  "0 ,1 "
bitfld.long 0 4. " DPM_STATE_STORE "  "0 ,1 "
bitfld.long 0 5. " DPM_STATE_LOAD "  "0 ,1 "
bitfld.long 0 6. " DPM_STATE_CLEAR "  "0 ,1 "
bitfld.long 0 7. " DPM_CONTROL_STORE "  "0 ,1 "
bitfld.long 0 8. " DPM_CONTROL_LOAD "  "0 ,1 "
bitfld.long 0 9. " DPM_CONTROL_CLEAR "  "0 ,1 "
bitfld.long 0 10. " TPC_FLUSH "  "0 ,1 "
bitfld.long 0 11. " TPC_CLEAR "  "0 ,1 "
bitfld.long 0 12. " TA_TERMINATE "  "0 ,1 "
bitfld.long 0 13. " TA_FINISHED "  "0 ,1 "
bitfld.long 0 14. " SW_EVENT "  "0 ,1 "
bitfld.long 0 15. " BREAKPOINT "  "0 ,1 "
bitfld.long 0 16. " ISP_VISIBILITY_FAIL "  "0 ,1 "
bitfld.long 0 17. " ISP_HALT "  "0 ,1 "
bitfld.long 0 18. " PIXELBE_END_RENDER "  "0 ,1 "
bitfld.long 0 19. " OTPM_FLUSHE "  "0 ,1 "
bitfld.long 0 20. " OTPM_INV "  "0 ,1 "
bitfld.long 0 21. " OTPM_LOADED "  "0 ,1 "
bitfld.long 0 22. " DPM_INITEND "  "0 ,1 "
bitfld.long 0 23. " ISP_END_TILE "  "0 ,1 "
bitfld.long 0 24. " DPM_TA_MEM_FREE "  "0 ,1 "
bitfld.long 0 25. " DPM_OUT_OF_MEMORY_ZLS "  "0 ,1 "
bitfld.long 0 26. " TCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 27. " TWOD_COMPLETE "  "0 ,1 "
bitfld.long 0 28. " TA_DPM_FAULT "  "0 ,1 "
bitfld.long 0 29. " TIMER "  "0 ,1 "
bitfld.long 0 30. " PCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 31. " MASTER_INTERRUPT "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_EVENT_HOST_ENABLE2"
base ad:0xa0304110
group 0--3
line.long 0 "EUR_CR_MASTER_EVENT_HOST_ENABLE2"
bitfld.long 0 0. " DPM_TA_FREE_LOAD "  "0 ,1 "
bitfld.long 0 1. " DPM_3D_FREE_LOAD "  "0 ,1 "
bitfld.long 0 2. " TRIG_DL "  "0 ,1 "
bitfld.long 0 3. " TRIG_3D "  "0 ,1 "
bitfld.long 0 4. " TRIG_TA "  "0 ,1 "
bitfld.long 0 5. " TE_RGNHDR_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 6. " MTE_STATE_FLUSHED "  "0 ,1 "
bitfld.long 0 7. " DCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 8. " ISP2_ZLS_CSW_FINISHED "  "0 ,1 "
bitfld.long 0 9. " MTE_CONTEXT_DRAINED "  "0 ,1 "
bitfld.long 0 10. " DATA_BREAKP "  "0 ,1 "
bitfld.long 0 11. " DATA_BREAKPOINT_UNTRAPPED "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_EVENT_HOST_CLEAR"
base ad:0xa0304134
wgroup 0--3
line.long 0 "EUR_CR_MASTER_EVENT_HOST_CLEAR"
bitfld.long 0 0. " DPM_3D_MEM_FREE "  "0 ,1 "
bitfld.long 0 1. " DPM_OUT_OF_MEMORY_MT "  "0 ,1 "
bitfld.long 0 2. " DPM_OUT_OF_MEMORY_GBL "  "0 ,1 "
bitfld.long 0 3. " DPM_REACHED_MEM_THRESH "  "0 ,1 "
bitfld.long 0 4. " DPM_STATE_STORE "  "0 ,1 "
bitfld.long 0 5. " DPM_STATE_LOAD "  "0 ,1 "
bitfld.long 0 6. " DPM_STATE_CLEAR "  "0 ,1 "
bitfld.long 0 7. " DPM_CONTROL_STORE "  "0 ,1 "
bitfld.long 0 8. " DPM_CONTROL_LOAD "  "0 ,1 "
bitfld.long 0 9. " DPM_CONTROL_CLEAR "  "0 ,1 "
bitfld.long 0 10. " TPC_FLUSH "  "0 ,1 "
bitfld.long 0 11. " TPC_CLEAR "  "0 ,1 "
bitfld.long 0 12. " TA_TERMINATE "  "0 ,1 "
bitfld.long 0 13. " TA_FINISHED "  "0 ,1 "
bitfld.long 0 14. " SW_EVENT "  "0 ,1 "
bitfld.long 0 15. " BREAKPOINT "  "0 ,1 "
bitfld.long 0 16. " ISP_VISIBILITY_FAIL "  "0 ,1 "
bitfld.long 0 17. " ISP_HALT "  "0 ,1 "
bitfld.long 0 18. " PIXELBE_END_RENDER "  "0 ,1 "
bitfld.long 0 19. " OTPM_FLUSHE "  "0 ,1 "
bitfld.long 0 20. " OTPM_INV "  "0 ,1 "
bitfld.long 0 21. " OTPM_LOADED "  "0 ,1 "
bitfld.long 0 22. " DPM_INITEND "  "0 ,1 "
bitfld.long 0 23. " ISP_END_TILE "  "0 ,1 "
bitfld.long 0 24. " DPM_TA_MEM_FREE "  "0 ,1 "
bitfld.long 0 25. " DPM_OUT_OF_MEMORY_ZLS "  "0 ,1 "
bitfld.long 0 26. " TCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 27. " TWOD_COMPLETE "  "0 ,1 "
bitfld.long 0 28. " TA_DPM_FAULT "  "0 ,1 "
bitfld.long 0 29. " TIMER "  "0 ,1 "
bitfld.long 0 30. " PCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 31. " MASTER_INTERRUPT "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_EVENT_HOST_CLEAR2"
base ad:0xa0304114
wgroup 0--3
line.long 0 "EUR_CR_MASTER_EVENT_HOST_CLEAR2"
bitfld.long 0 0. " DPM_TA_FREE_LOAD "  "0 ,1 "
bitfld.long 0 1. " DPM_3D_FREE_LOAD "  "0 ,1 "
bitfld.long 0 2. " TRIG_DL "  "0 ,1 "
bitfld.long 0 3. " TRIG_3D "  "0 ,1 "
bitfld.long 0 4. " TRIG_TA "  "0 ,1 "
bitfld.long 0 5. " TE_RGNHDR_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 6. " MTE_STATE_FLUSHED "  "0 ,1 "
bitfld.long 0 7. " DCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 8. " ISP2_ZLS_CSW_FINISHED "  "0 ,1 "
bitfld.long 0 9. " MTE_CONTEXT_DRAINED "  "0 ,1 "
bitfld.long 0 10. " DATA_BREAKPOINT_TRAPPED "  "0 ,1 "
bitfld.long 0 11. " DATA_BREAKPOINT_UNTRAPPED "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_PDS_CACHE_STATUS"
base ad:0xa0304138
group 0--3
line.long 0 "EUR_CR_MASTER_PDS_CACHE_STATUS"
bitfld.long 0 0. " CSC_INV "  "0 ,1 "
bitfld.long 0 1. " DSC_INV0 "  "0 ,1 "
bitfld.long 0 2. " DSC_INV1 "  "0 ,1 "
bitfld.long 0 4. " DSC_INV3 "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_PDS_CACHE_HOST_ENABLE"
base ad:0xa030413c
group 0--3
line.long 0 "EUR_CR_MASTER_PDS_CACHE_HOST_ENABLE"
bitfld.long 0 0. " CSC_INV "  "0 ,1 "
bitfld.long 0 1. " DSC_INV0 "  "0 ,1 "
bitfld.long 0 2. " DSC_INV1 "  "0 ,1 "
bitfld.long 0 4. " DSC_INV3 "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_PDS_CACHE_HOST_CLEAR"
base ad:0xa0304140
wgroup 0--3
line.long 0 "EUR_CR_MASTER_PDS_CACHE_HOST_CLEAR"
bitfld.long 0 0. " CSC_INV "  "0 ,1 "
bitfld.long 0 1. " DSC_INV0 "  "0 ,1 "
bitfld.long 0 2. " DSC_INV1 "  "0 ,1 "
bitfld.long 0 4. " DSC_INV3 "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_CONTEXT_DRAIN_STATUS"
base ad:0xa0304744
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_CONTEXT_DRAIN_STATUS"
bitfld.long 0 0. " DRAINED "  "0 ,1 "
bitfld.long 0 1. " RESUMED "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_DRAIN_STATUS"
base ad:0xa0304748
wgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_DRAIN_STATUS"
bitfld.long 0 0. " DRAIN_CLEAR "  "0 ,1 "
bitfld.long 0 1. " RESUME_CLEAR "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_CLIP_CHECKSUM"
base ad:0xa0304900
rgroup 0--3
line.long 0 "EUR_CR_MASTER_CLIP_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_MTE_MEM_CHECKSUM"
base ad:0xa0304904
rgroup 0--3
line.long 0 "EUR_CR_MASTER_MTE_MEM_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_MTE_TE_CHECKSUM"
base ad:0xa0304908
rgroup 0--3
line.long 0 "EUR_CR_MASTER_MTE_TE_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_TE_CHECKSUM"
base ad:0xa030490c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_TE_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_ISP_FPU_CHECKSUM"
base ad:0xa0304910
rgroup 0--3
line.long 0 "EUR_CR_MASTER_ISP_FPU_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_ISP_PRECALC_CHECKSUM"
base ad:0xa0304914
rgroup 0--3
line.long 0 "EUR_CR_MASTER_ISP_PRECALC_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_ISP_EDGE_CHECKSUM"
base ad:0xa0304918
rgroup 0--3
line.long 0 "EUR_CR_MASTER_ISP_EDGE_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_ISP_TAGWRITE_CHECKSUM"
base ad:0xa030491c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_ISP_TAGWRITE_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_ISP_SPAN_CHECKSUM"
base ad:0xa0304920
rgroup 0--3
line.long 0 "EUR_CR_MASTER_ISP_SPAN_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_PBE_CHECKSUM"
base ad:0xa0304924
rgroup 0--3
line.long 0 "EUR_CR_MASTER_PBE_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_EVENT_PDS_ENABLE"
base ad:0xa0304a58
group 0--3
line.long 0 "EUR_CR_MASTER_EVENT_PDS_ENABLE"
bitfld.long 0 0. " DPM_3D_MEM_FREE "  "0 ,1 "
bitfld.long 0 1. " DPM_OUT_OF_MEMORY_MT "  "0 ,1 "
bitfld.long 0 2. " DPM_OUT_OF_MEMORY_GBL "  "0 ,1 "
bitfld.long 0 3. " DPM_REACHED_MEM_THRESH "  "0 ,1 "
bitfld.long 0 12. " TA_TERMINATE "  "0 ,1 "
bitfld.long 0 13. " TA_FINISHED "  "0 ,1 "
bitfld.long 0 18. " PIXELBE_END_RENDER "  "0 ,1 "
bitfld.long 0 20. " TWOD_COMPLETE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_EVENT_PDS_ENABLE2"
base ad:0xa0304a50
group 0--3
line.long 0 "EUR_CR_MASTER_EVENT_PDS_ENABLE2"
bitfld.long 0 9. " MTE_CONTEXT_DRAINED "  "0 ,1 "
bitfld.long 0 10. " DATA_BREAKPOINT_TRAPPED "  "0 ,1 "
bitfld.long 0 11. " DATA_BREAKPOINT_UNTRAPPED "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_PTLA_STATUS"
base ad:0xa0304178
rgroup 0--3
line.long 0 "EUR_CR_MASTER_PTLA_STATUS"
bitfld.long 0 0. " BUSY "  "0 ,1 "
bitfld.long 0 1.--6. " FIFO_FULLNESS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "EUR_CR_MASTER_PTLA_REQUEST"
base ad:0xa030417c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_PTLA_REQUEST"
hexfld.long 0 " STATUS "
;tree.end

;tree "EUR_CR_MASTER_PTLA_SLAVE_CMD"
base ad:0xa0304180
group 0--3
line.long 0 "EUR_CR_MASTER_PTLA_SLAVE_CMD"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_CLKGATECTL2"
base ad:0xa0304020
group 0--3
line.long 0 "EUR_CR_MASTER_CLKGATECTL2"
bitfld.long 0 0.--1. " BIF_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " DPM_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " IPF_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " VDM_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PTLA_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 31. " AUTO_MAN_REG "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_CLKGATESTATUS2"
base ad:0xa0304024
group 0--3
line.long 0 "EUR_CR_MASTER_CLKGATESTATUS2"
bitfld.long 0 0. " BIF_CLKS "  "0 ,1 "
bitfld.long 0 1. " DPM_CLKS "  "0 ,1 "
bitfld.long 0 2. " IPF_CLKS "  "0 ,1 "
bitfld.long 0 3. " VDM_CLKS "  "0 ,1 "
bitfld.long 0 4. " PTLA_CLKS "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_CLKGATECTLOVR2"
base ad:0xa0304028
group 0--3
line.long 0 "EUR_CR_MASTER_CLKGATECTLOVR2"
bitfld.long 0 0.--1. " BIF_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " DPM_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " IPF_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " VDM_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " PTLA_CLKO "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_MASTER_MP_PRIMITIVE"
base ad:0xa0304144
group 0--3
line.long 0 "EUR_CR_MASTER_MP_PRIMITIVE"
hexfld.word 0 " SPLIT_THRESHOLD "
bitfld.long 0 16. " MODE "  "0 ,1 "
bitfld.long 0 17. " OMIT_OPT_WORDS "  "0 ,1 "
bitfld.long 0 18. " SPLIT_MODE "  "0 ,1 "
bitfld.long 0 20.--23. " MAX_BLOCKS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_MASTER_MP_PRIMITIVE_CG"
base ad:0xa0304148
group 0--3
line.long 0 "EUR_CR_MASTER_MP_PRIMITIVE_CG"
hexfld.word 0 " SPLIT_THRESHOLD "
;tree.end

;tree "EUR_CR_MASTER_MP_TILE"
base ad:0xa030414c
group 0--3
line.long 0 "EUR_CR_MASTER_MP_TILE"
bitfld.long 0 0.--1. " MODE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_MASTER_VDM_START"
base ad:0xa0304200
group 0--3
line.long 0 "EUR_CR_MASTER_VDM_START"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_TE_AA"
base ad:0xa0304204
group 0--3
line.long 0 "EUR_CR_MASTER_TE_AA"
bitfld.long 0 30. " Y "  "0 ,1 "
bitfld.long 0 31. " X "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_TE_MTILE"
base ad:0xa0304214
group 0--3
line.long 0 "EUR_CR_MASTER_TE_MTILE"
bitfld.long 0 0.--17. " STRIDE "  " "
;tree.end

;tree "EUR_CR_MASTER_VDM_CTRL_STREAM_BASE"
base ad:0xa0304238
group 0--3
line.long 0 "EUR_CR_MASTER_VDM_CTRL_STREAM_BASE"
bitfld.long 0 2.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_MTE_FIRST_PAGE"
base ad:0xa0304258
group 0--3
line.long 0 "EUR_CR_MASTER_MTE_FIRST_PAGE"
hexfld.word 0 " DATA "
bitfld.long 0 16.--20. " MACROTILE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 31. " VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_MTE_SECOND_PAGE"
base ad:0xa030425c
group 0--3
line.long 0 "EUR_CR_MASTER_MTE_SECOND_PAGE"
hexfld.word 0 " DATA "
bitfld.long 0 31. " VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_VDM_CONTEXT_STORE_SNAPSHOT"
base ad:0xa0304280
group 0--3
line.long 0 "EUR_CR_MASTER_VDM_CONTEXT_STORE_SNAPSHOT"
bitfld.long 0 0.--27. " BASE_ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_VDM_CONTEXT_LOAD_START"
base ad:0xa0304284
wgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_CONTEXT_LOAD_START"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_VDM_CONTEXT_LOAD_STATUS"
base ad:0xa0304288
rgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_CONTEXT_LOAD_STATUS"
bitfld.long 0 0. " COMPLETE "  "0 ,1 "
bitfld.long 0 1. " PROCESSING "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_VDM_CONTEXT_LOAD_STATUS_CLEAR"
base ad:0xa030428c
wgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_CONTEXT_LOAD_STATUS_CLEAR"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_VDM_TASK_KICK"
base ad:0xa0304290
wgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_TASK_KICK"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_VDM_TASK_KICK_STATUS"
base ad:0xa0304294
rgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_TASK_KICK_STATUS"
bitfld.long 0 0. " COMPLETE "  "0 ,1 "
bitfld.long 0 1. " PROCESSING "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_VDM_TASK_KICK_STATUS_CLEAR"
base ad:0xa0304298
wgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_TASK_KICK_STATUS_CLEAR"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_VDM_BATCH_NUM"
base ad:0xa0304320
wgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_BATCH_NUM"
bitfld.long 0 0. " LOAD "  "0 ,1 "
bitfld.long 0 1.--13. " VALUE "  " "
;tree.end

;tree "EUR_CR_MASTER_VDM_BATCH_NUM_STATUS"
base ad:0xa0304324
rgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_BATCH_NUM_STATUS"
bitfld.long 0 0.--12. " VALUE "  " "
;tree.end

;tree "EUR_CR_MASTER_VDM_CONTEXT_STORE_GENERIC_WORD0"
base ad:0xa0304328
group 0--3
line.long 0 "EUR_CR_MASTER_VDM_CONTEXT_STORE_GENERIC_WORD0"
bitfld.long 0 0.--23. " DATA "  " "
;tree.end

;tree "EUR_CR_MASTER_VDM_CONTEXT_STORE_GENERIC_WORD1"
base ad:0xa030432c
group 0--3
line.long 0 "EUR_CR_MASTER_VDM_CONTEXT_STORE_GENERIC_WORD1"
bitfld.long 0 0.--23. " DATA "  " "
;tree.end

;tree "EUR_CR_MASTER_VDM_CONTEXT_STORE_START"
base ad:0xa0304330
wgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_CONTEXT_STORE_START"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_VDM_CONTEXT_STORE_STREAM"
base ad:0xa0304334
rgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_CONTEXT_STORE_STREAM"
bitfld.long 0 2.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_VDM_CONTEXT_STORE_STATUS"
base ad:0xa030433c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_CONTEXT_STORE_STATUS"
bitfld.long 0 0. " COMPLETE "  "0 ,1 "
bitfld.long 0 4. " PROCESS "  "0 ,1 "
bitfld.long 0 8. " NA "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_VDM_CONTEXT_STORE_STATE0"
base ad:0xa0304340
group 0--3
line.long 0 "EUR_CR_MASTER_VDM_CONTEXT_STORE_STATE0"
bitfld.long 0 0.--27. " TAPDSSTATE_BASEADDR "  " "
bitfld.long 0 28. " TAPDSSTATE_COMPLEX "  "0 ,1 "
bitfld.long 0 29. " TAPDSSTATE_TERMINATE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_VDM_CONTEXT_STORE_STATE1"
base ad:0xa0304344
group 0--3
line.long 0 "EUR_CR_MASTER_VDM_CONTEXT_STORE_STATE1"
hexfld.byte 0 " TAPDSSTATE_USEATTRIBUTESIZE "
bitfld.long 0 8. " TAPDSSTATE_SECONDARY "  "0 ,1 "
bitfld.long 0 9.--11. " TAPDSSTATE_PARTITIONS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12. " TAPDSSTATE_PARTIAL "  "0 ,1 "
bitfld.long 0 13.--15. " TAPDSSTATE_USEPIPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17. " TAPDSSTATE_MTE_EMIT "  "0 ,1 "
bitfld.long 0 18. " TAPDSSTATE_FENCE_ENABLE "  "0 ,1 "
bitfld.long 0 19.--20. " TAPDSSTATE_GENERIC_PRESENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 25. " TAPDSSTATE_SD "  "0 ,1 "
bitfld.long 0 27.--31. " TAPDSSTATE_DATASIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "EUR_CR_MASTER_VDM_WAIT_FOR_KICK"
base ad:0xa0304348
rgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_WAIT_FOR_KICK"
bitfld.long 0 0. " STATUS "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_VDM_PIM"
base ad:0xa030435c
wgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_PIM"
bitfld.long 0 0. " CLEAR "  "0 ,1 "
bitfld.long 0 1. " LOAD "  "0 ,1 "
bitfld.long 0 2.--29. " VALUE "  " "
;tree.end

;tree "EUR_CR_MASTER_VDM_PIM_STATUS"
base ad:0xa0304360
rgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_PIM_STATUS"
bitfld.long 0 0. " CLEARED "  "0 ,1 "
bitfld.long 0 1. " LOADED "  "0 ,1 "
bitfld.long 0 2.--29. " VALUE "  " "
;tree.end

;tree "EUR_CR_MASTER_VDM_PIM_MAX"
base ad:0xa0304364
group 0--3
line.long 0 "EUR_CR_MASTER_VDM_PIM_MAX"
bitfld.long 0 0.--27. " VALUE "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_TASK_DPLIST"
base ad:0xa0304368
wgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_TASK_DPLIST"
bitfld.long 0 0. " CLEAR "  "0 ,1 "
bitfld.long 0 1. " LOAD "  "0 ,1 "
bitfld.long 0 2. " STORE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_DPLIST_EVENT_STATUS"
base ad:0xa030436c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_DPLIST_EVENT_STATUS"
bitfld.long 0 0. " CLEARED "  "0 ,1 "
bitfld.long 0 1. " LOADED "  "0 ,1 "
bitfld.long 0 2. " STORED "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_DPLIST_CLEAR_EVENT"
base ad:0xa0304370
wgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_DPLIST_CLEAR_EVENT"
bitfld.long 0 0. " CLEAR "  "0 ,1 "
bitfld.long 0 1. " LOAD "  "0 ,1 "
bitfld.long 0 2. " STORE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_VDM_CORE"
base ad:0xa0304374
wgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_CORE"
bitfld.long 0 0. " LOAD "  "0 ,1 "
bitfld.long 0 1.--2. " NUM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_MASTER_VDM_FENCE"
base ad:0xa0304390
wgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_FENCE"
bitfld.long 0 0. " INCREMENT "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_VDM_FENCE_STATUS"
base ad:0xa0304394
rgroup 0--3
line.long 0 "EUR_CR_MASTER_VDM_FENCE_STATUS"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_ISP_RENDER"
base ad:0xa0304404
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_RENDER"
bitfld.long 0 0.--1. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CONTEXT_RESUMED "  "0 ,1 "
bitfld.long 0 4.--5. " FAST_SCANDIR "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_MASTER_ISP_RGN_BASE"
base ad:0xa0304408
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_RGN_BASE"
bitfld.long 0 2.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_ISP_RENDBOX1"
base ad:0xa030440c
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_RENDBOX1"
hexfld.byte 0 " Y "
hexfld.byte 2 " X "
;tree.end

;tree "EUR_CR_MASTER_ISP_RENDBOX2"
base ad:0xa0304410
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_RENDBOX2"
hexfld.byte 0 " Y "
hexfld.byte 2 " X "
;tree.end

;tree "EUR_CR_MASTER_ISP_START_RENDER"
base ad:0xa0304428
wgroup 0--3
line.long 0 "EUR_CR_MASTER_ISP_START_RENDER"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_3D_AA_MODE"
base ad:0xa030442c
group 0--3
line.long 0 "EUR_CR_MASTER_3D_AA_MODE"
bitfld.long 0 0.--1. " VALUE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_MASTER_ISP_BREAK"
base ad:0xa0304430
wgroup 0--3
line.long 0 "EUR_CR_MASTER_ISP_BREAK"
bitfld.long 0 0. " HALT "  "0 ,1 "
bitfld.long 0 4. " RESUME "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_3DCONTEXT"
base ad:0xa0304434
wgroup 0--3
line.long 0 "EUR_CR_MASTER_ISP_3DCONTEXT"
bitfld.long 0 0. " STORE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_RGN_BASE1"
base ad:0xa0304510
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_RGN_BASE1"
bitfld.long 0 2.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_ISP_RGN_BASE2"
base ad:0xa0304514
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_RGN_BASE2"
bitfld.long 0 2.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_ISP_RGN_BASE3"
base ad:0xa0304518
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_RGN_BASE3"
bitfld.long 0 2.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_ISP_RGN"
base ad:0xa030451c
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_RGN"
bitfld.long 0 2.--23. " SIZE "  " "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME2"
base ad:0xa0304560
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME2"
bitfld.long 0 0.--8. " ZLS_BURST "  " "
bitfld.long 0 9. " PT_IN_FLIGHT "  "0 ,1 "
bitfld.long 0 10. " END_OF_RENDER "  "0 ,1 "
bitfld.long 0 11. " END_OF_TILE "  "0 ,1 "
hexfld.byte 2 " TILE_Y "
hexfld.byte 3 " TILE_X "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME4"
base ad:0xa0304564
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME4"
bitfld.long 0 0.--27. " PIM_ID "  " "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME5"
base ad:0xa0304568
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME5"
bitfld.long 0 0.--1. " STREAM_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " EMPTY_STATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME6"
base ad:0xa030456c
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME6"
bitfld.long 0 2.--27. " RGN0_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN0_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME7"
base ad:0xa0304570
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME7"
bitfld.long 0 2.--27. " RGN1_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN1_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME8"
base ad:0xa0304574
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME8"
bitfld.long 0 2.--27. " RGN2_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN2_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME9"
base ad:0xa0304578
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE0_CONTEXT_RESUME9"
bitfld.long 0 2.--27. " RGN3_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN3_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME2"
base ad:0xa030457c
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME2"
bitfld.long 0 0.--8. " ZLS_BURST "  " "
bitfld.long 0 9. " PT_IN_FLIGHT "  "0 ,1 "
bitfld.long 0 10. " END_OF_RENDER "  "0 ,1 "
bitfld.long 0 11. " END_OF_TILE "  "0 ,1 "
hexfld.byte 2 " TILE_Y "
hexfld.byte 3 " TILE_X "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME4"
base ad:0xa0304580
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME4"
bitfld.long 0 0.--27. " PIM_ID "  " "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME5"
base ad:0xa0304584
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME5"
bitfld.long 0 0.--1. " STREAM_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " EMPTY_STATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME6"
base ad:0xa0304588
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME6"
bitfld.long 0 2.--27. " RGN0_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN0_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME7"
base ad:0xa030458c
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME7"
bitfld.long 0 2.--27. " RGN1_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN1_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME8"
base ad:0xa0304590
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME8"
bitfld.long 0 2.--27. " RGN2_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN2_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME9"
base ad:0xa0304594
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE1_CONTEXT_RESUME9"
bitfld.long 0 2.--27. " RGN3_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN3_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME2"
base ad:0xa0304598
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME2"
bitfld.long 0 0.--8. " ZLS_BURST "  " "
bitfld.long 0 9. " PT_IN_FLIGHT "  "0 ,1 "
bitfld.long 0 10. " END_OF_RENDER "  "0 ,1 "
bitfld.long 0 11. " END_OF_TILE "  "0 ,1 "
hexfld.byte 2 " TILE_Y "
hexfld.byte 3 " TILE_X "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME4"
base ad:0xa030459c
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME4"
bitfld.long 0 0.--27. " PIM_ID "  " "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME5"
base ad:0xa03045a0
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME5"
bitfld.long 0 0.--1. " STREAM_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " EMPTY_STATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME6"
base ad:0xa03045a4
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME6"
bitfld.long 0 2.--27. " RGN0_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN0_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME7"
base ad:0xa03045a8
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME7"
bitfld.long 0 2.--27. " RGN1_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN1_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME8"
base ad:0xa03045ac
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME8"
bitfld.long 0 2.--27. " RGN2_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN2_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME9"
base ad:0xa03045b0
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE2_CONTEXT_RESUME9"
bitfld.long 0 2.--27. " RGN3_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN3_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME2"
base ad:0xa03045b4
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME2"
bitfld.long 0 0.--8. " ZLS_BURST "  " "
bitfld.long 0 9. " PT_IN_FLIGHT "  "0 ,1 "
bitfld.long 0 10. " END_OF_RENDER "  "0 ,1 "
bitfld.long 0 11. " END_OF_TILE "  "0 ,1 "
hexfld.byte 2 " TILE_Y "
hexfld.byte 3 " TILE_X "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME4"
base ad:0xa03045b8
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME4"
bitfld.long 0 0.--27. " PIM_ID "  " "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME5"
base ad:0xa03045bc
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME5"
bitfld.long 0 0.--1. " STREAM_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " EMPTY_STATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME6"
base ad:0xa03045c0
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME6"
bitfld.long 0 2.--27. " RGN0_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN0_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME7"
base ad:0xa03045c4
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME7"
bitfld.long 0 2.--27. " RGN1_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN1_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME8"
base ad:0xa03045c8
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME8"
bitfld.long 0 2.--27. " RGN2_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN2_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME9"
base ad:0xa03045cc
group 0--3
line.long 0 "EUR_CR_MASTER_ISP_CORE3_CONTEXT_RESUME9"
bitfld.long 0 2.--27. " RGN3_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN3_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_3D_PAGE_TABLE_BASE"
base ad:0xa0304600
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_3D_PAGE_TABLE_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_3D_FREE_LIST"
base ad:0xa0304604
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_3D_FREE_LIST"
hexfld.word 0 " HEAD "
hexfld.word 2 " TAIL "
;tree.end

;tree "EUR_CR_MASTER_DPM_PDS_PAGE_THRESHOLD"
base ad:0xa0304614
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_PDS_PAGE_THRESHOLD"
hexfld.word 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_DPM_TA_ALLOC_PAGE_TABLE_BASE"
base ad:0xa0304618
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_TA_ALLOC_PAGE_TABLE_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_TA_ALLOC_FREE_LIST"
base ad:0xa030461c
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_TA_ALLOC_FREE_LIST"
hexfld.word 0 " HEAD "
hexfld.word 2 " TAIL "
;tree.end

;tree "EUR_CR_MASTER_DPM_TA_PAGE_THRESHOLD"
base ad:0xa0304620
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_TA_PAGE_THRESHOLD"
hexfld.word 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_DPM_ZLS_PAGE_THRESHOLD"
base ad:0xa0304624
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_ZLS_PAGE_THRESHOLD"
hexfld.word 0 " VALUE "
;tree.end

;tree "EUR_CR_MASTER_DPM_TA_GLOBAL_LIST"
base ad:0xa0304628
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_TA_GLOBAL_LIST"
hexfld.word 0 " SIZE "
bitfld.long 0 16. " POLICY "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_STATE_TABLE_CONTEXT0_BASE"
base ad:0xa030462c
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_STATE_TABLE_CONTEXT0_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_STATE_CONTEXT_ID"
base ad:0xa0304630
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_STATE_CONTEXT_ID"
bitfld.long 0 0. " LS "  "0 ,1 "
bitfld.long 0 1. " DALLOC "  "0 ,1 "
bitfld.long 0 2. " ALLOC "  "0 ,1 "
bitfld.long 0 3. " NCOP "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_CONTEXT_PAGES_ALLOCATED"
base ad:0xa0304638
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_CONTEXT_PAGES_ALLOCATED"
hexfld.word 0 " LOCAL "
hexfld.word 2 " GLOBAL "
;tree.end

;tree "EUR_CR_MASTER_DPM_3D_DEALLOCATE"
base ad:0xa030463c
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_3D_DEALLOCATE"
bitfld.long 0 0. " GLOBAL "  "0 ,1 "
bitfld.long 0 1. " ENABLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_ALLOC"
base ad:0xa0304640
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_ALLOC"
hexfld.word 0 " PAGE "
bitfld.long 0 16. " PAGE_VALID "  "0 ,1 "
bitfld.long 0 17. " PAGE_OUTOFMEMORY "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_DALLOC"
base ad:0xa0304644
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_DALLOC"
hexfld.word 0 " PAGE "
bitfld.long 0 16. " PAGE_FREE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_TA_ALLOC"
base ad:0xa0304648
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_TA_ALLOC"
hexfld.word 2 " FREE_LIST_PR "
;tree.end

;tree "EUR_CR_MASTER_DPM_3D"
base ad:0xa030464c
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_3D"
hexfld.word 2 " FREE_LIST_PREVIOUS "
;tree.end

;tree "EUR_CR_MASTER_DPM_PARTIAL_RENDER"
base ad:0xa0304658
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_PARTIAL_RENDER"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_LSS_PARTIAL_CONTEXT"
base ad:0xa030465c
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_LSS_PARTIAL_CONTEXT"
bitfld.long 0 0. " OPERATION "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_3D_CONTEXT_PAGES_ALLOCATED"
base ad:0xa0304660
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_3D_CONTEXT_PAGES_ALLOCATED"
hexfld.word 0 " LOCAL "
hexfld.word 2 " GLOBAL "
;tree.end

;tree "EUR_CR_MASTER_DPM_CONTEXT_PB_BASE"
base ad:0xa0304664
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_CONTEXT_PB_BASE"
bitfld.long 0 0.--2. " CMP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_MASTER_DPM_PAGE_MANAGEOP"
base ad:0xa0304670
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_PAGE_MANAGEOP"
bitfld.long 0 0. " DISABLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_STATE_TABLE_CONTEXT1_BASE"
base ad:0xa0304674
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_STATE_TABLE_CONTEXT1_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_TASK_3D_FREE"
base ad:0xa0304680
wgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_TASK_3D_FREE"
bitfld.long 0 0. " LOAD "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_TASK_TA_FREE"
base ad:0xa0304684
wgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_TASK_TA_FREE"
bitfld.long 0 0. " LOAD "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_TASK_HOST_FREE"
base ad:0xa0304688
wgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_TASK_HOST_FREE"
bitfld.long 0 0. " LOAD "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_TASK_STATE"
base ad:0xa0304694
wgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_TASK_STATE"
bitfld.long 0 0. " STORE "  "0 ,1 "
bitfld.long 0 1. " CLEAR "  "0 ,1 "
bitfld.long 0 2. " LOAD "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_OUTOFMEM"
base ad:0xa030469c
wgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_OUTOFMEM"
bitfld.long 0 0. " RESTART "  "0 ,1 "
bitfld.long 0 1. " ABORT "  "0 ,1 "
bitfld.long 0 2. " ABORTALL "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_FREE_CONTEXT"
base ad:0xa03046a0
wgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_FREE_CONTEXT"
bitfld.long 0 0. " NOW "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_3D_TIMEOUT"
base ad:0xa03046a4
wgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_3D_TIMEOUT"
bitfld.long 0 0. " NOW "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_TA_EVM"
base ad:0xa03046a8
wgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_TA_EVM"
bitfld.long 0 0. " INIT "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_TA_ALLOC_FREE_LIST_STATUS1"
base ad:0xa0304700
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_TA_ALLOC_FREE_LIST_STATUS1"
hexfld.word 0 " HEAD "
hexfld.word 2 " TAIL "
;tree.end

;tree "EUR_CR_MASTER_DPM_3D_FREE_LIST_STATUS1"
base ad:0xa030470c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_3D_FREE_LIST_STATUS1"
hexfld.word 0 " HEAD "
hexfld.word 2 " TAIL "
;tree.end

;tree "EUR_CR_MASTER_DPM_TA_ALLOC_FREE_LIST_STATUS2"
base ad:0xa0304710
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_TA_ALLOC_FREE_LIST_STATUS2"
hexfld.word 0 " PREVIOUS "
;tree.end

;tree "EUR_CR_MASTER_DPM_3D_FREE_LIST_STATUS2"
base ad:0xa030471c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_3D_FREE_LIST_STATUS2"
hexfld.word 0 " PREVIOUS "
;tree.end

;tree "EUR_CR_MASTER_DPM_ABORT_STATUS_MTILE"
base ad:0xa0304720
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_ABORT_STATUS_MTILE"
bitfld.long 0 0.--3. " INDEX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " GLOBAL "  "0 ,1 "
bitfld.long 0 5.--7. " CORE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_MASTER_DPM_PAGE_STATUS"
base ad:0xa0304724
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_PAGE_STATUS"
hexfld.word 0 " TOTAL "
hexfld.word 2 " TA "
;tree.end

;tree "EUR_CR_MASTER_DPM_PAGE"
base ad:0xa0304728
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_PAGE"
hexfld.word 0 " STATUS_3D "
;tree.end

;tree "EUR_CR_MASTER_DPM_GLOBAL_PAGE_STATUS"
base ad:0xa030472c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_GLOBAL_PAGE_STATUS"
hexfld.word 0 " TOTAL "
hexfld.word 2 " TA "
;tree.end

;tree "EUR_CR_MASTER_DPM_GLOBAL_PAGE"
base ad:0xa0304730
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_GLOBAL_PAGE"
hexfld.word 0 " STATUS_3D "
;tree.end

;tree "EUR_CR_MASTER_DPM_REQUESTING"
base ad:0xa0304734
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_REQUESTING"
bitfld.long 0 0.--1. " SOURCE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_MASTER_DPM_DPLIST_STATUS"
base ad:0xa030473c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_DPLIST_STATUS"
bitfld.long 0 0.--27. " PIM "  " "
bitfld.long 0 28.--29. " CORE "  "0 ,1 ,2 ,3 "
bitfld.long 0 30. " ACTIVE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_DPLIST_START_OF"
base ad:0xa0304740
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_DPLIST_START_OF"
bitfld.long 0 0.--27. " PIM "  " "
bitfld.long 0 28.--29. " CORE "  "0 ,1 ,2 ,3 "
bitfld.long 0 30. " ACTIVE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_PAGE_MANAGEOP_STATUS"
base ad:0xa0304750
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_PAGE_MANAGEOP_STATUS"
bitfld.long 0 0. " DISABLED "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_IDLE"
base ad:0xa0304754
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_IDLE"
hexfld.byte 0 " STATUS "
;tree.end

;tree "EUR_CR_MASTER_DPM_DEBUG_STATUS"
base ad:0xa0304758
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_DEBUG_STATUS"
bitfld.long 0 0. " OUTOFMEM_DEADLOCK "  "0 ,1 "
bitfld.long 0 1. " OUTOFMEM_SLEEP "  "0 ,1 "
bitfld.long 0 2. " OUTOFMEM_WAIT "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_NCPIM0_STATUS"
base ad:0xa030475c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_NCPIM0_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_NCPIM1_STATUS"
base ad:0xa0304760
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_NCPIM1_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_NCPIM2_STATUS"
base ad:0xa0304764
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_NCPIM2_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_NCPIM3_STATUS"
base ad:0xa0304768
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_NCPIM3_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_NCPIM4_STATUS"
base ad:0xa030476c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_NCPIM4_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_NCPIM5_STATUS"
base ad:0xa0304770
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_NCPIM5_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_NCPIM6_STATUS"
base ad:0xa0304774
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_NCPIM6_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_NCPIM7_STATUS"
base ad:0xa0304778
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_NCPIM7_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_NCPIM8_STATUS"
base ad:0xa030477c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_NCPIM8_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_NCPIM9_STATUS"
base ad:0xa0304780
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_NCPIM9_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_NCPIM10_STATUS"
base ad:0xa0304784
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_NCPIM10_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_NCPIM11_STATUS"
base ad:0xa030478c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_NCPIM11_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_REQUESTOR0_PIM_STATUS"
base ad:0xa0304790
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_REQUESTOR0_PIM_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_REQUESTOR1_PIM_STATUS"
base ad:0xa0304794
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_REQUESTOR1_PIM_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_REQUESTOR2_PIM_STATUS"
base ad:0xa0304798
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_REQUESTOR2_PIM_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_REQUESTOR3_PIM_STATUS"
base ad:0xa030479c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_REQUESTOR3_PIM_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_REQUESTOR4_PIM_STATUS"
base ad:0xa03047a0
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_REQUESTOR4_PIM_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_REQUESTOR5_PIM_STATUS"
base ad:0xa03047a4
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_REQUESTOR5_PIM_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_REQUESTOR6_PIM_STATUS"
base ad:0xa03047a8
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_REQUESTOR6_PIM_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_REQUESTOR7_PIM_STATUS"
base ad:0xa03047ac
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_REQUESTOR7_PIM_STATUS"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_NCPIM0"
base ad:0xa03047b0
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_NCPIM0"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_NCPIM1"
base ad:0xa03047b4
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_NCPIM1"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_NCPIM2"
base ad:0xa03047b8
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_NCPIM2"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_NCPIM3"
base ad:0xa03047bc
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_NCPIM3"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_NCPIM4"
base ad:0xa03047c0
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_NCPIM4"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_NCPIM5"
base ad:0xa03047c4
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_NCPIM5"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_NCPIM6"
base ad:0xa03047c8
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_NCPIM6"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_NCPIM7"
base ad:0xa03047cc
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_NCPIM7"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_NCPIM8"
base ad:0xa03047d0
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_NCPIM8"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_NCPIM9"
base ad:0xa03047d4
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_NCPIM9"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_NCPIM10"
base ad:0xa03047d8
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_NCPIM10"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_NCPIM11"
base ad:0xa03047dc
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_NCPIM11"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TE "  "0 ,1 "
bitfld.long 0 30. " MTE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_REQUESTOR0_PIM"
base ad:0xa03047e0
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_REQUESTOR0_PIM"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_REQUESTOR1_PIM"
base ad:0xa03047e4
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_REQUESTOR1_PIM"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_REQUESTOR2_PIM"
base ad:0xa03047e8
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_REQUESTOR2_PIM"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_REQUESTOR3_PIM"
base ad:0xa03047ec
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_REQUESTOR3_PIM"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_REQUESTOR4_PIM"
base ad:0xa03047f0
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_REQUESTOR4_PIM"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_REQUESTOR5_PIM"
base ad:0xa03047f4
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_REQUESTOR5_PIM"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_REQUESTOR6_PIM"
base ad:0xa03047f8
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_REQUESTOR6_PIM"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_REQUESTOR7_PIM"
base ad:0xa03047fc
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_REQUESTOR7_PIM"
bitfld.long 0 0.--27. " STATUS "  " "
bitfld.long 0 28. " ACTIVE "  "0 ,1 "
bitfld.long 0 29. " TERM "  "0 ,1 "
bitfld.long 0 30. " PIM_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_PROACTIVE_PIM_SPEC"
base ad:0xa0304800
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_PROACTIVE_PIM_SPEC"
bitfld.long 0 0.--12. " TIMOUT_CNT "  " "
bitfld.long 0 31. " EN_N "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_MTILE_PARTI_PIM_TABLE_BASE_ADDR"
base ad:0xa0304804
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_MTILE_PARTI_PIM_TABLE_BASE_ADDR"
bitfld.long 0 4.--31. " STATUS "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_PIMSHARE_RESERVE_PAGES"
base ad:0xa0304808
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_PIMSHARE_RESERVE_PAGES"
bitfld.long 0 0.--16. " STATUS "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_DRAIN_HEAP"
base ad:0xa030480c
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_DRAIN_HEAP"
hexfld.word 0 " HEAD "
hexfld.word 2 " TAIL "
;tree.end

;tree "EUR_CR_MASTER_DPM_DRAIN_HEAP_FREE"
base ad:0xa0304810
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_DRAIN_HEAP_FREE"
hexfld.word 0 " PTR "
;tree.end

;tree "EUR_CR_MASTER_DPM_DRAIN"
base ad:0xa0304814
wgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_DRAIN"
bitfld.long 0 0. " START_PULSE "  "0 ,1 "
bitfld.long 0 1. " RESUME_PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_CONTEXT_DRAIN"
base ad:0xa0304818
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_CONTEXT_DRAIN"
bitfld.long 0 4.--31. " BASE_ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_MTE_FORCEREISSUE"
base ad:0xa030481c
group 0--3
line.long 0 "EUR_CR_MASTER_MTE_FORCEREISSUE"
bitfld.long 0 0. " ENABLE_N "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_DPM_MTILE_ABORTED"
base ad:0xa0304820
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_MTILE_ABORTED"
hexfld.word 0 " MASK "
;tree.end

;tree "EUR_CR_MASTER_DPM_TSP0_MTILEFREE"
base ad:0xa0304824
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_TSP0_MTILEFREE"
bitfld.long 0 0.--16. " STATUS "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_TSP1_MTILEFREE"
base ad:0xa0304828
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_TSP1_MTILEFREE"
bitfld.long 0 0.--16. " STATUS "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_TSP2_MTILEFREE"
base ad:0xa030482c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_TSP2_MTILEFREE"
bitfld.long 0 0.--16. " STATUS "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_TSP3_MTILEFREE"
base ad:0xa0304830
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_TSP3_MTILEFREE"
bitfld.long 0 0.--16. " STATUS "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_TSP0_START_OF_MTILEFREE"
base ad:0xa0304834
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_TSP0_START_OF_MTILEFREE"
bitfld.long 0 0.--16. " STATUS "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_TSP1_START_OF_MTILEFREE"
base ad:0xa0304838
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_TSP1_START_OF_MTILEFREE"
bitfld.long 0 0.--16. " STATUS "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_TSP2_START_OF_MTILEFREE"
base ad:0xa030483c
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_TSP2_START_OF_MTILEFREE"
bitfld.long 0 0.--16. " STATUS "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_TSP3_START_OF_MTILEFREE"
base ad:0xa0304840
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_TSP3_START_OF_MTILEFREE"
bitfld.long 0 0.--16. " STATUS "  " "
;tree.end

;tree "EUR_CR_MASTER_DPM_DEALLOCATE_MASK"
base ad:0xa0304844
rgroup 0--3
line.long 0 "EUR_CR_MASTER_DPM_DEALLOCATE_MASK"
hexfld.word 0 " STATUS "
;tree.end

;tree "EUR_CR_MASTER_DPM_START_OF_DEALLOCATE_MASK"
base ad:0xa0304848
group 0--3
line.long 0 "EUR_CR_MASTER_DPM_START_OF_DEALLOCATE_MASK"
hexfld.word 0 " STATUS "
;tree.end

;tree "EUR_CR_MASTER_BIF_CTRL"
base ad:0xa0304c00
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_CTRL"
bitfld.long 0 0. " NOREORDER "  "0 ,1 "
bitfld.long 0 1. " PAUSE "  "0 ,1 "
bitfld.long 0 4. " CLEAR_FAULT "  "0 ,1 "
bitfld.long 0 8. " MMU_BYPASS_CACHE "  "0 ,1 "
bitfld.long 0 9. " MMU_BYPASS_VDM "  "0 ,1 "
bitfld.long 0 10. " MMU_BYPASS_TE "  "0 ,1 "
bitfld.long 0 11. " MMU_BYPASS_TWOD "  "0 ,1 "
bitfld.long 0 12. " MMU_BYPASS_PBE "  "0 ,1 "
bitfld.long 0 13. " MMU_BYPASS_TSPP "  "0 ,1 "
bitfld.long 0 14. " MMU_BYPASS_ISP "  "0 ,1 "
bitfld.long 0 15. " MMU_BYPASS_USE "  "0 ,1 "
bitfld.long 0 16. " MMU_BYPASS_PTLA "  "0 ,1 "
bitfld.long 0 17. " MMU_BYPASS_MASTER_VDM "  "0 ,1 "
bitfld.long 0 18. " MMU_BYPASS_MASTER_ "  "0 ,1 "
bitfld.long 0 19. " MMU_BYPASS_MASTER_DPM "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_BIF_INT_STAT"
base ad:0xa0304c04
rgroup 0--3
line.long 0 "EUR_CR_MASTER_BIF_INT_STAT"
bitfld.long 0 0.--13. " FAULT_REQ "  " "
bitfld.long 0 16.--18. " FAULT_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19. " FLUSH_COMPLETE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_BIF_FAULT"
base ad:0xa0304c08
rgroup 0--3
line.long 0 "EUR_CR_MASTER_BIF_FAULT"
bitfld.long 0 0.--3. " CID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--8. " SB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_BIF_CTRL_INVAL"
base ad:0xa0304c34
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_CTRL_INVAL"
bitfld.long 0 2. " PTE "  "0 ,1 "
bitfld.long 0 3. " ALL "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_BIF_DIR_LIST_BASE0"
base ad:0xa0304c84
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_DIR_LIST_BASE0"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_BIF_DIR_LIST_BASE1"
base ad:0xa0304c38
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_DIR_LIST_BASE1"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_BIF_DIR_LIST_BASE2"
base ad:0xa0304c3c
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_DIR_LIST_BASE2"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_BIF_DIR_LIST_BASE3"
base ad:0xa0304c40
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_DIR_LIST_BASE3"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_BIF_DIR_LIST_BASE4"
base ad:0xa0304c44
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_DIR_LIST_BASE4"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_BIF_DIR_LIST_BASE5"
base ad:0xa0304c48
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_DIR_LIST_BASE5"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_BIF_DIR_LIST_BASE6"
base ad:0xa0304c4c
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_DIR_LIST_BASE6"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_BIF_DIR_LIST_BASE7"
base ad:0xa0304c50
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_DIR_LIST_BASE7"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_BIF_BANK_SET"
base ad:0xa0304c74
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_BANK_SET"
bitfld.long 0 2.--3. " SELECT_3D "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " SELECT_TA "  "0 ,1 ,2 ,3 "
bitfld.long 0 9. " SELECT_DPM_LSS "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_BIF_BANK0"
base ad:0xa0304c78
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_BANK0"
bitfld.long 0 4.--6. " INDEX_TA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " INDEX_3D "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 16.--18. " INDEX_PTLA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_MASTER_BIF_BANK1"
base ad:0xa0304c7c
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_BANK1"
bitfld.long 0 4.--6. " INDEX_TA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--14. " INDEX_3D "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_MASTER_BIF_BANK_STATUS"
base ad:0xa0304cb4
rgroup 0--3
line.long 0 "EUR_CR_MASTER_BIF_BANK_STATUS"
bitfld.long 0 0. " 3D_CURRENT_BANK "  "0 ,1 "
bitfld.long 0 1. " TA_CURRENT_BANK "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_BIF_MEM_REQ_STAT"
base ad:0xa0304ca8
rgroup 0--3
line.long 0 "EUR_CR_MASTER_BIF_MEM_REQ_STAT"
hexfld.byte 0 " READS "
;tree.end

;tree "EUR_CR_MASTER_BIF_3D_REQ_BASE"
base ad:0xa0304cac
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_3D_REQ_BASE"
bitfld.long 0 20.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MASTER_BIF_MMU_CTRL"
base ad:0xa0304cd0
group 0--3
line.long 0 "EUR_CR_MASTER_BIF_MMU_CTRL"
bitfld.long 0 0. " PREFETCHING_ON "  "0 ,1 "
bitfld.long 0 1.--2. " ADDR_HASH_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " ENABLE_DC_TLB "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_SLC_CTRL"
base ad:0xa0304d00
group 0--3
line.long 0 "EUR_CR_MASTER_SLC_CTRL"
bitfld.long 0 8. " PAUSE "  "0 ,1 "
bitfld.long 0 9.--11. " ADDR_DECODE_MODE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12.--15. " ARB_PAGE_SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " DM_REF_SET_ALL "  "0 ,1 "
bitfld.long 0 18. " USSE_INVAL_REQ0 "  "0 ,1 "
bitfld.long 0 19. " USSE_INVAL_REQ1 "  "0 ,1 "
bitfld.long 0 20. " USSE_INVAL_REQ2 "  "0 ,1 "
bitfld.long 0 21. " USSE_INVAL_REQ3 "  "0 ,1 "
bitfld.long 0 22. " DISABLE_BURST_EXP "  "0 ,1 "
bitfld.long 0 23. " DISABLE_REORDERING "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_SLC_CTRL_BYPASS"
base ad:0xa0304d04
group 0--3
line.long 0 "EUR_CR_MASTER_SLC_CTRL_BYPASS"
bitfld.long 0 0. " ALL "  "0 ,1 "
bitfld.long 0 1. " DM_VERTEX "  "0 ,1 "
bitfld.long 0 2. " DM_PIXEL "  "0 ,1 "
bitfld.long 0 3. " DM_EVENT "  "0 ,1 "
bitfld.long 0 4. " REQ_MMU "  "0 ,1 "
bitfld.long 0 5. " REQ_CACHE "  "0 ,1 "
bitfld.long 0 6. " REQ_TA "  "0 ,1 "
bitfld.long 0 7. " REQ_TPF "  "0 ,1 "
bitfld.long 0 8. " REQ_IPF_OBJ "  "0 ,1 "
bitfld.long 0 9. " REQ_USE0 "  "0 ,1 "
bitfld.long 0 10. " REQ_USE1 "  "0 ,1 "
bitfld.long 0 11. " REQ_USE2 "  "0 ,1 "
bitfld.long 0 12. " REQ_USE3 "  "0 ,1 "
bitfld.long 0 13. " REQ_USEC "  "0 ,1 "
bitfld.long 0 14. " REQ_PDS "  "0 ,1 "
bitfld.long 0 15. " REQ_IPF "  "0 ,1 "
bitfld.long 0 16. " REQ_VDM "  "0 ,1 "
bitfld.long 0 17. " REQ_PBE "  "0 ,1 "
bitfld.long 0 18. " REQ_ZLS "  "0 ,1 "
bitfld.long 0 19. " REQ_ISP2_RCIF "  "0 ,1 "
bitfld.long 0 20. " REQ_PTLA "  "0 ,1 "
bitfld.long 0 21. " CORE0 "  "0 ,1 "
bitfld.long 0 22. " CORE1 "  "0 ,1 "
bitfld.long 0 23. " CORE2 "  "0 ,1 "
bitfld.long 0 24. " CORE3 "  "0 ,1 "
bitfld.long 0 25. " CORE4 "  "0 ,1 "
bitfld.long 0 26. " BYP_CC "  "0 ,1 "
bitfld.long 0 27. " BYP_CC_N "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_SLC_CTRL_USSE_INVAL"
base ad:0xa0304d08
group 0--3
line.long 0 "EUR_CR_MASTER_SLC_CTRL_USSE_INVAL"
hexfld.long 0 " ADDR "
;tree.end

;tree "EUR_CR_MASTER_SLC_STATUS"
base ad:0xa0304d0c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_SLC_STATUS"
bitfld.long 0 0.--6. " READS0 "  " "
bitfld.long 0 7.--13. " READS1 "  " "
bitfld.long 0 14.--20. " READS2 "  " "
bitfld.long 0 21.--27. " READS3 "  " "
bitfld.long 0 28. " PAUSED "  "0 ,1 "
bitfld.long 0 29. " BYPASS "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_SLC_EVENT_STATUS"
base ad:0xa0304d10
rgroup 0--3
line.long 0 "EUR_CR_MASTER_SLC_EVENT_STATUS"
bitfld.long 0 0. " INVAL "  "0 ,1 "
bitfld.long 0 1. " FLUSH "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_SLC_EVENT_CLEAR"
base ad:0xa0304d14
wgroup 0--3
line.long 0 "EUR_CR_MASTER_SLC_EVENT_CLEAR"
bitfld.long 0 0. " INVAL "  "0 ,1 "
bitfld.long 0 1. " FLUSH "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_SLC_STATS0"
base ad:0xa0304d18
group 0--3
line.long 0 "EUR_CR_MASTER_SLC_STATS0"
bitfld.long 0 0. " TYPE_HIT "  "0 ,1 "
bitfld.long 0 1. " TYPE_MISS "  "0 ,1 "
bitfld.long 0 2. " TYPE_FLUSH "  "0 ,1 "
bitfld.long 0 3. " SELECT_RNW "  "0 ,1 "
bitfld.long 0 4. " SELECT_NC "  "0 ,1 "
bitfld.long 0 5. " SELECT_DM "  "0 ,1 "
bitfld.long 0 6. " SELECT_TAGID "  "0 ,1 "
bitfld.long 0 7. " SELECT_CORE "  "0 ,1 "
bitfld.long 0 8.--10. " CORE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11.--14. " TAG_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 15.--16. " DM "  "0 ,1 ,2 ,3 "
bitfld.long 0 17. " NC "  "0 ,1 "
bitfld.long 0 18. " RNW "  "0 ,1 "
bitfld.long 0 19. " RESET "  "0 ,1 "
bitfld.long 0 20. " STOP "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_SLC_STATS0_OUTPUT"
base ad:0xa0304d1c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_SLC_STATS0_OUTPUT"
bitfld.long 0 0.--17. " VALUE "  " "
;tree.end

;tree "EUR_CR_MASTER_SLC_STATS1"
base ad:0xa0304d20
group 0--3
line.long 0 "EUR_CR_MASTER_SLC_STATS1"
bitfld.long 0 0. " TYPE_HIT "  "0 ,1 "
bitfld.long 0 1. " TYPE_MISS "  "0 ,1 "
bitfld.long 0 2. " TYPE_FLUSH "  "0 ,1 "
bitfld.long 0 3. " SELECT_RNW "  "0 ,1 "
bitfld.long 0 4. " SELECT_NC "  "0 ,1 "
bitfld.long 0 5. " SELECT_DM "  "0 ,1 "
bitfld.long 0 6. " SELECT_TAGID "  "0 ,1 "
bitfld.long 0 7. " SELECT_CORE "  "0 ,1 "
bitfld.long 0 8.--10. " CORE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 11.--14. " TAG_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 15.--16. " DM "  "0 ,1 ,2 ,3 "
bitfld.long 0 17. " NC "  "0 ,1 "
bitfld.long 0 18. " RNW "  "0 ,1 "
bitfld.long 0 19. " RESET "  "0 ,1 "
bitfld.long 0 20. " STOP "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_SLC_STATS1_OUTPUT"
base ad:0xa0304d24
rgroup 0--3
line.long 0 "EUR_CR_MASTER_SLC_STATS1_OUTPUT"
bitfld.long 0 0.--17. " VALUE "  " "
;tree.end

;tree "EUR_CR_MASTER_SLC_CTRL_INVAL"
base ad:0xa0304d28
group 0--3
line.long 0 "EUR_CR_MASTER_SLC_CTRL_INVAL"
bitfld.long 0 0. " ALL "  "0 ,1 "
bitfld.long 0 1. " DM_VERTEX "  "0 ,1 "
bitfld.long 0 2. " DM_PIXEL "  "0 ,1 "
bitfld.long 0 3. " DM_EVENT "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_SLC_CTRL_FLUSH"
base ad:0xa0304d2c
group 0--3
line.long 0 "EUR_CR_MASTER_SLC_CTRL_FLUSH"
bitfld.long 0 4. " ALL "  "0 ,1 "
bitfld.long 0 5. " DM_VERTEX "  "0 ,1 "
bitfld.long 0 6. " DM_PIXEL "  "0 ,1 "
bitfld.long 0 7. " DM_EVENT "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_EMU_CYCLE_COUNT"
base ad:0xa0304e80
group 0--3
line.long 0 "EUR_CR_MASTER_EMU_CYCLE_COUNT"
bitfld.long 0 0. " RESET "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_EMU_TA_PHASE"
base ad:0xa0304e84
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_TA_PHASE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_3D_PHASE"
base ad:0xa0304e88
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_3D_PHASE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_TA_CYCLE"
base ad:0xa0304e8c
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_TA_CYCLE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_3D_CYCLE"
base ad:0xa0304e90
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_3D_CYCLE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_MEM_READ"
base ad:0xa0304eb4
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_MEM_READ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_TA_OR_3D_CYCLE"
base ad:0xa0304eb8
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_TA_OR_3D_CYCLE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_MEM_WRITE"
base ad:0xa0304ebc
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_MEM_WRITE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_MEM_BYTE_WRITE"
base ad:0xa0304ec0
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_MEM_BYTE_WRITE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_MEM1_READ"
base ad:0xa0304ec4
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_MEM1_READ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_MEM1_WRITE"
base ad:0xa0304ec8
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_MEM1_WRITE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_MEM1_BYTE_WRITE"
base ad:0xa0304ecc
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_MEM1_BYTE_WRITE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_MEM2_READ"
base ad:0xa0304ed0
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_MEM2_READ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_MEM2_WRITE"
base ad:0xa0304ed4
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_MEM2_WRITE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_MEM2_BYTE_WRITE"
base ad:0xa0304ed8
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_MEM2_BYTE_WRITE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_MEM3_READ"
base ad:0xa0304edc
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_MEM3_READ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_MEM3_WRITE"
base ad:0xa0304ee0
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_MEM3_WRITE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_EMU_MEM3_BYTE_WRITE"
base ad:0xa0304ee4
rgroup 0--3
line.long 0 "EUR_CR_MASTER_EMU_MEM3_BYTE_WRITE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT0_START"
base ad:0xa0304ee8
group 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT0_START"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT0_END"
base ad:0xa0304eec
group 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT0_END"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT0"
base ad:0xa0304ef0
group 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT0"
bitfld.long 0 0. " CTRL_RENABLE "  "0 ,1 "
bitfld.long 0 1. " CTRL_WENABLE "  "0 ,1 "
bitfld.long 0 2. " CTRL_TRAPENABLE "  "0 ,1 "
bitfld.long 0 4.--6. " MASK_DM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT1_START"
base ad:0xa0304ef4
group 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT1_START"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT1_END"
base ad:0xa0304ef8
group 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT1_END"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT1"
base ad:0xa0304efc
group 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT1"
bitfld.long 0 0. " CTRL_RENABLE "  "0 ,1 "
bitfld.long 0 1. " CTRL_WENABLE "  "0 ,1 "
bitfld.long 0 2. " CTRL_TRAPENABLE "  "0 ,1 "
bitfld.long 0 4.--6. " MASK_DM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT2_START"
base ad:0xa0304f00
group 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT2_START"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT2_END"
base ad:0xa0304f04
group 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT2_END"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT2"
base ad:0xa0304f08
group 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT2"
bitfld.long 0 0. " CTRL_RENABLE "  "0 ,1 "
bitfld.long 0 1. " CTRL_WENABLE "  "0 ,1 "
bitfld.long 0 2. " CTRL_TRAPENABLE "  "0 ,1 "
bitfld.long 0 4.--6. " MASK_DM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT3_START"
base ad:0xa0304f0c
group 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT3_START"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT3_END"
base ad:0xa0304f10
group 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT3_END"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT3"
base ad:0xa0304f14
group 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT3"
bitfld.long 0 0. " CTRL_RENABLE "  "0 ,1 "
bitfld.long 0 1. " CTRL_WENABLE "  "0 ,1 "
bitfld.long 0 2. " CTRL_TRAPENABLE "  "0 ,1 "
bitfld.long 0 4.--6. " MASK_DM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT_READ"
base ad:0xa0304f18
group 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT_READ"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT_TRAP"
base ad:0xa0304f1c
wgroup 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT_TRAP"
bitfld.long 0 0. " WRNOTIFY "  "0 ,1 "
bitfld.long 0 1. " CONTINUE "  "0 ,1 "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT"
base ad:0xa0304f20
rgroup 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT"
bitfld.long 0 2. " TRAPPED "  "0 ,1 "
bitfld.long 0 3. " UNTRAPPED "  "0 ,1 "
bitfld.long 0 4.--5. " ID "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT_TRAP_INFO0"
base ad:0xa0304f24
rgroup 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT_TRAP_INFO0"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_MASTER_BREAKPOINT_TRAP_INFO1"
base ad:0xa0304f28
rgroup 0--3
line.long 0 "EUR_CR_MASTER_BREAKPOINT_TRAP_INFO1"
bitfld.long 0 0.--1. " DATA_MASTER "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--6. " TAG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 7.--8. " NUMBER "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--13. " SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "EUR_CR_CLKGATECTL"
base ad:0xa0308000
group 0--3
line.long 0 "EUR_CR_CLKGATECTL"
bitfld.long 0 0.--1. " ISP_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " ISP2_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " TSP_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " TE_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " MTE_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " DPM_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " VDM_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PDS_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " IDXFIFO_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " TA_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " BIF_CORE_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 24. " AUTO_MAN_REG "  "0 ,1 "
bitfld.long 0 28. " SYSTEM_CLKG "  "0 ,1 "
;tree.end

;tree "EUR_CR_CLKGATECTL2"
base ad:0xa0308004
group 0--3
line.long 0 "EUR_CR_CLKGATECTL2"
bitfld.long 0 0.--1. " PBE_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " TCU_L2_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " UCACHEL2_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " USE0_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " ITR0_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " TEX0_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " USE1_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " ITR1_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " TEX1_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " DCU_L2_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " DCU1_L0L1_CLKG "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " DCU0_L0L1_CLKG "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_CLKGATESTATUS"
base ad:0xa0308008
group 0--3
line.long 0 "EUR_CR_CLKGATESTATUS"
bitfld.long 0 0. " ISP_CLKS "  "0 ,1 "
bitfld.long 0 1. " ISP2_CLKS "  "0 ,1 "
bitfld.long 0 2. " TSP_CLKS "  "0 ,1 "
bitfld.long 0 3. " TE_CLKS "  "0 ,1 "
bitfld.long 0 4. " MTE_CLKS "  "0 ,1 "
bitfld.long 0 5. " DPM_CLKS "  "0 ,1 "
bitfld.long 0 6. " VDM_CLKS "  "0 ,1 "
bitfld.long 0 7. " PDS_CLKS "  "0 ,1 "
bitfld.long 0 8. " PBE_CLKS "  "0 ,1 "
bitfld.long 0 9. " TCU_L2_CLKS "  "0 ,1 "
bitfld.long 0 10. " UCACHEL2_CLKS "  "0 ,1 "
bitfld.long 0 11. " USE0_CLKS "  "0 ,1 "
bitfld.long 0 12. " ITR0_CLKS "  "0 ,1 "
bitfld.long 0 13. " TEX0_CLKS "  "0 ,1 "
bitfld.long 0 15. " USE1_CLKS "  "0 ,1 "
bitfld.long 0 16. " ITR1_CLKS "  "0 ,1 "
bitfld.long 0 17. " TEX1_CLKS "  "0 ,1 "
bitfld.long 0 19. " IDXFIFO_CLKS "  "0 ,1 "
bitfld.long 0 20. " TA_CLKS "  "0 ,1 "
bitfld.long 0 21. " DCU_L2_CLKS "  "0 ,1 "
bitfld.long 0 22. " DCU0_L0L1_CLKS "  "0 ,1 "
bitfld.long 0 23. " DCU1_L0L1_CLKS "  "0 ,1 "
bitfld.long 0 24. " BIF_CORE_CLKS "  "0 ,1 "
;tree.end

;tree "EUR_CR_CLKGATECTLOVR"
base ad:0xa030800c
group 0--3
line.long 0 "EUR_CR_CLKGATECTLOVR"
bitfld.long 0 0.--1. " ISP_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " ISP2_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " TSP_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " TE_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " MTE_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " DPM_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " VDM_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " PDS_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " IDXFIFO_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " TA_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " BIF_CORE_CLKO "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_CLKGATECTLOVR2"
base ad:0xa0308010
group 0--3
line.long 0 "EUR_CR_CLKGATECTLOVR2"
bitfld.long 0 0.--1. " PBE_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " TCU_L2_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " UCACHEL2_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " USE0_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " ITR0_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " TEX0_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " USE1_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " ITR1_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " TEX1_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " DCU_L2_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " DCU0_L0L1_CLKO "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " DCU1_L0L1_CLKO "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_POWER"
base ad:0xa030801c
group 0--3
line.long 0 "EUR_CR_POWER"
bitfld.long 0 0. " PIPE_DISABLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_CORE_ID"
base ad:0xa0308020
rgroup 0--3
line.long 0 "EUR_CR_CORE_ID"
bitfld.long 0 0. " CONFIG_MULTI "  "0 ,1 "
bitfld.long 0 1. " CONFIG_BASE "  "0 ,1 "
bitfld.long 0 2.--7. " CONFIG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8.--11. " CONFIG_CORES "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " CONFIG_SLC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
hexfld.word 2 " ID "
;tree.end

;tree "EUR_CR_CORE_REVISION"
base ad:0xa0308024
rgroup 0--3
line.long 0 "EUR_CR_CORE_REVISION"
hexfld.byte 0 " MAINTENANCE "
hexfld.byte 1 " MINOR "
hexfld.byte 2 " MAJOR "
hexfld.byte 3 " DESIGNER "
;tree.end

;tree "EUR_CR_DESIGNER_REV_FIELD1"
base ad:0xa0308028
rgroup 0--3
line.long 0 "EUR_CR_DESIGNER_REV_FIELD1"
hexfld.long 0 " DESIGNER_REV_FIELD1 "
;tree.end

;tree "EUR_CR_DESIGNER_REV_FIELD2"
base ad:0xa030802c
rgroup 0--3
line.long 0 "EUR_CR_DESIGNER_REV_FIELD2"
hexfld.long 0 " DESIGNER_REV_FIELD2 "
;tree.end

;tree "EUR_CR_PERF"
base ad:0xa0308040
group 0--3
line.long 0 "EUR_CR_PERF"
bitfld.long 0 0. " COUNTER_0_CLR "  "0 ,1 "
bitfld.long 0 1. " COUNTER_1_CLR "  "0 ,1 "
bitfld.long 0 2. " COUNTER_2_CLR "  "0 ,1 "
bitfld.long 0 3. " COUNTER_3_CLR "  "0 ,1 "
bitfld.long 0 4. " COUNTER_4_CLR "  "0 ,1 "
bitfld.long 0 5. " COUNTER_5_CLR "  "0 ,1 "
bitfld.long 0 6. " COUNTER_6_CLR "  "0 ,1 "
bitfld.long 0 7. " COUNTER_7_CLR "  "0 ,1 "
bitfld.long 0 8. " COUNTER_SUM_MUX_0 "  "0 ,1 "
bitfld.long 0 9. " COUNTER_SUM_MUX_1 "  "0 ,1 "
bitfld.long 0 10. " COUNTER_SUM_MUX_2 "  "0 ,1 "
bitfld.long 0 11. " COUNTER_SUM_MUX_3 "  "0 ,1 "
bitfld.long 0 12. " COUNTER_SUM_MUX_4 "  "0 ,1 "
bitfld.long 0 13. " COUNTER_SUM_MUX_5 "  "0 ,1 "
bitfld.long 0 14. " COUNTER_SUM_MUX_6 "  "0 ,1 "
bitfld.long 0 15. " COUNTER_SUM_MUX_7 "  "0 ,1 "
;tree.end

;tree "EUR_CR_PERF_COUNTER0"
base ad:0xa0308044
group 0--3
line.long 0 "EUR_CR_PERF_COUNTER0"
;tree.end

;tree "EUR_CR_PERF_COUNTER1"
base ad:0xa0308048
group 0--3
line.long 0 "EUR_CR_PERF_COUNTER1"
hexfld.long 0 " 1 "
;tree.end

;tree "EUR_CR_PERF_COUNTER2"
base ad:0xa030804c
group 0--3
line.long 0 "EUR_CR_PERF_COUNTER2"
hexfld.long 0 " 2 "
;tree.end

;tree "EUR_CR_PERF_COUNTER3"
base ad:0xa0308050
group 0--3
line.long 0 "EUR_CR_PERF_COUNTER3"
hexfld.long 0 " 3 "
;tree.end

;tree "EUR_CR_PERF_COUNTER4"
base ad:0xa0308054
group 0--3
line.long 0 "EUR_CR_PERF_COUNTER4"
hexfld.long 0 " 4 "
;tree.end

;tree "EUR_CR_PERF_COUNTER5"
base ad:0xa0308058
group 0--3
line.long 0 "EUR_CR_PERF_COUNTER5"
hexfld.long 0 " 5 "
;tree.end

;tree "EUR_CR_PERF_COUNTER6"
base ad:0xa030805c
group 0--3
line.long 0 "EUR_CR_PERF_COUNTER6"
hexfld.long 0 " 6 "
;tree.end

;tree "EUR_CR_PERF_COUNTER7"
base ad:0xa0308060
group 0--3
line.long 0 "EUR_CR_PERF_COUNTER7"
hexfld.long 0 " 7 "
;tree.end

;tree "EUR_CR_DEBUG_REG0"
base ad:0xa0308070
rgroup 0--3
line.long 0 "EUR_CR_DEBUG_REG0"
;tree.end

;tree "EUR_CR_DEBUG_REG1"
base ad:0xa0308074
rgroup 0--3
line.long 0 "EUR_CR_DEBUG_REG1"
;tree.end

;tree "EUR_CR_PERF_DEBUG_CTRL"
base ad:0xa0308078
group 0--3
line.long 0 "EUR_CR_PERF_DEBUG_CTRL"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_SOFT_RESET"
base ad:0xa0308080
group 0--3
line.long 0 "EUR_CR_SOFT_RESET"
bitfld.long 0 0. " BIF_RESET "  "0 ,1 "
bitfld.long 0 1. " VDM_RESET "  "0 ,1 "
bitfld.long 0 2. " DPM_RESET "  "0 ,1 "
bitfld.long 0 3. " TE_RESET "  "0 ,1 "
bitfld.long 0 4. " MTE_RESET "  "0 ,1 "
bitfld.long 0 5. " ISP_RESET "  "0 ,1 "
bitfld.long 0 6. " ISP2_RESET "  "0 ,1 "
bitfld.long 0 7. " TSP_RESET "  "0 ,1 "
bitfld.long 0 8. " PDS_RESET "  "0 ,1 "
bitfld.long 0 9. " PBE_RESET "  "0 ,1 "
bitfld.long 0 10. " TCU_L2_RESET "  "0 ,1 "
bitfld.long 0 11. " UCACHEL2_RESET "  "0 ,1 "
bitfld.long 0 13. " ITR_RESET "  "0 ,1 "
bitfld.long 0 14. " TEX_RESET "  "0 ,1 "
bitfld.long 0 15. " USE_RESET "  "0 ,1 "
bitfld.long 0 16. " IDXFIFO_RESET "  "0 ,1 "
bitfld.long 0 17. " TA_RESET "  "0 ,1 "
bitfld.long 0 18. " DCU_L2_RESET "  "0 ,1 "
bitfld.long 0 19. " DCU_L0L1_RESET "  "0 ,1 "
;tree.end

;tree "EUR_CR_PERF0"
base ad:0xa0308090
group 0--3
line.long 0 "EUR_CR_PERF0"
bitfld.long 0 0.--6. " GROUP_SELECT_A0 "  " "
bitfld.long 0 8.--12. " COUNTER_SELECT_A0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--22. " GROUP_SELECT_A1 "  " "
bitfld.long 0 24.--28. " COUNTER_SELECT_A1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "EUR_CR_PERF1"
base ad:0xa0308094
group 0--3
line.long 0 "EUR_CR_PERF1"
bitfld.long 0 0.--6. " GROUP_SELECT_A2 "  " "
bitfld.long 0 8.--12. " COUNTER_SELECT_A2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--22. " GROUP_SELECT_A3 "  " "
bitfld.long 0 24.--28. " COUNTER_SELECT_A3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "EUR_CR_PERF2"
base ad:0xa0308098
group 0--3
line.long 0 "EUR_CR_PERF2"
bitfld.long 0 0.--6. " GROUP_SELECT_B0 "  " "
bitfld.long 0 8.--12. " COUNTER_SELECT_B0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--22. " GROUP_SELECT_B1 "  " "
bitfld.long 0 24.--28. " COUNTER_SELECT_B1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "EUR_CR_PERF3"
base ad:0xa030809c
group 0--3
line.long 0 "EUR_CR_PERF3"
bitfld.long 0 0.--6. " GROUP_SELECT_B2 "  " "
bitfld.long 0 8.--12. " COUNTER_SELECT_B2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 16.--22. " GROUP_SELECT_B3 "  " "
bitfld.long 0 24.--28. " COUNTER_SELECT_B3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "EUR_CR_TRIGGER"
base ad:0xa0308100
group 0--3
line.long 0 "EUR_CR_TRIGGER"
bitfld.long 0 0.--5. " COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "EUR_CR_EVENT_HOST_ENABLE2"
base ad:0xa0308110
group 0--3
line.long 0 "EUR_CR_EVENT_HOST_ENABLE2"
bitfld.long 0 0. " DPM_TA_FREE_LOAD "  "0 ,1 "
bitfld.long 0 1. " DPM_3D_FREE_LOAD "  "0 ,1 "
bitfld.long 0 2. " TRIG_DL "  "0 ,1 "
bitfld.long 0 3. " TRIG_3D "  "0 ,1 "
bitfld.long 0 4. " TRIG_TA "  "0 ,1 "
bitfld.long 0 5. " TE_RGNHDR_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 6. " MTE_STATE_FLUSHED "  "0 ,1 "
bitfld.long 0 7. " DCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 8. " ISP2_ZLS_CSW_FINISHED "  "0 ,1 "
bitfld.long 0 9. " MTE_CONTEXT_DRAINED "  "0 ,1 "
bitfld.long 0 10. " DATA_BREAKPOINT_TRAPPED "  "0 ,1 "
bitfld.long 0 11. " DATA_BREAKPOINT_UNTRAPPED "  "0 ,1 "
;tree.end

;tree "EUR_CR_EVENT_HOST_CLEAR2"
base ad:0xa0308114
wgroup 0--3
line.long 0 "EUR_CR_EVENT_HOST_CLEAR2"
bitfld.long 0 0. " DPM_TA_FREE_LOAD "  "0 ,1 "
bitfld.long 0 1. " DPM_3D_FREE_LOAD "  "0 ,1 "
bitfld.long 0 2. " TRIG_DL "  "0 ,1 "
bitfld.long 0 3. " TRIG_3D "  "0 ,1 "
bitfld.long 0 4. " TRIG_TA "  "0 ,1 "
bitfld.long 0 5. " TE_RGNHDR_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 6. " MTE_STATE_FLUSHED "  "0 ,1 "
bitfld.long 0 7. " DCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 8. " ISP2_ZLS_CSW_FINISHED "  "0 ,1 "
bitfld.long 0 9. " MTE_CONTEXT_DRAINED "  "0 ,1 "
bitfld.long 0 10. " DATA_BREAKPOINT_TRAPPED "  "0 ,1 "
bitfld.long 0 11. " DATA_BREAKPOINT_UNTRAPPED "  "0 ,1 "
;tree.end

;tree "EUR_CR_EVENT_STATUS2"
base ad:0xa0308118
group 0--3
line.long 0 "EUR_CR_EVENT_STATUS2"
bitfld.long 0 0. " DPM_TA_FREE_LOAD "  "0 ,1 "
bitfld.long 0 1. " DPM_3D_FREE_LOAD "  "0 ,1 "
bitfld.long 0 2. " TRIG_DL "  "0 ,1 "
bitfld.long 0 3. " TRIG_3D "  "0 ,1 "
bitfld.long 0 4. " TRIG_TA "  "0 ,1 "
bitfld.long 0 5. " TE_RGNHDR_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 6. " MTE_STATE_FLUSHED "  "0 ,1 "
bitfld.long 0 7. " DCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 8. " ISP2_ZLS_CSW_FINISHED "  "0 ,1 "
bitfld.long 0 9. " MTE_CONTEXT_DRAINED "  "0 ,1 "
bitfld.long 0 10. " DATA_BREAKPOINT_TRAPPED "  "0 ,1 "
bitfld.long 0 11. " DATA_BREAKPOINT_UNTRAPPED "  "0 ,1 "
;tree.end

;tree "EUR_CR_EVENT_STATUS"
base ad:0xa030812c
group 0--3
line.long 0 "EUR_CR_EVENT_STATUS"
bitfld.long 0 0. " DPM_3D_MEM_FREE "  "0 ,1 "
bitfld.long 0 1. " DPM_OUT_OF_MEMORY_MT "  "0 ,1 "
bitfld.long 0 2. " DPM_OUT_OF_MEMORY_GBL "  "0 ,1 "
bitfld.long 0 3. " DPM_REACHED_MEM_THRESH "  "0 ,1 "
bitfld.long 0 4. " DPM_STATE_STORE "  "0 ,1 "
bitfld.long 0 5. " DPM_STATE_LOAD "  "0 ,1 "
bitfld.long 0 6. " DPM_STATE_CLEAR "  "0 ,1 "
bitfld.long 0 7. " DPM_CONTROL_STORE "  "0 ,1 "
bitfld.long 0 8. " DPM_CONTROL_LOAD "  "0 ,1 "
bitfld.long 0 9. " DPM_CONTROL_CLEAR "  "0 ,1 "
bitfld.long 0 10. " TPC_FLUSH "  "0 ,1 "
bitfld.long 0 11. " TPC_CLEAR "  "0 ,1 "
bitfld.long 0 12. " TA_TERMINATE "  "0 ,1 "
bitfld.long 0 13. " TA_FINISHED "  "0 ,1 "
bitfld.long 0 14. " SW_EVENT "  "0 ,1 "
bitfld.long 0 15. " BREAKPOINT "  "0 ,1 "
bitfld.long 0 18. " PIXELBE_END_RENDER "  "0 ,1 "
bitfld.long 0 19. " OTPM_FLUSHED "  "0 ,1 "
bitfld.long 0 20. " OTPM_INV "  "0 ,1 "
bitfld.long 0 21. " OTPM_LOADED "  "0 ,1 "
bitfld.long 0 22. " DPM_INITEND "  "0 ,1 "
bitfld.long 0 23. " ISP_END_TILE "  "0 ,1 "
bitfld.long 0 24. " DPM_TA_MEM_FREE "  "0 ,1 "
bitfld.long 0 25. " DPM_OUT_OF_MEMORY_ZLS "  "0 ,1 "
bitfld.long 0 26. " TCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 28. " TA_DPM_FAULT "  "0 ,1 "
bitfld.long 0 29. " TIMER "  "0 ,1 "
bitfld.long 0 31. " MASTER_INTERRUPT "  "0 ,1 "
;tree.end

;tree "EUR_CR_EVENT_HOST_ENABLE"
base ad:0xa0308130
group 0--3
line.long 0 "EUR_CR_EVENT_HOST_ENABLE"
bitfld.long 0 0. " DPM_3D_MEM_FREE "  "0 ,1 "
bitfld.long 0 1. " DPM_OUT_OF_MEMORY_MT "  "0 ,1 "
bitfld.long 0 2. " DPM_OUT_OF_MEMORY_GBL "  "0 ,1 "
bitfld.long 0 3. " DPM_REACHED_MEM_THRESH "  "0 ,1 "
bitfld.long 0 4. " DPM_STATE_STORE "  "0 ,1 "
bitfld.long 0 5. " DPM_STATE_LOAD "  "0 ,1 "
bitfld.long 0 6. " DPM_STATE_CLEAR "  "0 ,1 "
bitfld.long 0 7. " DPM_CONTROL_STORE "  "0 ,1 "
bitfld.long 0 8. " DPM_CONTROL_LOAD "  "0 ,1 "
bitfld.long 0 9. " DPM_CONTROL_CLEAR "  "0 ,1 "
bitfld.long 0 10. " TPC_FLUSH "  "0 ,1 "
bitfld.long 0 11. " TPC_CLEAR "  "0 ,1 "
bitfld.long 0 12. " TA_TERMINATE "  "0 ,1 "
bitfld.long 0 13. " TA_FINISHED "  "0 ,1 "
bitfld.long 0 14. " SW_EVENT "  "0 ,1 "
bitfld.long 0 15. " BREAKPOINT "  "0 ,1 "
bitfld.long 0 18. " PIXELBE_END_RENDER "  "0 ,1 "
bitfld.long 0 19. " OTPM_FLUSHED "  "0 ,1 "
bitfld.long 0 20. " OTPM_INV "  "0 ,1 "
bitfld.long 0 21. " OTPM_LOADED "  "0 ,1 "
bitfld.long 0 22. " DPM_INITEND "  "0 ,1 "
bitfld.long 0 23. " ISP_END_TILE "  "0 ,1 "
bitfld.long 0 24. " DPM_TA_MEM_ "  "0 ,1 "
bitfld.long 0 25. " DPM_OUT_OF_MEMORY_ZLS "  "0 ,1 "
bitfld.long 0 26. " TCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 28. " TA_DPM_FAULT "  "0 ,1 "
bitfld.long 0 29. " TIMER "  "0 ,1 "
bitfld.long 0 31. " MASTER_INTERRUPT "  "0 ,1 "
;tree.end

;tree "EUR_CR_EVENT_HOST_CLEAR"
base ad:0xa0308134
wgroup 0--3
line.long 0 "EUR_CR_EVENT_HOST_CLEAR"
bitfld.long 0 0. " DPM_3D_MEM_FREE "  "0 ,1 "
bitfld.long 0 1. " DPM_OUT_OF_MEMORY_MT "  "0 ,1 "
bitfld.long 0 2. " DPM_OUT_OF_MEMORY_GBL "  "0 ,1 "
bitfld.long 0 3. " DPM_REACHED_MEM_THRESH "  "0 ,1 "
bitfld.long 0 4. " DPM_STATE_STORE "  "0 ,1 "
bitfld.long 0 5. " DPM_STATE_LOAD "  "0 ,1 "
bitfld.long 0 6. " DPM_STATE_CLEAR "  "0 ,1 "
bitfld.long 0 7. " DPM_CONTROL_STORE "  "0 ,1 "
bitfld.long 0 8. " DPM_CONTROL_LOAD "  "0 ,1 "
bitfld.long 0 9. " DPM_CONTROL_CLEAR "  "0 ,1 "
bitfld.long 0 10. " TPC_FLUSH "  "0 ,1 "
bitfld.long 0 11. " TPC_CLEAR "  "0 ,1 "
bitfld.long 0 12. " TA_TERMINATE "  "0 ,1 "
bitfld.long 0 13. " TA_FINISHED "  "0 ,1 "
bitfld.long 0 14. " SW_EVENT "  "0 ,1 "
bitfld.long 0 15. " BREAKPOINT "  "0 ,1 "
bitfld.long 0 18. " PIXELBE_END_RENDER "  "0 ,1 "
bitfld.long 0 19. " OTPM_FLUSHED "  "0 ,1 "
bitfld.long 0 20. " OTPM_INV "  "0 ,1 "
bitfld.long 0 21. " OTPM_LOADED "  "0 ,1 "
bitfld.long 0 22. " DPM_INITEND "  "0 ,1 "
bitfld.long 0 23. " ISP_END_TILE "  "0 ,1 "
bitfld.long 0 24. " DPM_TA_MEM_FREE "  "0 ,1 "
bitfld.long 0 25. " DPM_OUT_OF_MEMORY_ZLS "  "0 ,1 "
bitfld.long 0 26. " TCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 28. " TA_DPM_FAULT "  "0 ,1 "
bitfld.long 0 29. " TIMER "  "0 ,1 "
bitfld.long 0 31. " MASTER_INTERRUPT "  "0 ,1 "
;tree.end

;tree "EUR_CR_PDS_CACHE_STATUS"
base ad:0xa0308138
group 0--3
line.long 0 "EUR_CR_PDS_CACHE_STATUS"
bitfld.long 0 0. " CSC_INV "  "0 ,1 "
bitfld.long 0 1. " DSC_INV0 "  "0 ,1 "
bitfld.long 0 2. " DSC_INV1 "  "0 ,1 "
bitfld.long 0 4. " DSC_INV3 "  "0 ,1 "
;tree.end

;tree "EUR_CR_PDS_CACHE_HOST_ENABLE"
base ad:0xa030813c
group 0--3
line.long 0 "EUR_CR_PDS_CACHE_HOST_ENABLE"
bitfld.long 0 0. " CSC_INV "  "0 ,1 "
bitfld.long 0 1. " DSC_INV0 "  "0 ,1 "
bitfld.long 0 2. " DSC_INV1 "  "0 ,1 "
bitfld.long 0 4. " DSC_INV3 "  "0 ,1 "
;tree.end

;tree "EUR_CR_PDS_CACHE_HOST_CLEAR"
base ad:0xa0308140
wgroup 0--3
line.long 0 "EUR_CR_PDS_CACHE_HOST_CLEAR"
bitfld.long 0 0. " CSC_INV "  "0 ,1 "
bitfld.long 0 1. " DSC_INV0 "  "0 ,1 "
bitfld.long 0 2. " DSC_INV1 "  "0 ,1 "
bitfld.long 0 4. " DSC_INV3 "  "0 ,1 "
;tree.end

;tree "EUR_CR_TIMER"
base ad:0xa0308144
group 0--3
line.long 0 "EUR_CR_TIMER"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_DOUBLE_PIXEL_PARTITIONS"
base ad:0xa0308148
group 0--3
line.long 0 "EUR_CR_DOUBLE_PIXEL_PARTITIONS"
bitfld.long 0 0. " VALUE "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_START"
base ad:0xa0308200
wgroup 0--3
line.long 0 "EUR_CR_VDM_START"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_TE_RGNHDR_INIT"
base ad:0xa0308380
wgroup 0--3
line.long 0 "EUR_CR_TE_RGNHDR_INIT"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_TE_AA"
base ad:0xa0308204
group 0--3
line.long 0 "EUR_CR_TE_AA"
bitfld.long 0 30. " Y "  "0 ,1 "
bitfld.long 0 31. " X "  "0 ,1 "
;tree.end

;tree "EUR_CR_TE_MTILE1"
base ad:0xa0308208
group 0--3
line.long 0 "EUR_CR_TE_MTILE1"
hexfld.byte 0 " X3 "
bitfld.long 0 12.--19. " X2 "  " "
bitfld.long 0 22.--29. " X1 "  " "
bitfld.long 0 31. " NUMBER "  "0 ,1 "
;tree.end

;tree "EUR_CR_TE_MTILE2"
base ad:0xa030820c
group 0--3
line.long 0 "EUR_CR_TE_MTILE2"
hexfld.byte 0 " Y3 "
bitfld.long 0 12.--19. " Y2 "  " "
bitfld.long 0 22.--29. " Y1 "  " "
;tree.end

;tree "EUR_CR_TE_SCREEN"
base ad:0xa0308210
group 0--3
line.long 0 "EUR_CR_TE_SCREEN"
hexfld.byte 0 " XMAX "
bitfld.long 0 12.--19. " YMAX "  " "
;tree.end

;tree "EUR_CR_TE_MTILE"
base ad:0xa0308214
group 0--3
line.long 0 "EUR_CR_TE_MTILE"
bitfld.long 0 0.--17. " STRIDE "  " "
;tree.end

;tree "EUR_CR_TE_PSG"
base ad:0xa0308218
group 0--3
line.long 0 "EUR_CR_TE_PSG"
bitfld.long 0 18. " FORCENEWSTATE "  "0 ,1 "
bitfld.long 0 19. " PADZEROS "  "0 ,1 "
bitfld.long 0 20. " ZSTOREENABLE "  "0 ,1 "
bitfld.long 0 21. " ZLOADENABLE "  "0 ,1 "
bitfld.long 0 22. " COMPLETEONTERMINATE "  "0 ,1 "
bitfld.long 0 23. " ZONLYRENDER "  "0 ,1 "
bitfld.long 0 24. " ENABLE_CONTEXT_STATE_RESTORE "  "0 ,1 "
bitfld.long 0 25. " EXTERNALZBUFFER "  "0 ,1 "
;tree.end

;tree "EUR_CR_TE_PSGREGION_BASE"
base ad:0xa030821c
group 0--3
line.long 0 "EUR_CR_TE_PSGREGION_BASE"
bitfld.long 0 6.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_TE_TPC_BASE"
base ad:0xa0308220
group 0--3
line.long 0 "EUR_CR_TE_TPC_BASE"
bitfld.long 0 6.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_TE_TPCCONTROL"
base ad:0xa0308224
wgroup 0--3
line.long 0 "EUR_CR_TE_TPCCONTROL"
bitfld.long 0 30. " FLUSH "  "0 ,1 "
bitfld.long 0 31. " CLEAR "  "0 ,1 "
;tree.end

;tree "EUR_CR_TE_RGNBBOX_X"
base ad:0xa0308228
rgroup 0--3
line.long 0 "EUR_CR_TE_RGNBBOX_X"
bitfld.long 0 0.--8. " MIN "  " "
bitfld.long 0 16.--24. " MAX "  " "
;tree.end

;tree "EUR_CR_TE_RGNBBOX_Y"
base ad:0xa030822c
rgroup 0--3
line.long 0 "EUR_CR_TE_RGNBBOX_Y"
bitfld.long 0 0.--8. " MIN "  " "
bitfld.long 0 16.--24. " MAX "  " "
;tree.end

;tree "EUR_CR_MTE_OTPM_CSM_FLUSH_BASE"
base ad:0xa0308230
group 0--3
line.long 0 "EUR_CR_MTE_OTPM_CSM_FLUSH_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MTE_OTPM_CSM_LOAD_BASE"
base ad:0xa0308234
group 0--3
line.long 0 "EUR_CR_MTE_OTPM_CSM_LOAD_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_VDM_CTRL_STREAM_BASE"
base ad:0xa0308238
group 0--3
line.long 0 "EUR_CR_VDM_CTRL_STREAM_BASE"
bitfld.long 0 2.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_VDM_BATCH_NUM"
base ad:0xa0308320
wgroup 0--3
line.long 0 "EUR_CR_VDM_BATCH_NUM"
bitfld.long 0 0. " LOAD "  "0 ,1 "
bitfld.long 0 1.--13. " VALUE "  " "
;tree.end

;tree "EUR_CR_VDM_BATCH_NUM_STATUS"
base ad:0xa0308324
rgroup 0--3
line.long 0 "EUR_CR_VDM_BATCH_NUM_STATUS"
bitfld.long 0 0.--12. " VALUE "  " "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_STORE_GENERIC_WORD0"
base ad:0xa0308328
group 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_STORE_GENERIC_WORD0"
bitfld.long 0 0.--23. " DATA "  " "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_STORE_GENERIC_WORD1"
base ad:0xa030832c
group 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_STORE_GENERIC_WORD1"
bitfld.long 0 0.--23. " DATA "  " "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_STORE_START"
base ad:0xa0308330
wgroup 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_STORE_START"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_STORE_STREAM"
base ad:0xa0308334
rgroup 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_STORE_STREAM"
bitfld.long 0 2.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_STORE_INDEX_ADDR"
base ad:0xa0308338
rgroup 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_STORE_INDEX_ADDR"
bitfld.long 0 0.--21. " ADDR "  " "
bitfld.long 0 22. " WINDING_ORDER "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_STORE_WRAP_INDEX"
base ad:0xa030834c
rgroup 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_STORE_WRAP_INDEX"
bitfld.long 0 0.--21. " COUNT "  " "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_STORE_WRAPPED"
base ad:0xa0308350
rgroup 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_STORE_WRAPPED"
bitfld.long 0 0.--21. " COUNT "  " "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_STORE_FAN_INDEX"
base ad:0xa0308354
group 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_STORE_FAN_INDEX"
bitfld.long 0 0.--23. " INDEX "  " "
bitfld.long 0 24. " ENABLE "  "0 ,1 "
bitfld.long 0 25. " WINDING "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_STORE_WRAP_RESUME"
base ad:0xa0308358
group 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_STORE_WRAP_RESUME"
bitfld.long 0 0.--21. " RESUME "  " "
bitfld.long 0 22. " ENABLE "  "0 ,1 "
bitfld.long 0 23. " PLUSONE "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_STORE_STATUS"
base ad:0xa030833c
rgroup 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_STORE_STATUS"
bitfld.long 0 0. " COMPLETE "  "0 ,1 "
bitfld.long 0 4. " PROCESS "  "0 ,1 "
bitfld.long 0 8. " NA "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_STORE_STATE0"
base ad:0xa0308340
group 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_STORE_STATE0"
bitfld.long 0 0.--27. " TAPDSSTATE_BASEADDR "  " "
bitfld.long 0 28. " TAPDSSTATE_COMPLEX "  "0 ,1 "
bitfld.long 0 29. " TAPDSSTATE_TERMINATE "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_STORE_STATE1"
base ad:0xa0308344
group 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_STORE_STATE1"
hexfld.byte 0 " TAPDSSTATE_USEATTRIBUTESIZE "
bitfld.long 0 8. " TAPDSSTATE_SECONDARY "  "0 ,1 "
bitfld.long 0 9.--11. " TAPDSSTATE_PARTITIONS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 12. " TAPDSSTATE_PARTIAL "  "0 ,1 "
bitfld.long 0 13.--15. " TAPDSSTATE_USEPIPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 17. " TAPDSSTATE_MTE_EMIT "  "0 ,1 "
bitfld.long 0 18. " TAPDSSTATE_ "  "0 ,1 "
bitfld.long 0 19.--20. " TAPDSSTATE_GENERIC_PRESENT "  "0 ,1 ,2 ,3 "
bitfld.long 0 25. " TAPDSSTATE_SD "  "0 ,1 "
bitfld.long 0 27.--31. " TAPDSSTATE_DATASIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "EUR_CR_VDM_WAIT_FOR_KICK"
base ad:0xa0308348
rgroup 0--3
line.long 0 "EUR_CR_VDM_WAIT_FOR_KICK"
bitfld.long 0 0. " STATUS "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_MTE"
base ad:0xa0308378
rgroup 0--3
line.long 0 "EUR_CR_VDM_MTE"
hexfld.long 0 " SIG "
;tree.end

;tree "EUR_CR_VDM_FENCE"
base ad:0xa0308390
wgroup 0--3
line.long 0 "EUR_CR_VDM_FENCE"
bitfld.long 0 0. " INCREMENT "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_FENCE_STATUS"
base ad:0xa0308394
rgroup 0--3
line.long 0 "EUR_CR_VDM_FENCE_STATUS"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_MTE_CTRL"
base ad:0xa030823c
group 0--3
line.long 0 "EUR_CR_MTE_CTRL"
bitfld.long 0 0.--4. " GLOBALMACROTILETHRESH "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " WCLAMPEN "  "0 ,1 "
bitfld.long 0 6. " PSOCULL_DISABLE "  "0 ,1 "
bitfld.long 0 7. " OPENGL "  "0 ,1 "
bitfld.long 0 8. " NUM_PARTITIONS "  "0 ,1 "
bitfld.long 0 9. " TE_PAD128 "  "0 ,1 "
bitfld.long 0 10. " TE_PAD256 "  "0 ,1 "
;tree.end

;tree "EUR_CR_MTE_WCOMPARE"
base ad:0xa0308240
group 0--3
line.long 0 "EUR_CR_MTE_WCOMPARE"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MTE_WCLAMP"
base ad:0xa0308244
group 0--3
line.long 0 "EUR_CR_MTE_WCLAMP"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MTE_SCREEN"
base ad:0xa0308248
group 0--3
line.long 0 "EUR_CR_MTE_SCREEN"
bitfld.long 0 0.--11. " PIXXMAX "  " "
bitfld.long 0 12.--23. " PIXYMAX "  " "
;tree.end

;tree "EUR_CR_MTE_OTPM_OP"
base ad:0xa030824c
wgroup 0--3
line.long 0 "EUR_CR_MTE_OTPM_OP"
bitfld.long 0 0. " CSM_INV "  "0 ,1 "
bitfld.long 0 1. " CSM_LOAD "  "0 ,1 "
bitfld.long 0 2. " CSM_FLUSH "  "0 ,1 "
;tree.end

;tree "EUR_CR_MTE_MULTISAMPLECTL"
base ad:0xa0308250
group 0--3
line.long 0 "EUR_CR_MTE_MULTISAMPLECTL"
bitfld.long 0 0.--3. " MSAA_X0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " MSAA_Y0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " MSAA_X1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " MSAA_Y1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " MSAA_X2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " MSAA_Y2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MSAA_X3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " MSAA_Y3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_TA_MEM_TE_PAD"
base ad:0xa0308254
group 0--3
line.long 0 "EUR_CR_TA_MEM_TE_PAD"
hexfld.long 0 " DWORD "
;tree.end

;tree "EUR_CR_MTE_FIRST_PAGE"
base ad:0xa0308258
rgroup 0--3
line.long 0 "EUR_CR_MTE_FIRST_PAGE"
hexfld.word 0 " DATA "
bitfld.long 0 16.--20. " MACROTILE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 31. " VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MTE_SECOND_PAGE"
base ad:0xa030825c
rgroup 0--3
line.long 0 "EUR_CR_MTE_SECOND_PAGE"
hexfld.word 0 " DATA "
bitfld.long 0 31. " VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_MTE_ABORT"
base ad:0xa0308260
rgroup 0--3
line.long 0 "EUR_CR_MTE_ABORT"
bitfld.long 0 0. " SETTLED "  "0 ,1 "
;tree.end

;tree "EUR_CR_MTE_SIG1"
base ad:0xa030826c
rgroup 0--3
line.long 0 "EUR_CR_MTE_SIG1"
hexfld.long 0 " TE_SIGNATURE "
;tree.end

;tree "EUR_CR_MTE_SIG2"
base ad:0xa0308270
rgroup 0--3
line.long 0 "EUR_CR_MTE_SIG2"
hexfld.long 0 " MEM_SIGNATURE "
;tree.end

;tree "EUR_CR_TE_STATE"
base ad:0xa0308274
group 0--3
line.long 0 "EUR_CR_TE_STATE"
hexfld.word 0 " ABORTED_MTILE "
bitfld.long 0 16.--20. " ISP_STATE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_STORE_SNAPSHOT"
base ad:0xa0308280
group 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_STORE_SNAPSHOT"
bitfld.long 0 0.--27. " BASE_ADDR "  " "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_LOAD_START"
base ad:0xa0308284
wgroup 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_LOAD_START"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_LOAD_STATUS"
base ad:0xa0308288
rgroup 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_LOAD_STATUS"
bitfld.long 0 0. " COMPLETE "  "0 ,1 "
bitfld.long 0 1. " PROCESSING "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_CONTEXT_LOAD_STATUS_CLEAR"
base ad:0xa030828c
wgroup 0--3
line.long 0 "EUR_CR_VDM_CONTEXT_LOAD_STATUS_CLEAR"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_TASK_KICK"
base ad:0xa0308290
wgroup 0--3
line.long 0 "EUR_CR_VDM_TASK_KICK"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_TASK_KICK_STATUS"
base ad:0xa0308294
rgroup 0--3
line.long 0 "EUR_CR_VDM_TASK_KICK_STATUS"
bitfld.long 0 0. " COMPLETE "  "0 ,1 "
bitfld.long 0 1. " PROCESSING "  "0 ,1 "
;tree.end

;tree "EUR_CR_VDM_TASK_KICK_STATUS_CLEAR"
base ad:0xa0308298
wgroup 0--3
line.long 0 "EUR_CR_VDM_TASK_KICK_STATUS_CLEAR"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_TE_SAFE"
base ad:0xa030829c
group 0--3
line.long 0 "EUR_CR_TE_SAFE"
bitfld.long 0 0. " TO_DRAIN "  "0 ,1 "
;tree.end

;tree "EUR_CR_CLIP_SIG1"
base ad:0xa0308304
rgroup 0--3
line.long 0 "EUR_CR_CLIP_SIG1"
hexfld.long 0 " CLIP_SIGNATURE "
;tree.end

;tree "EUR_CR_PBE_NONPIXEL_CHECKSUM"
base ad:0xa030830c
rgroup 0--3
line.long 0 "EUR_CR_PBE_NONPIXEL_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_TA_CLK_GATE"
base ad:0xa0308310
group 0--3
line.long 0 "EUR_CR_TA_CLK_GATE"
bitfld.long 0 0. " START_TO_END "  "0 ,1 "
;tree.end

;tree "EUR_CR_MTE_STATE"
base ad:0xa030837c
wgroup 0--3
line.long 0 "EUR_CR_MTE_STATE"
bitfld.long 0 0. " FLUSH "  "0 ,1 "
;tree.end

;tree "EUR_CR_MTE_STATE_FLUSH_BASE"
base ad:0xa0308384
group 0--3
line.long 0 "EUR_CR_MTE_STATE_FLUSH_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_MTE_FIXED_POINT"
base ad:0xa0308388
group 0--3
line.long 0 "EUR_CR_MTE_FIXED_POINT"
bitfld.long 0 0. " FORMAT "  "0 ,1 "
;tree.end

;tree "EUR_CR_TA_CONTEXT"
base ad:0xa030838c
wgroup 0--3
line.long 0 "EUR_CR_TA_CONTEXT"
bitfld.long 0 0. " DRAIN_PULSE "  "0 ,1 "
bitfld.long 0 1. " RESUME_PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_TA_CONTEXT_DRAIN_MTE"
base ad:0xa0308398
group 0--3
line.long 0 "EUR_CR_TA_CONTEXT_DRAIN_MTE"
bitfld.long 0 4.--31. " BASE_ADDR "  " "
;tree.end

;tree "EUR_CR_TE_PRIMITIVE_BLOCK"
base ad:0xa030839c
group 0--3
line.long 0 "EUR_CR_TE_PRIMITIVE_BLOCK"
bitfld.long 0 0.--17. " PROGRESS "  " "
;tree.end

;tree "EUR_CR_PIXELBE"
base ad:0xa0308400
group 0--3
line.long 0 "EUR_CR_PIXELBE"
hexfld.byte 0 " ALPHATHRESHOLD "
bitfld.long 0 8. " IDF_USE_FBADDR "  "0 ,1 "
bitfld.long 0 9. " CHKSUM_INIT "  "0 ,1 "
bitfld.long 0 10. " AA_EDGEOPT_OFF "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_RENDER"
base ad:0xa0308404
group 0--3
line.long 0 "EUR_CR_ISP_RENDER"
bitfld.long 0 0.--1. " TYPE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " CONTEXT_RESUMED "  "0 ,1 "
bitfld.long 0 4.--5. " FAST_SCANDIR "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_ISP_RGN_BASE"
base ad:0xa0308408
group 0--3
line.long 0 "EUR_CR_ISP_RGN_BASE"
bitfld.long 0 2.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_ISP_RENDBOX1"
base ad:0xa030840c
group 0--3
line.long 0 "EUR_CR_ISP_RENDBOX1"
hexfld.byte 0 " Y "
hexfld.byte 2 " X "
;tree.end

;tree "EUR_CR_ISP_RENDBOX2"
base ad:0xa0308410
group 0--3
line.long 0 "EUR_CR_ISP_RENDBOX2"
hexfld.byte 0 " Y "
hexfld.byte 2 " X "
;tree.end

;tree "EUR_CR_ISP_IPFMISC"
base ad:0xa0308414
group 0--3
line.long 0 "EUR_CR_ISP_IPFMISC"
bitfld.long 0 0.--5. " VALIDID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 8. " PROCESSEMPTY "  "0 ,1 "
bitfld.long 0 16.--19. " UPASSSTART "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24. " CONTEXT_STORE_TILE_ONLY "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_OGL_MODE"
base ad:0xa0308418
group 0--3
line.long 0 "EUR_CR_ISP_OGL_MODE"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_PERPENDICULAR"
base ad:0xa030841c
group 0--3
line.long 0 "EUR_CR_ISP_PERPENDICULAR"
bitfld.long 0 4.--30. " THRESHOLD "  " "
;tree.end

;tree "EUR_CR_ISP_CULLVALUE"
base ad:0xa0308420
group 0--3
line.long 0 "EUR_CR_ISP_CULLVALUE"
bitfld.long 0 4.--30. " THRESHOLD "  " "
;tree.end

;tree "EUR_CR_ISP_DBIAS"
base ad:0xa0308424
group 0--3
line.long 0 "EUR_CR_ISP_DBIAS"
hexfld.byte 0 " UNITSADJ "
hexfld.byte 1 " FACTORADJ "
;tree.end

;tree "EUR_CR_ISP_START_RENDER"
base ad:0xa0308428
wgroup 0--3
line.long 0 "EUR_CR_ISP_START_RENDER"
bitfld.long 0 0. " PULSE "  "0 ,1 "
;tree.end

;tree "EUR_CR_3D_AA_MODE"
base ad:0xa030842c
group 0--3
line.long 0 "EUR_CR_3D_AA_MODE"
bitfld.long 0 0.--1. " VALUE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_ISP_BREAK"
base ad:0xa0308430
wgroup 0--3
line.long 0 "EUR_CR_ISP_BREAK"
bitfld.long 0 0. " HALT "  "0 ,1 "
bitfld.long 0 4. " RESUME "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_3DCONTEXT"
base ad:0xa0308434
wgroup 0--3
line.long 0 "EUR_CR_ISP_3DCONTEXT"
bitfld.long 0 0. " STORE "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_FPU"
base ad:0xa0308438
rgroup 0--3
line.long 0 "EUR_CR_ISP_FPU"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_TSP_PARAMETER_CACHE"
base ad:0xa030843c
wgroup 0--3
line.long 0 "EUR_CR_TSP_PARAMETER_CACHE"
bitfld.long 0 0. " INVALIDATE "  "0 ,1 "
;tree.end

;tree "EUR_CR_TSP_PARAMETER_FETCH"
base ad:0xa0308440
group 0--3
line.long 0 "EUR_CR_TSP_PARAMETER_FETCH"
bitfld.long 0 0. " REPLACE_MODE "  "0 ,1 "
;tree.end

;tree "EUR_CR_IFPU_ROUNDMODE"
base ad:0xa0308444
group 0--3
line.long 0 "EUR_CR_IFPU_ROUNDMODE"
bitfld.long 0 0.--1. " DEPTH "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_ISP_START"
base ad:0xa0308448
group 0--3
line.long 0 "EUR_CR_ISP_START"
bitfld.long 0 0.--4. " PRIM_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--30. " CTRL_STREAM_POS "  " "
;tree.end

;tree "EUR_CR_4KX4K_RENDER"
base ad:0xa030844c
group 0--3
line.long 0 "EUR_CR_4KX4K_RENDER"
bitfld.long 0 0. " MODE "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_BREAK_INDEX"
base ad:0xa0308450
rgroup 0--3
line.long 0 "EUR_CR_ISP_BREAK_INDEX"
bitfld.long 0 0.--25. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_ISP_ZLSCTL"
base ad:0xa0308480
group 0--3
line.long 0 "EUR_CR_ISP_ZLSCTL"
bitfld.long 0 0. " ZONLYRENDER "  "0 ,1 "
bitfld.long 0 1. " FORCEZLOAD "  "0 ,1 "
bitfld.long 0 2. " FORCEZSTORE "  "0 ,1 "
bitfld.long 0 3.--10. " ZLSEXTENT "  " "
bitfld.long 0 12. " LOADTILED "  "0 ,1 "
bitfld.long 0 13. " SLOADEN "  "0 ,1 "
bitfld.long 0 14. " ZLOADEN "  "0 ,1 "
bitfld.long 0 15. " MLOADEN "  "0 ,1 "
bitfld.long 0 16. " STORETILED "  "0 ,1 "
bitfld.long 0 17. " SSTOREEN "  "0 ,1 "
bitfld.long 0 18. " ZSTOREEN "  "0 ,1 "
bitfld.long 0 19. " MSTOREEN "  "0 ,1 "
bitfld.long 0 20. " EXTERNALZBUFFER "  "0 ,1 "
bitfld.long 0 21.--23. " ZLOADFORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 24.--26. " ZSTOREFORMAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_ISP_ZLOAD_BASE"
base ad:0xa0308484
group 0--3
line.long 0 "EUR_CR_ISP_ZLOAD_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_ISP_ZSTORE_BASE"
base ad:0xa0308488
group 0--3
line.long 0 "EUR_CR_ISP_ZSTORE_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_ISP_STENCIL_LOAD_BASE"
base ad:0xa030848c
group 0--3
line.long 0 "EUR_CR_ISP_STENCIL_LOAD_BASE"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_ISP_STENCIL_STORE_BASE"
base ad:0xa0308490
group 0--3
line.long 0 "EUR_CR_ISP_STENCIL_STORE_BASE"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_ISP_VISREGBASE"
base ad:0xa03084c0
group 0--3
line.long 0 "EUR_CR_ISP_VISREGBASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_ISP_BGOBJDEPTH"
base ad:0xa03084b8
group 0--3
line.long 0 "EUR_CR_ISP_BGOBJDEPTH"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ISP_BGOBJ"
base ad:0xa03084bc
group 0--3
line.long 0 "EUR_CR_ISP_BGOBJ"
hexfld.byte 0 " STENCIL "
bitfld.long 0 8. " MASK "  "0 ,1 "
bitfld.long 0 9. " ENABLEBGTAG "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_BGOBJTAG"
base ad:0xa03084c4
group 0--3
line.long 0 "EUR_CR_ISP_BGOBJTAG"
bitfld.long 0 0.--23. " VERTEXPTR "  " "
bitfld.long 0 24.--29. " TSPDATASIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "EUR_CR_ISP_MULTISAMPLECTL"
base ad:0xa03084c8
group 0--3
line.long 0 "EUR_CR_ISP_MULTISAMPLECTL"
bitfld.long 0 0.--3. " MSAA_X0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " MSAA_Y0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " MSAA_X1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " MSAA_Y1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " MSAA_X2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 20.--23. " MSAA_Y2 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 24.--27. " MSAA_X3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 28.--31. " MSAA_Y3 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_ISP_TAGCTRL"
base ad:0xa03084dc
group 0--3
line.long 0 "EUR_CR_ISP_TAGCTRL"
bitfld.long 0 0. " SAFE "  "0 ,1 "
bitfld.long 0 1. " FORCE_PT_OFF "  "0 ,1 "
bitfld.long 0 2. " REUSE_TAGS "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_STATUS2"
base ad:0xa03084e4
rgroup 0--3
line.long 0 "EUR_CR_ISP_STATUS2"
hexfld.byte 0 " TILE_X "
hexfld.byte 1 " TILE_Y "
bitfld.long 0 16.--20. " PRIM_NUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "EUR_CR_PIXELBE_EMIT"
base ad:0xa03084ec
rgroup 0--3
line.long 0 "EUR_CR_PIXELBE_EMIT"
bitfld.long 0 0. " STATUS0 "  "0 ,1 "
bitfld.long 0 1. " STATUS1 "  "0 ,1 "
bitfld.long 0 2. " STATUS2 "  "0 ,1 "
bitfld.long 0 3. " STATUS3 "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_CONTEXT_RESUME"
base ad:0xa0308500
group 0--3
line.long 0 "EUR_CR_ISP_CONTEXT_RESUME"
bitfld.long 0 5.--31. " ZLOAD_BASE "  " "
;tree.end

;tree "EUR_CR_ISP_CONTEXT_RESUME2"
base ad:0xa0308504
group 0--3
line.long 0 "EUR_CR_ISP_CONTEXT_RESUME2"
bitfld.long 0 0.--8. " ZLS_BURST "  " "
bitfld.long 0 9. " PT_IN_FLIGHT "  "0 ,1 "
bitfld.long 0 10. " END_OF_RENDER "  "0 ,1 "
bitfld.long 0 11. " END_OF_TILE "  "0 ,1 "
hexfld.byte 2 " TILE_Y "
hexfld.byte 3 " TILE_X "
;tree.end

;tree "EUR_CR_ISP_CONTEXT_RESUME3"
base ad:0xa0308508
group 0--3
line.long 0 "EUR_CR_ISP_CONTEXT_RESUME3"
bitfld.long 0 2.--25. " ZLS_CMP_BASE "  " "
bitfld.long 0 26. " ZLS_FIRST_TILE_IN_MT "  "0 ,1 "
bitfld.long 0 27.--30. " ZLS_MACROTILE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 31. " ZLS_ZSTORE_CMD "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_ZLS_EXTZ_RGN_BASE"
base ad:0xa030850c
group 0--3
line.long 0 "EUR_CR_ISP_ZLS_EXTZ_RGN_BASE"
bitfld.long 0 2.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_ISP_MTILE1"
base ad:0xa0308520
group 0--3
line.long 0 "EUR_CR_ISP_MTILE1"
hexfld.byte 0 " X3 "
bitfld.long 0 12.--19. " X2 "  " "
bitfld.long 0 22.--29. " X1 "  " "
bitfld.long 0 31. " NUMBER "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_MTILE2"
base ad:0xa0308524
group 0--3
line.long 0 "EUR_CR_ISP_MTILE2"
hexfld.byte 0 " Y3 "
bitfld.long 0 12.--19. " Y2 "  " "
bitfld.long 0 22.--29. " Y1 "  " "
;tree.end

;tree "EUR_CR_ISP_MTILE"
base ad:0xa0308528
group 0--3
line.long 0 "EUR_CR_ISP_MTILE"
bitfld.long 0 0.--17. " STRIDE "  " "
;tree.end

;tree "EUR_CR_ISP_ZLS_FALLBACK"
base ad:0xa030853c
group 0--3
line.long 0 "EUR_CR_ISP_ZLS_FALLBACK"
bitfld.long 0 0.--8. " THRESHOLD "  " "
bitfld.long 0 31. " ENABLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_CONTEXT_SWITCH"
base ad:0xa0308540
group 0--3
line.long 0 "EUR_CR_ISP_CONTEXT_SWITCH"
bitfld.long 0 5.--31. " ZSTORE_BASE "  " "
;tree.end

;tree "EUR_CR_ISP_CONTEXT_SWITCH2"
base ad:0xa0308544
rgroup 0--3
line.long 0 "EUR_CR_ISP_CONTEXT_SWITCH2"
bitfld.long 0 0.--8. " ZLS_BURST "  " "
bitfld.long 0 9. " PT_IN_FLIGHT "  "0 ,1 "
bitfld.long 0 10. " END_OF_RENDER "  "0 ,1 "
bitfld.long 0 11. " END_OF_TILE "  "0 ,1 "
hexfld.byte 2 " TILE_Y "
hexfld.byte 3 " TILE_X "
;tree.end

;tree "EUR_CR_ISP_CONTEXT_SWITCH3"
base ad:0xa0308548
rgroup 0--3
line.long 0 "EUR_CR_ISP_CONTEXT_SWITCH3"
bitfld.long 0 2.--25. " ZLS_CMP_BASE "  " "
bitfld.long 0 26. " ZLS_FIRST_TILE_IN_MT "  "0 ,1 "
bitfld.long 0 27.--30. " ZLS_MACROTILE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 31. " ZLS_ZSTORE_CMD "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_CONTEXT_SWITCH4"
base ad:0xa030854c
rgroup 0--3
line.long 0 "EUR_CR_ISP_CONTEXT_SWITCH4"
bitfld.long 0 0.--27. " PIM_ID "  " "
;tree.end

;tree "EUR_CR_ISP_CONTEXT_SWITCH5"
base ad:0xa0308550
rgroup 0--3
line.long 0 "EUR_CR_ISP_CONTEXT_SWITCH5"
bitfld.long 0 0.--1. " STREAM_ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--7. " EMPTY_STATUS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_ISP_CONTEXT_SWITCH6"
base ad:0xa0308554
rgroup 0--3
line.long 0 "EUR_CR_ISP_CONTEXT_SWITCH6"
bitfld.long 0 2.--27. " RGN0_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN0_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_CONTEXT_SWITCH7"
base ad:0xa0308558
rgroup 0--3
line.long 0 "EUR_CR_ISP_CONTEXT_SWITCH7"
bitfld.long 0 2.--27. " RGN1_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN1_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_CONTEXT_SWITCH8"
base ad:0xa030855c
rgroup 0--3
line.long 0 "EUR_CR_ISP_CONTEXT_SWITCH8"
bitfld.long 0 2.--27. " RGN2_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN2_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_ISP_CONTEXT_SWITCH9"
base ad:0xa0308560
rgroup 0--3
line.long 0 "EUR_CR_ISP_CONTEXT_SWITCH9"
bitfld.long 0 2.--27. " RGN3_CTRL_STREAM_POS "  " "
bitfld.long 0 31. " RGN3_CTRL_STREAM_VALID "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_3D_PAGE_TABLE_BASE"
base ad:0xa0308600
group 0--3
line.long 0 "EUR_CR_DPM_3D_PAGE_TABLE_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_DPM_3D_FREE_LIST"
base ad:0xa0308604
group 0--3
line.long 0 "EUR_CR_DPM_3D_FREE_LIST"
hexfld.word 0 " HEAD "
hexfld.word 2 " TAIL "
;tree.end

;tree "EUR_CR_DPM_PDS_PAGE_THRESHOLD"
base ad:0xa0308614
group 0--3
line.long 0 "EUR_CR_DPM_PDS_PAGE_THRESHOLD"
hexfld.word 0 " VALUE "
;tree.end

;tree "EUR_CR_DPM_TA_ALLOC_PAGE_TABLE_BASE"
base ad:0xa0308618
group 0--3
line.long 0 "EUR_CR_DPM_TA_ALLOC_PAGE_TABLE_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_DPM_TA_ALLOC_FREE_LIST"
base ad:0xa030861c
group 0--3
line.long 0 "EUR_CR_DPM_TA_ALLOC_FREE_LIST"
hexfld.word 0 " HEAD "
hexfld.word 2 " TAIL "
;tree.end

;tree "EUR_CR_DPM_TA_PAGE_THRESHOLD"
base ad:0xa0308620
group 0--3
line.long 0 "EUR_CR_DPM_TA_PAGE_THRESHOLD"
hexfld.word 0 " VALUE "
;tree.end

;tree "EUR_CR_DPM_ZLS_PAGE_THRESHOLD"
base ad:0xa0308624
group 0--3
line.long 0 "EUR_CR_DPM_ZLS_PAGE_THRESHOLD"
hexfld.word 0 " VALUE "
;tree.end

;tree "EUR_CR_DPM_TA_GLOBAL_LIST"
base ad:0xa0308628
group 0--3
line.long 0 "EUR_CR_DPM_TA_GLOBAL_LIST"
hexfld.word 0 " SIZE "
bitfld.long 0 16. " POLICY "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_STATE_TABLE_BASE"
base ad:0xa030862c
group 0--3
line.long 0 "EUR_CR_DPM_STATE_TABLE_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_DPM_STATE_CONTEXT_ID"
base ad:0xa0308630
group 0--3
line.long 0 "EUR_CR_DPM_STATE_CONTEXT_ID"
bitfld.long 0 0. " LS "  "0 ,1 "
bitfld.long 0 1. " DALLOC "  "0 ,1 "
bitfld.long 0 2. " ALLOC "  "0 ,1 "
bitfld.long 0 3. " NCOP "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_CONTROL_TABLE_BASE"
base ad:0xa0308634
group 0--3
line.long 0 "EUR_CR_DPM_CONTROL_TABLE_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_DPM_START_OF_CONTEXT_PAGES_ALLOCATED"
base ad:0xa0308638
group 0--3
line.long 0 "EUR_CR_DPM_START_OF_CONTEXT_PAGES_ALLOCATED"
hexfld.word 0 " LOCAL "
hexfld.word 2 " GLOBAL "
;tree.end

;tree "EUR_CR_DPM_3D_DEALLOCATE"
base ad:0xa030863c
group 0--3
line.long 0 "EUR_CR_DPM_3D_DEALLOCATE"
bitfld.long 0 0. " GLOBAL "  "0 ,1 "
bitfld.long 0 1. " ENABLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_ALLOC"
base ad:0xa0308640
group 0--3
line.long 0 "EUR_CR_DPM_ALLOC"
hexfld.word 0 " PAGE "
bitfld.long 0 16. " PAGE_VALID "  "0 ,1 "
bitfld.long 0 17. " PAGE_OUTOFMEMORY "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_DALLOC"
base ad:0xa0308644
group 0--3
line.long 0 "EUR_CR_DPM_DALLOC"
hexfld.word 0 " PAGE "
bitfld.long 0 16. " PAGE_FREE "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_TA_ALLOC"
base ad:0xa0308648
group 0--3
line.long 0 "EUR_CR_DPM_TA_ALLOC"
hexfld.word 2 " FREE_LIST_PR "
;tree.end

;tree "EUR_CR_DPM_3D"
base ad:0xa030864c
group 0--3
line.long 0 "EUR_CR_DPM_3D"
hexfld.word 2 " FREE_LIST_PREVIOUS "
;tree.end

;tree "EUR_CR_DPM_PARTIAL_RENDER"
base ad:0xa0308658
group 0--3
line.long 0 "EUR_CR_DPM_PARTIAL_RENDER"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_LSS_PARTIAL_CONTEXT"
base ad:0xa030865c
group 0--3
line.long 0 "EUR_CR_DPM_LSS_PARTIAL_CONTEXT"
bitfld.long 0 0. " OPERATION "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_START_OF_3D_CONTEXT_PAGES_ALLOCATED"
base ad:0xa0308660
group 0--3
line.long 0 "EUR_CR_DPM_START_OF_3D_CONTEXT_PAGES_ALLOCATED"
hexfld.word 0 " LOCAL "
hexfld.word 2 " GLOBAL "
;tree.end

;tree "EUR_CR_DPM_CONTEXT_PB_BASE"
base ad:0xa0308664
group 0--3
line.long 0 "EUR_CR_DPM_CONTEXT_PB_BASE"
bitfld.long 0 0.--2. " CMP "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_DPM_TASK_3D_FREE"
base ad:0xa0308680
wgroup 0--3
line.long 0 "EUR_CR_DPM_TASK_3D_FREE"
bitfld.long 0 0. " LOAD "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_TASK_TA_FREE"
base ad:0xa0308684
wgroup 0--3
line.long 0 "EUR_CR_DPM_TASK_TA_FREE"
bitfld.long 0 0. " LOAD "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_TASK_STATE"
base ad:0xa0308694
wgroup 0--3
line.long 0 "EUR_CR_DPM_TASK_STATE"
bitfld.long 0 0. " STORE "  "0 ,1 "
bitfld.long 0 1. " CLEAR "  "0 ,1 "
bitfld.long 0 2. " LOAD "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_TASK_CONTROL"
base ad:0xa0308698
wgroup 0--3
line.long 0 "EUR_CR_DPM_TASK_CONTROL"
bitfld.long 0 0. " STORE "  "0 ,1 "
bitfld.long 0 1. " CLEAR "  "0 ,1 "
bitfld.long 0 2. " LOAD "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_OUTOFMEM"
base ad:0xa030869c
wgroup 0--3
line.long 0 "EUR_CR_DPM_OUTOFMEM"
bitfld.long 0 0. " RESTART "  "0 ,1 "
bitfld.long 0 1. " ABORT "  "0 ,1 "
bitfld.long 0 2. " ABORTALL "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_FREE_CONTEXT"
base ad:0xa03086a0
wgroup 0--3
line.long 0 "EUR_CR_DPM_FREE_CONTEXT"
bitfld.long 0 0. " NOW "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_3D_TIMEOUT"
base ad:0xa03086a4
wgroup 0--3
line.long 0 "EUR_CR_DPM_3D_TIMEOUT"
bitfld.long 0 0. " NOW "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_TA_EVM"
base ad:0xa03086a8
wgroup 0--3
line.long 0 "EUR_CR_DPM_TA_EVM"
bitfld.long 0 0. " INIT "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_TA_ALLOC_FREE_LIST_STATUS1"
base ad:0xa0308700
rgroup 0--3
line.long 0 "EUR_CR_DPM_TA_ALLOC_FREE_LIST_STATUS1"
hexfld.word 0 " HEAD "
hexfld.word 2 " TAIL "
;tree.end

;tree "EUR_CR_DPM_3D_FREE_LIST_STATUS1"
base ad:0xa030870c
rgroup 0--3
line.long 0 "EUR_CR_DPM_3D_FREE_LIST_STATUS1"
hexfld.word 0 " HEAD "
hexfld.word 2 " TAIL "
;tree.end

;tree "EUR_CR_DPM_TA_ALLOC_FREE_LIST_STATUS2"
base ad:0xa0308710
rgroup 0--3
line.long 0 "EUR_CR_DPM_TA_ALLOC_FREE_LIST_STATUS2"
hexfld.word 0 " PREVIOUS "
;tree.end

;tree "EUR_CR_DPM_3D_FREE_LIST_STATUS2"
base ad:0xa030871c
rgroup 0--3
line.long 0 "EUR_CR_DPM_3D_FREE_LIST_STATUS2"
hexfld.word 0 " PREVIOUS "
;tree.end

;tree "EUR_CR_DPM_ABORT_STATUS_MTILE"
base ad:0xa0308720
group 0--3
line.long 0 "EUR_CR_DPM_ABORT_STATUS_MTILE"
bitfld.long 0 0.--3. " INDEX "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " GLOBAL "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_PAGE_STATUS"
base ad:0xa0308724
rgroup 0--3
line.long 0 "EUR_CR_DPM_PAGE_STATUS"
hexfld.word 0 " TOTAL "
hexfld.word 2 " TA "
;tree.end

;tree "EUR_CR_DPM_PAGE"
base ad:0xa0308728
rgroup 0--3
line.long 0 "EUR_CR_DPM_PAGE"
hexfld.word 0 " STATUS_3D "
;tree.end

;tree "EUR_CR_DPM_GLOBAL_PAGE_STATUS"
base ad:0xa030872c
rgroup 0--3
line.long 0 "EUR_CR_DPM_GLOBAL_PAGE_STATUS"
hexfld.word 0 " TOTAL "
hexfld.word 2 " TA "
;tree.end

;tree "EUR_CR_DPM_GLOBAL_PAGE"
base ad:0xa0308730
rgroup 0--3
line.long 0 "EUR_CR_DPM_GLOBAL_PAGE"
hexfld.word 0 " STATUS_3D "
;tree.end

;tree "EUR_CR_DPM_REQUESTING"
base ad:0xa0308734
rgroup 0--3
line.long 0 "EUR_CR_DPM_REQUESTING"
bitfld.long 0 0.--1. " SOURCE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_DPM_RGN_HDR_PARSER"
base ad:0xa0308738
group 0--3
line.long 0 "EUR_CR_DPM_RGN_HDR_PARSER"
bitfld.long 0 0. " IDLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_PIMSHARE"
base ad:0xa030873c
group 0--3
line.long 0 "EUR_CR_DPM_PIMSHARE"
bitfld.long 0 0. " TAAC_MODE "  "0 ,1 "
bitfld.long 0 1. " MTE_MODE "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_CONTEXT_DRAIN_BASE"
base ad:0xa0308740
group 0--3
line.long 0 "EUR_CR_DPM_CONTEXT_DRAIN_BASE"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_DPM_CONTEXT_DRAIN_STATUS"
base ad:0xa0308744
rgroup 0--3
line.long 0 "EUR_CR_DPM_CONTEXT_DRAIN_STATUS"
bitfld.long 0 0. " DRAINED "  "0 ,1 "
bitfld.long 0 1. " RESUMED "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_DRAIN_STATUS"
base ad:0xa0308748
wgroup 0--3
line.long 0 "EUR_CR_DPM_DRAIN_STATUS"
bitfld.long 0 0. " DRAIN_CLEAR "  "0 ,1 "
bitfld.long 0 1. " RESUME_CLEAR "  "0 ,1 "
;tree.end

;tree "EUR_CR_DPM_CONTEXT_DRAIN_BUF"
base ad:0xa030874c
group 0--3
line.long 0 "EUR_CR_DPM_CONTEXT_DRAIN_BUF"
bitfld.long 0 0.--10. " SIZE "  " "
;tree.end

;tree "EUR_CR_DPM_MTILE_ABORTED"
base ad:0xa0308750
group 0--3
line.long 0 "EUR_CR_DPM_MTILE_ABORTED"
hexfld.word 0 " MASK "
;tree.end

;tree "EUR_CR_TSP_CONFIG"
base ad:0xa0308800
group 0--3
line.long 0 "EUR_CR_TSP_CONFIG"
bitfld.long 0 0. " DXT35_TRANSOVR "  "0 ,1 "
bitfld.long 0 1. " CEMGRAD_DONTNEGATE "  "0 ,1 "
bitfld.long 0 2. " CEMEDGE_DONTFILTER "  "0 ,1 "
bitfld.long 0 4. " CEM_FACE_PACKING "  "0 ,1 "
bitfld.long 0 6. " CEM_YUVPLANAR_PACKING "  "0 ,1 "
;tree.end

;tree "EUR_CR_TCU_CTRL"
base ad:0xa0308804
group 0--3
line.long 0 "EUR_CR_TCU_CTRL"
bitfld.long 0 0. " L0P0OFF "  "0 ,1 "
bitfld.long 0 1. " L0P1OFF "  "0 ,1 "
bitfld.long 0 2. " L1P0OFF "  "0 ,1 "
bitfld.long 0 3. " L1P1OFF "  "0 ,1 "
bitfld.long 0 4. " L2OFF "  "0 ,1 "
bitfld.long 0 5.--11. " MAX_REQUEST "  " "
;tree.end

;tree "EUR_CR_TCU_ICTRL"
base ad:0xa0308808
wgroup 0--3
line.long 0 "EUR_CR_TCU_ICTRL"
bitfld.long 0 0. " INVALTCU "  "0 ,1 "
bitfld.long 0 1. " INVALDM0 "  "0 ,1 "
bitfld.long 0 2. " INVALDM1 "  "0 ,1 "
bitfld.long 0 3. " INVALDM2 "  "0 ,1 "
bitfld.long 0 4. " INVALDM3 "  "0 ,1 "
;tree.end

;tree "EUR_CR_DCU_ICTRL"
base ad:0xa0308810
wgroup 0--3
line.long 0 "EUR_CR_DCU_ICTRL"
bitfld.long 0 0. " INVALIDATE "  "0 ,1 "
bitfld.long 0 1. " INVALIDATEDM0 "  "0 ,1 "
bitfld.long 0 2. " INVALIDATEDM1 "  "0 ,1 "
bitfld.long 0 3. " INVALIDATEDM2 "  "0 ,1 "
bitfld.long 0 4. " INVALIDATEDM3 "  "0 ,1 "
;tree.end

;tree "EUR_CR_DCU_PCTRL"
base ad:0xa0308814
group 0--3
line.long 0 "EUR_CR_DCU_PCTRL"
bitfld.long 0 0.--3. " EDM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " PDM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 8.--11. " USE_VDM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " PDS_VDM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " DMTAG_OFF "  "0 ,1 "
;tree.end

;tree "EUR_CR_DCU_CTRL"
base ad:0xa0308818
group 0--3
line.long 0 "EUR_CR_DCU_CTRL"
bitfld.long 0 0. " L0P0OFF "  "0 ,1 "
bitfld.long 0 1. " L0P1OFF "  "0 ,1 "
bitfld.long 0 8. " L1P0OFF "  "0 ,1 "
bitfld.long 0 9. " L1P1OFF "  "0 ,1 "
bitfld.long 0 10. " L2OFF "  "0 ,1 "
;tree.end

;tree "EUR_CR_TPU_YUV00"
base ad:0xa030881c
group 0--3
line.long 0 "EUR_CR_TPU_YUV00"
bitfld.long 0 0.--11. " C00 "  " "
bitfld.long 0 16.--27. " C01 "  " "
;tree.end

;tree "EUR_CR_TPU_YUV01"
base ad:0xa0308820
group 0--3
line.long 0 "EUR_CR_TPU_YUV01"
bitfld.long 0 0.--11. " C02 "  " "
bitfld.long 0 16.--27. " C10 "  " "
;tree.end

;tree "EUR_CR_TPU_YUV02"
base ad:0xa0308824
group 0--3
line.long 0 "EUR_CR_TPU_YUV02"
bitfld.long 0 0.--11. " C11 "  " "
bitfld.long 0 16.--27. " C12 "  " "
;tree.end

;tree "EUR_CR_TPU_YUV03"
base ad:0xa0308828
group 0--3
line.long 0 "EUR_CR_TPU_YUV03"
bitfld.long 0 0.--11. " C20 "  " "
bitfld.long 0 16.--27. " C21 "  " "
;tree.end

;tree "EUR_CR_TPU_YUV04"
base ad:0xa030882c
group 0--3
line.long 0 "EUR_CR_TPU_YUV04"
bitfld.long 0 0.--11. " C22 "  " "
bitfld.long 0 16.--28. " D00 "  " "
;tree.end

;tree "EUR_CR_TPU_YUV05"
base ad:0xa0308830
group 0--3
line.long 0 "EUR_CR_TPU_YUV05"
bitfld.long 0 0.--12. " D10 "  " "
bitfld.long 0 16.--28. " D20 "  " "
;tree.end

;tree "EUR_CR_TPU_YUV10"
base ad:0xa0308834
group 0--3
line.long 0 "EUR_CR_TPU_YUV10"
bitfld.long 0 0.--11. " C00 "  " "
bitfld.long 0 16.--27. " C01 "  " "
;tree.end

;tree "EUR_CR_TPU_YUV11"
base ad:0xa0308838
group 0--3
line.long 0 "EUR_CR_TPU_YUV11"
bitfld.long 0 0.--11. " C02 "  " "
bitfld.long 0 16.--27. " C10 "  " "
;tree.end

;tree "EUR_CR_TPU_YUV12"
base ad:0xa030883c
group 0--3
line.long 0 "EUR_CR_TPU_YUV12"
bitfld.long 0 0.--11. " C11 "  " "
bitfld.long 0 16.--27. " C12 "  " "
;tree.end

;tree "EUR_CR_TPU_YUV13"
base ad:0xa0308840
group 0--3
line.long 0 "EUR_CR_TPU_YUV13"
bitfld.long 0 0.--11. " C20 "  " "
bitfld.long 0 16.--27. " C21 "  " "
;tree.end

;tree "EUR_CR_TPU_YUV14"
base ad:0xa0308844
group 0--3
line.long 0 "EUR_CR_TPU_YUV14"
bitfld.long 0 0.--11. " C22 "  " "
bitfld.long 0 16.--28. " D00 "  " "
;tree.end

;tree "EUR_CR_TPU_YUV15"
base ad:0xa0308848
group 0--3
line.long 0 "EUR_CR_TPU_YUV15"
bitfld.long 0 0.--12. " D10 "  " "
bitfld.long 0 16.--28. " D20 "  " "
;tree.end

;tree "EUR_CR_TF_SIG00"
base ad:0xa030884c
rgroup 0--3
line.long 0 "EUR_CR_TF_SIG00"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_TF_SIG01"
base ad:0xa0308850
rgroup 0--3
line.long 0 "EUR_CR_TF_SIG01"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_TF_SIG02"
base ad:0xa0308854
rgroup 0--3
line.long 0 "EUR_CR_TF_SIG02"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_TF_SIG03"
base ad:0xa0308858
rgroup 0--3
line.long 0 "EUR_CR_TF_SIG03"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ITR_TAG0"
base ad:0xa030885c
rgroup 0--3
line.long 0 "EUR_CR_ITR_TAG0"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ITR_TAG1"
base ad:0xa0308860
rgroup 0--3
line.long 0 "EUR_CR_ITR_TAG1"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ITR_USE0"
base ad:0xa0308864
rgroup 0--3
line.long 0 "EUR_CR_ITR_USE0"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ITR_USE1"
base ad:0xa0308868
rgroup 0--3
line.long 0 "EUR_CR_ITR_USE1"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ITR_USE2"
base ad:0xa030886c
rgroup 0--3
line.long 0 "EUR_CR_ITR_USE2"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_ITR_USE3"
base ad:0xa0308870
rgroup 0--3
line.long 0 "EUR_CR_ITR_USE3"
hexfld.long 0 " SIGNATURE "
;tree.end

;tree "EUR_CR_TPU_LUMA0"
base ad:0xa0308880
group 0--3
line.long 0 "EUR_CR_TPU_LUMA0"
bitfld.long 0 0.--9. " RCOEFF "  " "
bitfld.long 0 16.--25. " GCOEFF "  " "
;tree.end

;tree "EUR_CR_TPU_LUMA1"
base ad:0xa0308884
group 0--3
line.long 0 "EUR_CR_TPU_LUMA1"
bitfld.long 0 0.--9. " BCOEFF "  " "
bitfld.long 0 16.--25. " OUTOFF "  " "
;tree.end

;tree "EUR_CR_TPU_LUMA2"
base ad:0xa0308888
group 0--3
line.long 0 "EUR_CR_TPU_LUMA2"
hexfld.byte 0 " YMIN "
hexfld.byte 1 " YMAX "
hexfld.byte 2 " ALPHA_TRANS "
hexfld.byte 3 " ALPHA_OPAQUE "
;tree.end

;tree "EUR_CR_CLIP_CHECKSUM"
base ad:0xa0308900
rgroup 0--3
line.long 0 "EUR_CR_CLIP_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MTE_MEM_CHECKSUM"
base ad:0xa0308904
rgroup 0--3
line.long 0 "EUR_CR_MTE_MEM_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_MTE_TE_CHECKSUM"
base ad:0xa0308908
rgroup 0--3
line.long 0 "EUR_CR_MTE_TE_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_TE_CHECKSUM"
base ad:0xa030890c
rgroup 0--3
line.long 0 "EUR_CR_TE_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ISP_FPU_CHECKSUM"
base ad:0xa0308910
rgroup 0--3
line.long 0 "EUR_CR_ISP_FPU_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ISP_PRECALC_CHECKSUM"
base ad:0xa0308914
rgroup 0--3
line.long 0 "EUR_CR_ISP_PRECALC_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ISP_EDGE_CHECKSUM"
base ad:0xa0308918
rgroup 0--3
line.long 0 "EUR_CR_ISP_EDGE_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ISP_TAGWRITE_CHECKSUM"
base ad:0xa030891c
rgroup 0--3
line.long 0 "EUR_CR_ISP_TAGWRITE_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_ISP_SPAN_CHECKSUM"
base ad:0xa0308920
rgroup 0--3
line.long 0 "EUR_CR_ISP_SPAN_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_PBE_PIXEL_CHECKSUM"
base ad:0xa0308924
rgroup 0--3
line.long 0 "EUR_CR_PBE_PIXEL_CHECKSUM"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_USE_CTRL"
base ad:0xa0308a00
group 0--3
line.long 0 "EUR_CR_USE_CTRL"
bitfld.long 0 0.--1. " KILL_DM "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--3. " KILL_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--18. " INSTLIMIT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 19. " REGBOUND_ZERO "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE_LD_REDIRECT"
base ad:0xa0308a04
group 0--3
line.long 0 "EUR_CR_USE_LD_REDIRECT"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_USE_CACHE"
base ad:0xa0308a08
group 0--3
line.long 0 "EUR_CR_USE_CACHE"
bitfld.long 0 0. " INVALIDATE "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE0"
base ad:0xa0308a0c
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE0"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE1"
base ad:0xa0308a10
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE1"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE2"
base ad:0xa0308a14
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE2"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE3"
base ad:0xa0308a18
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE3"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE4"
base ad:0xa0308a1c
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE4"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE5"
base ad:0xa0308a20
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE5"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE6"
base ad:0xa0308a24
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE6"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE7"
base ad:0xa0308a28
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE7"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE8"
base ad:0xa0308a2c
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE8"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE9"
base ad:0xa0308a30
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE9"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE10"
base ad:0xa0308a34
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE10"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE11"
base ad:0xa0308a38
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE11"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE12"
base ad:0xa0308a3c
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE12"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE13"
base ad:0xa0308a40
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE13"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE14"
base ad:0xa0308a44
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE14"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_CODE_BASE15"
base ad:0xa0308a48
group 0--3
line.long 0 "EUR_CR_USE_CODE_BASE15"
bitfld.long 0 0.--25. " ADDR "  " "
bitfld.long 0 26.--27. " DM "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_EVENT_PDS_ENABLE2"
base ad:0xa0308a50
group 0--3
line.long 0 "EUR_CR_EVENT_PDS_ENABLE2"
bitfld.long 0 0. " DPM_TA_FREE_LOAD "  "0 ,1 "
bitfld.long 0 1. " DPM_3D_FREE_LOAD "  "0 ,1 "
bitfld.long 0 2. " TRIG_DL "  "0 ,1 "
bitfld.long 0 3. " TRIG_3D "  "0 ,1 "
bitfld.long 0 4. " TRIG_TA "  "0 ,1 "
bitfld.long 0 5. " TE_RGNHDR_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 7. " DCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 8. " ISP2_ZLS_CSW_FINISHED "  "0 ,1 "
bitfld.long 0 9. " MTE_CONTEXT_DRAINED "  "0 ,1 "
bitfld.long 0 10. " DATA_BREAKPOINT_TRAPPED "  "0 ,1 "
bitfld.long 0 11. " DATA_BREAKPOINT_UNTRAPPED "  "0 ,1 "
bitfld.long 0 15. " MTE_STATE_FLUSHED "  "0 ,1 "
;tree.end

;tree "EUR_CR_PDS_CACHE_ENABLE"
base ad:0xa0308a54
group 0--3
line.long 0 "EUR_CR_PDS_CACHE_ENABLE"
bitfld.long 0 0. " CSC_INV "  "0 ,1 "
bitfld.long 0 1. " DSC_INV0 "  "0 ,1 "
bitfld.long 0 2. " DSC_INV1 "  "0 ,1 "
bitfld.long 0 4. " DSC_INV3 "  "0 ,1 "
;tree.end

;tree "EUR_CR_EVENT_PDS_ENABLE"
base ad:0xa0308a58
group 0--3
line.long 0 "EUR_CR_EVENT_PDS_ENABLE"
bitfld.long 0 0. " DPM_3D_MEM_FREE "  "0 ,1 "
bitfld.long 0 1. " DPM_OUT_OF_MEMORY_MT "  "0 ,1 "
bitfld.long 0 2. " DPM_OUT_OF_MEMORY_GBL "  "0 ,1 "
bitfld.long 0 3. " DPM_REACHED_MEM_THRESH "  "0 ,1 "
bitfld.long 0 4. " DPM_STATE_STORE "  "0 ,1 "
bitfld.long 0 5. " DPM_STATE_L "  "0 ,1 "
bitfld.long 0 6. " DPM_STATE_CLEAR "  "0 ,1 "
bitfld.long 0 7. " DPM_CONTROL_STORE "  "0 ,1 "
bitfld.long 0 8. " DPM_CONTROL_LOAD "  "0 ,1 "
bitfld.long 0 9. " DPM_CONTROL_CLEAR "  "0 ,1 "
bitfld.long 0 10. " TPC_FLUSH "  "0 ,1 "
bitfld.long 0 11. " TPC_CLEAR "  "0 ,1 "
bitfld.long 0 12. " TA_TERMINATE "  "0 ,1 "
bitfld.long 0 13. " TA_FINISHED "  "0 ,1 "
bitfld.long 0 14. " SW_EVENT "  "0 ,1 "
bitfld.long 0 15. " BREAKPOINT "  "0 ,1 "
bitfld.long 0 18. " PIXELBE_END_RENDER "  "0 ,1 "
bitfld.long 0 19. " OTPM_FLUSHED "  "0 ,1 "
bitfld.long 0 20. " OTPM_INV "  "0 ,1 "
bitfld.long 0 21. " OTPM_LOADED "  "0 ,1 "
bitfld.long 0 22. " DPM_INITEND "  "0 ,1 "
bitfld.long 0 23. " ISP_END_PASS "  "0 ,1 "
bitfld.long 0 24. " DPM_TA_MEM_FREE "  "0 ,1 "
bitfld.long 0 25. " DPM_OUT_OF_MEMORY_ZLS "  "0 ,1 "
bitfld.long 0 26. " TCU_INVALCOMPLETE "  "0 ,1 "
bitfld.long 0 28. " TA_DPM_FAULT "  "0 ,1 "
bitfld.long 0 29. " TIMER "  "0 ,1 "
;tree.end

;tree "EUR_CR_EVENT_PIXEL_PDS_EXEC"
base ad:0xa0308a5c
group 0--3
line.long 0 "EUR_CR_EVENT_PIXEL_PDS_EXEC"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_EVENT_PIXEL_PDS_DATA"
base ad:0xa0308a60
group 0--3
line.long 0 "EUR_CR_EVENT_PIXEL_PDS_DATA"
bitfld.long 0 0.--4. " SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "EUR_CR_EVENT_PIXEL_PDS_INFO"
base ad:0xa0308a64
group 0--3
line.long 0 "EUR_CR_EVENT_PIXEL_PDS_INFO"
bitfld.long 0 13.--21. " ATTRIBUTE_SIZE "  " "
;tree.end

;tree "EUR_CR_EVENT_OTHER_PDS_EXEC"
base ad:0xa0308a68
group 0--3
line.long 0 "EUR_CR_EVENT_OTHER_PDS_EXEC"
bitfld.long 0 4.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_EVENT_OTHER_PDS_DATA"
base ad:0xa0308a6c
group 0--3
line.long 0 "EUR_CR_EVENT_OTHER_PDS_DATA"
bitfld.long 0 0.--4. " SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "EUR_CR_EVENT_OTHER_PDS_INFO"
base ad:0xa0308a70
group 0--3
line.long 0 "EUR_CR_EVENT_OTHER_PDS_INFO"
bitfld.long 0 0. " SD "  "0 ,1 "
bitfld.long 0 8. " USE_PIPELINE "  "0 ,1 "
bitfld.long 0 10. " MULTIPLE "  "0 ,1 "
bitfld.long 0 13.--20. " ATTRIBUTE_SIZE "  " "
;tree.end

;tree "EUR_CR_DMS_CTRL"
base ad:0xa0308a74
group 0--3
line.long 0 "EUR_CR_DMS_CTRL"
bitfld.long 0 0.--2. " DISABLE_DM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--9. " MAX_NUM_PIXEL_TASKS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 10.--15. " MAX_NUM_VERTEX_TASKS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 16.--21. " MAX_NUM_EDM_TASKS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 22.--25. " MAX_NUM_PIXEL_PARTITIONS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 26.--29. " MAX_NUM_VERTEX_PARTITIONS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_USE_G0"
base ad:0xa0308a7c
group 0--3
line.long 0 "EUR_CR_USE_G0"
hexfld.byte 0 " P "
;tree.end

;tree "EUR_CR_USE_G1"
base ad:0xa0308a80
group 0--3
line.long 0 "EUR_CR_USE_G1"
hexfld.byte 0 " P "
;tree.end

;tree "EUR_CR_USE_FILTER0_LEFT"
base ad:0xa0308a84
group 0--3
line.long 0 "EUR_CR_USE_FILTER0_LEFT"
hexfld.byte 0 " TAP3 "
hexfld.byte 1 " TAP2 "
hexfld.byte 2 " TAP1 "
hexfld.byte 3 " TAP0 "
;tree.end

;tree "EUR_CR_USE_FILTER0_RIGHT"
base ad:0xa0308a88
group 0--3
line.long 0 "EUR_CR_USE_FILTER0_RIGHT"
hexfld.byte 0 " TAP7 "
hexfld.byte 1 " TAP6 "
hexfld.byte 2 " TAP5 "
hexfld.byte 3 " TAP4 "
;tree.end

;tree "EUR_CR_USE_FILTER0_EXTRA"
base ad:0xa0308a8c
group 0--3
line.long 0 "EUR_CR_USE_FILTER0_EXTRA"
bitfld.long 0 0.--3. " SHR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--19. " CONSTANT "  " "
;tree.end

;tree "EUR_CR_USE_FILTER1_LEFT"
base ad:0xa0308a90
group 0--3
line.long 0 "EUR_CR_USE_FILTER1_LEFT"
hexfld.byte 0 " TAP3 "
hexfld.byte 1 " TAP2 "
hexfld.byte 2 " TAP1 "
hexfld.byte 3 " TAP0 "
;tree.end

;tree "EUR_CR_USE_FILTER1_RIGHT"
base ad:0xa0308a94
group 0--3
line.long 0 "EUR_CR_USE_FILTER1_RIGHT"
hexfld.byte 0 " TAP7 "
hexfld.byte 1 " TAP6 "
hexfld.byte 2 " TAP5 "
hexfld.byte 3 " TAP4 "
;tree.end

;tree "EUR_CR_USE_FILTER1_EXTRA"
base ad:0xa0308a98
group 0--3
line.long 0 "EUR_CR_USE_FILTER1_EXTRA"
bitfld.long 0 0.--3. " SHR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--19. " CONSTANT "  " "
;tree.end

;tree "EUR_CR_USE_FILTER_TABLE"
base ad:0xa0308a9c
group 0--3
line.long 0 "EUR_CR_USE_FILTER_TABLE"
bitfld.long 0 0.--1. " SEL "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_ST_RANGE"
base ad:0xa0308aa0
group 0--3
line.long 0 "EUR_CR_USE_ST_RANGE"
hexfld.long 0 " VALUE "
;tree.end

;tree "EUR_CR_USE0_DM_SLOT"
base ad:0xa0308aa4
rgroup 0--3
line.long 0 "EUR_CR_USE0_DM_SLOT"
bitfld.long 0 2.--3. " 1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " 2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " 3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " 4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " 5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " 6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " 7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " 8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " 9 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " 10 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " 11 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " 12 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " 13 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " 14 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " 15 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE1_DM_SLOT"
base ad:0xa0308aa8
rgroup 0--3
line.long 0 "EUR_CR_USE1_DM_SLOT"
bitfld.long 0 2.--3. " 1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " 2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " 3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " 4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " 5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " 6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " 7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " 8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " 9 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " 10 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " 11 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " 12 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " 13 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " 14 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " 15 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE_EXEF"
base ad:0xa0308ab4
group 0--3
line.long 0 "EUR_CR_USE_EXEF"
bitfld.long 0 0.--19. " COFF "  " "
bitfld.long 0 20.--23. " CBASE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_PDS_DMS_CTRL2"
base ad:0xa0308ab8
group 0--3
line.long 0 "EUR_CR_PDS_DMS_CTRL2"
bitfld.long 0 0.--2. " MAX_PARTITIONS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_PDS"
base ad:0xa0308abc
group 0--3
line.long 0 "EUR_CR_PDS"
bitfld.long 0 0.--5. " ATTRIBUTE_CHUNK_START "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6. " DOUT_TIMEOUT_DISABLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_PDS_INV0"
base ad:0xa0308ad0
wgroup 0--3
line.long 0 "EUR_CR_PDS_INV0"
bitfld.long 0 0. " DSC "  "0 ,1 "
;tree.end

;tree "EUR_CR_PDS_INV1"
base ad:0xa0308ad4
wgroup 0--3
line.long 0 "EUR_CR_PDS_INV1"
bitfld.long 0 0. " DSC "  "0 ,1 "
;tree.end

;tree "EUR_CR_PDS_INV3"
base ad:0xa0308adc
wgroup 0--3
line.long 0 "EUR_CR_PDS_INV3"
bitfld.long 0 0. " DSC "  "0 ,1 "
;tree.end

;tree "EUR_CR_PDS_INV_CSC"
base ad:0xa0308ae0
wgroup 0--3
line.long 0 "EUR_CR_PDS_INV_CSC"
bitfld.long 0 0. " KICK "  "0 ,1 "
;tree.end

;tree "EUR_CR_PDS_DMS_DYNAMIC_SCHEDULE"
base ad:0xa0308ae4
group 0--3
line.long 0 "EUR_CR_PDS_DMS_DYNAMIC_SCHEDULE"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_EVENT_KICKER"
base ad:0xa0308ac4
group 0--3
line.long 0 "EUR_CR_EVENT_KICKER"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_EVENT_KICK"
base ad:0xa0308ac8
group 0--3
line.long 0 "EUR_CR_EVENT_KICK"
bitfld.long 0 0. " NOW "  "0 ,1 "
;tree.end

;tree "EUR_CR_EVENT_KICK1"
base ad:0xa0308ab0
group 0--3
line.long 0 "EUR_CR_EVENT_KICK1"
hexfld.byte 0 " NOW "
;tree.end

;tree "EUR_CR_EVENT_KICK2"
base ad:0xa0308ac0
group 0--3
line.long 0 "EUR_CR_EVENT_KICK2"
bitfld.long 0 0. " NOW "  "0 ,1 "
;tree.end

;tree "EUR_CR_EVENT_KICK3"
base ad:0xa0308ad8
group 0--3
line.long 0 "EUR_CR_EVENT_KICK3"
bitfld.long 0 0. " NOW "  "0 ,1 "
;tree.end

;tree "EUR_CR_MICRO_DATA_BASE"
base ad:0xa0308bb0
group 0--3
line.long 0 "EUR_CR_MICRO_DATA_BASE"
bitfld.long 0 12.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_EVENT_KICK4"
base ad:0xa0308aac
group 0--3
line.long 0 "EUR_CR_EVENT_KICK4"
bitfld.long 0 0. " DPM_3D_MEM_FREE "  "0 ,1 "
bitfld.long 0 1. " DPM_OUT_OF_MEMORY_MT "  "0 ,1 "
bitfld.long 0 2. " DPM_OUT_OF_MEMORY_GBL "  "0 ,1 "
bitfld.long 0 3. " DPM_REACHED_MEM_THRESH "  "0 ,1 "
bitfld.long 0 12. " TA_TERMINATE "  "0 ,1 "
bitfld.long 0 13. " TA_FINISHED "  "0 ,1 "
bitfld.long 0 18. " PIXELBE_END_RENDER "  "0 ,1 "
;tree.end

;tree "EUR_CR_EVENT_TIMER"
base ad:0xa0308acc
group 0--3
line.long 0 "EUR_CR_EVENT_TIMER"
bitfld.long 0 0.--23. " VALUE "  " "
bitfld.long 0 24. " ENABLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_LOOPBACK"
base ad:0xa0308b04
rgroup 0--3
line.long 0 "EUR_CR_LOOPBACK"
bitfld.long 0 0. " STATUS "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE0_SERV_PIXEL"
base ad:0xa0308b08
rgroup 0--3
line.long 0 "EUR_CR_USE0_SERV_PIXEL"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE0_SERV_VERTEX"
base ad:0xa0308b0c
rgroup 0--3
line.long 0 "EUR_CR_USE0_SERV_VERTEX"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE0_SERV_EVENT"
base ad:0xa0308b10
rgroup 0--3
line.long 0 "EUR_CR_USE0_SERV_EVENT"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE1_SERV_PIXEL"
base ad:0xa0308b14
rgroup 0--3
line.long 0 "EUR_CR_USE1_SERV_PIXEL"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE1_SERV_VERTEX"
base ad:0xa0308b18
rgroup 0--3
line.long 0 "EUR_CR_USE1_SERV_VERTEX"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE1_SERV_EVENT"
base ad:0xa0308b1c
rgroup 0--3
line.long 0 "EUR_CR_USE1_SERV_EVENT"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE_FILTER2_LEFT"
base ad:0xa0308b20
group 0--3
line.long 0 "EUR_CR_USE_FILTER2_LEFT"
hexfld.byte 0 " TAP3 "
hexfld.byte 3 " TAP0 "
;tree.end

;tree "EUR_CR_USE_FILTER2_RIGHT"
base ad:0xa0308b24
group 0--3
line.long 0 "EUR_CR_USE_FILTER2_RIGHT"
hexfld.byte 1 " TAP6 "
;tree.end

;tree "EUR_CR_USE_FILTER2_EXTRA"
base ad:0xa0308b28
group 0--3
line.long 0 "EUR_CR_USE_FILTER2_EXTRA"
bitfld.long 0 0.--3. " SHR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--19. " CONSTANT "  " "
;tree.end

;tree "EUR_CR_PDS_EVDM_PC_BASE"
base ad:0xa0308b2c
rgroup 0--3
line.long 0 "EUR_CR_PDS_EVDM_PC_BASE"
bitfld.long 0 0.--29. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_USE_MOE"
base ad:0xa0308b30
group 0--3
line.long 0 "EUR_CR_USE_MOE"
bitfld.long 0 8. " CFASEL "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE_RESET_VTXCNT"
base ad:0xa0308b34
wgroup 0--3
line.long 0 "EUR_CR_USE_RESET_VTXCNT"
bitfld.long 0 0. " ALL "  "0 ,1 "
bitfld.long 0 1.--2. " PIPESEL "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--6. " PARTNUM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_PDS_PDM_PC_BASE"
base ad:0xa0308b38
rgroup 0--3
line.long 0 "EUR_CR_PDS_PDM_PC_BASE"
bitfld.long 0 0.--29. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_USE_GLOBCOM0"
base ad:0xa0308b40
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM0"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM1"
base ad:0xa0308b44
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM1"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM2"
base ad:0xa0308b48
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM2"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM3"
base ad:0xa0308b4c
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM3"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM4"
base ad:0xa0308b50
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM4"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM5"
base ad:0xa0308b54
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM5"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM6"
base ad:0xa0308b58
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM6"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM7"
base ad:0xa0308b5c
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM7"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM8"
base ad:0xa0308b60
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM8"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM9"
base ad:0xa0308b64
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM9"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM10"
base ad:0xa0308b68
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM10"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM11"
base ad:0xa0308b6c
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM11"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM12"
base ad:0xa0308b70
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM12"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM13"
base ad:0xa0308b74
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM13"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM14"
base ad:0xa0308b78
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM14"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE_GLOBCOM15"
base ad:0xa0308b7c
group 0--3
line.long 0 "EUR_CR_USE_GLOBCOM15"
hexfld.byte 0 " COUNT "
;tree.end

;tree "EUR_CR_USE2_DM_SLOT"
base ad:0xa0308b80
rgroup 0--3
line.long 0 "EUR_CR_USE2_DM_SLOT"
bitfld.long 0 2.--3. " 1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " 2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " 3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " 4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " 5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " 6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " 7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " 8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " 9 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " 10 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " 11 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " 12 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " 13 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " 14 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " 15 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE3_DM_SLOT"
base ad:0xa0308b84
rgroup 0--3
line.long 0 "EUR_CR_USE3_DM_SLOT"
bitfld.long 0 2.--3. " 1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 4.--5. " 2 "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--7. " 3 "  "0 ,1 ,2 ,3 "
bitfld.long 0 8.--9. " 4 "  "0 ,1 ,2 ,3 "
bitfld.long 0 10.--11. " 5 "  "0 ,1 ,2 ,3 "
bitfld.long 0 12.--13. " 6 "  "0 ,1 ,2 ,3 "
bitfld.long 0 14.--15. " 7 "  "0 ,1 ,2 ,3 "
bitfld.long 0 16.--17. " 8 "  "0 ,1 ,2 ,3 "
bitfld.long 0 18.--19. " 9 "  "0 ,1 ,2 ,3 "
bitfld.long 0 20.--21. " 10 "  "0 ,1 ,2 ,3 "
bitfld.long 0 22.--23. " 11 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24.--25. " 12 "  "0 ,1 ,2 ,3 "
bitfld.long 0 26.--27. " 13 "  "0 ,1 ,2 ,3 "
bitfld.long 0 28.--29. " 14 "  "0 ,1 ,2 ,3 "
bitfld.long 0 30.--31. " 15 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EUR_CR_USE2_SERV_PIXEL"
base ad:0xa0308b88
rgroup 0--3
line.long 0 "EUR_CR_USE2_SERV_PIXEL"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE2_SERV_VERTEX"
base ad:0xa0308b8c
rgroup 0--3
line.long 0 "EUR_CR_USE2_SERV_VERTEX"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE2_SERV_EVENT"
base ad:0xa0308b90
rgroup 0--3
line.long 0 "EUR_CR_USE2_SERV_EVENT"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE3_SERV_PIXEL"
base ad:0xa0308b94
rgroup 0--3
line.long 0 "EUR_CR_USE3_SERV_PIXEL"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE3_SERV_VERTEX"
base ad:0xa0308b98
rgroup 0--3
line.long 0 "EUR_CR_USE3_SERV_VERTEX"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE3_SERV_EVENT"
base ad:0xa0308b9c
rgroup 0--3
line.long 0 "EUR_CR_USE3_SERV_EVENT"
hexfld.word 0 " COUNT "
bitfld.long 0 16. " EMPTY "  "0 ,1 "
;tree.end

;tree "EUR_CR_USE_SPRV"
base ad:0xa0308ba0
group 0--3
line.long 0 "EUR_CR_USE_SPRV"
bitfld.long 0 0.--19. " VECTOR "  " "
;tree.end

;tree "EUR_CR_PDS_STATUS"
base ad:0xa0308ba4
group 0--3
line.long 0 "EUR_CR_PDS_STATUS"
bitfld.long 0 0. " RENDER_IN_PROGRESS "  "0 ,1 "
bitfld.long 0 1. " CSWITCH_STORE_END_RENDER "  "0 ,1 "
bitfld.long 0 2. " RENDER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " CSWITCH_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " IPF_COMPLETED "  "0 ,1 "
;tree.end

;tree "EUR_CR_PDS_CONTEXT_STORE"
base ad:0xa0308ba8
group 0--3
line.long 0 "EUR_CR_PDS_CONTEXT_STORE"
bitfld.long 0 0. " DISABLE "  "0 ,1 "
bitfld.long 0 1. " TILE_ONLY "  "0 ,1 "
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_PDS_CONTEXT_RESUME"
base ad:0xa0308bac
group 0--3
line.long 0 "EUR_CR_PDS_CONTEXT_RESUME"
bitfld.long 0 0. " VALID_STREAM "  "0 ,1 "
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_USE_SECURITY"
base ad:0xa0308bb4
group 0--3
line.long 0 "EUR_CR_USE_SECURITY"
bitfld.long 0 0. " DISABLE "  "0 ,1 "
;tree.end

;tree "EUR_CR_BIF_CTRL"
base ad:0xa0308c00
group 0--3
line.long 0 "EUR_CR_BIF_CTRL"
bitfld.long 0 0. " NOREORDER "  "0 ,1 "
bitfld.long 0 1. " PAUSE "  "0 ,1 "
bitfld.long 0 4. " CLEAR_FAULT "  "0 ,1 "
bitfld.long 0 9. " MMU_BYPASS_VDM "  "0 ,1 "
bitfld.long 0 10. " MMU_BYPASS_TA "  "0 ,1 "
bitfld.long 0 12. " MMU_BYPASS_PBE "  "0 ,1 "
bitfld.long 0 13. " MMU_BYPASS_TSPP "  "0 ,1 "
bitfld.long 0 14. " MMU_BYPASS_ISP "  "0 ,1 "
bitfld.long 0 15. " MMU_BYPASS_USE "  "0 ,1 "
bitfld.long 0 16. " MMU_BYPASS_PTLA "  "0 ,1 "
bitfld.long 0 17. " MMU_BYPASS_MASTER_VDM "  "0 ,1 "
bitfld.long 0 18. " MMU_BYPASS_MASTER_IPF "  "0 ,1 "
bitfld.long 0 19. " MMU_BYPASS_MASTER_DPM "  "0 ,1 "
;tree.end

;tree "EUR_CR_BIF_INT_STAT"
base ad:0xa0308c04
rgroup 0--3
line.long 0 "EUR_CR_BIF_INT_STAT"
bitfld.long 0 0.--13. " FAULT_REQ "  " "
bitfld.long 0 16.--18. " FAULT_TYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 19. " FLUSH_COMPLETE "  "0 ,1 "
;tree.end

;tree "EUR_CR_BIF_FAULT"
base ad:0xa0308c08
rgroup 0--3
line.long 0 "EUR_CR_BIF_FAULT"
bitfld.long 0 0.--3. " CID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--8. " SB "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_BIF_CTRL_INVAL"
base ad:0xa0308c34
group 0--3
line.long 0 "EUR_CR_BIF_CTRL_INVAL"
bitfld.long 0 2. " PTE "  "0 ,1 "
bitfld.long 0 3. " ALL "  "0 ,1 "
;tree.end

;tree "EUR_CR_BIF_TILE0"
base ad:0xa0308c0c
group 0--3
line.long 0 "EUR_CR_BIF_TILE0"
bitfld.long 0 0.--11. " MIN_ADDRESS "  " "
bitfld.long 0 12.--23. " MAX_ADDRESS "  " "
bitfld.long 0 24.--27. " CFG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_BIF_TILE1"
base ad:0xa0308c10
group 0--3
line.long 0 "EUR_CR_BIF_TILE1"
bitfld.long 0 0.--11. " MIN_ADDRESS "  " "
bitfld.long 0 12.--23. " MAX_ADDRESS "  " "
bitfld.long 0 24.--27. " CFG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_BIF_TILE2"
base ad:0xa0308c14
group 0--3
line.long 0 "EUR_CR_BIF_TILE2"
bitfld.long 0 0.--11. " MIN_ADDRESS "  " "
bitfld.long 0 12.--23. " MAX_ADDRESS "  " "
bitfld.long 0 24.--27. " CFG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_BIF_TILE3"
base ad:0xa0308c18
group 0--3
line.long 0 "EUR_CR_BIF_TILE3"
bitfld.long 0 0.--11. " MIN_ADDRESS "  " "
bitfld.long 0 12.--23. " MAX_ADDRESS "  " "
bitfld.long 0 24.--27. " CFG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_BIF_TILE4"
base ad:0xa0308c1c
group 0--3
line.long 0 "EUR_CR_BIF_TILE4"
bitfld.long 0 0.--11. " MIN_ADDRESS "  " "
bitfld.long 0 12.--23. " MAX_ADDRESS "  " "
bitfld.long 0 24.--27. " CFG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_BIF_TILE5"
base ad:0xa0308c20
group 0--3
line.long 0 "EUR_CR_BIF_TILE5"
bitfld.long 0 0.--11. " MIN_ADDRESS "  " "
bitfld.long 0 12.--23. " MAX_ADDRESS "  " "
bitfld.long 0 24.--27. " CFG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_BIF_TILE6"
base ad:0xa0308c24
group 0--3
line.long 0 "EUR_CR_BIF_TILE6"
bitfld.long 0 0.--11. " MIN_ADDRESS "  " "
bitfld.long 0 12.--23. " MAX_ADDRESS "  " "
bitfld.long 0 24.--27. " CFG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_BIF_TILE7"
base ad:0xa0308c28
group 0--3
line.long 0 "EUR_CR_BIF_TILE7"
bitfld.long 0 0.--11. " MIN_ADDRESS "  " "
bitfld.long 0 12.--23. " MAX_ADDRESS "  " "
bitfld.long 0 24.--27. " CFG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_BIF_TILE8"
base ad:0xa0308c2c
group 0--3
line.long 0 "EUR_CR_BIF_TILE8"
bitfld.long 0 0.--11. " MIN_ADDRESS "  " "
bitfld.long 0 12.--23. " MAX_ADDRESS "  " "
bitfld.long 0 24.--27. " CFG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_BIF_TILE9"
base ad:0xa0308c30
group 0--3
line.long 0 "EUR_CR_BIF_TILE9"
bitfld.long 0 0.--11. " MIN_ADDRESS "  " "
bitfld.long 0 12.--23. " MAX_ADDRESS "  " "
bitfld.long 0 24.--27. " CFG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_BIF_DIR_LIST_BASE0"
base ad:0xa0308c84
group 0--3
line.long 0 "EUR_CR_BIF_DIR_LIST_BASE0"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_BIF_DIR_LIST_BASE1"
base ad:0xa0308c38
group 0--3
line.long 0 "EUR_CR_BIF_DIR_LIST_BASE1"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_BIF_DIR_LIST_BASE2"
base ad:0xa0308c3c
group 0--3
line.long 0 "EUR_CR_BIF_DIR_LIST_BASE2"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_BIF_DIR_LIST_BASE3"
base ad:0xa0308c40
group 0--3
line.long 0 "EUR_CR_BIF_DIR_LIST_BASE3"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_BIF_DIR_LIST_BASE4"
base ad:0xa0308c44
group 0--3
line.long 0 "EUR_CR_BIF_DIR_LIST_BASE4"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_BIF_DIR_LIST_BASE5"
base ad:0xa0308c48
group 0--3
line.long 0 "EUR_CR_BIF_DIR_LIST_BASE5"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_BIF_DIR_LIST_BASE6"
base ad:0xa0308c4c
group 0--3
line.long 0 "EUR_CR_BIF_DIR_LIST_BASE6"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_BIF_DIR_LIST_BASE7"
base ad:0xa0308c50
group 0--3
line.long 0 "EUR_CR_BIF_DIR_LIST_BASE7"
bitfld.long 0 12.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_BIF_BANK_SET"
base ad:0xa0308c74
group 0--3
line.long 0 "EUR_CR_BIF_BANK_SET"
bitfld.long 0 0. " SELECT_2D "  "0 ,1 "
bitfld.long 0 2.--3. " SELECT_3D "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " SELECT_HOST "  "0 ,1 "
bitfld.long 0 6.--7. " SELECT_TA "  "0 ,1 ,2 ,3 "
bitfld.long 0 8. " SELECT_EDM "  "0 ,1 "
bitfld.long 0 9. " SELECT_DPM_LSS "  "0 ,1 "
;tree.end

;tree "EUR_CR_BIF_BANK0"
base ad:0xa0308c78
group 0--3
line.long 0 "EUR_CR_BIF_BANK0"
bitfld.long 0 0.--3. " INDEX_EDM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " INDEX_TA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " INDEX_3D "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16.--19. " INDEX_PTLA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_BIF_BANK1"
base ad:0xa0308c7c
group 0--3
line.long 0 "EUR_CR_BIF_BANK1"
bitfld.long 0 0.--3. " INDEX_EDM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " INDEX_TA "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 12.--15. " INDEX_3D "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_BIF_TA_REQ_BASE"
base ad:0xa0308c90
group 0--3
line.long 0 "EUR_CR_BIF_TA_REQ_BASE"
bitfld.long 0 20.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_BIF_MEM_REQ_STAT"
base ad:0xa0308ca8
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_REQ_STAT"
hexfld.byte 0 " READS "
;tree.end

;tree "EUR_CR_BIF_3D_REQ_BASE"
base ad:0xa0308cac
group 0--3
line.long 0 "EUR_CR_BIF_3D_REQ_BASE"
bitfld.long 0 20.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_BIF_ZLS_REQ_BASE"
base ad:0xa0308cb0
group 0--3
line.long 0 "EUR_CR_BIF_ZLS_REQ_BASE"
bitfld.long 0 20.--31. " ADDR "  " "
;tree.end

;tree "EUR_CR_BIF_BANK_STATUS"
base ad:0xa0308cb4
rgroup 0--3
line.long 0 "EUR_CR_BIF_BANK_STATUS"
bitfld.long 0 0. " 3D_CURRENT_BANK "  "0 ,1 "
bitfld.long 0 1. " TA_CURRENT_BANK "  "0 ,1 "
;tree.end

;tree "EUR_CR_BIF_SIG0"
base ad:0xa0308cc0
rgroup 0--3
line.long 0 "EUR_CR_BIF_SIG0"
hexfld.long 0 " WDATA_SIGNATURE "
;tree.end

;tree "EUR_CR_BIF_SIG1"
base ad:0xa0308cc4
rgroup 0--3
line.long 0 "EUR_CR_BIF_SIG1"
hexfld.long 0 " ADDR_SIGNATURE "
;tree.end

;tree "EUR_CR_BIF_MMU_CTRL"
base ad:0xa0308cd0
group 0--3
line.long 0 "EUR_CR_BIF_MMU_CTRL"
bitfld.long 0 0. " PREFETCHING_ON "  "0 ,1 "
bitfld.long 0 1.--2. " ADDR_HASH_MODE "  "0 ,1 ,2 ,3 "
bitfld.long 0 3. " ENABLE_WRITE_BURST_COLLATE "  "0 ,1 "
bitfld.long 0 4. " ENABLE_DC_TLB "  "0 ,1 "
bitfld.long 0 5. " DISABLE_BURST_EXP "  "0 ,1 "
;tree.end

;tree "EUR_CR_EMU_CYCLE_COUNT"
base ad:0xa0308e80
group 0--3
line.long 0 "EUR_CR_EMU_CYCLE_COUNT"
bitfld.long 0 0. " RESET "  "0 ,1 "
;tree.end

;tree "EUR_CR_EMU_TA_PHASE"
base ad:0xa0308e84
rgroup 0--3
line.long 0 "EUR_CR_EMU_TA_PHASE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_EMU_3D_PHASE"
base ad:0xa0308e88
rgroup 0--3
line.long 0 "EUR_CR_EMU_3D_PHASE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_EMU_TA_CYCLE"
base ad:0xa0308e8c
rgroup 0--3
line.long 0 "EUR_CR_EMU_TA_CYCLE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_EMU_3D_CYCLE"
base ad:0xa0308e90
rgroup 0--3
line.long 0 "EUR_CR_EMU_3D_CYCLE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_EMU_MEM_READ"
base ad:0xa0308eb4
rgroup 0--3
line.long 0 "EUR_CR_EMU_MEM_READ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_EMU_TA_OR_3D_CYCLE"
base ad:0xa0308eb8
rgroup 0--3
line.long 0 "EUR_CR_EMU_TA_OR_3D_CYCLE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_EMU_MEM_WRITE"
base ad:0xa0308ebc
rgroup 0--3
line.long 0 "EUR_CR_EMU_MEM_WRITE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_EMU_MEM_BYTE_WRITE"
base ad:0xa0308ec0
rgroup 0--3
line.long 0 "EUR_CR_EMU_MEM_BYTE_WRITE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_EMU_MEM_STALL"
base ad:0xa0308ec4
rgroup 0--3
line.long 0 "EUR_CR_EMU_MEM_STALL"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_CYCLE_COUNT"
base ad:0xa0308ec8
group 0--3
line.long 0 "EUR_CR_BIF_CYCLE_COUNT"
bitfld.long 0 0. " RESET "  "0 ,1 "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_MMU"
base ad:0xa0308ecc
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_MMU"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_CACHE"
base ad:0xa0308ed0
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_CACHE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_TA"
base ad:0xa0308ed4
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_TA"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_WRITE_TA"
base ad:0xa0308ed8
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_WRITE_TA"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_VDM"
base ad:0xa0308edc
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_VDM"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_PBE"
base ad:0xa0308ee0
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_PBE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_WRITE_PBE"
base ad:0xa0308ee4
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_WRITE_PBE"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_TSP"
base ad:0xa0308ee8
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_TSP"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_ISP"
base ad:0xa0308eec
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_ISP"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_ISPZ"
base ad:0xa0308ef0
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_ISPZ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_WRITE_ISPZ"
base ad:0xa0308ef4
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_WRITE_ISPZ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_USE0"
base ad:0xa0308ef8
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_USE0"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_WRITE_USE0"
base ad:0xa0308efc
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_WRITE_USE0"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_USE1"
base ad:0xa0308f08
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_USE1"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_WRITE_USE1"
base ad:0xa0308f0c
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_WRITE_USE1"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_USEC"
base ad:0xa0308f10
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_USEC"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_PDS"
base ad:0xa0308f14
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_PDS"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_USE2"
base ad:0xa0308f18
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_USE2"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_WRITE_USE2"
base ad:0xa0308f1c
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_WRITE_USE2"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_READ_USE3"
base ad:0xa0308f20
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_READ_USE3"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_WRITE_USE3"
base ad:0xa0308f24
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_WRITE_USE3"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_USEC_BIF_CYCLE_COUNT"
base ad:0xa0308f28
group 0--3
line.long 0 "EUR_CR_USEC_BIF_CYCLE_COUNT"
bitfld.long 0 0. " RESET "  "0 ,1 "
;tree.end

;tree "EUR_CR_USEC_BIF_VERTEX_READ"
base ad:0xa0308f2c
rgroup 0--3
line.long 0 "EUR_CR_USEC_BIF_VERTEX_READ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_USEC_BIF_PIXEL_READ"
base ad:0xa0308f30
rgroup 0--3
line.long 0 "EUR_CR_USEC_BIF_PIXEL_READ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_USEC_BIF_EVENT_READ"
base ad:0xa0308f34
rgroup 0--3
line.long 0 "EUR_CR_USEC_BIF_EVENT_READ"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_THREE_D_COUNT"
base ad:0xa0308f38
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_THREE_D_COUNT"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_OVER_LAPPED_TA_READ_COUNT"
base ad:0xa0308f3c
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_OVER_LAPPED_TA_READ_COUNT"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BIF_MEM_OVER_LAPPED_TA_WRITE_COUNT"
base ad:0xa0308f40
rgroup 0--3
line.long 0 "EUR_CR_BIF_MEM_OVER_LAPPED_TA_WRITE_COUNT"
hexfld.long 0 " COUNT "
;tree.end

;tree "EUR_CR_BREAKPOINT0_START"
base ad:0xa0308f44
group 0--3
line.long 0 "EUR_CR_BREAKPOINT0_START"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_BREAKPOINT0_END"
base ad:0xa0308f48
group 0--3
line.long 0 "EUR_CR_BREAKPOINT0_END"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_BREAKPOINT0"
base ad:0xa0308f4c
group 0--3
line.long 0 "EUR_CR_BREAKPOINT0"
bitfld.long 0 0. " CTRL_RENABLE "  "0 ,1 "
bitfld.long 0 1. " CTRL_WENABLE "  "0 ,1 "
bitfld.long 0 2. " CTRL_TRAPENABLE "  "0 ,1 "
bitfld.long 0 3.--5. " MASK_DM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_BREAKPOINT1_START"
base ad:0xa0308f50
group 0--3
line.long 0 "EUR_CR_BREAKPOINT1_START"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_BREAKPOINT1_END"
base ad:0xa0308f54
group 0--3
line.long 0 "EUR_CR_BREAKPOINT1_END"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_BREAKPOINT1"
base ad:0xa0308f58
group 0--3
line.long 0 "EUR_CR_BREAKPOINT1"
bitfld.long 0 0. " CTRL_RENABLE "  "0 ,1 "
bitfld.long 0 1. " CTRL_WENABLE "  "0 ,1 "
bitfld.long 0 2. " CTRL_TRAPENABLE "  "0 ,1 "
bitfld.long 0 3.--5. " MASK_DM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_BREAKPOINT2_START"
base ad:0xa0308f5c
group 0--3
line.long 0 "EUR_CR_BREAKPOINT2_START"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_BREAKPOINT2_END"
base ad:0xa0308f60
group 0--3
line.long 0 "EUR_CR_BREAKPOINT2_END"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_BREAKPOINT2"
base ad:0xa0308f64
group 0--3
line.long 0 "EUR_CR_BREAKPOINT2"
bitfld.long 0 0. " CTRL_RENABLE "  "0 ,1 "
bitfld.long 0 1. " CTRL_WENABLE "  "0 ,1 "
bitfld.long 0 2. " CTRL_TRAPENABLE "  "0 ,1 "
bitfld.long 0 3.--5. " MASK_DM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_BREAKPOINT3_START"
base ad:0xa0308f68
group 0--3
line.long 0 "EUR_CR_BREAKPOINT3_START"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_BREAKPOINT3_END"
base ad:0xa0308f6c
group 0--3
line.long 0 "EUR_CR_BREAKPOINT3_END"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_BREAKPOINT3"
base ad:0xa0308f70
group 0--3
line.long 0 "EUR_CR_BREAKPOINT3"
bitfld.long 0 0. " CTRL_RENABLE "  "0 ,1 "
bitfld.long 0 1. " CTRL_WENABLE "  "0 ,1 "
bitfld.long 0 2. " CTRL_TRAPENABLE "  "0 ,1 "
bitfld.long 0 3.--5. " MASK_DM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EUR_CR_BREAKPOINT_READ"
base ad:0xa0308f74
group 0--3
line.long 0 "EUR_CR_BREAKPOINT_READ"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_BREAKPOINT_TRAP"
base ad:0xa0308f78
wgroup 0--3
line.long 0 "EUR_CR_BREAKPOINT_TRAP"
bitfld.long 0 0. " WRNOTIFY "  "0 ,1 "
bitfld.long 0 1. " CONTINUE "  "0 ,1 "
;tree.end

;tree "EUR_CR_BREAKPOINT"
base ad:0xa0308f7c
group 0--3
line.long 0 "EUR_CR_BREAKPOINT"
bitfld.long 0 2. " TRAPPED "  "0 ,1 "
bitfld.long 0 3. " UNTRAPPED "  "0 ,1 "
bitfld.long 0 4.--5. " ID "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--9. " MODULE_ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EUR_CR_BREAKPOINT_TRAP_INFO0"
base ad:0xa0308f80
rgroup 0--3
line.long 0 "EUR_CR_BREAKPOINT_TRAP_INFO0"
bitfld.long 0 4.--31. " ADDRESS "  " "
;tree.end

;tree "EUR_CR_BREAKPOINT_TRAP_INFO1"
base ad:0xa0308f84
rgroup 0--3
line.long 0 "EUR_CR_BREAKPOINT_TRAP_INFO1"
bitfld.long 0 0.--1. " DATA_MASTER "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--6. " TAG "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 7.--8. " NUMBER "  "0 ,1 ,2 ,3 "
bitfld.long 0 9.--13. " SIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "SKE"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CR"
base ad:0x80006000
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SKEN0 "  "0 ,1 "
bitfld.long 0 1. " SKEN1 "  "0 ,1 "
bitfld.long 0 2. " KPASEN "  "0 ,1 "
bitfld.long 0 3.--5. " KPCN "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6. " KPMLT "  "0 ,1 "
bitfld.long 0 7. " KPSON "  "0 ,1 "
bitfld.long 0 8. " KPOC0 "  "0 ,1 "
bitfld.long 0 9. " KPOC1 "  "0 ,1 "
bitfld.long 0 10. " KPOC2 "  "0 ,1 "
bitfld.long 0 11. " KPOC3 "  "0 ,1 "
bitfld.long 0 12. " KPOC4 "  "0 ,1 "
bitfld.long 0 13. " KPOC5 "  "0 ,1 "
bitfld.long 0 14. " KPOC6 "  "0 ,1 "
bitfld.long 0 15. " KPOC7 "  "0 ,1 "
;tree.end

;tree "VAL0"
base ad:0x80006004
group 0--3
line.long 0 "VAL0"
hexfld.byte 0 " SKEVAL0 "
bitfld.long 0 14. " UDF0 "  "0 ,1 "
bitfld.long 0 15. " OVF0 "  "0 ,1 "
;tree.end

;tree "VAL1"
base ad:0x80006008
group 0--3
line.long 0 "VAL1"
hexfld.byte 0 " SKEVAL1 "
bitfld.long 0 14. " UDF1 "  "0 ,1 "
bitfld.long 0 15. " OVF1 "  "0 ,1 "
;tree.end

;tree "DBCR"
base ad:0x8000600c
group 0--3
line.long 0 "DBCR"
hexfld.byte 0 " SKEDBC "
hexfld.byte 1 " KPDBC "
;tree.end

;tree "IMSC"
base ad:0x80006010
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " SKEIM0 "  "0 ,1 "
bitfld.long 0 1. " SKEIM1 "  "0 ,1 "
bitfld.long 0 2. " KPIMA "  "0 ,1 "
bitfld.long 0 3. " KPIMS "  "0 ,1 "
;tree.end

;tree "RIS"
base ad:0x80006014
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " SKERIS0 "  "0 ,1 "
bitfld.long 0 1. " SKERIS1 "  "0 ,1 "
bitfld.long 0 2. " KPRISA "  "0 ,1 "
bitfld.long 0 3. " KPRISS "  "0 ,1 "
;tree.end

;tree "MIS"
base ad:0x80006018
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " SKEMIS0 "  "0 ,1 "
bitfld.long 0 1. " SKEMIS1 "  "0 ,1 "
bitfld.long 0 2. " KPMISA "  "0 ,1 "
bitfld.long 0 3. " KPMISS "  "0 ,1 "
;tree.end

;tree "ICR"
base ad:0x8000601c
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " SKEIC0 "  "0 ,1 "
bitfld.long 0 1. " SKEIC1 "  "0 ,1 "
bitfld.long 0 2. " KPICA "  "0 ,1 "
bitfld.long 0 3. " KPICS "  "0 ,1 "
;tree.end

;tree "ASR0"
base ad:0x80006020
group 0--3
line.long 0 "ASR0"
hexfld.byte 0 " KPRVAL0 "
hexfld.byte 1 " KPRVAL1 "
;tree.end

;tree "ASR1"
base ad:0x80006024
group 0--3
line.long 0 "ASR1"
hexfld.byte 0 " KPRVAL2 "
hexfld.byte 1 " KPRVAL3 "
;tree.end

;tree "ASR2"
base ad:0x80006028
group 0--3
line.long 0 "ASR2"
hexfld.byte 0 " KPRVAL4 "
hexfld.byte 1 " KPRVAL5 "
;tree.end

;tree "ASR3"
base ad:0x8000602c
group 0--3
line.long 0 "ASR3"
hexfld.byte 0 " KPRVAL6 "
hexfld.byte 1 " KPRVAL7 "
;tree.end

;tree "ITCR"
base ad:0x80006080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " RITEN "  "0 ,1 "
bitfld.long 0 1. " KBD_ERR "  "0 ,1 "
;tree.end

;tree "ITIP"
base ad:0x80006084
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " PKI0 "  "0 ,1 "
bitfld.long 0 1. " PKI1 "  "0 ,1 "
bitfld.long 0 2. " PKI2 "  "0 ,1 "
bitfld.long 0 3. " PKI3 "  "0 ,1 "
bitfld.long 0 4. " PKI4 "  "0 ,1 "
bitfld.long 0 5. " PKI5 "  "0 ,1 "
bitfld.long 0 6. " PKI6 "  "0 ,1 "
bitfld.long 0 7. " PKI7 "  "0 ,1 "
bitfld.long 0 8. " SKA0 "  "0 ,1 "
bitfld.long 0 9. " SKB0 "  "0 ,1 "
bitfld.long 0 10. " SKA1 "  "0 ,1 "
bitfld.long 0 11. " SKB1 "  "0 ,1 "
;tree.end

;tree "ITOP"
base ad:0x80006088
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " KPO0 "  "0 ,1 "
bitfld.long 0 1. " KPO1 "  "0 ,1 "
bitfld.long 0 2. " KPO2 "  "0 ,1 "
bitfld.long 0 3. " KPO3 "  "0 ,1 "
bitfld.long 0 4. " KPO4 "  "0 ,1 "
bitfld.long 0 5. " KPO5 "  "0 ,1 "
bitfld.long 0 6. " KPO6 "  "0 ,1 "
bitfld.long 0 7. " KPO7 "  "0 ,1 "
bitfld.long 0 8. " SKEINTR0 "  "0 ,1 "
bitfld.long 0 9. " SKEINTR1 "  "0 ,1 "
bitfld.long 0 10. " KPINTR "  "0 ,1 "
;tree.end

;tree "SKEPeriphID0"
base ad:0x80006fe0
rgroup 0--3
line.long 0 "SKEPeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "SKEPeriphID1"
base ad:0x80006fe4
rgroup 0--3
line.long 0 "SKEPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "SKEPeriphID2"
base ad:0x80006fe8
rgroup 0--3
line.long 0 "SKEPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "SKEPeriphID3"
base ad:0x80006fec
rgroup 0--3
line.long 0 "SKEPeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "SKEPCellID0"
base ad:0x80006ff0
rgroup 0--3
line.long 0 "SKEPCellID0"
hexfld.byte 0 " SKEPCellID0 "
;tree.end

;tree "SKEPCellID1"
base ad:0x80006ff4
rgroup 0--3
line.long 0 "SKEPCellID1"
hexfld.byte 0 " SKEPCellID1 "
;tree.end

;tree "SKEPCellID2"
base ad:0x80006ff8
rgroup 0--3
line.long 0 "SKEPCellID2"
hexfld.byte 0 " SKEPCellID2 "
;tree.end

;tree "SKEPCellID3"
base ad:0x80006ffc
rgroup 0--3
line.long 0 "SKEPCellID3"
hexfld.byte 0 " SKEPCellID3 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "SKETB"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "test_select"
base ad:0x63000000
group 0--3
line.long 0 "test_select"
bitfld.long 0 0. " test_inc_scroll0 "  "0 ,1 "
bitfld.long 0 1. " test_dec_scroll0 "  "0 ,1 "
bitfld.long 0 2. " test_inc_scroll1 "  "0 ,1 "
bitfld.long 0 3. " test_dec_scroll1 "  "0 ,1 "
;tree.end

;tree "keypad0to31"
base ad:0x63000004
group 0--3
line.long 0 "keypad0to31"
hexfld.long 0 " data "
;tree.end

;tree "keypad32to63"
base ad:0x63000008
group 0--3
line.long 0 "keypad32to63"
hexfld.long 0 " data "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "SPDIFTB"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "Status"
base ad:0x63e00000
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " DataRight "  "0 ,1 "
bitfld.long 0 1. " DataLeft "  "0 ,1 "
bitfld.long 0 2. " DatRxEnd "  "0 ,1 "
bitfld.long 0 3. " TrBoxEn "  "0 ,1 "
;tree.end

;tree "AudioLeft"
base ad:0x63e00004
rgroup 0--3
line.long 0 "AudioLeft"
bitfld.long 0 0.--23. " AudioL "  " "
;tree.end

;tree "AudioRight"
base ad:0x63e00008
rgroup 0--3
line.long 0 "AudioRight"
bitfld.long 0 0.--23. " AudioR "  " "
;tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "SPI (4 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "SPI-3"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "3CR0"
base ad:0x80129000
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

;tree "3CR1"
base ad:0x80129004
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "3DR"
base ad:0x80129008
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

;tree "3SR"
base ad:0x8012900c
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

;tree "3CPSR"
base ad:0x80129010
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

;tree "3IMSC"
base ad:0x80129014
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

;tree "3RIS"
base ad:0x80129018
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

;tree "3MIS"
base ad:0x8012901c
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

;tree "3ICR"
base ad:0x80129020
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

;tree "3DMACR"
base ad:0x80129024
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

;tree "3PeriphID0"
base ad:0x80129fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "3PeriphID1"
base ad:0x80129fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "3PeriphID2"
base ad:0x80129fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "3PeriphID3"
base ad:0x80129fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "3PCellID0"
base ad:0x80129ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
;tree.end

;tree "3PCellID1"
base ad:0x80129ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
;tree.end

;tree "3PCellID2"
base ad:0x80129ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
;tree.end

;tree "3PCellID3"
base ad:0x80129ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "SPI-2"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "2CR0"
base ad:0x80111000
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

;tree "2CR1"
base ad:0x80111004
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "2DR"
base ad:0x80111008
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

;tree "2SR"
base ad:0x8011100c
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

;tree "2CPSR"
base ad:0x80111010
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

;tree "2IMSC"
base ad:0x80111014
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

;tree "2RIS"
base ad:0x80111018
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

;tree "2MIS"
base ad:0x8011101c
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

;tree "2ICR"
base ad:0x80111020
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

;tree "2DMACR"
base ad:0x80111024
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

;tree "2PeriphID0"
base ad:0x80111fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "2PeriphID1"
base ad:0x80111fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2PeriphID2"
base ad:0x80111fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2PeriphID3"
base ad:0x80111fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "2PCellID0"
base ad:0x80111ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
;tree.end

;tree "2PCellID1"
base ad:0x80111ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
;tree.end

;tree "2PCellID2"
base ad:0x80111ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
;tree.end

;tree "2PCellID3"
base ad:0x80111ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "SPI-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1CR0"
base ad:0x80112000
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

;tree "1CR1"
base ad:0x80112004
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "1DR"
base ad:0x80112008
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

;tree "1SR"
base ad:0x8011200c
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

;tree "1CPSR"
base ad:0x80112010
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

;tree "1IMSC"
base ad:0x80112014
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

;tree "1RIS"
base ad:0x80112018
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

;tree "1MIS"
base ad:0x8011201c
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

;tree "1ICR"
base ad:0x80112020
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

;tree "1DMACR"
base ad:0x80112024
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

;tree "1PeriphID0"
base ad:0x80112fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "1PeriphID1"
base ad:0x80112fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID2"
base ad:0x80112fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID3"
base ad:0x80112fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "1PCellID0"
base ad:0x80112ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
;tree.end

;tree "1PCellID1"
base ad:0x80112ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
;tree.end

;tree "1PCellID2"
base ad:0x80112ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
;tree.end

;tree "1PCellID3"
base ad:0x80112ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "SPI-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0CR0"
base ad:0x8011a000
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

;tree "0CR1"
base ad:0x8011a004
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "0DR"
base ad:0x8011a008
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

;tree "0SR"
base ad:0x8011a00c
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

;tree "0CPSR"
base ad:0x8011a010
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

;tree "0IMSC"
base ad:0x8011a014
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

;tree "0RIS"
base ad:0x8011a018
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

;tree "0MIS"
base ad:0x8011a01c
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

;tree "0ICR"
base ad:0x8011a020
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

;tree "0DMACR"
base ad:0x8011a024
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

;tree "0PeriphID0"
base ad:0x8011afe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "0PeriphID1"
base ad:0x8011afe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID2"
base ad:0x8011afe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID3"
base ad:0x8011afec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "0PCellID0"
base ad:0x8011aff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SPIPCellID0 "
;tree.end

;tree "0PCellID1"
base ad:0x8011aff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SPIPCellID1 "
;tree.end

;tree "0PCellID2"
base ad:0x8011aff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SPIPCellID2 "
;tree.end

;tree "0PCellID3"
base ad:0x8011affc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SPIPCellID3 "
;tree.end

tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "SPITB (4 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "SPITB-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0PRE"
base ad:0x63680000
group 0--3
line.long 0 "PRE"
hexfld.byte 0 " PRESCALE "
;tree.end

;tree "0CR0"
base ad:0x63680004
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " FRF "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " ENABLE "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

;tree "0CR1"
base ad:0x63680008
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " SPO "  "0 ,1 "
bitfld.long 0 1. " SPH "  "0 ,1 "
bitfld.long 0 2.--3. " RXW "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MS "  "0 ,1 "
bitfld.long 0 5. " OD "  "0 ,1 "
;tree.end

;tree "0TDR"
base ad:0x6368000c
group 0--3
line.long 0 "TDR"
hexfld.word 0 " DATA "
;tree.end

;tree "0RDR"
base ad:0x63680010
group 0--3
line.long 0 "RDR"
hexfld.word 0 " DATA "
;tree.end

;tree "0SR"
base ad:0x63680014
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXFF "  "0 ,1 "
bitfld.long 0 2. " TXFE "  "0 ,1 "
bitfld.long 0 3. " TXFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
bitfld.long 0 5. " SPIINT "  "0 ,1 "
bitfld.long 0 6. " RXWFLG "  "0 ,1 "
bitfld.long 0 7. " RFSFLG "  "0 ,1 "
bitfld.long 0 8. " TFSFLG "  "0 ,1 "
bitfld.long 0 9. " RORFLG "  "0 ,1 "
bitfld.long 0 10. " PCLKON "  "0 ,1 "
bitfld.long 0 11. " REFCLKON "  "0 ,1 "
bitfld.long 0 12. " REFCLK1ON "  "0 ,1 "
;tree.end

;tree "0SCANMODE"
base ad:0x63680018
group 0--3
line.long 0 "SCANMODE"
bitfld.long 0 0. " SCANMODE "  "0 ,1 "
bitfld.long 0 1. " RSTMODE "  "0 ,1 "
bitfld.long 0 2. " GENCLK "  "0 ,1 "
bitfld.long 0 3. " SPICLKSEL "  "0 ,1 "
bitfld.long 0 4. " SPICLK1SEL "  "0 ,1 "
bitfld.long 0 5. " GENCLK1 "  "0 ,1 "
;tree.end

;tree "0CLKREG"
base ad:0x6368001c
group 0--3
line.long 0 "CLKREG"
hexfld.word 0 " CLKPERIOD "
;tree.end

;tree "0CR2"
base ad:0x63680020
group 0--3
line.long 0 "CR2"
hexfld.byte 0 " ESFRM "
bitfld.long 0 8. " FRC "  "0 ,1 "
bitfld.long 0 9. " SPISFRMEn "  "0 ,1 "
bitfld.long 0 10. " TIDASFRM "  "0 ,1 "
;tree.end

;tree "0CLKREG1"
base ad:0x63680024
group 0--3
line.long 0 "CLKREG1"
hexfld.word 0 " CLKPERIOD "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "SPITB-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1PRE"
base ad:0x63c80000
group 0--3
line.long 0 "PRE"
hexfld.byte 0 " PRESCALE "
;tree.end

;tree "1CR0"
base ad:0x63c80004
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " FRF "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " ENABLE "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

;tree "1CR1"
base ad:0x63c80008
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " SPO "  "0 ,1 "
bitfld.long 0 1. " SPH "  "0 ,1 "
bitfld.long 0 2.--3. " RXW "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MS "  "0 ,1 "
bitfld.long 0 5. " OD "  "0 ,1 "
;tree.end

;tree "1TDR"
base ad:0x63c8000c
group 0--3
line.long 0 "TDR"
hexfld.word 0 " DATA "
;tree.end

;tree "1RDR"
base ad:0x63c80010
group 0--3
line.long 0 "RDR"
hexfld.word 0 " DATA "
;tree.end

;tree "1SR"
base ad:0x63c80014
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXFF "  "0 ,1 "
bitfld.long 0 2. " TXFE "  "0 ,1 "
bitfld.long 0 3. " TXFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
bitfld.long 0 5. " SPIINT "  "0 ,1 "
bitfld.long 0 6. " RXWFLG "  "0 ,1 "
bitfld.long 0 7. " RFSFLG "  "0 ,1 "
bitfld.long 0 8. " TFSFLG "  "0 ,1 "
bitfld.long 0 9. " RORFLG "  "0 ,1 "
bitfld.long 0 10. " PCLKON "  "0 ,1 "
bitfld.long 0 11. " REFCLKON "  "0 ,1 "
bitfld.long 0 12. " REFCLK1ON "  "0 ,1 "
;tree.end

;tree "1SCANMODE"
base ad:0x63c80018
group 0--3
line.long 0 "SCANMODE"
bitfld.long 0 0. " SCANMODE "  "0 ,1 "
bitfld.long 0 1. " RSTMODE "  "0 ,1 "
bitfld.long 0 2. " GENCLK "  "0 ,1 "
bitfld.long 0 3. " SPICLKSEL "  "0 ,1 "
bitfld.long 0 4. " SPICLK1SEL "  "0 ,1 "
bitfld.long 0 5. " GENCLK1 "  "0 ,1 "
;tree.end

;tree "1CLKREG"
base ad:0x63c8001c
group 0--3
line.long 0 "CLKREG"
hexfld.word 0 " CLKPERIOD "
;tree.end

;tree "1CR2"
base ad:0x63c80020
group 0--3
line.long 0 "CR2"
hexfld.byte 0 " ESFRM "
bitfld.long 0 8. " FRC "  "0 ,1 "
bitfld.long 0 9. " SPISFRMEn "  "0 ,1 "
bitfld.long 0 10. " TIDASFRM "  "0 ,1 "
;tree.end

;tree "1CLKREG1"
base ad:0x63c80024
group 0--3
line.long 0 "CLKREG1"
hexfld.word 0 " CLKPERIOD "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "SPITB-2"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "2PRE"
base ad:0x63d00000
group 0--3
line.long 0 "PRE"
hexfld.byte 0 " PRESCALE "
;tree.end

;tree "2CR0"
base ad:0x63d00004
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " FRF "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " ENABLE "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

;tree "2CR1"
base ad:0x63d00008
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " SPO "  "0 ,1 "
bitfld.long 0 1. " SPH "  "0 ,1 "
bitfld.long 0 2.--3. " RXW "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MS "  "0 ,1 "
bitfld.long 0 5. " OD "  "0 ,1 "
;tree.end

;tree "2TDR"
base ad:0x63d0000c
group 0--3
line.long 0 "TDR"
hexfld.word 0 " DATA "
;tree.end

;tree "2RDR"
base ad:0x63d00010
group 0--3
line.long 0 "RDR"
hexfld.word 0 " DATA "
;tree.end

;tree "2SR"
base ad:0x63d00014
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXFF "  "0 ,1 "
bitfld.long 0 2. " TXFE "  "0 ,1 "
bitfld.long 0 3. " TXFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
bitfld.long 0 5. " SPIINT "  "0 ,1 "
bitfld.long 0 6. " RXWFLG "  "0 ,1 "
bitfld.long 0 7. " RFSFLG "  "0 ,1 "
bitfld.long 0 8. " TFSFLG "  "0 ,1 "
bitfld.long 0 9. " RORFLG "  "0 ,1 "
bitfld.long 0 10. " PCLKON "  "0 ,1 "
bitfld.long 0 11. " REFCLKON "  "0 ,1 "
bitfld.long 0 12. " REFCLK1ON "  "0 ,1 "
;tree.end

;tree "2SCANMODE"
base ad:0x63d00018
group 0--3
line.long 0 "SCANMODE"
bitfld.long 0 0. " SCANMODE "  "0 ,1 "
bitfld.long 0 1. " RSTMODE "  "0 ,1 "
bitfld.long 0 2. " GENCLK "  "0 ,1 "
bitfld.long 0 3. " SPICLKSEL "  "0 ,1 "
bitfld.long 0 4. " SPICLK1SEL "  "0 ,1 "
bitfld.long 0 5. " GENCLK1 "  "0 ,1 "
;tree.end

;tree "2CLKREG"
base ad:0x63d0001c
group 0--3
line.long 0 "CLKREG"
hexfld.word 0 " CLKPERIOD "
;tree.end

;tree "2CR2"
base ad:0x63d00020
group 0--3
line.long 0 "CR2"
hexfld.byte 0 " ESFRM "
bitfld.long 0 8. " FRC "  "0 ,1 "
bitfld.long 0 9. " SPISFRMEn "  "0 ,1 "
bitfld.long 0 10. " TIDASFRM "  "0 ,1 "
;tree.end

;tree "2CLKREG1"
base ad:0x63d00024
group 0--3
line.long 0 "CLKREG1"
hexfld.word 0 " CLKPERIOD "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "SPITB-3"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "3PRE"
base ad:0x63e80000
group 0--3
line.long 0 "PRE"
hexfld.byte 0 " PRESCALE "
;tree.end

;tree "3CR0"
base ad:0x63e80004
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " FRF "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " ENABLE "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

;tree "3CR1"
base ad:0x63e80008
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " SPO "  "0 ,1 "
bitfld.long 0 1. " SPH "  "0 ,1 "
bitfld.long 0 2.--3. " RXW "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MS "  "0 ,1 "
bitfld.long 0 5. " OD "  "0 ,1 "
;tree.end

;tree "3TDR"
base ad:0x63e8000c
group 0--3
line.long 0 "TDR"
hexfld.word 0 " DATA "
;tree.end

;tree "3RDR"
base ad:0x63e80010
group 0--3
line.long 0 "RDR"
hexfld.word 0 " DATA "
;tree.end

;tree "3SR"
base ad:0x63e80014
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXFF "  "0 ,1 "
bitfld.long 0 2. " TXFE "  "0 ,1 "
bitfld.long 0 3. " TXFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
bitfld.long 0 5. " SPIINT "  "0 ,1 "
bitfld.long 0 6. " RXWFLG "  "0 ,1 "
bitfld.long 0 7. " RFSFLG "  "0 ,1 "
bitfld.long 0 8. " TFSFLG "  "0 ,1 "
bitfld.long 0 9. " RORFLG "  "0 ,1 "
bitfld.long 0 10. " PCLKON "  "0 ,1 "
bitfld.long 0 11. " REFCLKON "  "0 ,1 "
bitfld.long 0 12. " REFCLK1ON "  "0 ,1 "
;tree.end

;tree "3SCANMODE"
base ad:0x63e80018
group 0--3
line.long 0 "SCANMODE"
bitfld.long 0 0. " SCANMODE "  "0 ,1 "
bitfld.long 0 1. " RSTMODE "  "0 ,1 "
bitfld.long 0 2. " GENCLK "  "0 ,1 "
bitfld.long 0 3. " SPICLKSEL "  "0 ,1 "
bitfld.long 0 4. " SPICLK1SEL "  "0 ,1 "
bitfld.long 0 5. " GENCLK1 "  "0 ,1 "
;tree.end

;tree "3CLKREG"
base ad:0x63e8001c
group 0--3
line.long 0 "CLKREG"
hexfld.word 0 " CLKPERIOD "
;tree.end

;tree "3CR2"
base ad:0x63e80020
group 0--3
line.long 0 "CR2"
hexfld.byte 0 " ESFRM "
bitfld.long 0 8. " FRC "  "0 ,1 "
bitfld.long 0 9. " SPISFRMEn "  "0 ,1 "
bitfld.long 0 10. " TIDASFRM "  "0 ,1 "
;tree.end

;tree "3CLKREG1"
base ad:0x63e80024
group 0--3
line.long 0 "CLKREG1"
hexfld.word 0 " CLKPERIOD "
;tree.end

tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "SSIR"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CFR0"
base ad:0x8011b000
group 0--3
line.long 0 "CFR0"
bitfld.long 0 0.--2. " MODE0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " FRMSZ0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--9. " NOC0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 24. " FIFORAS0 "  "0 ,1 "
bitfld.long 0 25. " FIFORAS1 "  "0 ,1 "
bitfld.long 0 26. " FIFORAS2 "  "0 ,1 "
bitfld.long 0 27. " FIFORAS3 "  "0 ,1 "
bitfld.long 0 28. " FIFORAS4 "  "0 ,1 "
bitfld.long 0 29. " FIFORAS5 "  "0 ,1 "
bitfld.long 0 30. " FIFORAS6 "  "0 ,1 "
bitfld.long 0 31. " FIFORAS7 "  "0 ,1 "
;tree.end

;tree "TOR0"
base ad:0x8011b004
group 0--3
line.long 0 "TOR0"
bitfld.long 0 0.--19. " TIMEOUTPER0 "  " "
;tree.end

;tree "RSR"
base ad:0x8011b008
rgroup 0--3
line.long 0 "RSR"
bitfld.long 0 0.--2. " RXSTATE0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXSTATE1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "BSR"
base ad:0x8011b00c
rgroup 0--3
line.long 0 "BSR"
bitfld.long 0 0. " TC0FU "  "0 ,1 "
bitfld.long 0 1. " TC1FU "  "0 ,1 "
bitfld.long 0 2. " TC2FU "  "0 ,1 "
bitfld.long 0 3. " TC3FU "  "0 ,1 "
bitfld.long 0 4. " TC4FU "  "0 ,1 "
bitfld.long 0 5. " TC5FU "  "0 ,1 "
bitfld.long 0 6. " TC6FU "  "0 ,1 "
bitfld.long 0 7. " TC7FU "  "0 ,1 "
bitfld.long 0 16. " TC0FE "  "0 ,1 "
bitfld.long 0 17. " TC1FE "  "0 ,1 "
bitfld.long 0 18. " TC2FE "  "0 ,1 "
bitfld.long 0 19. " TC3FE "  "0 ,1 "
bitfld.long 0 20. " TC4FE "  "0 ,1 "
bitfld.long 0 21. " TC5FE "  "0 ,1 "
bitfld.long 0 22. " TC6FE "  "0 ,1 "
bitfld.long 0 23. " TC7FE "  "0 ,1 "
;tree.end

;tree "ESR0"
base ad:0x8011b010
group 0--3
line.long 0 "ESR0"
bitfld.long 0 0. " OVR0 "  "0 ,1 "
bitfld.long 0 1. " OVR1 "  "0 ,1 "
bitfld.long 0 2. " OVR2 "  "0 ,1 "
bitfld.long 0 3. " OVR3 "  "0 ,1 "
bitfld.long 0 4. " OVR4 "  "0 ,1 "
bitfld.long 0 5. " OVR5 "  "0 ,1 "
bitfld.long 0 6. " OVR6 "  "0 ,1 "
bitfld.long 0 7. " OVR7 "  "0 ,1 "
bitfld.long 0 16. " BREAK0 "  "0 ,1 "
bitfld.long 0 17. " TIMEOUT0 "  "0 ,1 "
bitfld.long 0 18. " SIGNAL0 "  "0 ,1 "
;tree.end

;tree "DMACR"
base ad:0x8011b014
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " DMAE0 "  "0 ,1 "
bitfld.long 0 1. " DMAE1 "  "0 ,1 "
bitfld.long 0 2. " DMAE2 "  "0 ,1 "
bitfld.long 0 3. " DMAE3 "  "0 ,1 "
bitfld.long 0 4. " DMAE4 "  "0 ,1 "
bitfld.long 0 5. " DMAE5 "  "0 ,1 "
bitfld.long 0 6. " DMAE6 "  "0 ,1 "
bitfld.long 0 7. " DMAE7 "  "0 ,1 "
;tree.end

;tree "CFR1"
base ad:0x8011b018
group 0--3
line.long 0 "CFR1"
bitfld.long 0 0.--2. " MODE1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " FRMSZ1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--9. " NOC1 "  "0 ,1 ,2 ,3 "
;tree.end

;tree "TOR1"
base ad:0x8011b01c
group 0--3
line.long 0 "TOR1"
bitfld.long 0 0.--19. " TIMEOUTPER1 "  " "
;tree.end

;tree "IMSC"
base ad:0x8011b020
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RC0IM "  "0 ,1 "
bitfld.long 0 1. " RC1IM "  "0 ,1 "
bitfld.long 0 2. " RC2IM "  "0 ,1 "
bitfld.long 0 3. " RC3IM "  "0 ,1 "
bitfld.long 0 4. " RC4IM "  "0 ,1 "
bitfld.long 0 5. " RC5IM "  "0 ,1 "
bitfld.long 0 6. " RC6IM "  "0 ,1 "
bitfld.long 0 7. " RC7IM "  "0 ,1 "
bitfld.long 0 16. " EX0IM "  "0 ,1 "
bitfld.long 0 17. " EX1IM "  "0 ,1 "
;tree.end

;tree "RIS"
base ad:0x8011b024
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RC0RIS "  "0 ,1 "
bitfld.long 0 1. " RC1RIS "  "0 ,1 "
bitfld.long 0 2. " RC2RIS "  "0 ,1 "
bitfld.long 0 3. " RC3RIS "  "0 ,1 "
bitfld.long 0 4. " RC4RIS "  "0 ,1 "
bitfld.long 0 5. " RC5RIS "  "0 ,1 "
bitfld.long 0 6. " RC6RIS "  "0 ,1 "
bitfld.long 0 7. " RC7RIS "  "0 ,1 "
bitfld.long 0 16. " EXRIS0 "  "0 ,1 "
bitfld.long 0 17. " EXRIS1 "  "0 ,1 "
;tree.end

;tree "MIS"
base ad:0x8011b028
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RC0MIS "  "0 ,1 "
bitfld.long 0 1. " RC1MIS "  "0 ,1 "
bitfld.long 0 2. " RC2MIS "  "0 ,1 "
bitfld.long 0 3. " RC3MIS "  "0 ,1 "
bitfld.long 0 4. " RC4MIS "  "0 ,1 "
bitfld.long 0 5. " RC5MIS "  "0 ,1 "
bitfld.long 0 6. " RC6MIS "  "0 ,1 "
bitfld.long 0 7. " RC7MIS "  "0 ,1 "
bitfld.long 0 16. " EXMIS0 "  "0 ,1 "
bitfld.long 0 17. " EXMIS1 "  "0 ,1 "
;tree.end

;tree "IDSR"
base ad:0x8011b02c
group 0--3
line.long 0 "IDSR"
bitfld.long 0 0. " RC0IDS "  "0 ,1 "
bitfld.long 0 1. " RC1IDS "  "0 ,1 "
bitfld.long 0 2. " RC2IDS "  "0 ,1 "
bitfld.long 0 3. " RC3IDS "  "0 ,1 "
bitfld.long 0 4. " RC4IDS "  "0 ,1 "
bitfld.long 0 5. " RC5IDS "  "0 ,1 "
bitfld.long 0 6. " RC6IDS "  "0 ,1 "
bitfld.long 0 7. " RC7IDS "  "0 ,1 "
bitfld.long 0 16. " REXIDS0 "  "0 ,1 "
bitfld.long 0 17. " REXIDS1 "  "0 ,1 "
;tree.end

;tree "ESR1"
base ad:0x8011b030
group 0--3
line.long 0 "ESR1"
bitfld.long 0 0. " OVR10 "  "0 ,1 "
bitfld.long 0 1. " OVR11 "  "0 ,1 "
bitfld.long 0 2. " OVR12 "  "0 ,1 "
bitfld.long 0 3. " OVR13 "  "0 ,1 "
bitfld.long 0 4. " OVR14 "  "0 ,1 "
bitfld.long 0 5. " OVR15 "  "0 ,1 "
bitfld.long 0 6. " OVR16 "  "0 ,1 "
bitfld.long 0 7. " OVR17 "  "0 ,1 "
bitfld.long 0 16. " BREAK1 "  "0 ,1 "
bitfld.long 0 17. " TIMEOUT1 "  "0 ,1 "
bitfld.long 0 18. " SIGNAL1 "  "0 ,1 "
;tree.end

;tree "RD0"
base ad:0x8011b040
rgroup 0--3
line.long 0 "RD0"
hexfld.long 0 " DATA "
;tree.end

;tree "RD1"
base ad:0x8011b044
rgroup 0--3
line.long 0 "RD1"
hexfld.long 0 " DATA "
;tree.end

;tree "RD2"
base ad:0x8011b048
rgroup 0--3
line.long 0 "RD2"
hexfld.long 0 " DATA "
;tree.end

;tree "RD3"
base ad:0x8011b04c
rgroup 0--3
line.long 0 "RD3"
hexfld.long 0 " DATA "
;tree.end

;tree "RD4"
base ad:0x8011b050
rgroup 0--3
line.long 0 "RD4"
hexfld.long 0 " DATA "
;tree.end

;tree "RD5"
base ad:0x8011b054
rgroup 0--3
line.long 0 "RD5"
hexfld.long 0 " DATA "
;tree.end

;tree "RD6"
base ad:0x8011b058
rgroup 0--3
line.long 0 "RD6"
hexfld.long 0 " DATA "
;tree.end

;tree "RD7"
base ad:0x8011b05c
rgroup 0--3
line.long 0 "RD7"
hexfld.long 0 " DATA "
;tree.end

;tree "RBSD0"
base ad:0x8011b080
rgroup 0--3
line.long 0 "RBSD0"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "RBSD1"
base ad:0x8011b084
rgroup 0--3
line.long 0 "RBSD1"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "RBSD2"
base ad:0x8011b088
rgroup 0--3
line.long 0 "RBSD2"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "RBSD3"
base ad:0x8011b08c
rgroup 0--3
line.long 0 "RBSD3"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "RBSD4"
base ad:0x8011b090
rgroup 0--3
line.long 0 "RBSD4"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "RBSD5"
base ad:0x8011b094
rgroup 0--3
line.long 0 "RBSD5"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "RBSD6"
base ad:0x8011b098
rgroup 0--3
line.long 0 "RBSD6"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "RBSD7"
base ad:0x8011b09c
rgroup 0--3
line.long 0 "RBSD7"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "RHSD0"
base ad:0x8011b0c0
rgroup 0--3
line.long 0 "RHSD0"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "RHSD1"
base ad:0x8011b0c4
rgroup 0--3
line.long 0 "RHSD1"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "RHSD2"
base ad:0x8011b0c8
rgroup 0--3
line.long 0 "RHSD2"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "RHSD3"
base ad:0x8011b0cc
rgroup 0--3
line.long 0 "RHSD3"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "RHSD4"
base ad:0x8011b0d0
rgroup 0--3
line.long 0 "RHSD4"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "RHSD5"
base ad:0x8011b0d4
rgroup 0--3
line.long 0 "RHSD5"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "RHSD6"
base ad:0x8011b0d8
rgroup 0--3
line.long 0 "RHSD6"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "RHSD7"
base ad:0x8011b0dc
rgroup 0--3
line.long 0 "RHSD7"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "ITCR"
base ad:0x8011b100
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

;tree "ITIP"
base ad:0x8011b104
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACI0 "  "0 ,1 "
bitfld.long 0 1. " DMACI1 "  "0 ,1 "
bitfld.long 0 2. " DMACI2 "  "0 ,1 "
bitfld.long 0 3. " DMACI3 "  "0 ,1 "
bitfld.long 0 4. " DMACI4 "  "0 ,1 "
bitfld.long 0 5. " DMACI5 "  "0 ,1 "
bitfld.long 0 6. " DMACI6 "  "0 ,1 "
bitfld.long 0 7. " DMACI7 "  "0 ,1 "
bitfld.long 0 16. " DATI0 "  "0 ,1 "
bitfld.long 0 17. " FLAI0 "  "0 ,1 "
bitfld.long 0 18. " DATI1 "  "0 ,1 "
bitfld.long 0 19. " FLAI1 "  "0 ,1 "
;tree.end

;tree "ITOP1"
base ad:0x8011b108
group 0--3
line.long 0 "ITOP1"
bitfld.long 0 0. " DMABREQ0 "  "0 ,1 "
bitfld.long 0 1. " DMABREQ1 "  "0 ,1 "
bitfld.long 0 2. " DMABREQ2 "  "0 ,1 "
bitfld.long 0 3. " DMABREQ3 "  "0 ,1 "
bitfld.long 0 4. " DMABREQ4 "  "0 ,1 "
bitfld.long 0 5. " DMABREQ5 "  "0 ,1 "
bitfld.long 0 6. " DMABREQ6 "  "0 ,1 "
bitfld.long 0 7. " DMABREQ7 "  "0 ,1 "
bitfld.long 0 16. " DMASREQ0 "  "0 ,1 "
bitfld.long 0 17. " DMASREQ1 "  "0 ,1 "
bitfld.long 0 18. " DMASREQ2 "  "0 ,1 "
bitfld.long 0 19. " DMASREQ3 "  "0 ,1 "
bitfld.long 0 20. " DMASREQ4 "  "0 ,1 "
bitfld.long 0 21. " DMASREQ5 "  "0 ,1 "
bitfld.long 0 22. " DMASREQ6 "  "0 ,1 "
bitfld.long 0 23. " DMASREQ7 "  "0 ,1 "
;tree.end

;tree "ITOP2"
base ad:0x8011b10c
group 0--3
line.long 0 "ITOP2"
bitfld.long 0 0. " CINTR0 "  "0 ,1 "
bitfld.long 0 1. " CINTR1 "  "0 ,1 "
bitfld.long 0 2. " CINTR2 "  "0 ,1 "
bitfld.long 0 3. " CINTR3 "  "0 ,1 "
bitfld.long 0 4. " CINTR4 "  "0 ,1 "
bitfld.long 0 5. " CINTR5 "  "0 ,1 "
bitfld.long 0 6. " CINTR6 "  "0 ,1 "
bitfld.long 0 7. " CINTR7 "  "0 ,1 "
bitfld.long 0 16. " RRDY0 "  "0 ,1 "
bitfld.long 0 17. " EXINTR0 "  "0 ,1 "
bitfld.long 0 18. " RRDY1 "  "0 ,1 "
bitfld.long 0 19. " EXINTR1 "  "0 ,1 "
;tree.end

;tree "PeriphID0"
base ad:0x8011bfe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PeriphID1"
base ad:0x8011bfe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0x8011bfe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0x8011bfec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0x8011bff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SSIRPCellID0 "
;tree.end

;tree "PCellID1"
base ad:0x8011bff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SSIRPCellID1 "
;tree.end

;tree "PCellID2"
base ad:0x8011bff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SSIRPCellID2 "
;tree.end

;tree "PCellID3"
base ad:0x8011bffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SSIRPCellIDC "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "SSIT"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CFR0"
base ad:0x8011c000
group 0--3
line.long 0 "CFR0"
bitfld.long 0 0.--2. " MODE0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " FRMSZ0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--9. " NOC0 "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " ARP0 "  "0 ,1 "
bitfld.long 0 12.--15. " IDLE_H0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 16. " FIFORST0 "  "0 ,1 "
bitfld.long 0 17. " FIFORST1 "  "0 ,1 "
bitfld.long 0 18. " FIFORST2 "  "0 ,1 "
bitfld.long 0 19. " FIFORST3 "  "0 ,1 "
bitfld.long 0 20. " FIFORST4 "  "0 ,1 "
bitfld.long 0 21. " FIFORST5 "  "0 ,1 "
bitfld.long 0 22. " FIFORST6 "  "0 ,1 "
bitfld.long 0 23. " FIFORST7 "  "0 ,1 "
bitfld.long 0 24. " FIFOTAS0 "  "0 ,1 "
bitfld.long 0 25. " FIFOTAS1 "  "0 ,1 "
bitfld.long 0 26. " FIFOTAS2 "  "0 ,1 "
bitfld.long 0 27. " FIFOTAS3 "  "0 ,1 "
bitfld.long 0 28. " FIFOTAS4 "  "0 ,1 "
bitfld.long 0 29. " FIFOTAS5 "  "0 ,1 "
bitfld.long 0 30. " FIFOTAS6 "  "0 ,1 "
bitfld.long 0 31. " FIFOTAS7 "  "0 ,1 "
;tree.end

;tree "BRD"
base ad:0x8011c004
group 0--3
line.long 0 "BRD"
hexfld.word 0 " BRDIV0 "
hexfld.word 2 " BRDIV1 "
;tree.end

;tree "TSR"
base ad:0x8011c008
rgroup 0--3
line.long 0 "TSR"
bitfld.long 0 0.--2. " TXSTATE0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " TXSTATE1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "BSR"
base ad:0x8011c00c
rgroup 0--3
line.long 0 "BSR"
bitfld.long 0 0. " TC0FU "  "0 ,1 "
bitfld.long 0 1. " TC1FU "  "0 ,1 "
bitfld.long 0 2. " TC2FU "  "0 ,1 "
bitfld.long 0 3. " TC3FU "  "0 ,1 "
bitfld.long 0 4. " TC4FU "  "0 ,1 "
bitfld.long 0 5. " TC5FU "  "0 ,1 "
bitfld.long 0 6. " TC6FU "  "0 ,1 "
bitfld.long 0 7. " TC7FU "  "0 ,1 "
bitfld.long 0 16. " TC0FE "  "0 ,1 "
bitfld.long 0 17. " TC1FE "  "0 ,1 "
bitfld.long 0 18. " TC2FE "  "0 ,1 "
bitfld.long 0 19. " TC3FE "  "0 ,1 "
bitfld.long 0 20. " TC4FE "  "0 ,1 "
bitfld.long 0 21. " TC5FE "  "0 ,1 "
bitfld.long 0 22. " TC6FE "  "0 ,1 "
bitfld.long 0 23. " TC7FE "  "0 ,1 "
;tree.end

;tree "BCR"
base ad:0x8011c010
group 0--3
line.long 0 "BCR"
bitfld.long 0 0. " BREAK0 "  "0 ,1 "
bitfld.long 0 1. " BREAK1 "  "0 ,1 "
;tree.end

;tree "DMACR"
base ad:0x8011c014
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " DMAE0 "  "0 ,1 "
bitfld.long 0 1. " DMAE1 "  "0 ,1 "
bitfld.long 0 2. " DMAE2 "  "0 ,1 "
bitfld.long 0 3. " DMAE3 "  "0 ,1 "
bitfld.long 0 4. " DMAE4 "  "0 ,1 "
bitfld.long 0 5. " DMAE5 "  "0 ,1 "
bitfld.long 0 6. " DMAE6 "  "0 ,1 "
bitfld.long 0 7. " DMAE7 "  "0 ,1 "
;tree.end

;tree "CFR1"
base ad:0x8011c018
group 0--3
line.long 0 "CFR1"
bitfld.long 0 0.--2. " MODE1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " FRMSZ1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8.--9. " NOC1 "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " ARP1 "  "0 ,1 "
bitfld.long 0 12.--15. " IDLEH1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "IMSC"
base ad:0x8011c020
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " TC0IM "  "0 ,1 "
bitfld.long 0 1. " TC1IM "  "0 ,1 "
bitfld.long 0 2. " TC2IM "  "0 ,1 "
bitfld.long 0 3. " TC3IM "  "0 ,1 "
bitfld.long 0 4. " TC4IM "  "0 ,1 "
bitfld.long 0 5. " TC5IM "  "0 ,1 "
bitfld.long 0 6. " TC6IM "  "0 ,1 "
bitfld.long 0 7. " TC7IM "  "0 ,1 "
;tree.end

;tree "RIS"
base ad:0x8011c024
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " TC0RIS "  "0 ,1 "
bitfld.long 0 1. " TC1RIS "  "0 ,1 "
bitfld.long 0 2. " TC2RIS "  "0 ,1 "
bitfld.long 0 3. " TC3RIS "  "0 ,1 "
bitfld.long 0 4. " TC4RIS "  "0 ,1 "
bitfld.long 0 5. " TC5RIS "  "0 ,1 "
bitfld.long 0 6. " TC6RIS "  "0 ,1 "
bitfld.long 0 7. " TC7RIS "  "0 ,1 "
;tree.end

;tree "MIS"
base ad:0x8011c028
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " TC0MIS "  "0 ,1 "
bitfld.long 0 1. " TC1MIS "  "0 ,1 "
bitfld.long 0 2. " TC2MIS "  "0 ,1 "
bitfld.long 0 3. " TC3MIS "  "0 ,1 "
bitfld.long 0 4. " TC4MIS "  "0 ,1 "
bitfld.long 0 5. " TC5MIS "  "0 ,1 "
bitfld.long 0 6. " TC6MIS "  "0 ,1 "
bitfld.long 0 7. " TC7MIS "  "0 ,1 "
;tree.end

;tree "IDSR"
base ad:0x8011c02c
group 0--3
line.long 0 "IDSR"
bitfld.long 0 0. " TC0IDS "  "0 ,1 "
bitfld.long 0 1. " TC1IDS "  "0 ,1 "
bitfld.long 0 2. " TC2IDS "  "0 ,1 "
bitfld.long 0 3. " TC3IDS "  "0 ,1 "
bitfld.long 0 4. " TC4IDS "  "0 ,1 "
bitfld.long 0 5. " TC5IDS "  "0 ,1 "
bitfld.long 0 6. " TC6IDS "  "0 ,1 "
bitfld.long 0 7. " TC7IDS "  "0 ,1 "
;tree.end

;tree "TD0"
base ad:0x8011c040
wgroup 0--3
line.long 0 "TD0"
hexfld.long 0 " DATA "
;tree.end

;tree "TD1"
base ad:0x8011c044
wgroup 0--3
line.long 0 "TD1"
hexfld.long 0 " DATA "
;tree.end

;tree "TD2"
base ad:0x8011c048
wgroup 0--3
line.long 0 "TD2"
hexfld.long 0 " DATA "
;tree.end

;tree "TD3"
base ad:0x8011c04c
wgroup 0--3
line.long 0 "TD3"
hexfld.long 0 " DATA "
;tree.end

;tree "TD4"
base ad:0x8011c050
wgroup 0--3
line.long 0 "TD4"
hexfld.long 0 " DATA "
;tree.end

;tree "TD5"
base ad:0x8011c054
wgroup 0--3
line.long 0 "TD5"
hexfld.long 0 " DATA "
;tree.end

;tree "TD6"
base ad:0x8011c058
wgroup 0--3
line.long 0 "TD6"
hexfld.long 0 " DATA "
;tree.end

;tree "TD7"
base ad:0x8011c05c
wgroup 0--3
line.long 0 "TD7"
hexfld.long 0 " DATA "
;tree.end

;tree "TBSD0"
base ad:0x8011c080
wgroup 0--3
line.long 0 "TBSD0"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "TBSD1"
base ad:0x8011c084
wgroup 0--3
line.long 0 "TBSD1"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "TBSD2"
base ad:0x8011c088
wgroup 0--3
line.long 0 "TBSD2"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "TBSD3"
base ad:0x8011c08c
wgroup 0--3
line.long 0 "TBSD3"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "TBSD4"
base ad:0x8011c090
wgroup 0--3
line.long 0 "TBSD4"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "TBSD5"
base ad:0x8011c094
wgroup 0--3
line.long 0 "TBSD5"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "TBSD6"
base ad:0x8011c098
wgroup 0--3
line.long 0 "TBSD6"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "TBSD7"
base ad:0x8011c09c
wgroup 0--3
line.long 0 "TBSD7"
hexfld.byte 0 " DATA_3 "
hexfld.byte 1 " DATA_2 "
hexfld.byte 2 " DATA_1 "
hexfld.byte 3 " DATA_0 "
;tree.end

;tree "THSD0"
base ad:0x8011c0c0
rgroup 0--3
line.long 0 "THSD0"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "THSD1"
base ad:0x8011c0c4
rgroup 0--3
line.long 0 "THSD1"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "THSD2"
base ad:0x8011c0c8
rgroup 0--3
line.long 0 "THSD2"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "THSD3"
base ad:0x8011c0cc
rgroup 0--3
line.long 0 "THSD3"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "THSD4"
base ad:0x8011c0d0
rgroup 0--3
line.long 0 "THSD4"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "THSD5"
base ad:0x8011c0d4
rgroup 0--3
line.long 0 "THSD5"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "THSD6"
base ad:0x8011c0d8
rgroup 0--3
line.long 0 "THSD6"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "THSD7"
base ad:0x8011c0dc
rgroup 0--3
line.long 0 "THSD7"
hexfld.word 0 " DATA_H "
hexfld.word 2 " DATA_L "
;tree.end

;tree "ITCR"
base ad:0x8011c100
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

;tree "ITIP"
base ad:0x8011c104
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACI0 "  "0 ,1 "
bitfld.long 0 1. " DMACI1 "  "0 ,1 "
bitfld.long 0 2. " DMACI2 "  "0 ,1 "
bitfld.long 0 3. " DMACI3 "  "0 ,1 "
bitfld.long 0 4. " DMACI4 "  "0 ,1 "
bitfld.long 0 5. " DMACI5 "  "0 ,1 "
bitfld.long 0 6. " DMACI6 "  "0 ,1 "
bitfld.long 0 7. " DMACI7 "  "0 ,1 "
bitfld.long 0 16. " RDYI0 "  "0 ,1 "
bitfld.long 0 17. " RDYI1 "  "0 ,1 "
;tree.end

;tree "ITOP1"
base ad:0x8011c108
group 0--3
line.long 0 "ITOP1"
bitfld.long 0 0. " DMABREQ0 "  "0 ,1 "
bitfld.long 0 1. " DMABREQ1 "  "0 ,1 "
bitfld.long 0 2. " DMABREQ2 "  "0 ,1 "
bitfld.long 0 3. " DMABREQ3 "  "0 ,1 "
bitfld.long 0 4. " DMABREQ4 "  "0 ,1 "
bitfld.long 0 5. " DMABREQ5 "  "0 ,1 "
bitfld.long 0 6. " DMABREQ6 "  "0 ,1 "
bitfld.long 0 7. " DMABREQ7 "  "0 ,1 "
bitfld.long 0 16. " DMASREQ0 "  "0 ,1 "
bitfld.long 0 17. " DMASREQ1 "  "0 ,1 "
bitfld.long 0 18. " DMASREQ2 "  "0 ,1 "
bitfld.long 0 19. " DMASREQ3 "  "0 ,1 "
bitfld.long 0 20. " DMASREQ4 "  "0 ,1 "
bitfld.long 0 21. " DMASREQ5 "  "0 ,1 "
bitfld.long 0 22. " DMASREQ6 "  "0 ,1 "
bitfld.long 0 23. " DMASREQ7 "  "0 ,1 "
;tree.end

;tree "ITOP2"
base ad:0x8011c10c
group 0--3
line.long 0 "ITOP2"
bitfld.long 0 0. " CINTR0 "  "0 ,1 "
bitfld.long 0 1. " CINTR1 "  "0 ,1 "
bitfld.long 0 2. " CINTR2 "  "0 ,1 "
bitfld.long 0 3. " CINTR3 "  "0 ,1 "
bitfld.long 0 4. " CINTR4 "  "0 ,1 "
bitfld.long 0 5. " CINTR5 "  "0 ,1 "
bitfld.long 0 6. " CINTR6 "  "0 ,1 "
bitfld.long 0 7. " CINTR7 "  "0 ,1 "
bitfld.long 0 16. " TDAT0 "  "0 ,1 "
bitfld.long 0 17. " TFLA0 "  "0 ,1 "
bitfld.long 0 18. " TOEn0 "  "0 ,1 "
bitfld.long 0 19. " TDAT1 "  "0 ,1 "
bitfld.long 0 20. " TFLA1 "  "0 ,1 "
bitfld.long 0 21. " TOEn1 "  "0 ,1 "
;tree.end

;tree "PeriphID0"
base ad:0x8011cfe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "PeriphID1"
base ad:0x8011cfe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID2"
base ad:0x8011cfe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphID3"
base ad:0x8011cfec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PCellID0"
base ad:0x8011cff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SSITPCellID0 "
;tree.end

;tree "PCellID1"
base ad:0x8011cff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SSITPCellID1 "
;tree.end

;tree "PCellID2"
base ad:0x8011cff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SSITPCellID2 "
;tree.end

;tree "PCellID3"
base ad:0x8011cffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SSITPCellID3 "
;tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "SSP (2 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "SSP-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0CR0"
base ad:0x80002000
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " HALFDUP "  "0 ,1 "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
bitfld.long 0 16.--20. " CSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21.--22. " FRF "  "0 ,1 ,2 ,3 "
;tree.end

;tree "0CR1"
base ad:0x80002004
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " LBM "  "0 ,1 "
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 6. " MWAIT "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "0DR"
base ad:0x80002008
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

;tree "0SR"
base ad:0x8000200c
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

;tree "0CPSR"
base ad:0x80002010
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

;tree "0IMSC"
base ad:0x80002014
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

;tree "0RIS"
base ad:0x80002018
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

;tree "0MIS"
base ad:0x8000201c
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

;tree "0ICR"
base ad:0x80002020
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

;tree "0DMACR"
base ad:0x80002024
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

;tree "0ITCR"
base ad:0x80002080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

;tree "0ITIP"
base ad:0x80002084
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SSPRXD "  "0 ,1 "
bitfld.long 0 1. " SSPFSSIN "  "0 ,1 "
bitfld.long 0 2. " SSPCLKIN "  "0 ,1 "
bitfld.long 0 3. " RXDMAC "  "0 ,1 "
bitfld.long 0 4. " TXDMAC "  "0 ,1 "
bitfld.long 0 5. " SSPTXDIN "  "0 ,1 "
;tree.end

;tree "0ITOP"
base ad:0x80002088
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " SSTXDOUT "  "0 ,1 "
bitfld.long 0 1. " SSPFSSOUT "  "0 ,1 "
bitfld.long 0 2. " SSPCLKOUT "  "0 ,1 "
bitfld.long 0 3. " SSPOEn "  "0 ,1 "
bitfld.long 0 4. " SSPCTLOEn "  "0 ,1 "
bitfld.long 0 5. " RORINTR "  "0 ,1 "
bitfld.long 0 6. " RINTR "  "0 ,1 "
bitfld.long 0 7. " RXINTR "  "0 ,1 "
bitfld.long 0 8. " TXINTR "  "0 ,1 "
bitfld.long 0 9. " INTR "  "0 ,1 "
bitfld.long 0 10. " RXDMABREQ "  "0 ,1 "
bitfld.long 0 11. " RXDMASREQ "  "0 ,1 "
bitfld.long 0 12. " TXDMABREQ "  "0 ,1 "
bitfld.long 0 13. " TXDMASREQ "  "0 ,1 "
;tree.end

;tree "0TDR"
base ad:0x8000208c
group 0--3
line.long 0 "TDR"
hexfld.long 0 " TestDATA "
;tree.end

;tree "0PeriphID0"
base ad:0x80002fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "0PeriphID1"
base ad:0x80002fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID2"
base ad:0x80002fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID3"
base ad:0x80002fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "0PCellID0"
base ad:0x80002ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SSPPCellID0 "
;tree.end

;tree "0PCellID1"
base ad:0x80002ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SSPPCellID1 "
;tree.end

;tree "0PCellID2"
base ad:0x80002ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SSPPCellID2 "
;tree.end

;tree "0PCellID3"
base ad:0x80002ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SSPPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "SSP-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1CR0"
base ad:0x80003000
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5. " HALFDUP "  "0 ,1 "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
hexfld.byte 1 " SCR "
bitfld.long 0 16.--20. " CSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 21.--22. " FRF "  "0 ,1 ,2 ,3 "
;tree.end

;tree "1CR1"
base ad:0x80003004
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " LBM "  "0 ,1 "
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 6. " MWAIT "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 10.--12. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "1DR"
base ad:0x80003008
group 0--3
line.long 0 "DR"
hexfld.long 0 " DATA "
;tree.end

;tree "1SR"
base ad:0x8000300c
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
;tree.end

;tree "1CPSR"
base ad:0x80003010
group 0--3
line.long 0 "CPSR"
hexfld.byte 0 " CPSDVSR "
;tree.end

;tree "1IMSC"
base ad:0x80003014
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
;tree.end

;tree "1RIS"
base ad:0x80003018
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
;tree.end

;tree "1MIS"
base ad:0x8000301c
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
;tree.end

;tree "1ICR"
base ad:0x80003020
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
;tree.end

;tree "1DMACR"
base ad:0x80003024
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
;tree.end

;tree "1ITCR"
base ad:0x80003080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
;tree.end

;tree "1ITIP"
base ad:0x80003084
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SSPRXD "  "0 ,1 "
bitfld.long 0 1. " SSPFSSIN "  "0 ,1 "
bitfld.long 0 2. " SSPCLKIN "  "0 ,1 "
bitfld.long 0 3. " RXDMAC "  "0 ,1 "
bitfld.long 0 4. " TXDMAC "  "0 ,1 "
bitfld.long 0 5. " SSPTXDIN "  "0 ,1 "
;tree.end

;tree "1ITOP"
base ad:0x80003088
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " SSTXDOUT "  "0 ,1 "
bitfld.long 0 1. " SSPFSSOUT "  "0 ,1 "
bitfld.long 0 2. " SSPCLKOUT "  "0 ,1 "
bitfld.long 0 3. " SSPOEn "  "0 ,1 "
bitfld.long 0 4. " SSPCTLOEn "  "0 ,1 "
bitfld.long 0 5. " RORINTR "  "0 ,1 "
bitfld.long 0 6. " RINTR "  "0 ,1 "
bitfld.long 0 7. " RXINTR "  "0 ,1 "
bitfld.long 0 8. " TXINTR "  "0 ,1 "
bitfld.long 0 9. " INTR "  "0 ,1 "
bitfld.long 0 10. " RXDMABREQ "  "0 ,1 "
bitfld.long 0 11. " RXDMASREQ "  "0 ,1 "
bitfld.long 0 12. " TXDMABREQ "  "0 ,1 "
bitfld.long 0 13. " TXDMASREQ "  "0 ,1 "
;tree.end

;tree "1TDR"
base ad:0x8000308c
group 0--3
line.long 0 "TDR"
hexfld.long 0 " TestDATA "
;tree.end

;tree "1PeriphID0"
base ad:0x80003fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "1PeriphID1"
base ad:0x80003fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID2"
base ad:0x80003fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID3"
base ad:0x80003fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "1PCellID0"
base ad:0x80003ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " SSPPCellID0 "
;tree.end

;tree "1PCellID1"
base ad:0x80003ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " SSPPCellID1 "
;tree.end

;tree "1PCellID2"
base ad:0x80003ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " SSPPCellID2 "
;tree.end

;tree "1PCellID3"
base ad:0x80003ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " SSPPCellID3 "
;tree.end

tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "SSPTB (2 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "SSPTB-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0PRE"
base ad:0x63500000
group 0--3
line.long 0 "PRE"
hexfld.byte 0 " PRESCALE "
;tree.end

;tree "0CR0"
base ad:0x63500004
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " FRF "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " ENABLE "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

;tree "0CR1"
base ad:0x63500008
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " SPO "  "0 ,1 "
bitfld.long 0 1. " SPH "  "0 ,1 "
bitfld.long 0 2.--3. " RXW "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MS "  "0 ,1 "
bitfld.long 0 5. " OD "  "0 ,1 "
;tree.end

;tree "0TDR"
base ad:0x6350000c
group 0--3
line.long 0 "TDR"
hexfld.word 0 " DATA "
;tree.end

;tree "0RDR"
base ad:0x63500010
group 0--3
line.long 0 "RDR"
hexfld.word 0 " DATA "
;tree.end

;tree "0SR"
base ad:0x63500014
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXFF "  "0 ,1 "
bitfld.long 0 2. " TXFE "  "0 ,1 "
bitfld.long 0 3. " TXFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
bitfld.long 0 5. " SSPINT "  "0 ,1 "
bitfld.long 0 6. " RXWFLG "  "0 ,1 "
bitfld.long 0 7. " RFSFLG "  "0 ,1 "
bitfld.long 0 8. " TFSFLG "  "0 ,1 "
bitfld.long 0 9. " RORFLG "  "0 ,1 "
bitfld.long 0 10. " PCLKON "  "0 ,1 "
bitfld.long 0 11. " REFCLKON "  "0 ,1 "
bitfld.long 0 12. " REFCLK1ON "  "0 ,1 "
;tree.end

;tree "0SCANMODE"
base ad:0x63500018
group 0--3
line.long 0 "SCANMODE"
bitfld.long 0 0. " SCANMODE "  "0 ,1 "
bitfld.long 0 1. " RSTMODE "  "0 ,1 "
bitfld.long 0 2. " GENCLK "  "0 ,1 "
bitfld.long 0 3. " SSPCLKSEL "  "0 ,1 "
bitfld.long 0 4. " SSPCLK1SEL "  "0 ,1 "
bitfld.long 0 5. " GENCLK1 "  "0 ,1 "
;tree.end

;tree "0CLKREG"
base ad:0x6350001c
group 0--3
line.long 0 "CLKREG"
hexfld.word 0 " CLKPERIOD "
;tree.end

;tree "0CR2"
base ad:0x63500020
group 0--3
line.long 0 "CR2"
hexfld.byte 0 " ESFRM "
bitfld.long 0 8. " FRC "  "0 ,1 "
bitfld.long 0 9. " SPISFRMEn "  "0 ,1 "
bitfld.long 0 10. " TIDASFRM "  "0 ,1 "
;tree.end

;tree "0CLKREG1"
base ad:0x63500024
group 0--3
line.long 0 "CLKREG1"
hexfld.word 0 " CLKPERIOD "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "SSPTB-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1PRE"
base ad:0x63580000
group 0--3
line.long 0 "PRE"
hexfld.byte 0 " PRESCALE "
;tree.end

;tree "1CR0"
base ad:0x63580004
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 5.--6. " FRF "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " ENABLE "  "0 ,1 "
hexfld.byte 1 " SCR "
;tree.end

;tree "1CR1"
base ad:0x63580008
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " SPO "  "0 ,1 "
bitfld.long 0 1. " SPH "  "0 ,1 "
bitfld.long 0 2.--3. " RXW "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " MS "  "0 ,1 "
bitfld.long 0 5. " OD "  "0 ,1 "
;tree.end

;tree "1TDR"
base ad:0x6358000c
group 0--3
line.long 0 "TDR"
hexfld.word 0 " DATA "
;tree.end

;tree "1RDR"
base ad:0x63580010
group 0--3
line.long 0 "RDR"
hexfld.word 0 " DATA "
;tree.end

;tree "1SR"
base ad:0x63580014
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXFF "  "0 ,1 "
bitfld.long 0 2. " TXFE "  "0 ,1 "
bitfld.long 0 3. " TXFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
bitfld.long 0 5. " SSPINT "  "0 ,1 "
bitfld.long 0 6. " RXWFLG "  "0 ,1 "
bitfld.long 0 7. " RFSFLG "  "0 ,1 "
bitfld.long 0 8. " TFSFLG "  "0 ,1 "
bitfld.long 0 9. " RORFLG "  "0 ,1 "
bitfld.long 0 10. " PCLKON "  "0 ,1 "
bitfld.long 0 11. " REFCLKON "  "0 ,1 "
bitfld.long 0 12. " REFCLK1ON "  "0 ,1 "
;tree.end

;tree "1SCANMODE"
base ad:0x63580018
group 0--3
line.long 0 "SCANMODE"
bitfld.long 0 0. " SCANMODE "  "0 ,1 "
bitfld.long 0 1. " RSTMODE "  "0 ,1 "
bitfld.long 0 2. " GENCLK "  "0 ,1 "
bitfld.long 0 3. " SSPCLKSEL "  "0 ,1 "
bitfld.long 0 4. " SSPCLK1SEL "  "0 ,1 "
bitfld.long 0 5. " GENCLK1 "  "0 ,1 "
;tree.end

;tree "1CLKREG"
base ad:0x6358001c
group 0--3
line.long 0 "CLKREG"
hexfld.word 0 " CLKPERIOD "
;tree.end

;tree "1CR2"
base ad:0x63580020
group 0--3
line.long 0 "CR2"
hexfld.byte 0 " ESFRM "
bitfld.long 0 8. " FRC "  "0 ,1 "
bitfld.long 0 9. " SPISFRMEn "  "0 ,1 "
bitfld.long 0 10. " TIDASFRM "  "0 ,1 "
;tree.end

;tree "1CLKREG1"
base ad:0x63580024
group 0--3
line.long 0 "CLKREG1"
hexfld.word 0 " CLKPERIOD "
;tree.end

tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "STM"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CR_L"
base ad:0x8010f000
group 0--3
line.long 0 "CR_L"
bitfld.long 0 0. " PLP0 "  "0 ,1 "
bitfld.long 0 1. " PLP1 "  "0 ,1 "
bitfld.long 0 2. " PLP2 "  "0 ,1 "
bitfld.long 0 3. " TSnTS "  "0 ,1 "
bitfld.long 0 4.--5. " DWNG "  "0 ,1 ,2 ,3 "
bitfld.long 0 6.--8. " XCKDIV "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 9. " SWAP_PRCMU "  "0 ,1 "
;tree.end

;tree "CR_H"
base ad:0x8010f004
group 0--3
line.long 0 "CR_H"
;tree.end

;tree "MMCR_L"
base ad:0x8010f008
group 0--3
line.long 0 "MMCR_L"
bitfld.long 0 0. " HWnSW0 "  "0 ,1 "
bitfld.long 0 1. " HWnSW1 "  "0 ,1 "
bitfld.long 0 2. " HWnSW2 "  "0 ,1 "
bitfld.long 0 3. " HWnSW3 "  "0 ,1 "
bitfld.long 0 4. " HWnSW4 "  "0 ,1 "
bitfld.long 0 5. " HWnSW5 "  "0 ,1 "
;tree.end

;tree "MMCR_H"
base ad:0x8010f00c
group 0--3
line.long 0 "MMCR_H"
;tree.end

;tree "TER_L"
base ad:0x8010f010
group 0--3
line.long 0 "TER_L"
bitfld.long 0 0. " TE0 "  "0 ,1 "
bitfld.long 0 2. " TE2 "  "0 ,1 "
bitfld.long 0 3. " TE3 "  "0 ,1 "
bitfld.long 0 4. " TE4 "  "0 ,1 "
bitfld.long 0 5. " TE5 "  "0 ,1 "
bitfld.long 0 9. " TE9 "  "0 ,1 "
;tree.end

;tree "TER_H"
base ad:0x8010f014
group 0--3
line.long 0 "TER_H"
;tree.end

;tree "TDSR_L"
base ad:0x8010f018
rgroup 0--3
line.long 0 "TDSR_L"
bitfld.long 0 0. " TDis0 "  "0 ,1 "
bitfld.long 0 1. " TDis1 "  "0 ,1 "
bitfld.long 0 2. " TDis2 "  "0 ,1 "
bitfld.long 0 3. " TDis3 "  "0 ,1 "
bitfld.long 0 4. " TDis4 "  "0 ,1 "
bitfld.long 0 5. " TDis5 "  "0 ,1 "
bitfld.long 0 9. " TDis9 "  "0 ,1 "
;tree.end

;tree "TDSR_H"
base ad:0x8010f01c
rgroup 0--3
line.long 0 "TDSR_H"
;tree.end

;tree "OFSR_L"
base ad:0x8010f020
rgroup 0--3
line.long 0 "OFSR_L"
bitfld.long 0 0. " ovF0 "  "0 ,1 "
bitfld.long 0 1. " ovF1 "  "0 ,1 "
bitfld.long 0 2. " ovF2 "  "0 ,1 "
bitfld.long 0 3. " ovF3 "  "0 ,1 "
bitfld.long 0 4. " ovF4 "  "0 ,1 "
bitfld.long 0 5. " ovF5 "  "0 ,1 "
bitfld.long 0 9. " ovF9 "  "0 ,1 "
bitfld.long 0 10. " SecTrej "  "0 ,1 "
bitfld.long 0 11. " DecErr "  "0 ,1 "
bitfld.long 0 12.--16. " AddrErr "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "OFSR_H"
base ad:0x8010f024
rgroup 0--3
line.long 0 "OFSR_H"
;tree.end

;tree "TFSR_L"
base ad:0x8010f028
rgroup 0--3
line.long 0 "TFSR_L"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TFF "  "0 ,1 "
bitfld.long 0 2. " PRCME "  "0 ,1 "
bitfld.long 0 3. " PRCMF "  "0 ,1 "
bitfld.long 0 4. " CHGCFG "  "0 ,1 "
;tree.end

;tree "TFSR_H"
base ad:0x8010f02c
rgroup 0--3
line.long 0 "TFSR_H"
;tree.end

;tree "SBSR_L"
base ad:0x8010f030
rgroup 0--3
line.long 0 "SBSR_L"
bitfld.long 0 0. " SBFE "  "0 ,1 "
bitfld.long 0 1. " SBFF "  "0 ,1 "
bitfld.long 0 2. " SBOv "  "0 ,1 "
bitfld.long 0 3.--7. " SBOvNb "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "SBSR_H"
base ad:0x8010f034
rgroup 0--3
line.long 0 "SBSR_H"
;tree.end

;tree "TSR_L"
base ad:0x8010f050
rgroup 0--3
line.long 0 "TSR_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " Stamp "  "0 ,1 "
bitfld.long 0 2. " Time "  "0 ,1 "
;tree.end

;tree "TSR_H"
base ad:0x8010f054
rgroup 0--3
line.long 0 "TSR_H"
;tree.end

;tree "SCCR_L"
base ad:0x8010f058
group 0--3
line.long 0 "SCCR_L"
hexfld.long 0 " SCC "
;tree.end

;tree "SCCR_H"
base ad:0x8010f05c
group 0--3
line.long 0 "SCCR_H"
;tree.end

;tree "DBG_L"
base ad:0x8010f038
group 0--3
line.long 0 "DBG_L"
bitfld.long 0 0. " DBGEn "  "0 ,1 "
bitfld.long 0 1. " DBGM "  "0 ,1 "
bitfld.long 0 3.--5. " PTICSSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 6.--10. " FTFSel "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 12. " FSBFF "  "0 ,1 "
bitfld.long 0 16.--24. " PTI_State "  " "
;tree.end

;tree "DBG_H"
base ad:0x8010f03c
group 0--3
line.long 0 "DBG_H"
;tree.end

;tree "PeriphlD0_L"
base ad:0x8010ffc0
rgroup 0--3
line.long 0 "PeriphlD0_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " PartNumber0 "  "0 ,1 "
;tree.end

;tree "PeriphlD0_H"
base ad:0x8010ffc4
rgroup 0--3
line.long 0 "PeriphlD0_H"
;tree.end

;tree "PeriphlD1_L"
base ad:0x8010ffc8
rgroup 0--3
line.long 0 "PeriphlD1_L"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphlD1_H"
base ad:0x8010ffcc
rgroup 0--3
line.long 0 "PeriphlD1_H"
;tree.end

;tree "PeriphlD2_L"
base ad:0x8010ffd0
rgroup 0--3
line.long 0 "PeriphlD2_L"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "PeriphlD2_H"
base ad:0x8010ffd4
rgroup 0--3
line.long 0 "PeriphlD2_H"
;tree.end

;tree "PeriphlD3_L"
base ad:0x8010ffd8
rgroup 0--3
line.long 0 "PeriphlD3_L"
hexfld.byte 0 " Configuration "
;tree.end

;tree "PeriphD3_H"
base ad:0x8010ffdc
rgroup 0--3
line.long 0 "PeriphD3_H"
;tree.end

;tree "PCelllD0_L"
base ad:0x8010ffe0
rgroup 0--3
line.long 0 "PCelllD0_L"
hexfld.byte 0 " STMPCelllD0 "
;tree.end

;tree "PCelllD0_H"
base ad:0x8010ffe4
rgroup 0--3
line.long 0 "PCelllD0_H"
;tree.end

;tree "PCelllD1_L"
base ad:0x8010ffe8
rgroup 0--3
line.long 0 "PCelllD1_L"
hexfld.byte 0 " STMPCelllD1 "
;tree.end

;tree "PCelllD1_H"
base ad:0x8010ffec
rgroup 0--3
line.long 0 "PCelllD1_H"
;tree.end

;tree "PCelllD2_L"
base ad:0x8010fff0
rgroup 0--3
line.long 0 "PCelllD2_L"
hexfld.byte 0 " STMPCelllD2 "
;tree.end

;tree "PCelllD2_H"
base ad:0x8010fff4
rgroup 0--3
line.long 0 "PCelllD2_H"
;tree.end

;tree "PCelllD3_L"
base ad:0x8010fff8
rgroup 0--3
line.long 0 "PCelllD3_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " STMPCelllD3 "  "0 ,1 "
;tree.end

;tree "PCelllD3_H"
base ad:0x8010fffc
rgroup 0--3
line.long 0 "PCelllD3_H"
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "STMTB"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "Status"
base ad:0x63df8000
group 0--3
line.long 0 "Status"
hexfld.byte 0 " status "
;tree.end

;tree "dataptr"
base ad:0x63df8004
rgroup 0--3
line.long 0 "dataptr"
hexfld.byte 0 " dataptr "
;tree.end

;tree "data"
base ad:0x63df8008
rgroup 0--3
line.long 0 "data"
bitfld.long 0 0.--3. " data "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "tm0_status"
base ad:0x63df800c
group 0--3
line.long 0 "tm0_status"
bitfld.long 0 0.--12. " tm0status "  " "
;tree.end

;tree "pi_status"
base ad:0x63df8010
group 0--3
line.long 0 "pi_status"
hexfld.long 0 " pistatus "
;tree.end

;tree "wp_status"
base ad:0x63df8014
group 0--3
line.long 0 "wp_status"
hexfld.long 0 " pistatus "
;tree.end

;tree "mcterr_status"
base ad:0x63df8018
group 0--3
line.long 0 "mcterr_status"
bitfld.long 0 0.--12. " mcterrstatus "  " "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "THSENS"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "THSENS_CTRL"
base ad:0x801573c0
group 0--3
line.long 0 "THSENS_CTRL"
bitfld.long 0 0. " START "  "0 ,1 "
;tree.end

;tree "THSENS_STATUS"
base ad:0x801573c4
rgroup 0--3
line.long 0 "THSENS_STATUS"
bitfld.long 0 0.--3. " DATA_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " OVERFLOW "  "0 ,1 "
bitfld.long 0 5. " IT_STATUS "  "0 ,1 "
bitfld.long 0 6. " RUN "  "0 ,1 "
;tree.end

;tree "THSENS_IT_CLR"
base ad:0x801573c8
wgroup 0--3
line.long 0 "THSENS_IT_CLR"
bitfld.long 0 0. " IT_CLR "  "0 ,1 "
;tree.end

;tree "THSENS_CLKDIV"
base ad:0x801573cc
group 0--3
line.long 0 "THSENS_CLKDIV"
hexfld.byte 0 " CLKDIV "
;tree.end

;tree "THSENS_DCORRECT"
base ad:0x801573d0
group 0--3
line.long 0 "THSENS_DCORRECT"
bitfld.long 0 0.--4. " DCORRECT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "THSENS_TEMP"
base ad:0x801573d4
rgroup 0--3
line.long 0 "THSENS_TEMP"
bitfld.long 0 0.--6. " DATA "  " "
bitfld.long 0 7. " OVERFLOW "  "0 ,1 "
;tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "TIMER (2 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "TIMER-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0IMSC"
base ad:0xa03c6000
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " T0IM "  "0 ,1 "
bitfld.long 0 1. " T1IM "  "0 ,1 "
bitfld.long 0 2. " T2IM "  "0 ,1 "
bitfld.long 0 3. " T3IM "  "0 ,1 "
;tree.end

;tree "0RIS"
base ad:0xa03c6004
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " T0RIS "  "0 ,1 "
bitfld.long 0 1. " T1RIS "  "0 ,1 "
bitfld.long 0 2. " T2RIS "  "0 ,1 "
bitfld.long 0 3. " T3RIS "  "0 ,1 "
;tree.end

;tree "0MIS"
base ad:0xa03c6008
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " T0MIS "  "0 ,1 "
bitfld.long 0 1. " T1MIS "  "0 ,1 "
bitfld.long 0 2. " T2MIS "  "0 ,1 "
bitfld.long 0 3. " T3MIS "  "0 ,1 "
;tree.end

;tree "0ICR"
base ad:0xa03c600c
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " T0IC "  "0 ,1 "
bitfld.long 0 1. " T1IC "  "0 ,1 "
bitfld.long 0 2. " T2IC "  "0 ,1 "
bitfld.long 0 3. " T3IC "  "0 ,1 "
;tree.end

;tree "0T0LR"
base ad:0xa03c6010
group 0--3
line.long 0 "T0LR"
hexfld.long 0 " T0LOAD "
;tree.end

;tree "0T0VAL"
base ad:0xa03c6014
rgroup 0--3
line.long 0 "T0VAL"
;tree.end

;tree "0T0CR"
base ad:0xa03c6018
group 0--3
line.long 0 "T0CR"
bitfld.long 0 0. " T0OS "  "0 ,1 "
bitfld.long 0 1. " T0SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T0PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T0MOD "  "0 ,1 "
bitfld.long 0 7. " T0En "  "0 ,1 "
;tree.end

;tree "0T0BGLR"
base ad:0xa03c601c
group 0--3
line.long 0 "T0BGLR"
bitfld.long 0 0. " T0BGLOAD "  "0 ,1 "
;tree.end

;tree "0T1LR"
base ad:0xa03c6020
group 0--3
line.long 0 "T1LR"
hexfld.long 0 " T1LOAD "
;tree.end

;tree "0T1VAL"
base ad:0xa03c6024
rgroup 0--3
line.long 0 "T1VAL"
;tree.end

;tree "0T1CR"
base ad:0xa03c6028
group 0--3
line.long 0 "T1CR"
bitfld.long 0 0. " T1OS "  "0 ,1 "
bitfld.long 0 1. " T1SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T1PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T1MOD "  "0 ,1 "
bitfld.long 0 7. " T1En "  "0 ,1 "
;tree.end

;tree "0T1BGLR"
base ad:0xa03c602c
group 0--3
line.long 0 "T1BGLR"
bitfld.long 0 0. " T1BGLOAD "  "0 ,1 "
;tree.end

;tree "0T2LR"
base ad:0xa03c6030
group 0--3
line.long 0 "T2LR"
hexfld.long 0 " T2LOAD "
;tree.end

;tree "0T2VAL"
base ad:0xa03c6034
rgroup 0--3
line.long 0 "T2VAL"
;tree.end

;tree "0T2CR"
base ad:0xa03c6038
group 0--3
line.long 0 "T2CR"
bitfld.long 0 0. " T2OS "  "0 ,1 "
bitfld.long 0 1. " T2SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T2PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T2MOD "  "0 ,1 "
bitfld.long 0 7. " T2En "  "0 ,1 "
;tree.end

;tree "0T2BGLR"
base ad:0xa03c603c
group 0--3
line.long 0 "T2BGLR"
bitfld.long 0 0. " T2BGLOAD "  "0 ,1 "
;tree.end

;tree "0T3LR"
base ad:0xa03c6040
group 0--3
line.long 0 "T3LR"
hexfld.long 0 " T3LOAD "
;tree.end

;tree "0T3VAL"
base ad:0xa03c6044
rgroup 0--3
line.long 0 "T3VAL"
;tree.end

;tree "0T3CR"
base ad:0xa03c6048
group 0--3
line.long 0 "T3CR"
bitfld.long 0 0. " T3OS "  "0 ,1 "
bitfld.long 0 1. " T3SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T3PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T3MOD "  "0 ,1 "
bitfld.long 0 7. " T3En "  "0 ,1 "
;tree.end

;tree "0T3BGLR"
base ad:0xa03c604c
group 0--3
line.long 0 "T3BGLR"
bitfld.long 0 0. " T3BGLOAD "  "0 ,1 "
;tree.end

;tree "0ITCR"
base ad:0xa03c6f00
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITME "  "0 ,1 "
;tree.end

;tree "0ITOP"
base ad:0xa03c6f04
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " INTCT0 "  "0 ,1 "
bitfld.long 0 1. " INTCT1 "  "0 ,1 "
bitfld.long 0 2. " INTCT2 "  "0 ,1 "
bitfld.long 0 3. " INTCT3 "  "0 ,1 "
;tree.end

;tree "0PeriphID0"
base ad:0xa03c6fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "0PeriphID1"
base ad:0xa03c6fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID2"
base ad:0xa03c6fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID3"
base ad:0xa03c6fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "0PCellID0"
base ad:0xa03c6ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " MTUPCellID0 "
;tree.end

;tree "0PCellID1"
base ad:0xa03c6ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " MTUPCellID1 "
;tree.end

;tree "0PCellID2"
base ad:0xa03c6ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " MTUPCellID2 "
;tree.end

;tree "0PCellID3"
base ad:0xa03c6ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " MTUPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "TIMER-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1IMSC"
base ad:0xa03c7000
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " T0IM "  "0 ,1 "
bitfld.long 0 1. " T1IM "  "0 ,1 "
bitfld.long 0 2. " T2IM "  "0 ,1 "
bitfld.long 0 3. " T3IM "  "0 ,1 "
;tree.end

;tree "1RIS"
base ad:0xa03c7004
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " T0RIS "  "0 ,1 "
bitfld.long 0 1. " T1RIS "  "0 ,1 "
bitfld.long 0 2. " T2RIS "  "0 ,1 "
bitfld.long 0 3. " T3RIS "  "0 ,1 "
;tree.end

;tree "1MIS"
base ad:0xa03c7008
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " T0MIS "  "0 ,1 "
bitfld.long 0 1. " T1MIS "  "0 ,1 "
bitfld.long 0 2. " T2MIS "  "0 ,1 "
bitfld.long 0 3. " T3MIS "  "0 ,1 "
;tree.end

;tree "1ICR"
base ad:0xa03c700c
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " T0IC "  "0 ,1 "
bitfld.long 0 1. " T1IC "  "0 ,1 "
bitfld.long 0 2. " T2IC "  "0 ,1 "
bitfld.long 0 3. " T3IC "  "0 ,1 "
;tree.end

;tree "1T0LR"
base ad:0xa03c7010
group 0--3
line.long 0 "T0LR"
hexfld.long 0 " T0LOAD "
;tree.end

;tree "1T0VAL"
base ad:0xa03c7014
rgroup 0--3
line.long 0 "T0VAL"
;tree.end

;tree "1T0CR"
base ad:0xa03c7018
group 0--3
line.long 0 "T0CR"
bitfld.long 0 0. " T0OS "  "0 ,1 "
bitfld.long 0 1. " T0SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T0PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T0MOD "  "0 ,1 "
bitfld.long 0 7. " T0En "  "0 ,1 "
;tree.end

;tree "1T0BGLR"
base ad:0xa03c701c
group 0--3
line.long 0 "T0BGLR"
bitfld.long 0 0. " T0BGLOAD "  "0 ,1 "
;tree.end

;tree "1T1LR"
base ad:0xa03c7020
group 0--3
line.long 0 "T1LR"
hexfld.long 0 " T1LOAD "
;tree.end

;tree "1T1VAL"
base ad:0xa03c7024
rgroup 0--3
line.long 0 "T1VAL"
;tree.end

;tree "1T1CR"
base ad:0xa03c7028
group 0--3
line.long 0 "T1CR"
bitfld.long 0 0. " T1OS "  "0 ,1 "
bitfld.long 0 1. " T1SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T1PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T1MOD "  "0 ,1 "
bitfld.long 0 7. " T1En "  "0 ,1 "
;tree.end

;tree "1T1BGLR"
base ad:0xa03c702c
group 0--3
line.long 0 "T1BGLR"
bitfld.long 0 0. " T1BGLOAD "  "0 ,1 "
;tree.end

;tree "1T2LR"
base ad:0xa03c7030
group 0--3
line.long 0 "T2LR"
hexfld.long 0 " T2LOAD "
;tree.end

;tree "1T2VAL"
base ad:0xa03c7034
rgroup 0--3
line.long 0 "T2VAL"
;tree.end

;tree "1T2CR"
base ad:0xa03c7038
group 0--3
line.long 0 "T2CR"
bitfld.long 0 0. " T2OS "  "0 ,1 "
bitfld.long 0 1. " T2SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T2PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T2MOD "  "0 ,1 "
bitfld.long 0 7. " T2En "  "0 ,1 "
;tree.end

;tree "1T2BGLR"
base ad:0xa03c703c
group 0--3
line.long 0 "T2BGLR"
bitfld.long 0 0. " T2BGLOAD "  "0 ,1 "
;tree.end

;tree "1T3LR"
base ad:0xa03c7040
group 0--3
line.long 0 "T3LR"
hexfld.long 0 " T3LOAD "
;tree.end

;tree "1T3VAL"
base ad:0xa03c7044
rgroup 0--3
line.long 0 "T3VAL"
;tree.end

;tree "1T3CR"
base ad:0xa03c7048
group 0--3
line.long 0 "T3CR"
bitfld.long 0 0. " T3OS "  "0 ,1 "
bitfld.long 0 1. " T3SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T3PRE "  "0 ,1 ,2 ,3 "
bitfld.long 0 6. " T3MOD "  "0 ,1 "
bitfld.long 0 7. " T3En "  "0 ,1 "
;tree.end

;tree "1T3BGLR"
base ad:0xa03c704c
group 0--3
line.long 0 "T3BGLR"
bitfld.long 0 0. " T3BGLOAD "  "0 ,1 "
;tree.end

;tree "1ITCR"
base ad:0xa03c7f00
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITME "  "0 ,1 "
;tree.end

;tree "1ITOP"
base ad:0xa03c7f04
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " INTCT0 "  "0 ,1 "
bitfld.long 0 1. " INTCT1 "  "0 ,1 "
bitfld.long 0 2. " INTCT2 "  "0 ,1 "
bitfld.long 0 3. " INTCT3 "  "0 ,1 "
;tree.end

;tree "1PeriphID0"
base ad:0xa03c7fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "1PeriphID1"
base ad:0xa03c7fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID2"
base ad:0xa03c7fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID3"
base ad:0xa03c7fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "1PCellID0"
base ad:0xa03c7ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " MTUPCellID0 "
;tree.end

;tree "1PCellID1"
base ad:0xa03c7ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " MTUPCellID1 "
;tree.end

;tree "1PCellID2"
base ad:0xa03c7ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " MTUPCellID2 "
;tree.end

;tree "1PCellID3"
base ad:0xa03c7ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " MTUPCellID3 "
;tree.end

tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "TOUAREGTB"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "CR"
base ad:0x63c00000
group 0--3
line.long 0 "CR"
hexfld.long 0 " STATUS "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "TPIU"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "PortSize"
base eapb:0x80190000
rgroup 0--3
line.long 0 "PortSize"
bitfld.long 0 0. " PortSize "  "0 ,1 "
;tree.end

;tree "CurrPortSize"
base eapb:0x80190004
group 0--3
line.long 0 "CurrPortSize"
bitfld.long 0 0. " CurrPortSize "  "0 ,1 "
;tree.end

;tree "SuppTrigMod"
base eapb:0x80190100
rgroup 0--3
line.long 0 "SuppTrigMod"
bitfld.long 0 0. " SuppTrigMod "  "0 ,1 "
;tree.end

;tree "TrigCountVal"
base eapb:0x80190104
group 0--3
line.long 0 "TrigCountVal"
bitfld.long 0 0. " TrigCountVal "  "0 ,1 "
;tree.end

;tree "TrigMult"
base eapb:0x80190108
group 0--3
line.long 0 "TrigMult"
bitfld.long 0 0. " TrigMult "  "0 ,1 "
;tree.end

;tree "SuppTest"
base eapb:0x80190200
rgroup 0--3
line.long 0 "SuppTest"
bitfld.long 0 0. " SuppTest "  "0 ,1 "
;tree.end

;tree "CurrTest"
base eapb:0x80190204
group 0--3
line.long 0 "CurrTest"
bitfld.long 0 0. " CurrTest "  "0 ,1 "
;tree.end

;tree "TestPatt"
base eapb:0x80190208
group 0--3
line.long 0 "TestPatt"
bitfld.long 0 0. " TestPatt "  "0 ,1 "
;tree.end

;tree "FormatStat"
base eapb:0x80190300
group 0--3
line.long 0 "FormatStat"
bitfld.long 0 0. " FormatStat "  "0 ,1 "
;tree.end

;tree "FormatCtrl"
base eapb:0x80190304
group 0--3
line.long 0 "FormatCtrl"
bitfld.long 0 0. " FormatCtrl "  "0 ,1 "
;tree.end

;tree "FormatSync"
base eapb:0x80190308
group 0--3
line.long 0 "FormatSync"
bitfld.long 0 0. " FormatSync "  "0 ,1 "
;tree.end

;tree "EXTCTLIN"
base eapb:0x80190400
group 0--3
line.long 0 "EXTCTLIN"
bitfld.long 0 0. " EXTCTLIN "  "0 ,1 "
;tree.end

;tree "EXTCTLOUT"
base eapb:0x80190404
group 0--3
line.long 0 "EXTCTLOUT"
bitfld.long 0 0. " EXTCTLOUT "  "0 ,1 "
;tree.end

;tree "ITTRFLINACK"
base eapb:0x80190ee4
wgroup 0--3
line.long 0 "ITTRFLINACK"
bitfld.long 0 0. " ITTRFLINACK "  "0 ,1 "
;tree.end

;tree "ITTRFLIN"
base eapb:0x80190ee8
group 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0. " ITTRFLIN "  "0 ,1 "
;tree.end

;tree "ITATBDATA0"
base eapb:0x80190eec
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ITATBDATA0 "  "0 ,1 "
;tree.end

;tree "ITATBCTR2"
base eapb:0x80190ef0
wgroup 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ITATBCTR2 "  "0 ,1 "
;tree.end

;tree "ITATBCTR1"
base eapb:0x80190ef4
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0. " ITATBCTR1 "  "0 ,1 "
;tree.end

;tree "ITATBCTR0"
base eapb:0x80190ef8
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ITATBCTR0 "  "0 ,1 "
;tree.end

;tree "IntModCTRLReg"
base eapb:0x80190f00
group 0--3
line.long 0 "IntModCTRLReg"
bitfld.long 0 0. " IntModCTRLReg "  "0 ,1 "
;tree.end

;tree "CTS"
base eapb:0x80190fa0
group 0--3
line.long 0 "CTS"
bitfld.long 0 0. " CTS "  "0 ,1 "
;tree.end

;tree "CTC"
base eapb:0x80190fa4
group 0--3
line.long 0 "CTC"
bitfld.long 0 0. " CTC "  "0 ,1 "
;tree.end

;tree "LockA"
base eapb:0x80190fb0
wgroup 0--3
line.long 0 "LockA"
bitfld.long 0 0. " LockA "  "0 ,1 "
;tree.end

;tree "Lock"
base eapb:0x80190fb4
rgroup 0--3
line.long 0 "Lock"
bitfld.long 0 0. " Lock "  "0 ,1 "
;tree.end

;tree "Aut"
base eapb:0x80190fb8
rgroup 0--3
line.long 0 "Aut"
bitfld.long 0 0. " Aut "  "0 ,1 "
;tree.end

;tree "DevID"
base eapb:0x80190fc8
rgroup 0--3
line.long 0 "DevID"
bitfld.long 0 0. " DevID "  "0 ,1 "
;tree.end

;tree "Dev"
base eapb:0x80190fcc
rgroup 0--3
line.long 0 "Dev"
bitfld.long 0 0. " Dev "  "0 ,1 "
;tree.end

;tree "PeriphID4"
base eapb:0x80190fd0
rgroup 0--3
line.long 0 "PeriphID4"
bitfld.long 0 0. " PeriphID4 "  "0 ,1 "
;tree.end

;tree "PeriphID5"
base eapb:0x80190fd4
group 0--3
line.long 0 "PeriphID5"
bitfld.long 0 0. " PeriphID5 "  "0 ,1 "
;tree.end

;tree "PeriphID6"
base eapb:0x80190fd8
group 0--3
line.long 0 "PeriphID6"
bitfld.long 0 0. " PeriphID6 "  "0 ,1 "
;tree.end

;tree "PeriphID7"
base eapb:0x80190fdc
group 0--3
line.long 0 "PeriphID7"
bitfld.long 0 0. " PeriphID7 "  "0 ,1 "
;tree.end

;tree "PeriphID0"
base eapb:0x80190fe0
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0. " PeriphID0 "  "0 ,1 "
;tree.end

;tree "PeriphID1"
base eapb:0x80190fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0. " PeriphID1 "  "0 ,1 "
;tree.end

;tree "PeriphID2"
base eapb:0x80190fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0. " PeriphID2 "  "0 ,1 "
;tree.end

;tree "PeriphID3"
base eapb:0x80190fec
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0. " PeriphID3 "  "0 ,1 "
;tree.end

;tree "CompID0"
base eapb:0x80190ff0
rgroup 0--3
line.long 0 "CompID0"
bitfld.long 0 0. " CompID0 "  "0 ,1 "
;tree.end

;tree "CompID1"
base eapb:0x80190ff4
rgroup 0--3
line.long 0 "CompID1"
bitfld.long 0 0. " CompID1 "  "0 ,1 "
;tree.end

;tree "CompID2"
base eapb:0x80190ff8
rgroup 0--3
line.long 0 "CompID2"
bitfld.long 0 0. " CompID2 "  "0 ,1 "
;tree.end

;tree "CompID3"
base eapb:0x80190ffc
rgroup 0--3
line.long 0 "CompID3"
bitfld.long 0 0. " CompID3 "  "0 ,1 "
;tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "TZIC (2 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "TZIC-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1FIQSR"
base ad:0x90413000
rgroup 0--3
line.long 0 "FIQSR"
hexfld.long 0 " FIQSTATUS "
;tree.end

;tree "1RIS"
base ad:0x90413004
group 0--3
line.long 0 "RIS"
hexfld.long 0 " RIS "
;tree.end

;tree "1IS"
base ad:0x90413008
group 0--3
line.long 0 "IS"
hexfld.long 0 " INTSEL "
;tree.end

;tree "1FIQEN"
base ad:0x9041300c
group 0--3
line.long 0 "FIQEN"
hexfld.long 0 " FIQEnable "
;tree.end

;tree "1FIQENCL"
base ad:0x90413010
wgroup 0--3
line.long 0 "FIQENCL"
hexfld.long 0 " FIQENCL "
;tree.end

;tree "1FIQBP"
base ad:0x90413014
group 0--3
line.long 0 "FIQBP"
bitfld.long 0 0. " FQBP "  "0 ,1 "
;tree.end

;tree "1PROT"
base ad:0x90413018
group 0--3
line.long 0 "PROT"
bitfld.long 0 0. " PROT "  "0 ,1 "
;tree.end

;tree "1LCK"
base ad:0x9041301c
group 0--3
line.long 0 "LCK"
bitfld.long 0 0. " LOCK "  "0 ,1 "
;tree.end

;tree "1LCKSR"
base ad:0x90413020
group 0--3
line.long 0 "LCKSR"
bitfld.long 0 0. " LCKSTAT "  "0 ,1 "
;tree.end

;tree "1INTCFG"
base ad:0x90413300
group 0--3
line.long 0 "INTCFG"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "1INTIP1"
base ad:0x90413304
group 0--3
line.long 0 "INTIP1"
bitfld.long 0 6. " nTZICSFIQIN "  "0 ,1 "
bitfld.long 0 10. " nTZICNSFIQIN "  "0 ,1 "
;tree.end

;tree "1INTIP2"
base ad:0x90413308
group 0--3
line.long 0 "INTIP2"
hexfld.long 0 " TZICINTSOURCE "
;tree.end

;tree "1INTOP1"
base ad:0x9041330c
group 0--3
line.long 0 "INTOP1"
bitfld.long 0 6. " nTZICFIQ "  "0 ,1 "
;tree.end

;tree "1INTOP2"
base ad:0x90413310
group 0--3
line.long 0 "INTOP2"
hexfld.long 0 " TZICIRQOUT "
;tree.end

;tree "1PeriphID0"
base ad:0x90413fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "1PeriphID1"
base ad:0x90413fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID2"
base ad:0x90413fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID3"
base ad:0x90413fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "1PCellID0"
base ad:0x90413ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " LCDPCellID0 "
;tree.end

;tree "1PCellID1"
base ad:0x90413ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " LCDPCellID1 "
;tree.end

;tree "1PCellID2"
base ad:0x90413ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " LCDPCellID2 "
;tree.end

;tree "1PCellID3"
base ad:0x90413ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " LCDPCellID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "TZIC-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0FIQSR"
base ad:0x90412000
rgroup 0--3
line.long 0 "FIQSR"
hexfld.long 0 " FIQSTATUS "
;tree.end

;tree "0RIS"
base ad:0x90412004
group 0--3
line.long 0 "RIS"
hexfld.long 0 " RIS "
;tree.end

;tree "0IS"
base ad:0x90412008
group 0--3
line.long 0 "IS"
hexfld.long 0 " INTSEL "
;tree.end

;tree "0FIQEN"
base ad:0x9041200c
group 0--3
line.long 0 "FIQEN"
hexfld.long 0 " FIQEnable "
;tree.end

;tree "0FIQENCL"
base ad:0x90412010
wgroup 0--3
line.long 0 "FIQENCL"
hexfld.long 0 " FIQENCL "
;tree.end

;tree "0FIQBP"
base ad:0x90412014
group 0--3
line.long 0 "FIQBP"
bitfld.long 0 0. " FQBP "  "0 ,1 "
;tree.end

;tree "0PROT"
base ad:0x90412018
group 0--3
line.long 0 "PROT"
bitfld.long 0 0. " PROT "  "0 ,1 "
;tree.end

;tree "0LCK"
base ad:0x9041201c
group 0--3
line.long 0 "LCK"
bitfld.long 0 0. " LOCK "  "0 ,1 "
;tree.end

;tree "0LCKSR"
base ad:0x90412020
group 0--3
line.long 0 "LCKSR"
bitfld.long 0 0. " LCKSTAT "  "0 ,1 "
;tree.end

;tree "0INTCFG"
base ad:0x90412300
group 0--3
line.long 0 "INTCFG"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "0INTIP1"
base ad:0x90412304
group 0--3
line.long 0 "INTIP1"
bitfld.long 0 6. " nTZICSFIQIN "  "0 ,1 "
bitfld.long 0 10. " nTZICNSFIQIN "  "0 ,1 "
;tree.end

;tree "0INTIP2"
base ad:0x90412308
group 0--3
line.long 0 "INTIP2"
hexfld.long 0 " TZICINTSOURCE "
;tree.end

;tree "0INTOP1"
base ad:0x9041230c
group 0--3
line.long 0 "INTOP1"
bitfld.long 0 6. " nTZICFIQ "  "0 ,1 "
;tree.end

;tree "0INTOP2"
base ad:0x90412310
group 0--3
line.long 0 "INTOP2"
hexfld.long 0 " TZICIRQOUT "
;tree.end

;tree "0PeriphID0"
base ad:0x90412fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " Partnumber0 "
;tree.end

;tree "0PeriphID1"
base ad:0x90412fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID2"
base ad:0x90412fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID3"
base ad:0x90412fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "0PCellID0"
base ad:0x90412ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " LCDPCellID0 "
;tree.end

;tree "0PCellID1"
base ad:0x90412ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " LCDPCellID1 "
;tree.end

;tree "0PCellID2"
base ad:0x90412ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " LCDPCellID2 "
;tree.end

;tree "0PCellID3"
base ad:0x90412ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " LCDPCellID3 "
;tree.end

tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "TZICPTB"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "Xfer"
base ad:0x63300014
group 0--3
line.long 0 "Xfer"
bitfld.long 0 0. " Xfer "  "0 ,1 "
;tree.end

;tree "Ctrl0"
base ad:0x63300100
group 0--3
line.long 0 "Ctrl0"
bitfld.long 0 0. " ExtInt0 "  "0 ,1 "
bitfld.long 0 1. " ExtInt1 "  "0 ,1 "
bitfld.long 0 2. " ExtInt2 "  "0 ,1 "
bitfld.long 0 3. " ExtInt3 "  "0 ,1 "
;tree.end

;tree "PeriphID4"
base ad:0x63300fd0
rgroup 0--3
line.long 0 "PeriphID4"
bitfld.long 0 0. " PeriphID4 "  "0 ,1 "
;tree.end

;tree "PeriphID5"
base ad:0x63300fd4
rgroup 0--3
line.long 0 "PeriphID5"
bitfld.long 0 0. " PeriphID5 "  "0 ,1 "
;tree.end

;tree "PeriphID6"
base ad:0x63300fd8
rgroup 0--3
line.long 0 "PeriphID6"
bitfld.long 0 0. " PeriphID6 "  "0 ,1 "
;tree.end

;tree "PeriphID7"
base ad:0x63300fdc
rgroup 0--3
line.long 0 "PeriphID7"
bitfld.long 0 0. " PeriphID7 "  "0 ,1 "
;tree.end

;tree "PeriphID0"
base ad:0x63300fe0
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0. " PeriphID0 "  "0 ,1 "
;tree.end

;tree "PeriphID1"
base ad:0x63300fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0. " PeriphID1 "  "0 ,1 "
;tree.end

;tree "PeriphID2"
base ad:0x63300fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0. " PeriphID2 "  "0 ,1 "
;tree.end

;tree "PeriphID3"
base ad:0x63300fec
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0. " PeriphID3 "  "0 ,1 "
;tree.end

;tree "CompID0"
base ad:0x63300ff0
rgroup 0--3
line.long 0 "CompID0"
bitfld.long 0 0. " CompID0 "  "0 ,1 "
;tree.end

;tree "CompID1"
base ad:0x63300ff4
rgroup 0--3
line.long 0 "CompID1"
bitfld.long 0 0. " CompID1 "  "0 ,1 "
;tree.end

;tree "CompID2"
base ad:0x63300ff8
rgroup 0--3
line.long 0 "CompID2"
bitfld.long 0 0. " CompID2 "  "0 ,1 "
;tree.end

;tree "CompID3"
base ad:0x63300ffc
rgroup 0--3
line.long 0 "CompID3"
bitfld.long 0 0. " CompID3 "  "0 ,1 "
;tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "UART (3 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "UART-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0DR"
base ad:0x80120000
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
;tree.end

;tree "0RSR_ECR"
base ad:0x80120004
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
;tree.end

;tree "0DMAWM"
base ad:0x80120008
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "0TIMEOUT"
base ad:0x8012000c
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0. " TIMEOUT_PERIOD "  "0 ,1 "
;tree.end

;tree "0FR"
base ad:0x80120018
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
;tree.end

;tree "0LCRH_RX"
base ad:0x8012001c
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
;tree.end

;tree "0ILPR"
base ad:0x80120020
group 0--3
line.long 0 "ILPR"
hexfld.byte 0 " ILPDVSR "
;tree.end

;tree "0IBRD"
base ad:0x80120024
group 0--3
line.long 0 "IBRD"
hexfld.word 0 " DIVINT "
;tree.end

;tree "0FBRD"
base ad:0x80120028
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "0LCRH_TX"
base ad:0x8012002c
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
;tree.end

;tree "0CR"
base ad:0x80120030
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
;tree.end

;tree "0IFLS"
base ad:0x80120034
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "0IMSC"
base ad:0x80120038
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
;tree.end

;tree "0RIS"
base ad:0x8012003c
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
;tree.end

;tree "0MIS"
base ad:0x80120040
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
;tree.end

;tree "0ICR"
base ad:0x80120044
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
;tree.end

;tree "0DMACR"
base ad:0x80120048
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
;tree.end

;tree "0XFCR"
base ad:0x80120050
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
;tree.end

;tree "0XON1"
base ad:0x80120054
group 0--3
line.long 0 "XON1"
hexfld.byte 0 " XON1 "
;tree.end

;tree "0XON2"
base ad:0x80120058
group 0--3
line.long 0 "XON2"
hexfld.byte 0 " XON2 "
;tree.end

;tree "0XOFF1"
base ad:0x8012005c
group 0--3
line.long 0 "XOFF1"
hexfld.byte 0 " XOFF1 "
;tree.end

;tree "0XOFF2"
base ad:0x80120060
group 0--3
line.long 0 "XOFF2"
hexfld.byte 0 " XOFF2 "
;tree.end

;tree "0ITCR"
base ad:0x80120080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "0ITIP"
base ad:0x80120084
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
;tree.end

;tree "0ITOP"
base ad:0x80120088
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
;tree.end

;tree "0TDR"
base ad:0x8012008c
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
;tree.end

;tree "0ABCR"
base ad:0x80120100
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
;tree.end

;tree "0ABSR"
base ad:0x80120104
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " BYTE1S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
;tree.end

;tree "0ABFMT"
base ad:0x80120108
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
;tree.end

;tree "0ABDR"
base ad:0x80120150
rgroup 0--3
line.long 0 "ABDR"
hexfld.word 0 " AUTOBAUDBDR "
;tree.end

;tree "0ABDFR"
base ad:0x80120154
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "0ABMR"
base ad:0x80120158
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
;tree.end

;tree "0ABIMSC"
base ad:0x8012015c
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
;tree.end

;tree "0ABRIS"
base ad:0x80120160
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
;tree.end

;tree "0ABMIS"
base ad:0x80120164
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
;tree.end

;tree "0ABICR"
base ad:0x80120168
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
;tree.end

;tree "0PeriphID0"
base ad:0x80120fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "0PeriphID1"
base ad:0x80120fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID2"
base ad:0x80120fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0PeriphID3"
base ad:0x80120fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "0PCellID0"
base ad:0x80120ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " IDO "
;tree.end

;tree "0PCellID1"
base ad:0x80120ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " ID1 "
;tree.end

;tree "0PCellID2"
base ad:0x80120ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " ID2 "
;tree.end

;tree "0PCellID3"
base ad:0x80120ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " ID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "UART-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1DR"
base ad:0x80121000
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
;tree.end

;tree "1RSR_ECR"
base ad:0x80121004
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
;tree.end

;tree "1DMAWM"
base ad:0x80121008
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "1TIMEOUT"
base ad:0x8012100c
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0. " TIMEOUT_PERIOD "  "0 ,1 "
;tree.end

;tree "1FR"
base ad:0x80121018
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
;tree.end

;tree "1LCRH_RX"
base ad:0x8012101c
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
;tree.end

;tree "1ILPR"
base ad:0x80121020
group 0--3
line.long 0 "ILPR"
hexfld.byte 0 " ILPDVSR "
;tree.end

;tree "1IBRD"
base ad:0x80121024
group 0--3
line.long 0 "IBRD"
hexfld.word 0 " DIVINT "
;tree.end

;tree "1FBRD"
base ad:0x80121028
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "1LCRH_TX"
base ad:0x8012102c
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
;tree.end

;tree "1CR"
base ad:0x80121030
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
;tree.end

;tree "1IFLS"
base ad:0x80121034
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "1IMSC"
base ad:0x80121038
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
;tree.end

;tree "1RIS"
base ad:0x8012103c
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
;tree.end

;tree "1MIS"
base ad:0x80121040
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
;tree.end

;tree "1ICR"
base ad:0x80121044
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
;tree.end

;tree "1DMACR"
base ad:0x80121048
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
;tree.end

;tree "1XFCR"
base ad:0x80121050
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
;tree.end

;tree "1XON1"
base ad:0x80121054
group 0--3
line.long 0 "XON1"
hexfld.byte 0 " XON1 "
;tree.end

;tree "1XON2"
base ad:0x80121058
group 0--3
line.long 0 "XON2"
hexfld.byte 0 " XON2 "
;tree.end

;tree "1XOFF1"
base ad:0x8012105c
group 0--3
line.long 0 "XOFF1"
hexfld.byte 0 " XOFF1 "
;tree.end

;tree "1XOFF2"
base ad:0x80121060
group 0--3
line.long 0 "XOFF2"
hexfld.byte 0 " XOFF2 "
;tree.end

;tree "1ITCR"
base ad:0x80121080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "1ITIP"
base ad:0x80121084
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
;tree.end

;tree "1ITOP"
base ad:0x80121088
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
;tree.end

;tree "1TDR"
base ad:0x8012108c
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
;tree.end

;tree "1ABCR"
base ad:0x80121100
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
;tree.end

;tree "1ABSR"
base ad:0x80121104
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " BYTE1S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
;tree.end

;tree "1ABFMT"
base ad:0x80121108
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
;tree.end

;tree "1ABDR"
base ad:0x80121150
rgroup 0--3
line.long 0 "ABDR"
hexfld.word 0 " AUTOBAUDBDR "
;tree.end

;tree "1ABDFR"
base ad:0x80121154
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "1ABMR"
base ad:0x80121158
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
;tree.end

;tree "1ABIMSC"
base ad:0x8012115c
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
;tree.end

;tree "1ABRIS"
base ad:0x80121160
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
;tree.end

;tree "1ABMIS"
base ad:0x80121164
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
;tree.end

;tree "1ABICR"
base ad:0x80121168
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
;tree.end

;tree "1PeriphID0"
base ad:0x80121fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "1PeriphID1"
base ad:0x80121fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID2"
base ad:0x80121fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1PeriphID3"
base ad:0x80121fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "1PCellID0"
base ad:0x80121ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " IDO "
;tree.end

;tree "1PCellID1"
base ad:0x80121ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " ID1 "
;tree.end

;tree "1PCellID2"
base ad:0x80121ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " ID2 "
;tree.end

;tree "1PCellID3"
base ad:0x80121ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " ID3 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "UART-2"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "2DR"
base ad:0x80007000
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
;tree.end

;tree "2RSR_ECR"
base ad:0x80007004
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
;tree.end

;tree "2DMAWM"
base ad:0x80007008
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXDMAWM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "2TIMEOUT"
base ad:0x8000700c
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0. " TIMEOUT_PERIOD "  "0 ,1 "
;tree.end

;tree "2FR"
base ad:0x80007018
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
;tree.end

;tree "2LCRH_RX"
base ad:0x8000701c
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
;tree.end

;tree "2ILPR"
base ad:0x80007020
group 0--3
line.long 0 "ILPR"
hexfld.byte 0 " ILPDVSR "
;tree.end

;tree "2IBRD"
base ad:0x80007024
group 0--3
line.long 0 "IBRD"
hexfld.word 0 " DIVINT "
;tree.end

;tree "2FBRD"
base ad:0x80007028
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "2LCRH_TX"
base ad:0x8000702c
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
;tree.end

;tree "2CR"
base ad:0x80007030
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
;tree.end

;tree "2IFLS"
base ad:0x80007034
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " RXIFLSEL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "2IMSC"
base ad:0x80007038
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
;tree.end

;tree "2RIS"
base ad:0x8000703c
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
;tree.end

;tree "2MIS"
base ad:0x80007040
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
;tree.end

;tree "2ICR"
base ad:0x80007044
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
;tree.end

;tree "2DMACR"
base ad:0x80007048
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
;tree.end

;tree "2XFCR"
base ad:0x80007050
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
;tree.end

;tree "2XON1"
base ad:0x80007054
group 0--3
line.long 0 "XON1"
hexfld.byte 0 " XON1 "
;tree.end

;tree "2XON2"
base ad:0x80007058
group 0--3
line.long 0 "XON2"
hexfld.byte 0 " XON2 "
;tree.end

;tree "2XOFF1"
base ad:0x8000705c
group 0--3
line.long 0 "XOFF1"
hexfld.byte 0 " XOFF1 "
;tree.end

;tree "2XOFF2"
base ad:0x80007060
group 0--3
line.long 0 "XOFF2"
hexfld.byte 0 " XOFF2 "
;tree.end

;tree "2ITCR"
base ad:0x80007080
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
;tree.end

;tree "2ITIP"
base ad:0x80007084
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
;tree.end

;tree "2ITOP"
base ad:0x80007088
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
;tree.end

;tree "2TDR"
base ad:0x8000708c
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
;tree.end

;tree "2ABCR"
base ad:0x80007100
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
;tree.end

;tree "2ABSR"
base ad:0x80007104
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--7. " BYTE1S "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  "0 ,1 ,2 ,3 "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
;tree.end

;tree "2ABFMT"
base ad:0x80007108
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
;tree.end

;tree "2ABDR"
base ad:0x80007150
rgroup 0--3
line.long 0 "ABDR"
hexfld.word 0 " AUTOBAUDBDR "
;tree.end

;tree "2ABDFR"
base ad:0x80007154
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "2ABMR"
base ad:0x80007158
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
;tree.end

;tree "2ABIMSC"
base ad:0x8000715c
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
;tree.end

;tree "2ABRIS"
base ad:0x80007160
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
;tree.end

;tree "2ABMIS"
base ad:0x80007164
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
;tree.end

;tree "2ABICR"
base ad:0x80007168
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
;tree.end

;tree "2PeriphID0"
base ad:0x80007fe0
rgroup 0--3
line.long 0 "PeriphID0"
hexfld.byte 0 " PartNumber0 "
;tree.end

;tree "2PeriphID1"
base ad:0x80007fe4
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Designer0 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2PeriphID2"
base ad:0x80007fe8
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4.--7. " Revision "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2PeriphID3"
base ad:0x80007fec
rgroup 0--3
line.long 0 "PeriphID3"
hexfld.byte 0 " Configuration "
;tree.end

;tree "2PCellID0"
base ad:0x80007ff0
rgroup 0--3
line.long 0 "PCellID0"
hexfld.byte 0 " IDO "
;tree.end

;tree "2PCellID1"
base ad:0x80007ff4
rgroup 0--3
line.long 0 "PCellID1"
hexfld.byte 0 " ID1 "
;tree.end

;tree "2PCellID2"
base ad:0x80007ff8
rgroup 0--3
line.long 0 "PCellID2"
hexfld.byte 0 " ID2 "
;tree.end

;tree "2PCellID3"
base ad:0x80007ffc
rgroup 0--3
line.long 0 "PCellID3"
hexfld.byte 0 " ID3 "
;tree.end

tree.end

tree.end

;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
tree "UARTTB (3 instances)"
;AAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAAA
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "UARTTB-0"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "0DR"
base ad:0x63380000
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
;tree.end

;tree "0RSR"
base ad:0x63380004
group 0--3
line.long 0 "RSR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1. " FE "  "0 ,1 "
;tree.end

;tree "0LCR_H"
base ad:0x63380008
group 0--3
line.long 0 "LCR_H"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " BITSFT_ENABLE "  "0 ,1 "
;tree.end

;tree "0LCR_M"
base ad:0x6338000c
group 0--3
line.long 0 "LCR_M"
hexfld.byte 0 " BAUD_DIVMS "
;tree.end

;tree "0LCR_L"
base ad:0x63380010
group 0--3
line.long 0 "LCR_L"
hexfld.byte 0 " BAUD_DIVLS "
;tree.end

;tree "0CR"
base ad:0x63380014
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " TB_ENABLE "  "0 ,1 "
bitfld.long 0 1. " IrDA_ENABLE "  "0 ,1 "
bitfld.long 0 2. " IrDA_LPWRMODE "  "0 ,1 "
bitfld.long 0 3.--6. " IrDA_DEC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 7. " FR_ENABLE "  "0 ,1 "
;tree.end

;tree "0INTR"
base ad:0x63380018
group 0--3
line.long 0 "INTR"
bitfld.long 0 0. " MIS "  "0 ,1 "
bitfld.long 0 1. " RIS "  "0 ,1 "
bitfld.long 0 2. " TIS "  "0 ,1 "
bitfld.long 0 3. " RTIS "  "0 ,1 "
bitfld.long 0 4. " UARTINTR "  "0 ,1 "
bitfld.long 0 5. " UARTEINTR "  "0 ,1 "
bitfld.long 0 7. " ERROR "  "0 ,1 "
;tree.end

;tree "0FR"
base ad:0x6338001c
group 0--3
line.long 0 "FR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXHF "  "0 ,1 "
bitfld.long 0 2. " RXFF "  "0 ,1 "
bitfld.long 0 3. " TXFE "  "0 ,1 "
bitfld.long 0 4. " TXHE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " TXBUSY "  "0 ,1 "
bitfld.long 0 7. " RXBUSY "  "0 ,1 "
bitfld.long 0 8. " RTXDIS "  "0 ,1 "
;tree.end

;tree "0FREQ_CTR_ERR"
base ad:0x63380020
group 0--3
line.long 0 "FREQ_CTR_ERR"
bitfld.long 0 0. " FREQ_CTR_ERR "  "0 ,1 "
;tree.end

;tree "0FORCED_ERRS"
base ad:0x63380024
group 0--3
line.long 0 "FORCED_ERRS"
bitfld.long 0 0. " PARITY_ERROR "  "0 ,1 "
bitfld.long 0 1. " FRAME_ERROR "  "0 ,1 "
bitfld.long 0 2.--3. " TX_JIT_FACT "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " TX_JIT_SIGN "  "0 ,1 "
bitfld.long 0 5.--6. " RX_JIT_FACT "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " RX_JIT_SIGN "  "0 ,1 "
;tree.end

;tree "0SET_PINS"
base ad:0x63380028
group 0--3
line.long 0 "SET_PINS"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DCD "  "0 ,1 "
bitfld.long 0 2. " DSR "  "0 ,1 "
bitfld.long 0 3. " RX "  "0 ,1 "
bitfld.long 0 4. " SIRIN "  "0 ,1 "
bitfld.long 0 5. " RI "  "0 ,1 "
bitfld.long 0 7. " SCANMODE "  "0 ,1 "
;tree.end

;tree "0CHECK_PINS"
base ad:0x6338002c
group 0--3
line.long 0 "CHECK_PINS"
bitfld.long 0 0. " UARTTXD "  "0 ,1 "
bitfld.long 0 1. " nSIROUT "  "0 ,1 "
bitfld.long 0 2. " DTR "  "0 ,1 "
bitfld.long 0 3. " RTS "  "0 ,1 "
bitfld.long 0 4. " Out1 "  "0 ,1 "
bitfld.long 0 5. " Out2 "  "0 ,1 "
;tree.end

;tree "0ILPR"
base ad:0x63380030
group 0--3
line.long 0 "ILPR"
bitfld.long 0 0.--3. " IRLP_DVSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "0BITSFT_DATA"
base ad:0x63380034
group 0--3
line.long 0 "BITSFT_DATA"
bitfld.long 0 0.--1. " SHIFT_FACTOR "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " END_PULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--7. " START_PULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "0BITSFT_DATA_2"
base ad:0x63380038
group 0--3
line.long 0 "BITSFT_DATA_2"
bitfld.long 0 0.--2. " SHIFT_FACTOR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " PULSE_NO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "0CLKREG"
base ad:0x6338003c
group 0--3
line.long 0 "CLKREG"
hexfld.byte 0 " UARTCLK "
;tree.end

;tree "0RSTMODE_REG"
base ad:0x63380040
group 0--3
line.long 0 "RSTMODE_REG"
bitfld.long 0 0. " RESETBIT "  "0 ,1 "
bitfld.long 0 1. " CLKSTATUS "  "0 ,1 "
bitfld.long 0 2. " PCLKGEN "  "0 ,1 "
bitfld.long 0 3. " REFCLKGEN "  "0 ,1 "
bitfld.long 0 4. " REFCLKON "  "0 ,1 "
bitfld.long 0 5. " PCLKON "  "0 ,1 "
;tree.end

;tree "0DMACR"
base ad:0x63380044
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " UARTTXDMACLR "  "0 ,1 "
bitfld.long 0 1. " UARTRXDMACLR "  "0 ,1 "
bitfld.long 0 2. " UARTTXDMASREQ "  "0 ,1 "
bitfld.long 0 3. " UARTRXDMASREQ "  "0 ,1 "
bitfld.long 0 4. " UARTTXDMABREQ "  "0 ,1 "
bitfld.long 0 5. " UARTRXDMABREQ "  "0 ,1 "
;tree.end

;tree "0STPARITY"
base ad:0x63380048
group 0--3
line.long 0 "STPARITY"
bitfld.long 0 7. " SPS "  "0 ,1 "
;tree.end

;tree "0FBRD"
base ad:0x6338004c
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " FBRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "0ITVM"
base ad:0x63380050
group 0--3
line.long 0 "ITVM"
bitfld.long 0 0. " ITVM "  "0 ,1 "
;tree.end

;tree "0INTRAB"
base ad:0x63380054
group 0--3
line.long 0 "INTRAB"
bitfld.long 0 0. " INTRAB "  "0 ,1 "
;tree.end

;tree "0ACR"
base ad:0x63380058
group 0--3
line.long 0 "ACR"
bitfld.long 0 0. " SWFCEn "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHAR "  "0 ,1 "
;tree.end

;tree "0XON1"
base ad:0x6338005c
group 0--3
line.long 0 "XON1"
bitfld.long 0 0. " XON1 "  "0 ,1 "
;tree.end

;tree "0XON2"
base ad:0x63380060
group 0--3
line.long 0 "XON2"
bitfld.long 0 0. " XON2 "  "0 ,1 "
;tree.end

;tree "0XOFF1"
base ad:0x63380064
group 0--3
line.long 0 "XOFF1"
bitfld.long 0 0. " XOFF1 "  "0 ,1 "
;tree.end

;tree "0XOFF2"
base ad:0x63380068
group 0--3
line.long 0 "XOFF2"
bitfld.long 0 0. " XOFF2 "  "0 ,1 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "UARTTB-1"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "1DR"
base ad:0x63400000
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
;tree.end

;tree "1RSR"
base ad:0x63400004
group 0--3
line.long 0 "RSR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1. " FE "  "0 ,1 "
;tree.end

;tree "1LCR_H"
base ad:0x63400008
group 0--3
line.long 0 "LCR_H"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " BITSFT_ENABLE "  "0 ,1 "
;tree.end

;tree "1LCR_M"
base ad:0x6340000c
group 0--3
line.long 0 "LCR_M"
hexfld.byte 0 " BAUD_DIVMS "
;tree.end

;tree "1LCR_L"
base ad:0x63400010
group 0--3
line.long 0 "LCR_L"
hexfld.byte 0 " BAUD_DIVLS "
;tree.end

;tree "1CR"
base ad:0x63400014
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " TB_ENABLE "  "0 ,1 "
bitfld.long 0 1. " IrDA_ENABLE "  "0 ,1 "
bitfld.long 0 2. " IrDA_LPWRMODE "  "0 ,1 "
bitfld.long 0 3.--6. " IrDA_DEC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 7. " FR_ENABLE "  "0 ,1 "
;tree.end

;tree "1INTR"
base ad:0x63400018
group 0--3
line.long 0 "INTR"
bitfld.long 0 0. " MIS "  "0 ,1 "
bitfld.long 0 1. " RIS "  "0 ,1 "
bitfld.long 0 2. " TIS "  "0 ,1 "
bitfld.long 0 3. " RTIS "  "0 ,1 "
bitfld.long 0 4. " UARTINTR "  "0 ,1 "
bitfld.long 0 5. " UARTEINTR "  "0 ,1 "
bitfld.long 0 7. " ERROR "  "0 ,1 "
;tree.end

;tree "1FR"
base ad:0x6340001c
group 0--3
line.long 0 "FR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXHF "  "0 ,1 "
bitfld.long 0 2. " RXFF "  "0 ,1 "
bitfld.long 0 3. " TXFE "  "0 ,1 "
bitfld.long 0 4. " TXHE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " TXBUSY "  "0 ,1 "
bitfld.long 0 7. " RXBUSY "  "0 ,1 "
bitfld.long 0 8. " RTXDIS "  "0 ,1 "
;tree.end

;tree "1FREQ_CTR_ERR"
base ad:0x63400020
group 0--3
line.long 0 "FREQ_CTR_ERR"
bitfld.long 0 0. " FREQ_CTR_ERR "  "0 ,1 "
;tree.end

;tree "1FORCED_ERRS"
base ad:0x63400024
group 0--3
line.long 0 "FORCED_ERRS"
bitfld.long 0 0. " PARITY_ERROR "  "0 ,1 "
bitfld.long 0 1. " FRAME_ERROR "  "0 ,1 "
bitfld.long 0 2.--3. " TX_JIT_FACT "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " TX_JIT_SIGN "  "0 ,1 "
bitfld.long 0 5.--6. " RX_JIT_FACT "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " RX_JIT_SIGN "  "0 ,1 "
;tree.end

;tree "1SET_PINS"
base ad:0x63400028
group 0--3
line.long 0 "SET_PINS"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DCD "  "0 ,1 "
bitfld.long 0 2. " DSR "  "0 ,1 "
bitfld.long 0 3. " RX "  "0 ,1 "
bitfld.long 0 4. " SIRIN "  "0 ,1 "
bitfld.long 0 5. " RI "  "0 ,1 "
bitfld.long 0 7. " SCANMODE "  "0 ,1 "
;tree.end

;tree "1CHECK_PINS"
base ad:0x6340002c
group 0--3
line.long 0 "CHECK_PINS"
bitfld.long 0 0. " UARTTXD "  "0 ,1 "
bitfld.long 0 1. " nSIROUT "  "0 ,1 "
bitfld.long 0 2. " DTR "  "0 ,1 "
bitfld.long 0 3. " RTS "  "0 ,1 "
bitfld.long 0 4. " Out1 "  "0 ,1 "
bitfld.long 0 5. " Out2 "  "0 ,1 "
;tree.end

;tree "1ILPR"
base ad:0x63400030
group 0--3
line.long 0 "ILPR"
bitfld.long 0 0.--3. " IRLP_DVSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "1BITSFT_DATA"
base ad:0x63400034
group 0--3
line.long 0 "BITSFT_DATA"
bitfld.long 0 0.--1. " SHIFT_FACTOR "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " END_PULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--7. " START_PULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "1BITSFT_DATA_2"
base ad:0x63400038
group 0--3
line.long 0 "BITSFT_DATA_2"
bitfld.long 0 0.--2. " SHIFT_FACTOR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " PULSE_NO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "1CLKREG"
base ad:0x6340003c
group 0--3
line.long 0 "CLKREG"
hexfld.byte 0 " UARTCLK "
;tree.end

;tree "1RSTMODE_REG"
base ad:0x63400040
group 0--3
line.long 0 "RSTMODE_REG"
bitfld.long 0 0. " RESETBIT "  "0 ,1 "
bitfld.long 0 1. " CLKSTATUS "  "0 ,1 "
bitfld.long 0 2. " PCLKGEN "  "0 ,1 "
bitfld.long 0 3. " REFCLKGEN "  "0 ,1 "
bitfld.long 0 4. " REFCLKON "  "0 ,1 "
bitfld.long 0 5. " PCLKON "  "0 ,1 "
;tree.end

;tree "1DMACR"
base ad:0x63400044
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " UARTTXDMACLR "  "0 ,1 "
bitfld.long 0 1. " UARTRXDMACLR "  "0 ,1 "
bitfld.long 0 2. " UARTTXDMASREQ "  "0 ,1 "
bitfld.long 0 3. " UARTRXDMASREQ "  "0 ,1 "
bitfld.long 0 4. " UARTTXDMABREQ "  "0 ,1 "
bitfld.long 0 5. " UARTRXDMABREQ "  "0 ,1 "
;tree.end

;tree "1STPARITY"
base ad:0x63400048
group 0--3
line.long 0 "STPARITY"
bitfld.long 0 7. " SPS "  "0 ,1 "
;tree.end

;tree "1FBRD"
base ad:0x6340004c
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " FBRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "1ITVM"
base ad:0x63400050
group 0--3
line.long 0 "ITVM"
bitfld.long 0 0. " ITVM "  "0 ,1 "
;tree.end

;tree "1INTRAB"
base ad:0x63400054
group 0--3
line.long 0 "INTRAB"
bitfld.long 0 0. " INTRAB "  "0 ,1 "
;tree.end

;tree "1ACR"
base ad:0x63400058
group 0--3
line.long 0 "ACR"
bitfld.long 0 0. " SWFCEn "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHAR "  "0 ,1 "
;tree.end

;tree "1XON1"
base ad:0x6340005c
group 0--3
line.long 0 "XON1"
bitfld.long 0 0. " XON1 "  "0 ,1 "
;tree.end

;tree "1XON2"
base ad:0x63400060
group 0--3
line.long 0 "XON2"
bitfld.long 0 0. " XON2 "  "0 ,1 "
;tree.end

;tree "1XOFF1"
base ad:0x63400064
group 0--3
line.long 0 "XOFF1"
bitfld.long 0 0. " XOFF1 "  "0 ,1 "
;tree.end

;tree "1XOFF2"
base ad:0x63400068
group 0--3
line.long 0 "XOFF2"
bitfld.long 0 0. " XOFF2 "  "0 ,1 "
;tree.end

tree.end

;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
tree "UARTTB-2"
;CCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCCC
;tree "2DR"
base ad:0x63480000
group 0--3
line.long 0 "DR"
hexfld.byte 0 " DATA "
;tree.end

;tree "2RSR"
base ad:0x63480004
group 0--3
line.long 0 "RSR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1. " FE "  "0 ,1 "
;tree.end

;tree "2LCR_H"
base ad:0x63480008
group 0--3
line.long 0 "LCR_H"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " BITSFT_ENABLE "  "0 ,1 "
;tree.end

;tree "2LCR_M"
base ad:0x6348000c
group 0--3
line.long 0 "LCR_M"
hexfld.byte 0 " BAUD_DIVMS "
;tree.end

;tree "2LCR_L"
base ad:0x63480010
group 0--3
line.long 0 "LCR_L"
hexfld.byte 0 " BAUD_DIVLS "
;tree.end

;tree "2CR"
base ad:0x63480014
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " TB_ENABLE "  "0 ,1 "
bitfld.long 0 1. " IrDA_ENABLE "  "0 ,1 "
bitfld.long 0 2. " IrDA_LPWRMODE "  "0 ,1 "
bitfld.long 0 3.--6. " IrDA_DEC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 7. " FR_ENABLE "  "0 ,1 "
;tree.end

;tree "2INTR"
base ad:0x63480018
group 0--3
line.long 0 "INTR"
bitfld.long 0 0. " MIS "  "0 ,1 "
bitfld.long 0 1. " RIS "  "0 ,1 "
bitfld.long 0 2. " TIS "  "0 ,1 "
bitfld.long 0 3. " RTIS "  "0 ,1 "
bitfld.long 0 4. " UARTINTR "  "0 ,1 "
bitfld.long 0 5. " UARTEINTR "  "0 ,1 "
bitfld.long 0 7. " ERROR "  "0 ,1 "
;tree.end

;tree "2FR"
base ad:0x6348001c
group 0--3
line.long 0 "FR"
bitfld.long 0 0. " RXFE "  "0 ,1 "
bitfld.long 0 1. " RXHF "  "0 ,1 "
bitfld.long 0 2. " RXFF "  "0 ,1 "
bitfld.long 0 3. " TXFE "  "0 ,1 "
bitfld.long 0 4. " TXHE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " TXBUSY "  "0 ,1 "
bitfld.long 0 7. " RXBUSY "  "0 ,1 "
bitfld.long 0 8. " RTXDIS "  "0 ,1 "
;tree.end

;tree "2FREQ_CTR_ERR"
base ad:0x63480020
group 0--3
line.long 0 "FREQ_CTR_ERR"
bitfld.long 0 0. " FREQ_CTR_ERR "  "0 ,1 "
;tree.end

;tree "2FORCED_ERRS"
base ad:0x63480024
group 0--3
line.long 0 "FORCED_ERRS"
bitfld.long 0 0. " PARITY_ERROR "  "0 ,1 "
bitfld.long 0 1. " FRAME_ERROR "  "0 ,1 "
bitfld.long 0 2.--3. " TX_JIT_FACT "  "0 ,1 ,2 ,3 "
bitfld.long 0 4. " TX_JIT_SIGN "  "0 ,1 "
bitfld.long 0 5.--6. " RX_JIT_FACT "  "0 ,1 ,2 ,3 "
bitfld.long 0 7. " RX_JIT_SIGN "  "0 ,1 "
;tree.end

;tree "2SET_PINS"
base ad:0x63480028
group 0--3
line.long 0 "SET_PINS"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DCD "  "0 ,1 "
bitfld.long 0 2. " DSR "  "0 ,1 "
bitfld.long 0 3. " RX "  "0 ,1 "
bitfld.long 0 4. " SIRIN "  "0 ,1 "
bitfld.long 0 5. " RI "  "0 ,1 "
bitfld.long 0 7. " SCANMODE "  "0 ,1 "
;tree.end

;tree "2CHECK_PINS"
base ad:0x6348002c
group 0--3
line.long 0 "CHECK_PINS"
bitfld.long 0 0. " UARTTXD "  "0 ,1 "
bitfld.long 0 1. " nSIROUT "  "0 ,1 "
bitfld.long 0 2. " DTR "  "0 ,1 "
bitfld.long 0 3. " RTS "  "0 ,1 "
bitfld.long 0 4. " Out1 "  "0 ,1 "
bitfld.long 0 5. " Out2 "  "0 ,1 "
;tree.end

;tree "2ILPR"
base ad:0x63480030
group 0--3
line.long 0 "ILPR"
bitfld.long 0 0.--3. " IRLP_DVSR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "2BITSFT_DATA"
base ad:0x63480034
group 0--3
line.long 0 "BITSFT_DATA"
bitfld.long 0 0.--1. " SHIFT_FACTOR "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--4. " END_PULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 5.--7. " START_PULSE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "2BITSFT_DATA_2"
base ad:0x63480038
group 0--3
line.long 0 "BITSFT_DATA_2"
bitfld.long 0 0.--2. " SHIFT_FACTOR "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 3.--5. " PULSE_NO "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "2CLKREG"
base ad:0x6348003c
group 0--3
line.long 0 "CLKREG"
hexfld.byte 0 " UARTCLK "
;tree.end

;tree "2RSTMODE_REG"
base ad:0x63480040
group 0--3
line.long 0 "RSTMODE_REG"
bitfld.long 0 0. " RESETBIT "  "0 ,1 "
bitfld.long 0 1. " CLKSTATUS "  "0 ,1 "
bitfld.long 0 2. " PCLKGEN "  "0 ,1 "
bitfld.long 0 3. " REFCLKGEN "  "0 ,1 "
bitfld.long 0 4. " REFCLKON "  "0 ,1 "
bitfld.long 0 5. " PCLKON "  "0 ,1 "
;tree.end

;tree "2DMACR"
base ad:0x63480044
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " UARTTXDMACLR "  "0 ,1 "
bitfld.long 0 1. " UARTRXDMACLR "  "0 ,1 "
bitfld.long 0 2. " UARTTXDMASREQ "  "0 ,1 "
bitfld.long 0 3. " UARTRXDMASREQ "  "0 ,1 "
bitfld.long 0 4. " UARTTXDMABREQ "  "0 ,1 "
bitfld.long 0 5. " UARTRXDMABREQ "  "0 ,1 "
;tree.end

;tree "2STPARITY"
base ad:0x63480048
group 0--3
line.long 0 "STPARITY"
bitfld.long 0 7. " SPS "  "0 ,1 "
;tree.end

;tree "2FBRD"
base ad:0x6348004c
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " FBRD "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
;tree.end

;tree "2ITVM"
base ad:0x63480050
group 0--3
line.long 0 "ITVM"
bitfld.long 0 0. " ITVM "  "0 ,1 "
;tree.end

;tree "2INTRAB"
base ad:0x63480054
group 0--3
line.long 0 "INTRAB"
bitfld.long 0 0. " INTRAB "  "0 ,1 "
;tree.end

;tree "2ACR"
base ad:0x63480058
group 0--3
line.long 0 "ACR"
bitfld.long 0 0. " SWFCEn "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 3.--4. " SFTMOD "  "0 ,1 ,2 ,3 "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHAR "  "0 ,1 "
;tree.end

;tree "2XON1"
base ad:0x6348005c
group 0--3
line.long 0 "XON1"
bitfld.long 0 0. " XON1 "  "0 ,1 "
;tree.end

;tree "2XON2"
base ad:0x63480060
group 0--3
line.long 0 "XON2"
bitfld.long 0 0. " XON2 "  "0 ,1 "
;tree.end

;tree "2XOFF1"
base ad:0x63480064
group 0--3
line.long 0 "XOFF1"
bitfld.long 0 0. " XOFF1 "  "0 ,1 "
;tree.end

;tree "2XOFF2"
base ad:0x63480068
group 0--3
line.long 0 "XOFF2"
bitfld.long 0 0. " XOFF2 "  "0 ,1 "
;tree.end

tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "VSENS"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "VSENS_CTRL"
base ad:0x80159600
group 0--3
line.long 0 "VSENS_CTRL"
bitfld.long 0 0. " START "  "0 ,1 "
bitfld.long 0 16.--17. " CALMODE "  "0 ,1 ,2 ,3 "
;tree.end

;tree "VSENS_STATUS"
base ad:0x80159604
rgroup 0--3
line.long 0 "VSENS_STATUS"
bitfld.long 0 0.--3. " DATA_COUNT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 4. " OVERFLOW "  "0 ,1 "
bitfld.long 0 5. " IT_STATUS "  "0 ,1 "
bitfld.long 0 6. " ON "  "0 ,1 "
bitfld.long 0 7. " CALDONE "  "0 ,1 "
;tree.end

;tree "VSENS_IT_CLR"
base ad:0x80159608
wgroup 0--3
line.long 0 "VSENS_IT_CLR"
bitfld.long 0 0. " IT_CLR "  "0 ,1 "
;tree.end

;tree "VSENS_CLKDIV"
base ad:0x8015960c
group 0--3
line.long 0 "VSENS_CLKDIV"
hexfld.byte 0 " CLKDIV "
;tree.end

;tree "VSENS_MEANFILTER"
base ad:0x80159610
group 0--3
line.long 0 "VSENS_MEANFILTER"
bitfld.long 0 0.--1. " MEANFILTER "  "0 ,1 ,2 ,3 "
;tree.end

;tree "VSENS_TRIM"
base ad:0x80159614
group 0--3
line.long 0 "VSENS_TRIM"
bitfld.long 0 0.--5. " TRIM "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--10. " TRIM_DAC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--15. " ADC_OFFSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "VSENS_VOLTAGE"
base ad:0x80159618
rgroup 0--3
line.long 0 "VSENS_VOLTAGE"
bitfld.long 0 0.--6. " VOLT "  " "
bitfld.long 0 7. " OVERFLOW "  "0 ,1 "
;tree.end

tree.end

;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
tree "PL310"
;DDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDDD
;tree "ID"
base ad:0xa0412000
rgroup 0--3
line.long 0 "ID"
bitfld.long 0 0.--5. " REL "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
bitfld.long 0 6.--9. " PART "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
bitfld.long 0 10.--15. " ID "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F ,20 ,21 ,22 ,23 ,24 ,25 ,26 ,27 ,28 ,29 ,2A ,2B ,2C ,2D ,2E ,2F ,30 ,31 ,32 ,33 ,34 ,35 ,36 ,37 ,38 ,39 ,3A ,3B ,3C ,3D ,3E ,3F "
hexfld.byte 3 " IMPL "
;tree.end

;tree "Type"
base ad:0xa0412004
rgroup 0--3
line.long 0 "Type"
bitfld.long 0 0. " ILINELEN "  "0 ,1 "
bitfld.long 0 5. " IASSOC "  "0 ,1 "
bitfld.long 0 6.--10. " ISIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 11.--12. " DLINELEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 17. " DASSOC "  "0 ,1 "
bitfld.long 0 18.--22. " DSIZE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
bitfld.long 0 23. " H "  "0 ,1 "
bitfld.long 0 24.--27. " CTYPE "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "Control"
base ad:0xa0412100
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " EN "  "0 ,1 "
;tree.end

;tree "AuxControl"
base ad:0xa0412104
group 0--3
line.long 0 "AuxControl"
bitfld.long 0 0. " FLZE "  "0 ,1 "
bitfld.long 0 10. " HPRE "  "0 ,1 "
bitfld.long 0 12. " EXCONF "  "0 ,1 "
bitfld.long 0 13. " SAIE "  "0 ,1 "
bitfld.long 0 16. " ASSOC "  "0 ,1 "
bitfld.long 0 17.--19. " WAYSZ "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 20. " EMBEN "  "0 ,1 "
bitfld.long 0 21. " PAREN "  "0 ,1 "
bitfld.long 0 22. " SAOEN "  "0 ,1 "
bitfld.long 0 23.--24. " FWALLOC "  "0 ,1 ,2 ,3 "
bitfld.long 0 26. " NSLCKEN "  "0 ,1 "
bitfld.long 0 27. " NSIAC "  "0 ,1 "
bitfld.long 0 28. " DPFEN "  "0 ,1 "
bitfld.long 0 29. " IPFEN "  "0 ,1 "
bitfld.long 0 30. " EBRESPEN "  "0 ,1 "
;tree.end

;tree "TagLatControl"
base ad:0xa0412108
group 0--3
line.long 0 "TagLatControl"
bitfld.long 0 0.--2. " SLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " RLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " WLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "DataLatControl"
base ad:0xa041210c
group 0--3
line.long 0 "DataLatControl"
bitfld.long 0 0.--2. " SLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 4.--6. " RLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
bitfld.long 0 8.--10. " WLAT "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 "
;tree.end

;tree "EventCountControl"
base ad:0xa0412200
group 0--3
line.long 0 "EventCountControl"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 1.--2. " RES "  "0 ,1 ,2 ,3 "
;tree.end

;tree "EventCount1Conf"
base ad:0xa0412204
group 0--3
line.long 0 "EventCount1Conf"
bitfld.long 0 0.--1. " EVINTGEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--5. " EVSRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EventCount0Conf"
base ad:0xa0412208
group 0--3
line.long 0 "EventCount0Conf"
bitfld.long 0 0.--1. " EVINTGEN "  "0 ,1 ,2 ,3 "
bitfld.long 0 2.--5. " EVSRC "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "EventCount1Value"
base ad:0xa041220c
group 0--3
line.long 0 "EventCount1Value"
hexfld.long 0 " DATA "
;tree.end

;tree "EventCount0Value"
base ad:0xa0412210
group 0--3
line.long 0 "EventCount0Value"
hexfld.long 0 " DATA "
;tree.end

;tree "IntMask"
base ad:0xa0412214
group 0--3
line.long 0 "IntMask"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
;tree.end

;tree "MaskedIntStatus"
base ad:0xa0412218
rgroup 0--3
line.long 0 "MaskedIntStatus"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
;tree.end

;tree "RawIntStatus"
base ad:0xa041221c
rgroup 0--3
line.long 0 "RawIntStatus"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
;tree.end

;tree "IntClear"
base ad:0xa0412220
wgroup 0--3
line.long 0 "IntClear"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
;tree.end

;tree "CacheSync"
base ad:0xa0412730
group 0--3
line.long 0 "CacheSync"
hexfld.long 0 " SYNC "
;tree.end

;tree "InvalidateLine"
base ad:0xa0412770
group 0--3
line.long 0 "InvalidateLine"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
;tree.end

;tree "InvalidateByWay"
base ad:0xa041277c
group 0--3
line.long 0 "InvalidateByWay"
hexfld.word 0 " WAYBITS "
;tree.end

;tree "CleanLine"
base ad:0xa04127b0
group 0--3
line.long 0 "CleanLine"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
;tree.end

;tree "CleanLineByWay"
base ad:0xa04127b8
group 0--3
line.long 0 "CleanLineByWay"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 28.--31. " WAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CleanByWay"
base ad:0xa04127bc
group 0--3
line.long 0 "CleanByWay"
hexfld.word 0 " WAYBITS "
;tree.end

;tree "CleanInvLine"
base ad:0xa04127f0
group 0--3
line.long 0 "CleanInvLine"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
;tree.end

;tree "CleanInvLineByWay"
base ad:0xa04127f8
group 0--3
line.long 0 "CleanInvLineByWay"
bitfld.long 0 0. " C "  "0 ,1 "
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 28.--31. " WAY "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F "
;tree.end

;tree "CleanInvByWay"
base ad:0xa04127fc
group 0--3
line.long 0 "CleanInvByWay"
hexfld.word 0 " WAYBITS "
;tree.end

;tree "DataLockdownByWay_0"
base ad:0xa0412900
group 0--3
line.long 0 "DataLockdownByWay_0"
hexfld.word 0 " DATALOCK000 "
;tree.end

;tree "InstLockdownByWay_0"
base ad:0xa0412904
group 0--3
line.long 0 "InstLockdownByWay_0"
hexfld.word 0 " INSTRLOCK000 "
;tree.end

;tree "DataLockdownByWay_1"
base ad:0xa0412908
group 0--3
line.long 0 "DataLockdownByWay_1"
hexfld.word 0 " DATALOCK001 "
;tree.end

;tree "InstLockdownByWay_1"
base ad:0xa041290c
group 0--3
line.long 0 "InstLockdownByWay_1"
hexfld.word 0 " INSTRLOCK001 "
;tree.end

;tree "DataLockdownByWay_2"
base ad:0xa0412910
group 0--3
line.long 0 "DataLockdownByWay_2"
hexfld.word 0 " DATALOCK010 "
;tree.end

;tree "InstLockdownByWay_2"
base ad:0xa0412914
group 0--3
line.long 0 "InstLockdownByWay_2"
hexfld.word 0 " INSTRLOCK010 "
;tree.end

;tree "DataLockdownByWay_3"
base ad:0xa0412918
group 0--3
line.long 0 "DataLockdownByWay_3"
hexfld.word 0 " DATALOCK011 "
;tree.end

;tree "InstLockdownByWay_3"
base ad:0xa041291c
group 0--3
line.long 0 "InstLockdownByWay_3"
hexfld.word 0 " INSTRLOCK011 "
;tree.end

;tree "DataLockdownByWay_4"
base ad:0xa0412920
group 0--3
line.long 0 "DataLockdownByWay_4"
hexfld.word 0 " DATALOCK100 "
;tree.end

;tree "InstLockdownByWay_4"
base ad:0xa0412924
group 0--3
line.long 0 "InstLockdownByWay_4"
hexfld.word 0 " INSTRLOCK100 "
;tree.end

;tree "DataLockdownByWay_5"
base ad:0xa0412928
group 0--3
line.long 0 "DataLockdownByWay_5"
hexfld.word 0 " DATALOCK101 "
;tree.end

;tree "InstLockdownByWay_5"
base ad:0xa041292c
group 0--3
line.long 0 "InstLockdownByWay_5"
hexfld.word 0 " INSTRLOCK101 "
;tree.end

;tree "DataLockdownByWay_6"
base ad:0xa0412930
group 0--3
line.long 0 "DataLockdownByWay_6"
hexfld.word 0 " DATALOCK110 "
;tree.end

;tree "InstLockdownByWay_6"
base ad:0xa0412934
group 0--3
line.long 0 "InstLockdownByWay_6"
hexfld.word 0 " INSTRLOCK110 "
;tree.end

;tree "DataLockdownByWay_7"
base ad:0xa0412938
group 0--3
line.long 0 "DataLockdownByWay_7"
hexfld.word 0 " DATALOCK111 "
;tree.end

;tree "InstLockdownByWay_7"
base ad:0xa041293c
group 0--3
line.long 0 "InstLockdownByWay_7"
hexfld.word 0 " INSTRLOCK111 "
;tree.end

;tree "LockdownByLineEnable"
base ad:0xa0412950
group 0--3
line.long 0 "LockdownByLineEnable"
bitfld.long 0 0. " EN "  "0 ,1 "
;tree.end

;tree "UnlockAllLinesByWay"
base ad:0xa0412954
group 0--3
line.long 0 "UnlockAllLinesByWay"
hexfld.word 0 " UNLOCK "
;tree.end

;tree "AddrFilterStart"
base ad:0xa0412c00
group 0--3
line.long 0 "AddrFilterStart"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 20.--31. " AFS "  " "
;tree.end

;tree "AddrFilterEnd"
base ad:0xa0412c04
group 0--3
line.long 0 "AddrFilterEnd"
bitfld.long 0 20.--31. " AFE "  " "
;tree.end

;tree "DebugControl"
base ad:0xa0412f40
group 0--3
line.long 0 "DebugControl"
bitfld.long 0 0. " DCL "  "0 ,1 "
bitfld.long 0 1. " DWB "  "0 ,1 "
bitfld.long 0 2. " SPNIDEN "  "0 ,1 "
;tree.end

;tree "PrefetchOffset"
base ad:0xa0412f60
group 0--3
line.long 0 "PrefetchOffset"
bitfld.long 0 0.--4. " OFFSET "  "0 ,1 ,2 ,3 ,4 ,5 ,6 ,7 ,8 ,9 ,A ,B ,C ,D ,E ,F ,10 ,11 ,12 ,13 ,14 ,15 ,16 ,17 ,18 ,19 ,1A ,1B ,1C ,1D ,1E ,1F "
;tree.end

;tree "PowerControl"
base ad:0xa0412f80
group 0--3
line.long 0 "PowerControl"
bitfld.long 0 0. " STANDBYEN "  "0 ,1 "
bitfld.long 0 1. " DYNCLKGEN "  "0 ,1 "
;tree.end

tree.end

