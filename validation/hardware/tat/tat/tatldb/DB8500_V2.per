;PER file generated from pmapv2 
;by script version 1.14 16-February-11
;flat mode
;Author : N. PERRIN - Modified : F.GOHIER

config 16. 8.
width  40. 8.

;==============================================================
tree "B2R2"
;==============================================================
base sd:0x80130a00
tree "BLT_CTL"
group 0--3
line.long 0 "BLT_CTL"
bitfld.long 0 28. " Big_not_little "  "0 ,1 "
bitfld.long 0 29. " Step_By_Step "  "0 ,1 "
bitfld.long 0 31. " GLOBAL_soft_reset "  "0 ,1 "
tree.end

base sd:0x80130a04
tree "BLT_ITS"
group 0--3
line.long 0 "BLT_ITS"
bitfld.long 0 0. " CQ1_completed "  "0 ,1 "
bitfld.long 0 1. " CQ1_retriggered "  "0 ,1 "
bitfld.long 0 2. " CQ1_Node_Notif "  "0 ,1 "
bitfld.long 0 3. " CQ1_Repaced "  "0 ,1 "
bitfld.long 0 4. " CQ2_completed "  "0 ,1 "
bitfld.long 0 5. " CQ2_retriggered "  "0 ,1 "
bitfld.long 0 6. " CQ2_Node_Notif "  "0 ,1 "
bitfld.long 0 7. " CQ2_Repaced "  "0 ,1 "
bitfld.long 0 12. " AQ1_LNA_Reached "  "0 ,1 "
bitfld.long 0 13. " AQ1_Stopped "  "0 ,1 "
bitfld.long 0 14. " AQ1_Node_repeat "  "0 ,1 "
bitfld.long 0 15. " AQ1_Node_Notif "  "0 ,1 "
bitfld.long 0 16. " AQ2_LNA_Reached "  "0 ,1 "
bitfld.long 0 17. " AQ2_Stopped "  "0 ,1 "
bitfld.long 0 18. " AQ2_Node_repeat "  "0 ,1 "
bitfld.long 0 19. " AQ2_Node_Notif "  "0 ,1 "
bitfld.long 0 20. " AQ3_LNA_Reached "  "0 ,1 "
bitfld.long 0 21. " AQ3_Stopped "  "0 ,1 "
bitfld.long 0 22. " AQ3_Node_repeat "  "0 ,1 "
bitfld.long 0 23. " AQ3_Node_Notif "  "0 ,1 "
bitfld.long 0 24. " AQ4_LNA_Reached "  "0 ,1 "
bitfld.long 0 25. " AQ4_Stopped "  "0 ,1 "
bitfld.long 0 26. " AQ4_Node_repeat "  "0 ,1 "
bitfld.long 0 27. " AQ4_Node_Notif "  "0 ,1 "
bitfld.long 0 31. " RLD_ERROR "  "0 ,1 "
tree.end

base sd:0x80130a08
tree "BLT_STA1"
group 0--3
line.long 0 "BLT_STA1"
bitfld.long 0 0. " BDISP_IDLE "  "0 ,1 "
tree.end

base sd:0x80130a10
tree "BLT_SSBA1"
group 0--3
line.long 0 "BLT_SSBA1"
bitfld.long 0 0.--25. " SSBA1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA1_bank_num "  " "
tree.end

base sd:0x80130a14
tree "BLT_SSBA2"
group 0--3
line.long 0 "BLT_SSBA2"
bitfld.long 0 0.--25. " SSBA2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA2_bank_num "  " "
tree.end

base sd:0x80130a18
tree "BLT_SSBA3"
group 0--3
line.long 0 "BLT_SSBA3"
bitfld.long 0 0.--25. " SSBA3_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA3_bank_num "  " "
tree.end

base sd:0x80130a1c
tree "BLT_SSBA4"
group 0--3
line.long 0 "BLT_SSBA4"
bitfld.long 0 0.--25. " SSBA4_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA4_bank_num "  " "
tree.end

base sd:0x80130a20
tree "BLT_SSBA5"
group 0--3
line.long 0 "BLT_SSBA5"
bitfld.long 0 0.--25. " SSBA5_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA5_bank_num "  " "
tree.end

base sd:0x80130a24
tree "BLT_SSBA6"
group 0--3
line.long 0 "BLT_SSBA6"
bitfld.long 0 0.--25. " SSBA6_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA6_bank_num "  " "
tree.end

base sd:0x80130a28
tree "BLT_SSBA7"
group 0--3
line.long 0 "BLT_SSBA7"
bitfld.long 0 0.--25. " SSBA7_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA7_bank_num "  " "
tree.end

base sd:0x80130a2c
tree "BLT_SSBA8"
group 0--3
line.long 0 "BLT_SSBA8"
bitfld.long 0 0.--25. " SSBA8_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA8_bank_num "  " "
tree.end

base sd:0x80130aa0
tree "BLT_SSBA9"
group 0--3
line.long 0 "BLT_SSBA9"
bitfld.long 0 0.--25. " SSBA9_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA9_bank_num "  " "
tree.end

base sd:0x80130aa4
tree "BLT_SSBA10"
group 0--3
line.long 0 "BLT_SSBA10"
bitfld.long 0 0.--25. " SSBA10_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA10_bank_num "  " "
tree.end

base sd:0x80130aa8
tree "BLT_SSBA11"
group 0--3
line.long 0 "BLT_SSBA11"
bitfld.long 0 0.--25. " SSBA11_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA11_bank_num "  " "
tree.end

base sd:0x80130aac
tree "BLT_SSBA12"
group 0--3
line.long 0 "BLT_SSBA12"
bitfld.long 0 0.--25. " SSBA12_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA12_bank_num "  " "
tree.end

base sd:0x80130ab0
tree "BLT_SSBA13"
group 0--3
line.long 0 "BLT_SSBA13"
bitfld.long 0 0.--25. " SSBA13_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA13_bank_num "  " "
tree.end

base sd:0x80130ab4
tree "BLT_SSBA14"
group 0--3
line.long 0 "BLT_SSBA14"
bitfld.long 0 0.--25. " SSBA14_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA14_bank_num "  " "
tree.end

base sd:0x80130ab8
tree "BLT_SSBA15"
group 0--3
line.long 0 "BLT_SSBA15"
bitfld.long 0 0.--25. " SSBA15_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA15_bank_num "  " "
tree.end

base sd:0x80130abc
tree "BLT_SSBA16"
group 0--3
line.long 0 "BLT_SSBA16"
bitfld.long 0 0.--25. " SSBA16_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " SSBA16_bank_num "  " "
tree.end

base sd:0x80130a30
tree "BLT_STBA1"
group 0--3
line.long 0 "BLT_STBA1"
bitfld.long 0 0.--25. " STBA1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA1_bank_num "  " "
tree.end

base sd:0x80130a34
tree "BLT_STBA2"
group 0--3
line.long 0 "BLT_STBA2"
bitfld.long 0 0.--25. " STBA2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA2_bank_num "  " "
tree.end

base sd:0x80130a38
tree "BLT_STBA3"
group 0--3
line.long 0 "BLT_STBA3"
bitfld.long 0 0.--25. " STBA3_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA3_bank_num "  " "
tree.end

base sd:0x80130a3c
tree "BLT_STBA4"
group 0--3
line.long 0 "BLT_STBA4"
bitfld.long 0 0.--25. " STBA4_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " STBA4_bank_num "  " "
tree.end

base sd:0x80130a40
tree "BLT_CQ1_TRIG_IP"
group 0--3
line.long 0 "BLT_CQ1_TRIG_IP"
bitfld.long 0 0.--25. " CQ1_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " TRIG_bank_num "  " "
tree.end

base sd:0x80130a50
tree "BLT_CQ2_TRIG_IP"
group 0--3
line.long 0 "BLT_CQ2_TRIG_IP"
bitfld.long 0 0.--25. " CQ2_MEMORY_ADDRESS "  " "
bitfld.long 0 26.--31. " TRIG_bank_num "  " "
tree.end

base sd:0x80130a44
tree "BLT_CQ1_TRIG_CTL"
group 0--3
line.long 0 "BLT_CQ1_TRIG_CTL"
bitfld.long 0 0.--11. " Trigger_line_num "  " "
bitfld.long 0 12.--15. " Trig_cond "  " "
bitfld.long 0 20.--23. " IRQ_mask "  " "
bitfld.long 0 24.--27. " Retrig_behav "  " "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
tree.end

base sd:0x80130a54
tree "BLT_CQ2_TRIG_CTL"
group 0--3
line.long 0 "BLT_CQ2_TRIG_CTL"
bitfld.long 0 0.--11. " Trigger_line_num "  " "
bitfld.long 0 12.--15. " Trig_cond "  " "
bitfld.long 0 20.--23. " IRQ_mask "  " "
bitfld.long 0 24.--27. " Retrig_behav "  " "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
tree.end

base sd:0x80130a48
tree "BLT_CQ1_PACE_CTL"
group 0--3
line.long 0 "BLT_CQ1_PACE_CTL"
bitfld.long 0 0.--11. " Pace_start "  " "
bitfld.long 0 16.--27. " Pace_Count "  " "
bitfld.long 0 31. " Dynamic_Pace "  "0 ,1 "
tree.end

base sd:0x80130a58
tree "BLT_CQ2_PACE_CTL"
group 0--3
line.long 0 "BLT_CQ2_PACE_CTL"
bitfld.long 0 0.--11. " Pace_start "  " "
bitfld.long 0 16.--27. " Pace_Count "  " "
bitfld.long 0 31. " Dynamic_Pace "  "0 ,1 "
tree.end

base sd:0x80130a4c
tree "BLT_CQ1_IP"
rgroup 0--3
line.long 0 "BLT_CQ1_IP"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  " "
tree.end

base sd:0x80130a5c
tree "BLT_CQ2_IP"
rgroup 0--3
line.long 0 "BLT_CQ2_IP"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  " "
tree.end

base sd:0x80130a60
tree "BLT_AQ1_CTL"
group 0--3
line.long 0 "BLT_AQ1_CTL"
bitfld.long 0 0.--1. " Priority "  " "
bitfld.long 0 20.--23. " IRQ_mask "  " "
bitfld.long 0 24.--26. " Event_behav "  " "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
tree.end

base sd:0x80130a70
tree "BLT_AQ2_CTL"
group 0--3
line.long 0 "BLT_AQ2_CTL"
bitfld.long 0 0.--1. " Priority "  " "
bitfld.long 0 20.--23. " IRQ_mask "  " "
bitfld.long 0 24.--26. " Event_behav "  " "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
tree.end

base sd:0x80130a80
tree "BLT_AQ3_CTL"
group 0--3
line.long 0 "BLT_AQ3_CTL"
bitfld.long 0 0.--1. " Priority "  " "
bitfld.long 0 20.--23. " IRQ_mask "  " "
bitfld.long 0 24.--26. " Event_behav "  " "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
tree.end

base sd:0x80130a90
tree "BLT_AQ4_CTL"
group 0--3
line.long 0 "BLT_AQ4_CTL"
bitfld.long 0 0.--1. " Priority "  " "
bitfld.long 0 20.--23. " IRQ_mask "  " "
bitfld.long 0 24.--26. " Event_behav "  " "
bitfld.long 0 31. " Queue_en "  "0 ,1 "
tree.end

base sd:0x80130a64
tree "BLT_AQ1_IP"
group 0--3
line.long 0 "BLT_AQ1_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  " "
tree.end

base sd:0x80130a74
tree "BLT_AQ2_IP"
group 0--3
line.long 0 "BLT_AQ2_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  " "
tree.end

base sd:0x80130a84
tree "BLT_AQ3_IP"
group 0--3
line.long 0 "BLT_AQ3_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  " "
tree.end

base sd:0x80130a94
tree "BLT_AQ4_IP"
group 0--3
line.long 0 "BLT_AQ4_IP"
bitfld.long 0 0.--25. " inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  " "
tree.end

base sd:0x80130a68
tree "BLT_AQ1_LNA"
group 0--3
line.long 0 "BLT_AQ1_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  " "
tree.end

base sd:0x80130a78
tree "BLT_AQ2_LNA"
group 0--3
line.long 0 "BLT_AQ2_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  " "
tree.end

base sd:0x80130a88
tree "BLT_AQ3_LNA"
group 0--3
line.long 0 "BLT_AQ3_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  " "
tree.end

base sd:0x80130a98
tree "BLT_AQ4_LNA"
group 0--3
line.long 0 "BLT_AQ4_LNA"
bitfld.long 0 0.--25. " Lna_Memory_address "  " "
bitfld.long 0 26.--31. " Lna_bank_num "  " "
tree.end

base sd:0x80130a6c
tree "BLT_AQ1_STA"
rgroup 0--3
line.long 0 "BLT_AQ1_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  " "
tree.end

base sd:0x80130a7c
tree "BLT_AQ2_STA"
rgroup 0--3
line.long 0 "BLT_AQ2_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  " "
tree.end

base sd:0x80130a8c
tree "BLT_AQ3_STA"
rgroup 0--3
line.long 0 "BLT_AQ3_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  " "
tree.end

base sd:0x80130a9c
tree "BLT_AQ4_STA"
rgroup 0--3
line.long 0 "BLT_AQ4_STA"
bitfld.long 0 0.--25. " Inst_Memory_address "  " "
bitfld.long 0 26.--31. " Inst_bank_num "  " "
tree.end

base sd:0x80130ac0
tree "BLT_SGA1"
group 0--3
line.long 0 "BLT_SGA1"
bitfld.long 0 0.--7. " Alpha1 "  " "
bitfld.long 0 8.--15. " Alpha2 "  " "
bitfld.long 0 16.--23. " Alpha3 "  " "
bitfld.long 0 24.--31. " Alpha4 "  " "
tree.end

base sd:0x80130ac4
tree "BLT_SGA2"
group 0--3
line.long 0 "BLT_SGA2"
bitfld.long 0 0.--7. " Alpha5 "  " "
bitfld.long 0 8.--15. " Alpha6 "  " "
bitfld.long 0 16.--23. " Alpha7 "  " "
bitfld.long 0 24.--31. " Alpha8 "  " "
tree.end

base sd:0x80130ad0
tree "BLT_ITM0"
group 0--3
line.long 0 "BLT_ITM0"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
tree.end

base sd:0x80130ad4
tree "BLT_ITM1"
group 0--3
line.long 0 "BLT_ITM1"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
tree.end

base sd:0x80130ad8
tree "BLT_ITM2"
group 0--3
line.long 0 "BLT_ITM2"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
tree.end

base sd:0x80130adc
tree "BLT_ITM3"
group 0--3
line.long 0 "BLT_ITM3"
bitfld.long 0 0. " b0 "  "0 ,1 "
bitfld.long 0 1. " b1 "  "0 ,1 "
bitfld.long 0 2. " b2 "  "0 ,1 "
bitfld.long 0 3. " b3 "  "0 ,1 "
bitfld.long 0 4. " b4 "  "0 ,1 "
bitfld.long 0 5. " b5 "  "0 ,1 "
bitfld.long 0 6. " b6 "  "0 ,1 "
bitfld.long 0 7. " b7 "  "0 ,1 "
bitfld.long 0 12. " b12 "  "0 ,1 "
bitfld.long 0 13. " b13 "  "0 ,1 "
bitfld.long 0 14. " b14 "  "0 ,1 "
bitfld.long 0 15. " b15 "  "0 ,1 "
bitfld.long 0 16. " b16 "  "0 ,1 "
bitfld.long 0 17. " b17 "  "0 ,1 "
bitfld.long 0 18. " b18 "  "0 ,1 "
bitfld.long 0 19. " b19 "  "0 ,1 "
bitfld.long 0 20. " b20 "  "0 ,1 "
bitfld.long 0 21. " b21 "  "0 ,1 "
bitfld.long 0 22. " b22 "  "0 ,1 "
bitfld.long 0 23. " b23 "  "0 ,1 "
bitfld.long 0 24. " b24 "  "0 ,1 "
bitfld.long 0 25. " b25 "  "0 ,1 "
bitfld.long 0 26. " b26 "  "0 ,1 "
bitfld.long 0 27. " b27 "  "0 ,1 "
bitfld.long 0 31. " b31 "  "0 ,1 "
tree.end

base sd:0x80130af4
tree "BLT_DFV1"
group 0--3
line.long 0 "BLT_DFV1"
bitfld.long 0 0.--11. " DFV1_Line_count "  " "
bitfld.long 0 12. " DFV1_ITM0_IT "  "0 ,1 "
bitfld.long 0 13. " DFV1_ITM1_IT "  "0 ,1 "
bitfld.long 0 14. " DFV1_ITM2_IT "  "0 ,1 "
bitfld.long 0 15. " DFV1_ITM3_IT "  "0 ,1 "
bitfld.long 0 16. " DFV1_AQ1_IT "  "0 ,1 "
bitfld.long 0 17. " DFV1_AQ2_IT "  "0 ,1 "
bitfld.long 0 18. " DFV1_AQ3_IT "  "0 ,1 "
bitfld.long 0 19. " DFV1_AQ4_IT "  "0 ,1 "
bitfld.long 0 20. " DFV1_CQ1_IT "  "0 ,1 "
bitfld.long 0 21. " DFV1_CQ2_IT "  "0 ,1 "
bitfld.long 0 24. " DFV1_GPO "  "0 ,1 "
bitfld.long 0 28. " DFV1_req "  "0 ,1 "
bitfld.long 0 29. " DFV1_ntop_bot "  "0 ,1 "
bitfld.long 0 30. " DFV1_Vsync "  "0 ,1 "
bitfld.long 0 31. " DFV1_Mode_En "  "0 ,1 "
tree.end

base sd:0x80130af0
tree "BLT_DFV2"
group 0--3
line.long 0 "BLT_DFV2"
bitfld.long 0 0.--11. " DFV2_Line_count "  " "
bitfld.long 0 28. " DFV2_req "  "0 ,1 "
bitfld.long 0 29. " DFV2_ntop_bot "  "0 ,1 "
bitfld.long 0 30. " DFV2_Vsync "  "0 ,1 "
bitfld.long 0 31. " DFV2_Mode_En "  "0 ,1 "
tree.end

base sd:0x80130af8
tree "BLT_PRI"
group 0--3
line.long 0 "BLT_PRI"
bitfld.long 0 0.--3. " CQ1_prio "  " "
bitfld.long 0 4.--7. " CQ2_prio "  " "
bitfld.long 0 12.--15. " AQ1_prio "  " "
bitfld.long 0 16.--19. " AQ2_prio "  " "
bitfld.long 0 20.--23. " AQ3_prio "  " "
bitfld.long 0 24.--27. " AQ4_prio "  " "
tree.end

base sd:0x80130900
tree "BLT_SSBA17"
group 0--3
line.long 0 "BLT_SSBA17"
bitfld.long 0 0.--25. " SSBA17_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA17_bank_num "  " "
tree.end

base sd:0x80130904
tree "BLT_SSBA18"
group 0--3
line.long 0 "BLT_SSBA18"
bitfld.long 0 0.--25. " SSBA18_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA18_bank_num "  " "
tree.end

base sd:0x80130908
tree "BLT_SSBA19"
group 0--3
line.long 0 "BLT_SSBA19"
bitfld.long 0 0.--25. " SSBA19_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA19_bank_num "  " "
tree.end

base sd:0x8013090c
tree "BLT_SSBA20"
group 0--3
line.long 0 "BLT_SSBA20"
bitfld.long 0 0.--25. " SSBA20_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA20_bank_num "  " "
tree.end

base sd:0x80130910
tree "BLT_SSBA21"
group 0--3
line.long 0 "BLT_SSBA21"
bitfld.long 0 0.--25. " SSBA21_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA21_bank_num "  " "
tree.end

base sd:0x80130914
tree "BLT_SSBA22"
group 0--3
line.long 0 "BLT_SSBA22"
bitfld.long 0 0.--25. " SSBA22_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA22_bank_num "  " "
tree.end

base sd:0x80130918
tree "BLT_SSBA23"
group 0--3
line.long 0 "BLT_SSBA23"
bitfld.long 0 0.--25. " SSBA23_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA23_bank_num "  " "
tree.end

base sd:0x8013091c
tree "BLT_SSBA24"
group 0--3
line.long 0 "BLT_SSBA24"
bitfld.long 0 0.--25. " SSBA24_Mem_address "  " "
bitfld.long 0 26.--31. " SSBA24_bank_num "  " "
tree.end

base sd:0x80130940
tree "BLT_STBA5"
group 0--3
line.long 0 "BLT_STBA5"
bitfld.long 0 0.--25. " STBA5_Mem_address "  " "
bitfld.long 0 26.--31. " STBA5_bank_num "  " "
tree.end

base sd:0x80130944
tree "BLT_STBA6"
group 0--3
line.long 0 "BLT_STBA6"
bitfld.long 0 0.--25. " STBA6_Mem_address "  " "
bitfld.long 0 26.--31. " STBA6_bank_num "  " "
tree.end

base sd:0x80130948
tree "BLT_STBA7"
group 0--3
line.long 0 "BLT_STBA7"
bitfld.long 0 0.--25. " STBA7_Mem_address "  " "
bitfld.long 0 26.--31. " STBA7_bank_num "  " "
tree.end

base sd:0x8013094c
tree "BLT_STBA8"
group 0--3
line.long 0 "BLT_STBA8"
bitfld.long 0 0.--25. " STBA8_Mem_address "  " "
bitfld.long 0 26.--31. " STBA8_bank_num "  " "
tree.end

base sd:0x80130b04
tree "PLUGS1_OP2"
group 0--3
line.long 0 "PLUGS1_OP2"
bitfld.long 0 0.--2. " Max_opcode "  " "
tree.end

base sd:0x80130b24
tree "PLUGS2_OP2"
group 0--3
line.long 0 "PLUGS2_OP2"
bitfld.long 0 0.--2. " Max_opcode "  " "
tree.end

base sd:0x80130b44
tree "PLUGS3_OP2"
group 0--3
line.long 0 "PLUGS3_OP2"
bitfld.long 0 0.--2. " Max_opcode "  " "
tree.end

base sd:0x80130b08
tree "PLUGS1_CHZ"
group 0--3
line.long 0 "PLUGS1_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  " "
tree.end

base sd:0x80130b28
tree "PLUGS2_CHZ"
group 0--3
line.long 0 "PLUGS2_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  " "
tree.end

base sd:0x80130b48
tree "PLUGS3_CHZ"
group 0--3
line.long 0 "PLUGS3_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  " "
tree.end

base sd:0x80130b0c
tree "PLUGS1_MSZ"
group 0--3
line.long 0 "PLUGS1_MSZ"
bitfld.long 0 0.--2. " Message_Size "  " "
bitfld.long 0 16.--31. " MinSpaceBetweenReq "  " "
tree.end

base sd:0x80130b2c
tree "PLUGS2_MSZ"
group 0--3
line.long 0 "PLUGS2_MSZ"
bitfld.long 0 0.--2. " Message_Size "  " "
bitfld.long 0 16.--31. " MinSpaceBetweenReq "  " "
tree.end

base sd:0x80130b4c
tree "PLUGS3_MSZ"
group 0--3
line.long 0 "PLUGS3_MSZ"
bitfld.long 0 0.--2. " Message_Size "  " "
bitfld.long 0 16.--31. " MinSpaceBetweenReq "  " "
tree.end

base sd:0x80130b10
tree "PLUGS1_PGZ"
group 0--3
line.long 0 "PLUGS1_PGZ"
bitfld.long 0 0.--3. " Page_size "  " "
tree.end

base sd:0x80130b30
tree "PLUGS2_PGZ"
group 0--3
line.long 0 "PLUGS2_PGZ"
bitfld.long 0 0.--3. " Page_size "  " "
tree.end

base sd:0x80130b50
tree "PLUGS3_PGZ"
group 0--3
line.long 0 "PLUGS3_PGZ"
bitfld.long 0 0.--3. " Page_size "  " "
tree.end

base sd:0x80130b84
tree "PLUGT_OP2"
group 0--3
line.long 0 "PLUGT_OP2"
bitfld.long 0 0.--2. " Max_code "  " "
tree.end

base sd:0x80130b88
tree "PLUGT_CHZ"
group 0--3
line.long 0 "PLUGT_CHZ"
bitfld.long 0 0.--2. " Chunk_size "  " "
tree.end

base sd:0x80130b8c
tree "PLUGT_MSZ"
group 0--3
line.long 0 "PLUGT_MSZ"
bitfld.long 0 0.--2. " Message_size "  " "
bitfld.long 0 16.--31. " MinSpaceBetweenReq "  " "
tree.end

base sd:0x80130b90
tree "PLUGT_PGZ"
group 0--3
line.long 0 "PLUGT_PGZ"
bitfld.long 0 0.--3. " Page_size "  " "
tree.end

base sd:0x80130c00
tree "BLT_NIP"
group 0--3
line.long 0 "BLT_NIP"
bitfld.long 0 0.--25. " NIP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " NIP_BANK_NUM "  " "
tree.end

base sd:0x80130c04
tree "BLT_CIC"
group 0--3
line.long 0 "BLT_CIC"
bitfld.long 0 2. " Group2 "  "0 ,1 "
bitfld.long 0 3. " Group3 "  "0 ,1 "
bitfld.long 0 4. " Group4 "  "0 ,1 "
bitfld.long 0 5. " Group5 "  "0 ,1 "
bitfld.long 0 6. " Group6 "  "0 ,1 "
bitfld.long 0 7. " Group7 "  "0 ,1 "
bitfld.long 0 8. " Group8 "  "0 ,1 "
bitfld.long 0 9. " Group9 "  "0 ,1 "
bitfld.long 0 10. " Group10 "  "0 ,1 "
bitfld.long 0 11. " Group11 "  "0 ,1 "
bitfld.long 0 12. " Group12 "  "0 ,1 "
bitfld.long 0 13. " Group13 "  "0 ,1 "
bitfld.long 0 14. " Group14 "  "0 ,1 "
bitfld.long 0 15. " Group15 "  "0 ,1 "
bitfld.long 0 16. " Group16 "  "0 ,1 "
bitfld.long 0 17. " Group17 "  "0 ,1 "
bitfld.long 0 18. " Group18 "  "0 ,1 "
tree.end

base sd:0x80130c08
tree "BLT_INS"
group 0--3
line.long 0 "BLT_INS"
bitfld.long 0 0.--2. " SOURCE1 "  " "
bitfld.long 0 3.--4. " SOURCE2 "  " "
bitfld.long 0 5. " SOURCE3 "  "0 ,1 "
bitfld.long 0 6. " IVMX "  "0 ,1 "
bitfld.long 0 7. " CLUTOP "  "0 ,1 "
bitfld.long 0 8. " 2DRESCALE "  "0 ,1 "
bitfld.long 0 9. " FILCK_FILT "  "0 ,1 "
bitfld.long 0 10. " RECT_CLIP "  "0 ,1 "
bitfld.long 0 11. " CKEY "  "0 ,1 "
bitfld.long 0 12. " OVMX "  "0 ,1 "
bitfld.long 0 13. " DEI "  "0 ,1 "
bitfld.long 0 14. " PLANE_MASK "  "0 ,1 "
bitfld.long 0 15. " XYL "  "0 ,1 "
bitfld.long 0 16. " DOT "  "0 ,1 "
bitfld.long 0 17. " VC1R "  "0 ,1 "
bitfld.long 0 18. " ROTATION "  "0 ,1 "
bitfld.long 0 30. " Pace_down "  "0 ,1 "
bitfld.long 0 31. " BlitCompIRQ "  "0 ,1 "
tree.end

base sd:0x80130c0c
tree "BLT_ACK"
group 0--3
line.long 0 "BLT_ACK"
bitfld.long 0 0.--3. " MODE "  " "
bitfld.long 0 4. " SWAP_FG_BG "  "0 ,1 "
bitfld.long 0 8.--15. " GALPHA_ROPID "  " "
bitfld.long 0 16.--21. " ACK_CKEY "  " "
bitfld.long 0 22.--23. " CKEY_SEL "  " "
tree.end

base sd:0x80130c10
tree "BLT_TBA"
group 0--3
line.long 0 "BLT_TBA"
bitfld.long 0 0.--25. " TBA_mem_addr "  " "
bitfld.long 0 26.--31. " TBA_bank_num "  " "
tree.end

base sd:0x80130c14
tree "BLT_TTY"
group 0--3
line.long 0 "BLT_TTY"
bitfld.long 0 0.--15. " PIXMAP_PITCH "  " "
bitfld.long 0 16.--20. " COLOR_FORM "  " "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 26. " RGB_ROUND "  "0 ,1 "
bitfld.long 0 27. " CHROMA_notLUMA "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
tree.end

base sd:0x80130c18
tree "BLT_TXY"
group 0--3
line.long 0 "BLT_TXY"
bitfld.long 0 0.--15. " XCOORD "  " "
bitfld.long 0 16.--31. " YCOORD "  " "
tree.end

base sd:0x80130c1c
tree "BLT_TSZ"
group 0--3
line.long 0 "BLT_TSZ"
bitfld.long 0 0.--11. " WIN_WIDTH "  " "
bitfld.long 0 16.--27. " WIN_HEIGHT "  " "
tree.end

base sd:0x80130c20
tree "BLT_S1CF"
group 0--3
line.long 0 "BLT_S1CF"
bitfld.long 0 0.--31. " SRC1_COLOR_FILL "  " "
tree.end

base sd:0x80130c24
tree "BLT_S2CF"
group 0--3
line.long 0 "BLT_S2CF"
bitfld.long 0 0.--31. " SRC2_COLOR_FILL "  " "
tree.end

base sd:0x80130c28
tree "BLT_S1BA"
group 0--3
line.long 0 "BLT_S1BA"
bitfld.long 0 0.--25. " S1BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S1BA_BANK_NUM "  " "
tree.end

base sd:0x80130c2c
tree "BLT_S1TY"
group 0--3
line.long 0 "BLT_S1TY"
bitfld.long 0 0.--15. " PIXMAP_PITCH "  " "
bitfld.long 0 16.--20. " COLOR_FORM "  " "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 22. " A1_SUBST "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 27. " ROTATION "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 29. " RGB_EXP "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
tree.end

base sd:0x80130c30
tree "BLT_S1XY"
group 0--3
line.long 0 "BLT_S1XY"
bitfld.long 0 0.--15. " XCOORD "  " "
bitfld.long 0 16.--31. " YCOORD "  " "
tree.end

base sd:0x80130c38
tree "BLT_S2BA"
group 0--3
line.long 0 "BLT_S2BA"
bitfld.long 0 0.--25. " S2BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S2BA_BANK_NUM "  " "
tree.end

base sd:0x80130c3c
tree "BLT_S2TY"
group 0--3
line.long 0 "BLT_S2TY"
bitfld.long 0 0.--15. " PIXMAP_PITCH "  " "
bitfld.long 0 16.--20. " COLOR_FORM "  " "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 22. " A1_SUBST "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " HSO "  "0 ,1 "
bitfld.long 0 25. " VSO "  "0 ,1 "
bitfld.long 0 26. " CHROMA_LEFT "  "0 ,1 "
bitfld.long 0 28. " SUBBYTE "  "0 ,1 "
bitfld.long 0 29. " RGB_EXP "  "0 ,1 "
bitfld.long 0 30. " BigNotLittle "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
tree.end

base sd:0x80130c40
tree "BLT_S2XY"
group 0--3
line.long 0 "BLT_S2XY"
bitfld.long 0 0.--15. " XCOORD "  " "
bitfld.long 0 16.--31. " YCOORD "  " "
tree.end

base sd:0x80130c44
tree "BLT_S2SZ"
group 0--3
line.long 0 "BLT_S2SZ"
bitfld.long 0 0.--11. " SRC2_WIN_WIDTH "  " "
bitfld.long 0 16.--27. " SRC2_WIN_HEIGHT "  " "
tree.end

base sd:0x80130c48
tree "BLT_S3BA"
group 0--3
line.long 0 "BLT_S3BA"
bitfld.long 0 0.--25. " S3BA_MEM_ADDR "  " "
bitfld.long 0 26.--31. " S3BA_bank_num "  " "
tree.end

base sd:0x80130c4c
tree "BLT_S3TY"
group 0--3
line.long 0 "BLT_S3TY"
bitfld.long 0 0.--15. " PIXMAP_PITCH "  " "
bitfld.long 0 16.--20. " COLOR_FORM "  " "
bitfld.long 0 21. " ALPHA_RANGE "  "0 ,1 "
bitfld.long 0 23. " MB_FIELD "  "0 ,1 "
bitfld.long 0 24. " VSO "  "0 ,1 "
bitfld.long 0 25. " HSO "  "0 ,1 "
bitfld.long 0 31. " Secure "  "0 ,1 "
tree.end

base sd:0x80130c50
tree "BLT_S3XY"
group 0--3
line.long 0 "BLT_S3XY"
bitfld.long 0 0.--15. " XCOORD "  " "
bitfld.long 0 16.--31. " YCOORD "  " "
tree.end

base sd:0x80130c54
tree "BLT_S3SZ"
group 0--3
line.long 0 "BLT_S3SZ"
bitfld.long 0 0.--11. " SRC3_WIN_WIDTH "  " "
bitfld.long 0 16.--27. " SRC3_WIN_HEIGHT "  " "
tree.end

base sd:0x80130c58
tree "BLT_CWO"
group 0--3
line.long 0 "BLT_CWO"
bitfld.long 0 0.--14. " XDO "  " "
bitfld.long 0 16.--26. " YDO "  " "
bitfld.long 0 27. " INTNL "  "0 ,1 "
tree.end

base sd:0x80130c5c
tree "BLT_CWS"
group 0--3
line.long 0 "BLT_CWS"
bitfld.long 0 0.--14. " XDS "  " "
bitfld.long 0 16.--26. " YDS "  " "
tree.end

base sd:0x80130c60
tree "BLT_CCO"
group 0--3
line.long 0 "BLT_CCO"
bitfld.long 0 15. " CLUT_NS2_1S1 "  "0 ,1 "
bitfld.long 0 16.--17. " CLUT_MODE "  " "
bitfld.long 0 18. " CLUT_UPDATE "  "0 ,1 "
bitfld.long 0 19.--22. " CLUT_ERRDIFF "  " "
tree.end

base sd:0x80130c64
tree "BLT_CML"
group 0--3
line.long 0 "BLT_CML"
bitfld.long 0 4.--25. " CML_MEM_ADDR "  " "
bitfld.long 0 26.--31. " CML_BANK_NUM "  " "
tree.end

base sd:0x80130c68
tree "BLT_FCTL"
group 0--3
line.long 0 "BLT_FCTL"
bitfld.long 0 0.--2. " 2DHF_MODE "  " "
bitfld.long 0 4.--6. " 2DVF_MODE "  " "
bitfld.long 0 12. " AB_Right "  "0 ,1 "
bitfld.long 0 13. " AB_Left "  "0 ,1 "
bitfld.long 0 14. " AB_BOT "  "0 ,1 "
bitfld.long 0 15. " AB_TOP "  "0 ,1 "
bitfld.long 0 24.--25. " Luma_2Dhf_mode "  " "
bitfld.long 0 28.--29. " Luma_2Dvf_mode "  " "
tree.end

base sd:0x80130c6c
tree "BLT_PMK"
group 0--3
line.long 0 "BLT_PMK"
bitfld.long 0 0. " PLANE_MASK "  "0 ,1 "
tree.end

base sd:0x80130c70
tree "BLT_RSF"
group 0--3
line.long 0 "BLT_RSF"
bitfld.long 0 0.--15. " HSRC_INC "  " "
bitfld.long 0 16.--31. " VSRC_INC "  " "
tree.end

base sd:0x80130c74
tree "BLT_RZI"
group 0--3
line.long 0 "BLT_RZI"
bitfld.long 0 0.--9. " HSRC_INIT "  " "
bitfld.long 0 12.--14. " Hnb_repeat "  " "
bitfld.long 0 16.--25. " VSRC_INIT "  " "
bitfld.long 0 28.--30. " Vnb_repeat "  " "
tree.end

base sd:0x80130c78
tree "BLT_HFP"
group 0--3
line.long 0 "BLT_HFP"
bitfld.long 0 0.--25. " HFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " HFP_BANK_NUM "  " "
tree.end

base sd:0x80130c7c
tree "BLT_VFP"
group 0--3
line.long 0 "BLT_VFP"
bitfld.long 0 0.--25. " VFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " VFP_BANK_NUM "  " "
tree.end

base sd:0x80130c80
tree "BLT_Y_RSF"
group 0--3
line.long 0 "BLT_Y_RSF"
bitfld.long 0 0.--15. " Luma_HSRC_INC "  " "
bitfld.long 0 16.--31. " Luma_VSRC_INC "  " "
tree.end

base sd:0x80130c84
tree "BLT_Y_RZI"
group 0--3
line.long 0 "BLT_Y_RZI"
bitfld.long 0 0.--9. " Hsrc_init_luma "  " "
bitfld.long 0 12.--14. " Hnb_repeat_luma "  " "
bitfld.long 0 16.--25. " Vsrc_init_luma "  " "
bitfld.long 0 28.--30. " Vnb_repeat_Luma "  " "
tree.end

base sd:0x80130c88
tree "BLT_Y_HFP"
group 0--3
line.long 0 "BLT_Y_HFP"
bitfld.long 0 0.--25. " Y_HFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " Y_Hfp_Bank_num "  " "
tree.end

base sd:0x80130c8c
tree "BLT_Y_VFP"
group 0--3
line.long 0 "BLT_Y_VFP"
bitfld.long 0 0.--25. " Y_VFP_MEM_ADDR "  " "
bitfld.long 0 26.--31. " Y_Vfp_Bank_num "  " "
tree.end

base sd:0x80130ca0
tree "BLT_KEY1"
group 0--3
line.long 0 "BLT_KEY1"
bitfld.long 0 0.--7. " BLUE_MIN "  " "
bitfld.long 0 8.--15. " GREEN_MIN "  " "
bitfld.long 0 16.--23. " RED_MIN "  " "
bitfld.long 0 24.--31. " ALPHA0 "  " "
tree.end

base sd:0x80130ca4
tree "BLT_KEY2"
group 0--3
line.long 0 "BLT_KEY2"
bitfld.long 0 0.--7. " BLUE_MAX "  " "
bitfld.long 0 8.--15. " GREEN_MAX "  " "
bitfld.long 0 16.--23. " RED_MAX "  " "
bitfld.long 0 24.--31. " ALPHA1 "  " "
tree.end

base sd:0x80130cb0
tree "BLT_SAR"
group 0--3
line.long 0 "BLT_SAR"
bitfld.long 0 0.--4. " S1_SSBA "  " "
bitfld.long 0 8.--12. " S2_SSBA "  " "
bitfld.long 0 16.--20. " S3_SSBA "  " "
bitfld.long 0 24.--27. " T_STBA "  " "
bitfld.long 0 28.--31. " A_SGA "  " "
tree.end

base sd:0x80130cb4
tree "BLT_USR"
group 0--3
line.long 0 "BLT_USR"
bitfld.long 0 0.--31. " GENERAL_PURPOSE "  " "
tree.end

base sd:0x80130cc0
tree "BLT_IVMX0"
group 0--3
line.long 0 "BLT_IVMX0"
bitfld.long 0 0.--9. " Coeff13 "  " "
bitfld.long 0 10.--20. " Coeff12 "  " "
bitfld.long 0 21.--31. " Coeff11 "  " "
tree.end

base sd:0x80130cc4
tree "BLT_IVMX1"
group 0--3
line.long 0 "BLT_IVMX1"
bitfld.long 0 0.--9. " Coeff23 "  " "
bitfld.long 0 10.--20. " Coeff22 "  " "
bitfld.long 0 21.--31. " Coeff21 "  " "
tree.end

base sd:0x80130cc8
tree "BLT_IVMX2"
group 0--3
line.long 0 "BLT_IVMX2"
bitfld.long 0 0.--9. " Coeff33 "  " "
bitfld.long 0 10.--20. " Coeff32 "  " "
bitfld.long 0 21.--31. " Coeff31 "  " "
tree.end

base sd:0x80130ccc
tree "BLT_IVMX3"
group 0--3
line.long 0 "BLT_IVMX3"
bitfld.long 0 0.--9. " Offset3 "  " "
bitfld.long 0 10.--19. " Offset2 "  " "
bitfld.long 0 20.--29. " Offset1 "  " "
tree.end

base sd:0x80130cd0
tree "BLT_OVMX0"
group 0--3
line.long 0 "BLT_OVMX0"
bitfld.long 0 0.--9. " Coeff13 "  " "
bitfld.long 0 10.--20. " Coeff12 "  " "
bitfld.long 0 21.--31. " Coeff11 "  " "
tree.end

base sd:0x80130cd4
tree "BLT_OVMX1"
group 0--3
line.long 0 "BLT_OVMX1"
bitfld.long 0 0.--9. " Coeff23 "  " "
bitfld.long 0 10.--20. " Coeff22 "  " "
bitfld.long 0 21.--31. " Coeff21 "  " "
tree.end

base sd:0x80130cd8
tree "BLT_OVMX2"
group 0--3
line.long 0 "BLT_OVMX2"
bitfld.long 0 0.--9. " Coeff33 "  " "
bitfld.long 0 10.--20. " Coeff32 "  " "
bitfld.long 0 21.--31. " Coeff31 "  " "
tree.end

base sd:0x80130cdc
tree "BLT_OVMX3"
group 0--3
line.long 0 "BLT_OVMX3"
bitfld.long 0 0.--9. " Offset3 "  " "
bitfld.long 0 10.--19. " Offset2 "  " "
bitfld.long 0 20.--29. " Offset1 "  " "
tree.end

base sd:0x80130ce8
tree "BLT_VC1R"
group 0--3
line.long 0 "BLT_VC1R"
bitfld.long 0 0.--2. " Luma_coeff "  " "
bitfld.long 0 3. " Luma_Map "  "0 ,1 "
bitfld.long 0 4.--6. " Chroma_coeff "  " "
bitfld.long 0 7. " Chroma_map "  "0 ,1 "
tree.end

base sd:0x80130e00
tree "BLT_HFC0"
group 0--3
line.long 0 "BLT_HFC0"
bitfld.long 0 0.--7. " K0 "  " "
bitfld.long 0 8.--15. " K1 "  " "
bitfld.long 0 16.--23. " K2 "  " "
bitfld.long 0 24.--31. " K3 "  " "
tree.end

base sd:0x80130e04
tree "BLT_HFC1"
group 0--3
line.long 0 "BLT_HFC1"
bitfld.long 0 0.--7. " K4 "  " "
bitfld.long 0 8.--15. " K5 "  " "
bitfld.long 0 16.--23. " K6 "  " "
bitfld.long 0 24.--31. " K7 "  " "
tree.end

base sd:0x80130e08
tree "BLT_HFC2"
group 0--3
line.long 0 "BLT_HFC2"
bitfld.long 0 0.--7. " K10 "  " "
bitfld.long 0 8.--15. " K11 "  " "
bitfld.long 0 16.--23. " K12 "  " "
bitfld.long 0 24.--31. " K13 "  " "
tree.end

base sd:0x80130e0c
tree "BLT_HFC3"
group 0--3
line.long 0 "BLT_HFC3"
bitfld.long 0 0.--7. " K14 "  " "
bitfld.long 0 8.--15. " K15 "  " "
bitfld.long 0 16.--23. " K16 "  " "
bitfld.long 0 24.--31. " K17 "  " "
tree.end

base sd:0x80130e10
tree "BLT_HFC4"
group 0--3
line.long 0 "BLT_HFC4"
bitfld.long 0 0.--7. " K20 "  " "
bitfld.long 0 8.--15. " K21 "  " "
bitfld.long 0 16.--23. " K22 "  " "
bitfld.long 0 24.--31. " K23 "  " "
tree.end

base sd:0x80130e14
tree "BLT_HFC5"
group 0--3
line.long 0 "BLT_HFC5"
bitfld.long 0 0.--7. " K24 "  " "
bitfld.long 0 8.--15. " K25 "  " "
bitfld.long 0 16.--23. " K26 "  " "
bitfld.long 0 24.--31. " K27 "  " "
tree.end

base sd:0x80130e18
tree "BLT_HFC6"
group 0--3
line.long 0 "BLT_HFC6"
bitfld.long 0 0.--7. " K30 "  " "
bitfld.long 0 8.--15. " K31 "  " "
bitfld.long 0 16.--23. " K32 "  " "
bitfld.long 0 24.--31. " K33 "  " "
tree.end

base sd:0x80130e1c
tree "BLT_HFC7"
group 0--3
line.long 0 "BLT_HFC7"
bitfld.long 0 0.--7. " K34 "  " "
bitfld.long 0 8.--15. " K35 "  " "
bitfld.long 0 16.--23. " K36 "  " "
bitfld.long 0 24.--31. " K37 "  " "
tree.end

base sd:0x80130e20
tree "BLT_HFC8"
group 0--3
line.long 0 "BLT_HFC8"
bitfld.long 0 0.--7. " K40 "  " "
bitfld.long 0 8.--15. " K41 "  " "
bitfld.long 0 16.--23. " K42 "  " "
bitfld.long 0 24.--31. " K43 "  " "
tree.end

base sd:0x80130e24
tree "BLT_HFC9"
group 0--3
line.long 0 "BLT_HFC9"
bitfld.long 0 0.--7. " K44 "  " "
bitfld.long 0 8.--15. " K45 "  " "
bitfld.long 0 16.--23. " K46 "  " "
bitfld.long 0 24.--31. " K47 "  " "
tree.end

base sd:0x80130e28
tree "BLT_HFC10"
group 0--3
line.long 0 "BLT_HFC10"
bitfld.long 0 0.--7. " K50 "  " "
bitfld.long 0 8.--15. " K51 "  " "
bitfld.long 0 16.--23. " K52 "  " "
bitfld.long 0 24.--31. " K53 "  " "
tree.end

base sd:0x80130e2c
tree "BLT_HFC11"
group 0--3
line.long 0 "BLT_HFC11"
bitfld.long 0 0.--7. " K54 "  " "
bitfld.long 0 8.--15. " K55 "  " "
bitfld.long 0 16.--23. " K56 "  " "
bitfld.long 0 24.--31. " K57 "  " "
tree.end

base sd:0x80130e30
tree "BLT_HFC12"
group 0--3
line.long 0 "BLT_HFC12"
bitfld.long 0 0.--7. " K60 "  " "
bitfld.long 0 8.--15. " K61 "  " "
bitfld.long 0 16.--23. " K62 "  " "
bitfld.long 0 24.--31. " K63 "  " "
tree.end

base sd:0x80130e34
tree "BLT_HFC13"
group 0--3
line.long 0 "BLT_HFC13"
bitfld.long 0 0.--7. " K64 "  " "
bitfld.long 0 8.--15. " K65 "  " "
bitfld.long 0 16.--23. " K66 "  " "
bitfld.long 0 24.--31. " K67 "  " "
tree.end

base sd:0x80130e38
tree "BLT_HFC14"
group 0--3
line.long 0 "BLT_HFC14"
bitfld.long 0 0.--7. " K70 "  " "
bitfld.long 0 8.--15. " K71 "  " "
bitfld.long 0 16.--23. " K72 "  " "
bitfld.long 0 24.--31. " K73 "  " "
tree.end

base sd:0x80130e3c
tree "BLT_HFC15"
group 0--3
line.long 0 "BLT_HFC15"
bitfld.long 0 0.--7. " K74 "  " "
bitfld.long 0 8.--15. " K75 "  " "
bitfld.long 0 16.--23. " K76 "  " "
bitfld.long 0 24.--31. " K77 "  " "
tree.end

base sd:0x80130e90
tree "BLT_VFC0"
group 0--3
line.long 0 "BLT_VFC0"
bitfld.long 0 0.--7. " K0 "  " "
bitfld.long 0 8.--15. " K1 "  " "
bitfld.long 0 16.--23. " K2 "  " "
bitfld.long 0 24.--31. " K3 "  " "
tree.end

base sd:0x80130e94
tree "BLT_VFC1"
group 0--3
line.long 0 "BLT_VFC1"
bitfld.long 0 0.--7. " K4 "  " "
bitfld.long 0 8.--15. " K10 "  " "
bitfld.long 0 16.--23. " K11 "  " "
bitfld.long 0 24.--31. " K12 "  " "
tree.end

base sd:0x80130e98
tree "BLT_VFC2"
group 0--3
line.long 0 "BLT_VFC2"
bitfld.long 0 0.--7. " K13 "  " "
bitfld.long 0 8.--15. " K14 "  " "
bitfld.long 0 16.--23. " K20 "  " "
bitfld.long 0 24.--31. " K21 "  " "
tree.end

base sd:0x80130e9c
tree "BLT_VFC3"
group 0--3
line.long 0 "BLT_VFC3"
bitfld.long 0 0.--7. " K22 "  " "
bitfld.long 0 8.--15. " K23 "  " "
bitfld.long 0 16.--23. " K24 "  " "
bitfld.long 0 24.--31. " K30 "  " "
tree.end

base sd:0x80130ea0
tree "BLT_VFC4"
group 0--3
line.long 0 "BLT_VFC4"
bitfld.long 0 0.--7. " K31 "  " "
bitfld.long 0 8.--15. " K32 "  " "
bitfld.long 0 16.--23. " K33 "  " "
bitfld.long 0 24.--31. " K34 "  " "
tree.end

base sd:0x80130ea4
tree "BLT_VFC5"
group 0--3
line.long 0 "BLT_VFC5"
bitfld.long 0 0.--7. " K40 "  " "
bitfld.long 0 8.--15. " K41 "  " "
bitfld.long 0 16.--23. " K42 "  " "
bitfld.long 0 24.--31. " K43 "  " "
tree.end

base sd:0x80130ea8
tree "BLT_VFC6"
group 0--3
line.long 0 "BLT_VFC6"
bitfld.long 0 0.--7. " K44 "  " "
bitfld.long 0 8.--15. " K50 "  " "
bitfld.long 0 16.--23. " K51 "  " "
bitfld.long 0 24.--31. " K52 "  " "
tree.end

base sd:0x80130eac
tree "BLT_VFC7"
group 0--3
line.long 0 "BLT_VFC7"
bitfld.long 0 0.--7. " K53 "  " "
bitfld.long 0 8.--15. " K54 "  " "
bitfld.long 0 16.--23. " K60 "  " "
bitfld.long 0 24.--31. " K61 "  " "
tree.end

base sd:0x80130eb0
tree "BLT_VFC8"
group 0--3
line.long 0 "BLT_VFC8"
bitfld.long 0 0.--7. " K62 "  " "
bitfld.long 0 8.--15. " K63 "  " "
bitfld.long 0 16.--23. " K64 "  " "
bitfld.long 0 24.--31. " K70 "  " "
tree.end

base sd:0x80130eb4
tree "BLT_VFC9"
group 0--3
line.long 0 "BLT_VFC9"
bitfld.long 0 0.--7. " K71 "  " "
bitfld.long 0 8.--15. " K72 "  " "
bitfld.long 0 16.--23. " K73 "  " "
bitfld.long 0 24.--31. " K74 "  " "
tree.end

base sd:0x80130d00
tree "BLT_Y_HFC0"
group 0--3
line.long 0 "BLT_Y_HFC0"
bitfld.long 0 0.--7. " K0 "  " "
bitfld.long 0 8.--15. " K1 "  " "
bitfld.long 0 16.--23. " K2 "  " "
bitfld.long 0 24.--31. " K3 "  " "
tree.end

base sd:0x80130d04
tree "BLT_Y_HFC1"
group 0--3
line.long 0 "BLT_Y_HFC1"
bitfld.long 0 0.--7. " K4 "  " "
bitfld.long 0 8.--15. " K5 "  " "
bitfld.long 0 16.--23. " K6 "  " "
bitfld.long 0 24.--31. " K7 "  " "
tree.end

base sd:0x80130d08
tree "BLT_Y_HFC2"
group 0--3
line.long 0 "BLT_Y_HFC2"
bitfld.long 0 0.--7. " K10 "  " "
bitfld.long 0 8.--15. " K11 "  " "
bitfld.long 0 16.--23. " K12 "  " "
bitfld.long 0 24.--31. " K13 "  " "
tree.end

base sd:0x80130d0c
tree "BLT_Y_HFC3"
group 0--3
line.long 0 "BLT_Y_HFC3"
bitfld.long 0 0.--7. " K14 "  " "
bitfld.long 0 8.--15. " K15 "  " "
bitfld.long 0 16.--23. " K16 "  " "
bitfld.long 0 24.--31. " K17 "  " "
tree.end

base sd:0x80130d10
tree "BLT_Y_HFC4"
group 0--3
line.long 0 "BLT_Y_HFC4"
bitfld.long 0 0.--7. " K20 "  " "
bitfld.long 0 8.--15. " K21 "  " "
bitfld.long 0 16.--23. " K22 "  " "
bitfld.long 0 24.--31. " K23 "  " "
tree.end

base sd:0x80130d14
tree "BLT_Y_HFC5"
group 0--3
line.long 0 "BLT_Y_HFC5"
bitfld.long 0 0.--7. " K24 "  " "
bitfld.long 0 8.--15. " K25 "  " "
bitfld.long 0 16.--23. " K26 "  " "
bitfld.long 0 24.--31. " K27 "  " "
tree.end

base sd:0x80130d18
tree "BLT_Y_HFC6"
group 0--3
line.long 0 "BLT_Y_HFC6"
bitfld.long 0 0.--7. " K30 "  " "
bitfld.long 0 8.--15. " K31 "  " "
bitfld.long 0 16.--23. " K32 "  " "
bitfld.long 0 24.--31. " K33 "  " "
tree.end

base sd:0x80130d1c
tree "BLT_Y_HFC7"
group 0--3
line.long 0 "BLT_Y_HFC7"
bitfld.long 0 0.--7. " K34 "  " "
bitfld.long 0 8.--15. " K35 "  " "
bitfld.long 0 16.--23. " K36 "  " "
bitfld.long 0 24.--31. " K37 "  " "
tree.end

base sd:0x80130d20
tree "BLT_Y_HFC8"
group 0--3
line.long 0 "BLT_Y_HFC8"
bitfld.long 0 0.--7. " K40 "  " "
bitfld.long 0 8.--15. " K41 "  " "
bitfld.long 0 16.--23. " K42 "  " "
bitfld.long 0 24.--31. " K43 "  " "
tree.end

base sd:0x80130d24
tree "BLT_Y_HFC9"
group 0--3
line.long 0 "BLT_Y_HFC9"
bitfld.long 0 0.--7. " K44 "  " "
bitfld.long 0 8.--15. " K45 "  " "
bitfld.long 0 16.--23. " K46 "  " "
bitfld.long 0 24.--31. " K47 "  " "
tree.end

base sd:0x80130d28
tree "BLT_Y_HFC10"
group 0--3
line.long 0 "BLT_Y_HFC10"
bitfld.long 0 0.--7. " K50 "  " "
bitfld.long 0 8.--15. " K51 "  " "
bitfld.long 0 16.--23. " K52 "  " "
bitfld.long 0 24.--31. " K53 "  " "
tree.end

base sd:0x80130d2c
tree "BLT_Y_HFC11"
group 0--3
line.long 0 "BLT_Y_HFC11"
bitfld.long 0 0.--7. " K54 "  " "
bitfld.long 0 8.--15. " K55 "  " "
bitfld.long 0 16.--23. " K56 "  " "
bitfld.long 0 24.--31. " K57 "  " "
tree.end

base sd:0x80130d30
tree "BLT_Y_HFC12"
group 0--3
line.long 0 "BLT_Y_HFC12"
bitfld.long 0 0.--7. " K60 "  " "
bitfld.long 0 8.--15. " K61 "  " "
bitfld.long 0 16.--23. " K62 "  " "
bitfld.long 0 24.--31. " K63 "  " "
tree.end

base sd:0x80130d34
tree "BLT_Y_HFC13"
group 0--3
line.long 0 "BLT_Y_HFC13"
bitfld.long 0 0.--7. " K64 "  " "
bitfld.long 0 8.--15. " K65 "  " "
bitfld.long 0 16.--23. " K66 "  " "
bitfld.long 0 24.--31. " K67 "  " "
tree.end

base sd:0x80130d38
tree "BLT_Y_HFC14"
group 0--3
line.long 0 "BLT_Y_HFC14"
bitfld.long 0 0.--7. " K70 "  " "
bitfld.long 0 8.--15. " K71 "  " "
bitfld.long 0 16.--23. " K72 "  " "
bitfld.long 0 24.--31. " K73 "  " "
tree.end

base sd:0x80130d3c
tree "BLT_Y_HFC15"
group 0--3
line.long 0 "BLT_Y_HFC15"
bitfld.long 0 0.--7. " K74 "  " "
bitfld.long 0 8.--15. " K75 "  " "
bitfld.long 0 16.--23. " K76 "  " "
bitfld.long 0 24.--31. " K77 "  " "
tree.end

base sd:0x80130d90
tree "BLT_Y_VFC0"
group 0--3
line.long 0 "BLT_Y_VFC0"
bitfld.long 0 0.--7. " K0 "  " "
bitfld.long 0 8.--15. " K1 "  " "
bitfld.long 0 16.--23. " K2 "  " "
bitfld.long 0 24.--31. " K3 "  " "
tree.end

base sd:0x80130d94
tree "BLT_Y_VFC1"
group 0--3
line.long 0 "BLT_Y_VFC1"
bitfld.long 0 0.--7. " K4 "  " "
bitfld.long 0 8.--15. " K10 "  " "
bitfld.long 0 16.--23. " K11 "  " "
bitfld.long 0 24.--31. " K12 "  " "
tree.end

base sd:0x80130d98
tree "BLT_Y_VFC2"
group 0--3
line.long 0 "BLT_Y_VFC2"
bitfld.long 0 0.--7. " K13 "  " "
bitfld.long 0 8.--15. " K14 "  " "
bitfld.long 0 16.--23. " K20 "  " "
bitfld.long 0 24.--31. " K21 "  " "
tree.end

base sd:0x80130d9c
tree "BLT_Y_VFC3"
group 0--3
line.long 0 "BLT_Y_VFC3"
bitfld.long 0 0.--7. " K22 "  " "
bitfld.long 0 8.--15. " K23 "  " "
bitfld.long 0 16.--23. " K24 "  " "
bitfld.long 0 24.--31. " K30 "  " "
tree.end

base sd:0x80130da0
tree "BLT_Y_VFC4"
group 0--3
line.long 0 "BLT_Y_VFC4"
bitfld.long 0 0.--7. " K31 "  " "
bitfld.long 0 8.--15. " K32 "  " "
bitfld.long 0 16.--23. " K33 "  " "
bitfld.long 0 24.--31. " K34 "  " "
tree.end

base sd:0x80130da4
tree "BLT_Y_VFC5"
group 0--3
line.long 0 "BLT_Y_VFC5"
bitfld.long 0 0.--7. " K40 "  " "
bitfld.long 0 8.--15. " K41 "  " "
bitfld.long 0 16.--23. " K42 "  " "
bitfld.long 0 24.--31. " K43 "  " "
tree.end

base sd:0x80130da8
tree "BLT_Y_VFC6"
group 0--3
line.long 0 "BLT_Y_VFC6"
bitfld.long 0 0.--7. " K44 "  " "
bitfld.long 0 8.--15. " K50 "  " "
bitfld.long 0 16.--23. " K51 "  " "
bitfld.long 0 24.--31. " K52 "  " "
tree.end

base sd:0x80130dac
tree "BLT_Y_VFC7"
group 0--3
line.long 0 "BLT_Y_VFC7"
bitfld.long 0 0.--7. " K53 "  " "
bitfld.long 0 8.--15. " K54 "  " "
bitfld.long 0 16.--23. " K60 "  " "
bitfld.long 0 24.--31. " K61 "  " "
tree.end

base sd:0x80130db0
tree "BLT_Y_VFC8"
group 0--3
line.long 0 "BLT_Y_VFC8"
bitfld.long 0 0.--7. " K62 "  " "
bitfld.long 0 8.--15. " K63 "  " "
bitfld.long 0 16.--23. " K64 "  " "
bitfld.long 0 24.--31. " K70 "  " "
tree.end

base sd:0x80130db4
tree "BLT_Y_VFC9"
group 0--3
line.long 0 "BLT_Y_VFC9"
bitfld.long 0 0.--7. " K71 "  " "
bitfld.long 0 8.--15. " K72 "  " "
bitfld.long 0 16.--23. " K73 "  " "
bitfld.long 0 24.--31. " K74 "  " "
tree.end

tree.end

;==============================================================
tree "CLK_RST1"
;==============================================================
base sd:0x8012f000
tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERCKEN8 "  "0 ,1 "
bitfld.long 0 9. " PERCKEN9 "  "0 ,1 "
bitfld.long 0 10. " PERCKEN10 "  "0 ,1 "
bitfld.long 0 11. " PERCKEN11 "  "0 ,1 "
tree.end

base sd:0x8012f004
tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERCKDIS8 "  "0 ,1 "
bitfld.long 0 9. " PERCKDIS9 "  "0 ,1 "
bitfld.long 0 10. " PERCKDIS10 "  "0 ,1 "
bitfld.long 0 11. " PERCKDIS11 "  "0 ,1 "
tree.end

base sd:0x8012f008
tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
bitfld.long 0 8. " PERKCKEN8 "  "0 ,1 "
bitfld.long 0 9. " PERKCKEN9 "  "0 ,1 "
bitfld.long 0 10. " PERKCKEN10 "  "0 ,1 "
tree.end

base sd:0x8012f00c
tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
bitfld.long 0 8. " PERKCKDIS8 "  "0 ,1 "
bitfld.long 0 9. " PERKCKDIS9 "  "0 ,1 "
bitfld.long 0 10. " PERKCKDIS10 "  "0 ,1 "
tree.end

base sd:0x8012f010
tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERCKSR8 "  "0 ,1 "
bitfld.long 0 9. " PERCKSR9 "  "0 ,1 "
bitfld.long 0 10. " PERCKSR10 "  "0 ,1 "
bitfld.long 0 11. " PERCKSR11 "  "0 ,1 "
tree.end

base sd:0x8012f014
tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
bitfld.long 0 8. " PERKCKSR8 "  "0 ,1 "
bitfld.long 0 9. " PERKCKSR9 "  "0 ,1 "
bitfld.long 0 10. " PERKCKSR10 "  "0 ,1 "
tree.end

base sd:0x8012f018
tree "PRCC_K_SOFTRST_SET"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 0. " K_SOFTRST_SET0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTRST_SET1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_SET2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_SET3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_SET4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_SET5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_SET6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_SET7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTRST_SET8 "  "0 ,1 "
bitfld.long 0 9. " K_SOFTRST_SET9 "  "0 ,1 "
bitfld.long 0 10. " K_SOFTRST_SET10 "  "0 ,1 "
bitfld.long 0 11. " K_SOFTRST_SET11 "  "0 ,1 "
bitfld.long 0 12. " K_SOFTRST_SET12 "  "0 ,1 "
bitfld.long 0 13. " K_SOFTRST_SET13 "  "0 ,1 "
bitfld.long 0 14. " K_SOFTRST_SET14 "  "0 ,1 "
tree.end

base sd:0x8012f01c
tree "PRCC_K_SOFTRST_CLR"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 0. " K_SOFTRST_CLR0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTRST_CLR1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_CLR2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_CLR3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_CLR4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_CLR5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_CLR6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_CLR7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTRST_CLR8 "  "0 ,1 "
bitfld.long 0 9. " K_SOFTRST_CLR9 "  "0 ,1 "
bitfld.long 0 10. " K_SOFTRST_CLR10 "  "0 ,1 "
bitfld.long 0 11. " K_SOFTRST_CLR11 "  "0 ,1 "
bitfld.long 0 12. " K_SOFTRST_CLR12 "  "0 ,1 "
bitfld.long 0 13. " K_SOFTRST_CLR13 "  "0 ,1 "
bitfld.long 0 14. " K_SOFTRST_CLR14 "  "0 ,1 "
tree.end

base sd:0x8012f020
tree "PRCC_K_RST_STATUS"
group 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 0. " K_RST_STATUS0 "  "0 ,1 "
bitfld.long 0 1. " K_RST_STATUS1 "  "0 ,1 "
bitfld.long 0 2. " K_RST_STATUS2 "  "0 ,1 "
bitfld.long 0 3. " K_RST_STATUS3 "  "0 ,1 "
bitfld.long 0 4. " K_RST_STATUS4 "  "0 ,1 "
bitfld.long 0 5. " K_RST_STATUS5 "  "0 ,1 "
bitfld.long 0 6. " K_RST_STATUS6 "  "0 ,1 "
bitfld.long 0 7. " K_RST_STATUS7 "  "0 ,1 "
bitfld.long 0 8. " K_RST_STATUS8 "  "0 ,1 "
bitfld.long 0 9. " K_RST_STATUS9 "  "0 ,1 "
bitfld.long 0 10. " K_RST_STATUS10 "  "0 ,1 "
bitfld.long 0 11. " K_RST_STATUS11 "  "0 ,1 "
bitfld.long 0 12. " K_RST_STATUS12 "  "0 ,1 "
bitfld.long 0 13. " K_RST_STATUS13 "  "0 ,1 "
tree.end

base sd:0x8012ffe0
tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x8012ffe4
tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x8012ffe8
tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x8012ffec
tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x8012fff0
tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
bitfld.long 0 0.--7. " PRCCPCellID0 "  " "
tree.end

base sd:0x8012fff4
tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
bitfld.long 0 0.--7. " PRCCPCellID1 "  " "
tree.end

base sd:0x8012fff8
tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
bitfld.long 0 0.--7. " PRCCPCellID2 "  " "
tree.end

base sd:0x8012fffc
tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
bitfld.long 0 0.--7. " PRCCPCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "CLK_RST2"
;==============================================================
base sd:0x8011f000
tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERCKEN8 "  "0 ,1 "
bitfld.long 0 9. " PERCKEN9 "  "0 ,1 "
bitfld.long 0 10. " PERCKEN10 "  "0 ,1 "
bitfld.long 0 11. " PERCKEN11 "  "0 ,1 "
tree.end

base sd:0x8011f004
tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERCKDIS8 "  "0 ,1 "
bitfld.long 0 9. " PERCKDIS9 "  "0 ,1 "
bitfld.long 0 10. " PERCKDIS10 "  "0 ,1 "
bitfld.long 0 11. " PERCKDIS11 "  "0 ,1 "
tree.end

base sd:0x8011f008
tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKEN7 "  "0 ,1 "
tree.end

base sd:0x8011f00c
tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKDIS7 "  "0 ,1 "
tree.end

base sd:0x8011f010
tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERCKSR8 "  "0 ,1 "
bitfld.long 0 9. " PERCKSR9 "  "0 ,1 "
bitfld.long 0 10. " PERCKSR10 "  "0 ,1 "
bitfld.long 0 11. " PERCKSR11 "  "0 ,1 "
tree.end

base sd:0x8011f014
tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKSR7 "  "0 ,1 "
tree.end

base sd:0x8011f018
tree "PRCC_K_SOFTRST_SET"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 0. " K_SOFTRST_SET0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTRST_SET1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_SET2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_SET3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_SET4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_SET5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_SET6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_SET7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTRST_SET8 "  "0 ,1 "
tree.end

base sd:0x8011f01c
tree "PRCC_K_SOFTRST_CLR"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 0. " K_SOFTRST_CLR0 "  "0 ,1 "
bitfld.long 0 1. " K_SOFTRST_CLR1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_CLR2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_CLR3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_CLR4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_CLR5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_CLR6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_CLR7 "  "0 ,1 "
bitfld.long 0 8. " K_SOFTRST_CLR8 "  "0 ,1 "
tree.end

base sd:0x8011f020
tree "PRCC_K_RST_STATUS"
group 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 0. " K_RST_STATUS0 "  "0 ,1 "
bitfld.long 0 1. " K_RST_STATUS1 "  "0 ,1 "
bitfld.long 0 2. " K_RST_STATUS2 "  "0 ,1 "
bitfld.long 0 3. " K_RST_STATUS3 "  "0 ,1 "
bitfld.long 0 4. " K_RST_STATUS4 "  "0 ,1 "
bitfld.long 0 5. " K_RST_STATUS5 "  "0 ,1 "
bitfld.long 0 6. " K_RST_STATUS6 "  "0 ,1 "
bitfld.long 0 7. " K_RST_STATUS7 "  "0 ,1 "
bitfld.long 0 8. " K_RST_STATUS8 "  "0 ,1 "
tree.end

base sd:0x8011ffe0
tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x8011ffe4
tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x8011ffe8
tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x8011ffec
tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x8011fff0
tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
bitfld.long 0 0.--7. " PRCCPCellID0 "  " "
tree.end

base sd:0x8011fff4
tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
bitfld.long 0 0.--7. " PRCCPCellID1 "  " "
tree.end

base sd:0x8011fff8
tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
bitfld.long 0 0.--7. " PRCCPCellID2 "  " "
tree.end

base sd:0x8011fffc
tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
bitfld.long 0 0.--7. " PRCCPCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "CLK_RST3"
;==============================================================
base sd:0x8000f000
tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
bitfld.long 0 8. " PERCKEN8 "  "0 ,1 "
tree.end

base sd:0x8000f004
tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
bitfld.long 0 8. " PERCKDIS8 "  "0 ,1 "
tree.end

base sd:0x8000f008
tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 1. " PERKCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKEN7 "  "0 ,1 "
tree.end

base sd:0x8000f00c
tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 1. " PERKCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKDIS7 "  "0 ,1 "
tree.end

base sd:0x8000f010
tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
bitfld.long 0 8. " PERCKSR8 "  "0 ,1 "
tree.end

base sd:0x8000f014
tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 1. " PERKCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERKCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERKCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERKCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERKCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERKCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERKCKSR7 "  "0 ,1 "
tree.end

base sd:0x8000f018
tree "PRCC_K_SOFTRST_SET"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 1. " K_SOFTRST_SET1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_SET2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_SET3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_SET4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_SET5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_SET6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_SET7 "  "0 ,1 "
tree.end

base sd:0x8000f01c
tree "PRCC_K_SOFTRST_CLR"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 1. " K_SOFTRST_CLR1 "  "0 ,1 "
bitfld.long 0 2. " K_SOFTRST_CLR2 "  "0 ,1 "
bitfld.long 0 3. " K_SOFTRST_CLR3 "  "0 ,1 "
bitfld.long 0 4. " K_SOFTRST_CLR4 "  "0 ,1 "
bitfld.long 0 5. " K_SOFTRST_CLR5 "  "0 ,1 "
bitfld.long 0 6. " K_SOFTRST_CLR6 "  "0 ,1 "
bitfld.long 0 7. " K_SOFTRST_CLR7 "  "0 ,1 "
tree.end

base sd:0x8000f020
tree "PRCC_K_RST_STATUS"
group 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 1. " K_RST_STATUS1 "  "0 ,1 "
bitfld.long 0 2. " K_RST_STATUS2 "  "0 ,1 "
bitfld.long 0 3. " K_RST_STATUS3 "  "0 ,1 "
bitfld.long 0 4. " K_RST_STATUS4 "  "0 ,1 "
bitfld.long 0 5. " K_RST_STATUS5 "  "0 ,1 "
bitfld.long 0 6. " K_RST_STATUS6 "  "0 ,1 "
bitfld.long 0 7. " K_RST_STATUS7 "  "0 ,1 "
tree.end

base sd:0x8000ffe0
tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x8000ffe4
tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x8000ffe8
tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x8000ffec
tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x8000fff0
tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
bitfld.long 0 0.--7. " PRCCPCellID0 "  " "
tree.end

base sd:0x8000fff4
tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
bitfld.long 0 0.--7. " PRCCPCellID1 "  " "
tree.end

base sd:0x8000fff8
tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
bitfld.long 0 0.--7. " PRCCPCellID2 "  " "
tree.end

base sd:0x8000fffc
tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
bitfld.long 0 0.--7. " PRCCPCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "CLK_RST5"
;==============================================================
base sd:0xa03ff000
tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
tree.end

base sd:0xa03ff004
tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
tree.end

base sd:0xa03ff010
tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
tree.end

base sd:0xa03fffe0
tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0xa03fffe4
tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0xa03fffe8
tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0xa03fffec
tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0xa03ffff0
tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
bitfld.long 0 0.--7. " PRCCPCellID0 "  " "
tree.end

base sd:0xa03ffff4
tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
bitfld.long 0 0.--7. " PRCCPCellID1 "  " "
tree.end

base sd:0xa03ffff8
tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
bitfld.long 0 0.--7. " PRCCPCellID2 "  " "
tree.end

base sd:0xa03ffffc
tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
bitfld.long 0 0.--7. " PRCCPCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "CLK_RST6"
;==============================================================
base sd:0xa03cf000
tree "PRCC_PCKEN"
wgroup 0--3
line.long 0 "PRCC_PCKEN"
bitfld.long 0 0. " PERCKEN0 "  "0 ,1 "
bitfld.long 0 1. " PERCKEN1 "  "0 ,1 "
bitfld.long 0 2. " PERCKEN2 "  "0 ,1 "
bitfld.long 0 3. " PERCKEN3 "  "0 ,1 "
bitfld.long 0 4. " PERCKEN4 "  "0 ,1 "
bitfld.long 0 5. " PERCKEN5 "  "0 ,1 "
bitfld.long 0 6. " PERCKEN6 "  "0 ,1 "
bitfld.long 0 7. " PERCKEN7 "  "0 ,1 "
tree.end

base sd:0xa03cf004
tree "PRCC_PCKDIS"
wgroup 0--3
line.long 0 "PRCC_PCKDIS"
bitfld.long 0 0. " PERCKDIS0 "  "0 ,1 "
bitfld.long 0 1. " PERCKDIS1 "  "0 ,1 "
bitfld.long 0 2. " PERCKDIS2 "  "0 ,1 "
bitfld.long 0 3. " PERCKDIS3 "  "0 ,1 "
bitfld.long 0 4. " PERCKDIS4 "  "0 ,1 "
bitfld.long 0 5. " PERCKDIS5 "  "0 ,1 "
bitfld.long 0 6. " PERCKDIS6 "  "0 ,1 "
bitfld.long 0 7. " PERCKDIS7 "  "0 ,1 "
tree.end

base sd:0xa03cf008
tree "PRCC_KCKEN"
wgroup 0--3
line.long 0 "PRCC_KCKEN"
bitfld.long 0 0. " PERKCKEN0 "  "0 ,1 "
tree.end

base sd:0xa03cf00c
tree "PRCC_KCKDIS"
wgroup 0--3
line.long 0 "PRCC_KCKDIS"
bitfld.long 0 0. " PERKCKDIS0 "  "0 ,1 "
tree.end

base sd:0xa03cf010
tree "PRCC_PCKSR"
rgroup 0--3
line.long 0 "PRCC_PCKSR"
bitfld.long 0 0. " PERCKSR0 "  "0 ,1 "
bitfld.long 0 1. " PERCKSR1 "  "0 ,1 "
bitfld.long 0 2. " PERCKSR2 "  "0 ,1 "
bitfld.long 0 3. " PERCKSR3 "  "0 ,1 "
bitfld.long 0 4. " PERCKSR4 "  "0 ,1 "
bitfld.long 0 5. " PERCKSR5 "  "0 ,1 "
bitfld.long 0 6. " PERCKSR6 "  "0 ,1 "
bitfld.long 0 7. " PERCKSR7 "  "0 ,1 "
tree.end

base sd:0xa03cf014
tree "PRCC_PKCKSR"
rgroup 0--3
line.long 0 "PRCC_PKCKSR"
bitfld.long 0 0. " PERKCKSR0 "  "0 ,1 "
tree.end

base sd:0xa03cf018
tree "PRCC_K_SOFTRST_SET"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_SET"
bitfld.long 0 0. " K_SOFTRST_SET0 "  "0 ,1 "
tree.end

base sd:0xa03cf01c
tree "PRCC_K_SOFTRST_CLR"
wgroup 0--3
line.long 0 "PRCC_K_SOFTRST_CLR"
bitfld.long 0 0. " K_SOFTRST_CLR0 "  "0 ,1 "
tree.end

base sd:0xa03cf020
tree "PRCC_K_RST_STATUS"
group 0--3
line.long 0 "PRCC_K_RST_STATUS"
bitfld.long 0 0. " K_RST_STATUS0 "  "0 ,1 "
tree.end

base sd:0xa03cffe0
tree "PRCCPeriphID0"
rgroup 0--3
line.long 0 "PRCCPeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0xa03cffe4
tree "PRCCPeriphID1"
rgroup 0--3
line.long 0 "PRCCPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0xa03cffe8
tree "PRCCPeriphID2"
rgroup 0--3
line.long 0 "PRCCPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0xa03cffec
tree "PRCCPeriphID3"
rgroup 0--3
line.long 0 "PRCCPeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0xa03cfff0
tree "PRCCPCellID0"
rgroup 0--3
line.long 0 "PRCCPCellID0"
bitfld.long 0 0.--7. " PRCCPCellID0 "  " "
tree.end

base sd:0xa03cfff4
tree "PRCCPCellID1"
rgroup 0--3
line.long 0 "PRCCPCellID1"
bitfld.long 0 0.--7. " PRCCPCellID1 "  " "
tree.end

base sd:0xa03cfff8
tree "PRCCPCellID2"
rgroup 0--3
line.long 0 "PRCCPCellID2"
bitfld.long 0 0.--7. " PRCCPCellID2 "  " "
tree.end

base sd:0xa03cfffc
tree "PRCCPCellID3"
rgroup 0--3
line.long 0 "PRCCPCellID3"
bitfld.long 0 0.--7. " PRCCPCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "CR"
;==============================================================
base sd:0xa03c8000
tree "CR_REG0"
group 0--3
line.long 0 "CR_REG0"
bitfld.long 0 0.--2. " VPIPWM8MUX "  " "
bitfld.long 0 3. " MSP0WR "  "0 ,1 "
bitfld.long 0 4.--6. " SPARE0 "  " "
bitfld.long 0 7. " MSSINTMSK "  "0 ,1 "
bitfld.long 0 8.--12. " MDMTPDATSIZE "  " "
bitfld.long 0 13. " MDMTPCTL "  "0 ,1 "
bitfld.long 0 16. " SXAGPIO "  "0 ,1 "
bitfld.long 0 18.--21. " SBAGD "  " "
bitfld.long 0 22.--25. " SBAGT "  " "
bitfld.long 0 26. " HTIMEN "  "0 ,1 "
bitfld.long 0 28.--31. " MSSHOSTADDROFF "  " "
tree.end

base sd:0xa03c8004
tree "CR_REG1"
group 0--3
line.long 0 "CR_REG1"
bitfld.long 0 0. " ICN_DEC_ERROR_ITMASK "  "0 ,1 "
bitfld.long 0 1. " ICN_DEC_ERROR_ITCLR "  "0 ,1 "
bitfld.long 0 10. " PRODTESTUICC_DP_OUT "  "0 ,1 "
bitfld.long 0 11. " PRODTESTUICC_DM_OUT "  "0 ,1 "
bitfld.long 0 12. " PRODTESTUICC_IOCTRL_OUT "  "0 ,1 "
bitfld.long 0 13.--31. " SPARE "  " "
tree.end

base sd:0xa03c8008
tree "CR_REG2"
group 0--3
line.long 0 "CR_REG2"
bitfld.long 0 0.--3. " KPSKA0MUX "  " "
bitfld.long 0 4.--7. " KPSKA1MUX "  " "
bitfld.long 0 8.--11. " KPSKA2MUX "  " "
bitfld.long 0 12.--15. " KPSKB0MUX "  " "
bitfld.long 0 16.--19. " KPSKB1MUX "  " "
bitfld.long 0 20.--23. " KPSKB2MUX "  " "
bitfld.long 0 24.--26. " KP08MUX "  " "
bitfld.long 0 27.--29. " KP09MUX "  " "
tree.end

base sd:0xa03c800c
tree "CR_REG3"
group 0--3
line.long 0 "CR_REG3"
bitfld.long 0 0.--1. " SVADMACH0 "  " "
bitfld.long 0 2.--3. " SVADMACH1 "  " "
bitfld.long 0 4.--8. " SVADMACH2 "  " "
bitfld.long 0 9.--13. " SVADMACH3 "  " "
bitfld.long 0 14. " SVASMSP2SLIMINT "  "0 ,1 "
bitfld.long 0 16.--17. " SIADMACH0 "  " "
bitfld.long 0 18.--19. " SIADMACH1 "  " "
bitfld.long 0 20.--24. " SIADMACH2 "  " "
bitfld.long 0 25.--29. " SIADMACH3 "  " "
bitfld.long 0 30. " SIASMSP2SLIMINT "  "0 ,1 "
bitfld.long 0 31. " FSMCFBCLK "  "0 ,1 "
tree.end

base sd:0xa03c8014
tree "CR_REG5"
group 0--3
line.long 0 "CR_REG5"
bitfld.long 0 0.--9. " HSISLIM0RX "  " "
bitfld.long 0 10.--19. " HSISLIM0TX "  " "
bitfld.long 0 30. " MSP0SLIM0RX "  "0 ,1 "
bitfld.long 0 31. " MSP0SLIM0TX "  "0 ,1 "
tree.end

base sd:0xa03c8018
tree "SLIM_CFG"
group 0--3
line.long 0 "SLIM_CFG"
bitfld.long 0 0.--1. " CLK_LOADREG "  " "
bitfld.long 0 2.--4. " CLK_BUSKEEP "  " "
bitfld.long 0 5.--8. " CLK_VSAFEBUSKEEP "  " "
bitfld.long 0 9. " CLK_SLIMBUSMODE "  "0 ,1 "
bitfld.long 0 10.--11. " DATA_LOADREG "  " "
bitfld.long 0 12.--14. " DATA_BUSKEEP "  " "
bitfld.long 0 15.--18. " DATA_VSAFEBUSKEEP "  " "
bitfld.long 0 19. " DATA_SLIMBUSMODE "  "0 ,1 "
bitfld.long 0 20.--26. " CALREQUEST "  " "
tree.end

base sd:0xa03c801c
tree "MCSBAG_CLKEN_CR"
group 0--3
line.long 0 "MCSBAG_CLKEN_CR"
bitfld.long 0 0. " PI_CLKGATE_EN "  "0 ,1 "
bitfld.long 0 1. " WPS_CLKGATE_EN "  "0 ,1 "
bitfld.long 0 2.--15. " TMS_CLKGATE_EN "  " "
tree.end

base sd:0xa03c8020
tree "CR_XDBG"
group 0--3
line.long 0 "CR_XDBG"
bitfld.long 0 0. " XDBGEN "  "0 ,1 "
bitfld.long 0 1. " EXTBRKEn "  "0 ,1 "
bitfld.long 0 2.--3. " XDBGMODE "  " "
bitfld.long 0 4.--11. " XDBGSRC "  " "
bitfld.long 0 12.--19. " XDBGSTA "  " "
tree.end

base sd:0xa03c8024
tree "CR_XDBG_BRKINEN"
group 0--3
line.long 0 "CR_XDBG_BRKINEN"
bitfld.long 0 0.--7. " BRKINEN "  " "
tree.end

base sd:0xa03c8028
tree "MCSBAG_CLKEN_TMS_STATUS"
rgroup 0--3
line.long 0 "MCSBAG_CLKEN_TMS_STATUS"
bitfld.long 0 0.--13. " CLKEN_TMS_STATUS "  " "
tree.end

base sd:0xa03c802c
tree "CR_USB"
group 0--3
line.long 0 "CR_USB"
bitfld.long 0 0. " XGATE "  "0 ,1 "
tree.end

base sd:0xa03c8fe0
tree "CRPeriphID0"
rgroup 0--3
line.long 0 "CRPeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0xa03c8fe4
tree "CRPeriphID1"
rgroup 0--3
line.long 0 "CRPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0xa03c8fe8
tree "CRPeriphID2"
rgroup 0--3
line.long 0 "CRPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0xa03c8fec
tree "CRPeriphID3"
rgroup 0--3
line.long 0 "CRPeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0xa03c8ff0
tree "CRPCellID0"
rgroup 0--3
line.long 0 "CRPCellID0"
bitfld.long 0 0.--7. " CRPCellID0 "  " "
tree.end

base sd:0xa03c8ff4
tree "CRPCellID1"
rgroup 0--3
line.long 0 "CRPCellID1"
bitfld.long 0 0.--7. " CRPCellID1 "  " "
tree.end

base sd:0xa03c8ff8
tree "CRPCellID2"
rgroup 0--3
line.long 0 "CRPCellID2"
bitfld.long 0 0.--7. " CRPCellID2 "  " "
tree.end

base sd:0xa03c8ffc
tree "CRPCellID3"
rgroup 0--3
line.long 0 "CRPCellID3"
bitfld.long 0 0.--7. " CRPCellID3 "  " "
tree.end

tree.end

;==============================================================
;tree "CRYP (2 instances)"
;==============================================================
base sd:0xa03ca000
;********************************************
tree "CRYP-0"
;********************************************
base sd:0xa03ca000
tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGODIR "  "0 ,1 "
bitfld.long 0 3.--5. " ALGOMODE "  " "
bitfld.long 0 6.--7. " DATATYPE "  " "
bitfld.long 0 8.--9. " KEYSIZE "  " "
bitfld.long 0 10. " KEYRDEN "  "0 ,1 "
bitfld.long 0 11. " KSE "  "0 ,1 "
bitfld.long 0 12. " START "  "0 ,1 "
bitfld.long 0 13. " INIT "  "0 ,1 "
bitfld.long 0 14. " FFLUSH "  "0 ,1 "
bitfld.long 0 15. " CRYPEN "  "0 ,1 "
bitfld.long 0 16. " SECONDLAST "  "0 ,1 "
bitfld.long 0 20. " ENS "  "0 ,1 "
bitfld.long 0 24. " KEYLOCK "  "0 ,1 "
tree.end

base sd:0xa03ca004
tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " IFEM "  "0 ,1 "
bitfld.long 0 1. " IFNF "  "0 ,1 "
bitfld.long 0 2. " OFNE "  "0 ,1 "
bitfld.long 0 3. " OFFU "  "0 ,1 "
bitfld.long 0 4. " BUSY "  "0 ,1 "
tree.end

base sd:0xa03ca008
tree "0DIN"
group 0--3
line.long 0 "DIN"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0xa03ca00c
tree "0DINSIZE"
group 0--3
line.long 0 "DINSIZE"
bitfld.long 0 0.--3. " DINSIZE "  " "
tree.end

base sd:0xa03ca010
tree "0DOUT"
rgroup 0--3
line.long 0 "DOUT"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0xa03ca014
tree "0DOUTSIZE"
rgroup 0--3
line.long 0 "DOUTSIZE"
bitfld.long 0 0.--3. " DOUTSIZE "  " "
tree.end

base sd:0xa03ca018
tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " DMAINEN "  "0 ,1 "
bitfld.long 0 1. " DMAOUTEN "  "0 ,1 "
tree.end

base sd:0xa03ca01c
tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " INIM "  "0 ,1 "
bitfld.long 0 1. " OUTIM "  "0 ,1 "
tree.end

base sd:0xa03ca020
tree "0RIS"
group 0--3
line.long 0 "RIS"
bitfld.long 0 0. " INRIS "  "0 ,1 "
bitfld.long 0 1. " OUTRIS "  "0 ,1 "
tree.end

base sd:0xa03ca024
tree "0MIS"
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " INMIS "  "0 ,1 "
bitfld.long 0 1. " OUTMIS "  "0 ,1 "
tree.end

base sd:0xa03ca028
tree "0K1L"
group 0--3
line.long 0 "K1L"
bitfld.long 0 0. " K31 "  "0 ,1 "
bitfld.long 0 1. " K30 "  "0 ,1 "
bitfld.long 0 2. " K29 "  "0 ,1 "
bitfld.long 0 3. " K28 "  "0 ,1 "
bitfld.long 0 4. " K27 "  "0 ,1 "
bitfld.long 0 5. " K26 "  "0 ,1 "
bitfld.long 0 6. " K25 "  "0 ,1 "
bitfld.long 0 7. " K24 "  "0 ,1 "
bitfld.long 0 8. " K23 "  "0 ,1 "
bitfld.long 0 9. " K22 "  "0 ,1 "
bitfld.long 0 10. " K21 "  "0 ,1 "
bitfld.long 0 11. " K20 "  "0 ,1 "
bitfld.long 0 12. " K19 "  "0 ,1 "
bitfld.long 0 13. " K18 "  "0 ,1 "
bitfld.long 0 14. " K17 "  "0 ,1 "
bitfld.long 0 15. " K16 "  "0 ,1 "
bitfld.long 0 16. " K15 "  "0 ,1 "
bitfld.long 0 17. " K14 "  "0 ,1 "
bitfld.long 0 18. " K13 "  "0 ,1 "
bitfld.long 0 19. " K12 "  "0 ,1 "
bitfld.long 0 20. " K11 "  "0 ,1 "
bitfld.long 0 21. " K10 "  "0 ,1 "
bitfld.long 0 22. " K9 "  "0 ,1 "
bitfld.long 0 23. " K8 "  "0 ,1 "
bitfld.long 0 24. " K7 "  "0 ,1 "
bitfld.long 0 25. " K6 "  "0 ,1 "
bitfld.long 0 26. " K5 "  "0 ,1 "
bitfld.long 0 27. " K4 "  "0 ,1 "
bitfld.long 0 28. " K3 "  "0 ,1 "
bitfld.long 0 29. " K2 "  "0 ,1 "
bitfld.long 0 30. " K1 "  "0 ,1 "
bitfld.long 0 31. " K0 "  "0 ,1 "
tree.end

base sd:0xa03ca02c
tree "0K1R"
group 0--3
line.long 0 "K1R"
bitfld.long 0 0. " K63 "  "0 ,1 "
bitfld.long 0 1. " K62 "  "0 ,1 "
bitfld.long 0 2. " K61 "  "0 ,1 "
bitfld.long 0 3. " K60 "  "0 ,1 "
bitfld.long 0 4. " K59 "  "0 ,1 "
bitfld.long 0 5. " K58 "  "0 ,1 "
bitfld.long 0 6. " K57 "  "0 ,1 "
bitfld.long 0 7. " K56 "  "0 ,1 "
bitfld.long 0 8. " K55 "  "0 ,1 "
bitfld.long 0 9. " K54 "  "0 ,1 "
bitfld.long 0 10. " K53 "  "0 ,1 "
bitfld.long 0 11. " K52 "  "0 ,1 "
bitfld.long 0 12. " K51 "  "0 ,1 "
bitfld.long 0 13. " K50 "  "0 ,1 "
bitfld.long 0 14. " K49 "  "0 ,1 "
bitfld.long 0 15. " K48 "  "0 ,1 "
bitfld.long 0 16. " K47 "  "0 ,1 "
bitfld.long 0 17. " K46 "  "0 ,1 "
bitfld.long 0 18. " K45 "  "0 ,1 "
bitfld.long 0 19. " K44 "  "0 ,1 "
bitfld.long 0 20. " K43 "  "0 ,1 "
bitfld.long 0 21. " K42 "  "0 ,1 "
bitfld.long 0 22. " K41 "  "0 ,1 "
bitfld.long 0 23. " K40 "  "0 ,1 "
bitfld.long 0 24. " K39 "  "0 ,1 "
bitfld.long 0 25. " K38 "  "0 ,1 "
bitfld.long 0 26. " K37 "  "0 ,1 "
bitfld.long 0 27. " K36 "  "0 ,1 "
bitfld.long 0 28. " K35 "  "0 ,1 "
bitfld.long 0 29. " K34 "  "0 ,1 "
bitfld.long 0 30. " K33 "  "0 ,1 "
bitfld.long 0 31. " K32 "  "0 ,1 "
tree.end

base sd:0xa03ca030
tree "0K2L"
group 0--3
line.long 0 "K2L"
bitfld.long 0 0. " K95 "  "0 ,1 "
bitfld.long 0 1. " K94 "  "0 ,1 "
bitfld.long 0 2. " K93 "  "0 ,1 "
bitfld.long 0 3. " K92 "  "0 ,1 "
bitfld.long 0 4. " K91 "  "0 ,1 "
bitfld.long 0 5. " K90 "  "0 ,1 "
bitfld.long 0 6. " K89 "  "0 ,1 "
bitfld.long 0 7. " K88 "  "0 ,1 "
bitfld.long 0 8. " K87 "  "0 ,1 "
bitfld.long 0 9. " K86 "  "0 ,1 "
bitfld.long 0 10. " K85 "  "0 ,1 "
bitfld.long 0 11. " K84 "  "0 ,1 "
bitfld.long 0 12. " K83 "  "0 ,1 "
bitfld.long 0 13. " K82 "  "0 ,1 "
bitfld.long 0 14. " K81 "  "0 ,1 "
bitfld.long 0 15. " K80 "  "0 ,1 "
bitfld.long 0 16. " K79 "  "0 ,1 "
bitfld.long 0 17. " K78 "  "0 ,1 "
bitfld.long 0 18. " K77 "  "0 ,1 "
bitfld.long 0 19. " K76 "  "0 ,1 "
bitfld.long 0 20. " K75 "  "0 ,1 "
bitfld.long 0 21. " K74 "  "0 ,1 "
bitfld.long 0 22. " K73 "  "0 ,1 "
bitfld.long 0 23. " K72 "  "0 ,1 "
bitfld.long 0 24. " K71 "  "0 ,1 "
bitfld.long 0 25. " K70 "  "0 ,1 "
bitfld.long 0 26. " K69 "  "0 ,1 "
bitfld.long 0 27. " K68 "  "0 ,1 "
bitfld.long 0 28. " K67 "  "0 ,1 "
bitfld.long 0 29. " K66 "  "0 ,1 "
bitfld.long 0 30. " K65 "  "0 ,1 "
bitfld.long 0 31. " K64 "  "0 ,1 "
tree.end

base sd:0xa03ca034
tree "0K2R"
group 0--3
line.long 0 "K2R"
bitfld.long 0 0. " K127 "  "0 ,1 "
bitfld.long 0 1. " K126 "  "0 ,1 "
bitfld.long 0 2. " K125 "  "0 ,1 "
bitfld.long 0 3. " K124 "  "0 ,1 "
bitfld.long 0 4. " K123 "  "0 ,1 "
bitfld.long 0 5. " K122 "  "0 ,1 "
bitfld.long 0 6. " K121 "  "0 ,1 "
bitfld.long 0 7. " K120 "  "0 ,1 "
bitfld.long 0 8. " K119 "  "0 ,1 "
bitfld.long 0 9. " K118 "  "0 ,1 "
bitfld.long 0 10. " K117 "  "0 ,1 "
bitfld.long 0 11. " K116 "  "0 ,1 "
bitfld.long 0 12. " K115 "  "0 ,1 "
bitfld.long 0 13. " K114 "  "0 ,1 "
bitfld.long 0 14. " K113 "  "0 ,1 "
bitfld.long 0 15. " K112 "  "0 ,1 "
bitfld.long 0 16. " K111 "  "0 ,1 "
bitfld.long 0 17. " K110 "  "0 ,1 "
bitfld.long 0 18. " K109 "  "0 ,1 "
bitfld.long 0 19. " K108 "  "0 ,1 "
bitfld.long 0 20. " K107 "  "0 ,1 "
bitfld.long 0 21. " K106 "  "0 ,1 "
bitfld.long 0 22. " K105 "  "0 ,1 "
bitfld.long 0 23. " K104 "  "0 ,1 "
bitfld.long 0 24. " K103 "  "0 ,1 "
bitfld.long 0 25. " K102 "  "0 ,1 "
bitfld.long 0 26. " K101 "  "0 ,1 "
bitfld.long 0 27. " K100 "  "0 ,1 "
bitfld.long 0 28. " K99 "  "0 ,1 "
bitfld.long 0 29. " K98 "  "0 ,1 "
bitfld.long 0 30. " K97 "  "0 ,1 "
bitfld.long 0 31. " K96 "  "0 ,1 "
tree.end

base sd:0xa03ca038
tree "0K3L"
group 0--3
line.long 0 "K3L"
bitfld.long 0 0. " K159 "  "0 ,1 "
bitfld.long 0 1. " K158 "  "0 ,1 "
bitfld.long 0 2. " K157 "  "0 ,1 "
bitfld.long 0 3. " K156 "  "0 ,1 "
bitfld.long 0 4. " K155 "  "0 ,1 "
bitfld.long 0 5. " K154 "  "0 ,1 "
bitfld.long 0 6. " K153 "  "0 ,1 "
bitfld.long 0 7. " K152 "  "0 ,1 "
bitfld.long 0 8. " K151 "  "0 ,1 "
bitfld.long 0 9. " K150 "  "0 ,1 "
bitfld.long 0 10. " K149 "  "0 ,1 "
bitfld.long 0 11. " K148 "  "0 ,1 "
bitfld.long 0 12. " K147 "  "0 ,1 "
bitfld.long 0 13. " K146 "  "0 ,1 "
bitfld.long 0 14. " K145 "  "0 ,1 "
bitfld.long 0 15. " K144 "  "0 ,1 "
bitfld.long 0 16. " K143 "  "0 ,1 "
bitfld.long 0 17. " K142 "  "0 ,1 "
bitfld.long 0 18. " K141 "  "0 ,1 "
bitfld.long 0 19. " K140 "  "0 ,1 "
bitfld.long 0 20. " K139 "  "0 ,1 "
bitfld.long 0 21. " K138 "  "0 ,1 "
bitfld.long 0 22. " K137 "  "0 ,1 "
bitfld.long 0 23. " K136 "  "0 ,1 "
bitfld.long 0 24. " K135 "  "0 ,1 "
bitfld.long 0 25. " K134 "  "0 ,1 "
bitfld.long 0 26. " K133 "  "0 ,1 "
bitfld.long 0 27. " K132 "  "0 ,1 "
bitfld.long 0 28. " K131 "  "0 ,1 "
bitfld.long 0 29. " K130 "  "0 ,1 "
bitfld.long 0 30. " K129 "  "0 ,1 "
bitfld.long 0 31. " K128 "  "0 ,1 "
tree.end

base sd:0xa03ca03c
tree "0K3R"
group 0--3
line.long 0 "K3R"
bitfld.long 0 0. " K191 "  "0 ,1 "
bitfld.long 0 1. " K190 "  "0 ,1 "
bitfld.long 0 2. " K189 "  "0 ,1 "
bitfld.long 0 3. " K188 "  "0 ,1 "
bitfld.long 0 4. " K187 "  "0 ,1 "
bitfld.long 0 5. " K186 "  "0 ,1 "
bitfld.long 0 6. " K185 "  "0 ,1 "
bitfld.long 0 7. " K184 "  "0 ,1 "
bitfld.long 0 8. " K183 "  "0 ,1 "
bitfld.long 0 9. " K182 "  "0 ,1 "
bitfld.long 0 10. " K181 "  "0 ,1 "
bitfld.long 0 11. " K180 "  "0 ,1 "
bitfld.long 0 12. " K179 "  "0 ,1 "
bitfld.long 0 13. " K178 "  "0 ,1 "
bitfld.long 0 14. " K177 "  "0 ,1 "
bitfld.long 0 15. " K176 "  "0 ,1 "
bitfld.long 0 16. " K175 "  "0 ,1 "
bitfld.long 0 17. " K174 "  "0 ,1 "
bitfld.long 0 18. " K173 "  "0 ,1 "
bitfld.long 0 19. " K172 "  "0 ,1 "
bitfld.long 0 20. " K171 "  "0 ,1 "
bitfld.long 0 21. " K170 "  "0 ,1 "
bitfld.long 0 22. " K169 "  "0 ,1 "
bitfld.long 0 23. " K168 "  "0 ,1 "
bitfld.long 0 24. " K167 "  "0 ,1 "
bitfld.long 0 25. " K166 "  "0 ,1 "
bitfld.long 0 26. " K165 "  "0 ,1 "
bitfld.long 0 27. " K164 "  "0 ,1 "
bitfld.long 0 28. " K163 "  "0 ,1 "
bitfld.long 0 29. " K162 "  "0 ,1 "
bitfld.long 0 30. " K161 "  "0 ,1 "
bitfld.long 0 31. " K160 "  "0 ,1 "
tree.end

base sd:0xa03ca040
tree "0K4L"
group 0--3
line.long 0 "K4L"
bitfld.long 0 0. " K223 "  "0 ,1 "
bitfld.long 0 1. " K222 "  "0 ,1 "
bitfld.long 0 2. " K221 "  "0 ,1 "
bitfld.long 0 3. " K220 "  "0 ,1 "
bitfld.long 0 4. " K219 "  "0 ,1 "
bitfld.long 0 5. " K218 "  "0 ,1 "
bitfld.long 0 6. " K217 "  "0 ,1 "
bitfld.long 0 7. " K216 "  "0 ,1 "
bitfld.long 0 8. " K215 "  "0 ,1 "
bitfld.long 0 9. " K214 "  "0 ,1 "
bitfld.long 0 10. " K213 "  "0 ,1 "
bitfld.long 0 11. " K212 "  "0 ,1 "
bitfld.long 0 12. " K211 "  "0 ,1 "
bitfld.long 0 13. " K210 "  "0 ,1 "
bitfld.long 0 14. " K209 "  "0 ,1 "
bitfld.long 0 15. " K208 "  "0 ,1 "
bitfld.long 0 16. " K207 "  "0 ,1 "
bitfld.long 0 17. " K206 "  "0 ,1 "
bitfld.long 0 18. " K205 "  "0 ,1 "
bitfld.long 0 19. " K204 "  "0 ,1 "
bitfld.long 0 20. " K203 "  "0 ,1 "
bitfld.long 0 21. " K202 "  "0 ,1 "
bitfld.long 0 22. " K201 "  "0 ,1 "
bitfld.long 0 23. " K200 "  "0 ,1 "
bitfld.long 0 24. " K199 "  "0 ,1 "
bitfld.long 0 25. " K198 "  "0 ,1 "
bitfld.long 0 26. " K197 "  "0 ,1 "
bitfld.long 0 27. " K196 "  "0 ,1 "
bitfld.long 0 28. " K195 "  "0 ,1 "
bitfld.long 0 29. " K194 "  "0 ,1 "
bitfld.long 0 30. " K193 "  "0 ,1 "
bitfld.long 0 31. " K192 "  "0 ,1 "
tree.end

base sd:0xa03ca044
tree "0K4R"
group 0--3
line.long 0 "K4R"
bitfld.long 0 0. " K255 "  "0 ,1 "
bitfld.long 0 1. " K254 "  "0 ,1 "
bitfld.long 0 2. " K253 "  "0 ,1 "
bitfld.long 0 3. " K252 "  "0 ,1 "
bitfld.long 0 4. " K251 "  "0 ,1 "
bitfld.long 0 5. " K250 "  "0 ,1 "
bitfld.long 0 6. " K249 "  "0 ,1 "
bitfld.long 0 7. " K248 "  "0 ,1 "
bitfld.long 0 8. " K247 "  "0 ,1 "
bitfld.long 0 9. " K246 "  "0 ,1 "
bitfld.long 0 10. " K245 "  "0 ,1 "
bitfld.long 0 11. " K244 "  "0 ,1 "
bitfld.long 0 12. " K243 "  "0 ,1 "
bitfld.long 0 13. " K242 "  "0 ,1 "
bitfld.long 0 14. " K241 "  "0 ,1 "
bitfld.long 0 15. " K240 "  "0 ,1 "
bitfld.long 0 16. " K239 "  "0 ,1 "
bitfld.long 0 17. " K238 "  "0 ,1 "
bitfld.long 0 18. " K237 "  "0 ,1 "
bitfld.long 0 19. " K236 "  "0 ,1 "
bitfld.long 0 20. " K235 "  "0 ,1 "
bitfld.long 0 21. " K234 "  "0 ,1 "
bitfld.long 0 22. " K233 "  "0 ,1 "
bitfld.long 0 23. " K232 "  "0 ,1 "
bitfld.long 0 24. " K231 "  "0 ,1 "
bitfld.long 0 25. " K230 "  "0 ,1 "
bitfld.long 0 26. " K229 "  "0 ,1 "
bitfld.long 0 27. " K228 "  "0 ,1 "
bitfld.long 0 28. " K227 "  "0 ,1 "
bitfld.long 0 29. " K226 "  "0 ,1 "
bitfld.long 0 30. " K225 "  "0 ,1 "
bitfld.long 0 31. " K224 "  "0 ,1 "
tree.end

base sd:0xa03ca048
tree "0IV0L"
group 0--3
line.long 0 "IV0L"
bitfld.long 0 0. " IV32 "  "0 ,1 "
bitfld.long 0 1. " IV31 "  "0 ,1 "
bitfld.long 0 2. " IV30 "  "0 ,1 "
bitfld.long 0 3. " IV29 "  "0 ,1 "
bitfld.long 0 4. " IV28 "  "0 ,1 "
bitfld.long 0 5. " IV27 "  "0 ,1 "
bitfld.long 0 6. " IV26 "  "0 ,1 "
bitfld.long 0 7. " IV25 "  "0 ,1 "
bitfld.long 0 8. " IV24 "  "0 ,1 "
bitfld.long 0 9. " IV23 "  "0 ,1 "
bitfld.long 0 10. " IV22 "  "0 ,1 "
bitfld.long 0 11. " IV21 "  "0 ,1 "
bitfld.long 0 12. " IV20 "  "0 ,1 "
bitfld.long 0 13. " IV19 "  "0 ,1 "
bitfld.long 0 14. " IV18 "  "0 ,1 "
bitfld.long 0 15. " IV17 "  "0 ,1 "
bitfld.long 0 16. " IV16 "  "0 ,1 "
bitfld.long 0 17. " IV15 "  "0 ,1 "
bitfld.long 0 18. " IV14 "  "0 ,1 "
bitfld.long 0 19. " IV13 "  "0 ,1 "
bitfld.long 0 20. " IV12 "  "0 ,1 "
bitfld.long 0 21. " IV11 "  "0 ,1 "
bitfld.long 0 22. " IV10 "  "0 ,1 "
bitfld.long 0 23. " IV9 "  "0 ,1 "
bitfld.long 0 24. " IV8 "  "0 ,1 "
bitfld.long 0 25. " IV7 "  "0 ,1 "
bitfld.long 0 26. " IV6 "  "0 ,1 "
bitfld.long 0 27. " IV5 "  "0 ,1 "
bitfld.long 0 28. " IV4 "  "0 ,1 "
bitfld.long 0 29. " IV3 "  "0 ,1 "
bitfld.long 0 30. " IV2 "  "0 ,1 "
bitfld.long 0 31. " IV1 "  "0 ,1 "
tree.end

base sd:0xa03ca04c
tree "0IV0R"
group 0--3
line.long 0 "IV0R"
bitfld.long 0 0. " IV64 "  "0 ,1 "
bitfld.long 0 1. " IV63 "  "0 ,1 "
bitfld.long 0 2. " IV62 "  "0 ,1 "
bitfld.long 0 3. " IV61 "  "0 ,1 "
bitfld.long 0 4. " IV60 "  "0 ,1 "
bitfld.long 0 5. " IV59 "  "0 ,1 "
bitfld.long 0 6. " IV58 "  "0 ,1 "
bitfld.long 0 7. " IV57 "  "0 ,1 "
bitfld.long 0 8. " IV56 "  "0 ,1 "
bitfld.long 0 9. " IV55 "  "0 ,1 "
bitfld.long 0 10. " IV54 "  "0 ,1 "
bitfld.long 0 11. " IV53 "  "0 ,1 "
bitfld.long 0 12. " IV52 "  "0 ,1 "
bitfld.long 0 13. " IV51 "  "0 ,1 "
bitfld.long 0 14. " IV50 "  "0 ,1 "
bitfld.long 0 15. " IV49 "  "0 ,1 "
bitfld.long 0 16. " IV48 "  "0 ,1 "
bitfld.long 0 17. " IV47 "  "0 ,1 "
bitfld.long 0 18. " IV46 "  "0 ,1 "
bitfld.long 0 19. " IV45 "  "0 ,1 "
bitfld.long 0 20. " IV44 "  "0 ,1 "
bitfld.long 0 21. " IV43 "  "0 ,1 "
bitfld.long 0 22. " IV42 "  "0 ,1 "
bitfld.long 0 23. " IV41 "  "0 ,1 "
bitfld.long 0 24. " IV40 "  "0 ,1 "
bitfld.long 0 25. " IV39 "  "0 ,1 "
bitfld.long 0 26. " IV38 "  "0 ,1 "
bitfld.long 0 27. " IV37 "  "0 ,1 "
bitfld.long 0 28. " IV36 "  "0 ,1 "
bitfld.long 0 29. " IV35 "  "0 ,1 "
bitfld.long 0 30. " IV34 "  "0 ,1 "
bitfld.long 0 31. " IV33 "  "0 ,1 "
tree.end

base sd:0xa03ca050
tree "0IV1L"
group 0--3
line.long 0 "IV1L"
bitfld.long 0 0. " IV96 "  "0 ,1 "
bitfld.long 0 1. " IV95 "  "0 ,1 "
bitfld.long 0 2. " IV94 "  "0 ,1 "
bitfld.long 0 3. " IV93 "  "0 ,1 "
bitfld.long 0 4. " IV92 "  "0 ,1 "
bitfld.long 0 5. " IV91 "  "0 ,1 "
bitfld.long 0 6. " IV90 "  "0 ,1 "
bitfld.long 0 7. " IV89 "  "0 ,1 "
bitfld.long 0 8. " IV88 "  "0 ,1 "
bitfld.long 0 9. " IV87 "  "0 ,1 "
bitfld.long 0 10. " IV86 "  "0 ,1 "
bitfld.long 0 11. " IV85 "  "0 ,1 "
bitfld.long 0 12. " IV84 "  "0 ,1 "
bitfld.long 0 13. " IV83 "  "0 ,1 "
bitfld.long 0 14. " IV82 "  "0 ,1 "
bitfld.long 0 15. " IV81 "  "0 ,1 "
bitfld.long 0 16. " IV80 "  "0 ,1 "
bitfld.long 0 17. " IV79 "  "0 ,1 "
bitfld.long 0 18. " IV78 "  "0 ,1 "
bitfld.long 0 19. " IV77 "  "0 ,1 "
bitfld.long 0 20. " IV76 "  "0 ,1 "
bitfld.long 0 21. " IV75 "  "0 ,1 "
bitfld.long 0 22. " IV74 "  "0 ,1 "
bitfld.long 0 23. " IV73 "  "0 ,1 "
bitfld.long 0 24. " IV72 "  "0 ,1 "
bitfld.long 0 25. " IV71 "  "0 ,1 "
bitfld.long 0 26. " IV70 "  "0 ,1 "
bitfld.long 0 27. " IV69 "  "0 ,1 "
bitfld.long 0 28. " IV68 "  "0 ,1 "
bitfld.long 0 29. " IV67 "  "0 ,1 "
bitfld.long 0 30. " IV66 "  "0 ,1 "
bitfld.long 0 31. " IV65 "  "0 ,1 "
tree.end

base sd:0xa03ca054
tree "0IV1R"
group 0--3
line.long 0 "IV1R"
bitfld.long 0 0. " IV128 "  "0 ,1 "
bitfld.long 0 1. " IV127 "  "0 ,1 "
bitfld.long 0 2. " IV126 "  "0 ,1 "
bitfld.long 0 3. " IV125 "  "0 ,1 "
bitfld.long 0 4. " IV124 "  "0 ,1 "
bitfld.long 0 5. " IV123 "  "0 ,1 "
bitfld.long 0 6. " IV122 "  "0 ,1 "
bitfld.long 0 7. " IV121 "  "0 ,1 "
bitfld.long 0 8. " IV120 "  "0 ,1 "
bitfld.long 0 9. " IV119 "  "0 ,1 "
bitfld.long 0 10. " IV118 "  "0 ,1 "
bitfld.long 0 11. " IV117 "  "0 ,1 "
bitfld.long 0 12. " IV116 "  "0 ,1 "
bitfld.long 0 13. " IV115 "  "0 ,1 "
bitfld.long 0 14. " IV114 "  "0 ,1 "
bitfld.long 0 15. " IV113 "  "0 ,1 "
bitfld.long 0 16. " IV112 "  "0 ,1 "
bitfld.long 0 17. " IV111 "  "0 ,1 "
bitfld.long 0 18. " IV110 "  "0 ,1 "
bitfld.long 0 19. " IV109 "  "0 ,1 "
bitfld.long 0 20. " IV108 "  "0 ,1 "
bitfld.long 0 21. " IV107 "  "0 ,1 "
bitfld.long 0 22. " IV106 "  "0 ,1 "
bitfld.long 0 23. " IV105 "  "0 ,1 "
bitfld.long 0 24. " IV104 "  "0 ,1 "
bitfld.long 0 25. " IV103 "  "0 ,1 "
bitfld.long 0 26. " IV102 "  "0 ,1 "
bitfld.long 0 27. " IV101 "  "0 ,1 "
bitfld.long 0 28. " IV100 "  "0 ,1 "
bitfld.long 0 29. " IV99 "  "0 ,1 "
bitfld.long 0 30. " IV98 "  "0 ,1 "
bitfld.long 0 31. " IV97 "  "0 ,1 "
tree.end

base sd:0xa03ca080
tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0xa03ca084
tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMAIUTC "  "0 ,1 "
bitfld.long 0 1. " DMAOUTC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
tree.end

base sd:0xa03ca088
tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMAINBREQ "  "0 ,1 "
bitfld.long 0 1. " DMAOUTBREQ "  "0 ,1 "
bitfld.long 0 2. " DMAOUTSREQ "  "0 ,1 "
bitfld.long 0 3. " ININTR "  "0 ,1 "
bitfld.long 0 4. " OUTINTR "  "0 ,1 "
tree.end

base sd:0xa03cafe0
tree "0CRYPPeriphID0"
rgroup 0--3
line.long 0 "CRYPPeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0xa03cafe4
tree "0CRYPPeriphID1"
rgroup 0--3
line.long 0 "CRYPPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0xa03cafe8
tree "0CRYPPeriphID2"
rgroup 0--3
line.long 0 "CRYPPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0xa03cafec
tree "0CRYPPeriphID3"
rgroup 0--3
line.long 0 "CRYPPeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0xa03caff0
tree "0CRYPPCellID0"
rgroup 0--3
line.long 0 "CRYPPCellID0"
bitfld.long 0 0.--7. " CRYPPCellID0 "  " "
tree.end

base sd:0xa03caff4
tree "0CRYPPCellID1"
rgroup 0--3
line.long 0 "CRYPPCellID1"
bitfld.long 0 0.--7. " CRYPPCellID1 "  " "
tree.end

base sd:0xa03caff8
tree "0CRYPPCellID2"
rgroup 0--3
line.long 0 "CRYPPCellID2"
bitfld.long 0 0.--7. " CRYPPCellID2 "  " "
tree.end

base sd:0xa03caffc
tree "0CRYPPCellID3"
rgroup 0--3
line.long 0 "CRYPPCellID3"
bitfld.long 0 0.--7. " CRYPPCellID3 "  " "
tree.end

tree.end

base sd:0xa03cb000
;********************************************
tree "CRYP-1"
;********************************************
base sd:0xa03cb000
tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGODIR "  "0 ,1 "
bitfld.long 0 3.--5. " ALGOMODE "  " "
bitfld.long 0 6.--7. " DATATYPE "  " "
bitfld.long 0 8.--9. " KEYSIZE "  " "
bitfld.long 0 10. " KEYRDEN "  "0 ,1 "
bitfld.long 0 11. " KSE "  "0 ,1 "
bitfld.long 0 12. " START "  "0 ,1 "
bitfld.long 0 13. " INIT "  "0 ,1 "
bitfld.long 0 14. " FFLUSH "  "0 ,1 "
bitfld.long 0 15. " CRYPEN "  "0 ,1 "
bitfld.long 0 16. " SECONDLAST "  "0 ,1 "
bitfld.long 0 20. " ENS "  "0 ,1 "
bitfld.long 0 24. " KEYLOCK "  "0 ,1 "
tree.end

base sd:0xa03cb004
tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " IFEM "  "0 ,1 "
bitfld.long 0 1. " IFNF "  "0 ,1 "
bitfld.long 0 2. " OFNE "  "0 ,1 "
bitfld.long 0 3. " OFFU "  "0 ,1 "
bitfld.long 0 4. " BUSY "  "0 ,1 "
tree.end

base sd:0xa03cb008
tree "1DIN"
group 0--3
line.long 0 "DIN"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0xa03cb00c
tree "1DINSIZE"
group 0--3
line.long 0 "DINSIZE"
bitfld.long 0 0.--3. " DINSIZE "  " "
tree.end

base sd:0xa03cb010
tree "1DOUT"
rgroup 0--3
line.long 0 "DOUT"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0xa03cb014
tree "1DOUTSIZE"
rgroup 0--3
line.long 0 "DOUTSIZE"
bitfld.long 0 0.--3. " DOUTSIZE "  " "
tree.end

base sd:0xa03cb018
tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " DMAINEN "  "0 ,1 "
bitfld.long 0 1. " DMAOUTEN "  "0 ,1 "
tree.end

base sd:0xa03cb01c
tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " INIM "  "0 ,1 "
bitfld.long 0 1. " OUTIM "  "0 ,1 "
tree.end

base sd:0xa03cb020
tree "1RIS"
group 0--3
line.long 0 "RIS"
bitfld.long 0 0. " INRIS "  "0 ,1 "
bitfld.long 0 1. " OUTRIS "  "0 ,1 "
tree.end

base sd:0xa03cb024
tree "1MIS"
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " INMIS "  "0 ,1 "
bitfld.long 0 1. " OUTMIS "  "0 ,1 "
tree.end

base sd:0xa03cb028
tree "1K1L"
group 0--3
line.long 0 "K1L"
bitfld.long 0 0. " K31 "  "0 ,1 "
bitfld.long 0 1. " K30 "  "0 ,1 "
bitfld.long 0 2. " K29 "  "0 ,1 "
bitfld.long 0 3. " K28 "  "0 ,1 "
bitfld.long 0 4. " K27 "  "0 ,1 "
bitfld.long 0 5. " K26 "  "0 ,1 "
bitfld.long 0 6. " K25 "  "0 ,1 "
bitfld.long 0 7. " K24 "  "0 ,1 "
bitfld.long 0 8. " K23 "  "0 ,1 "
bitfld.long 0 9. " K22 "  "0 ,1 "
bitfld.long 0 10. " K21 "  "0 ,1 "
bitfld.long 0 11. " K20 "  "0 ,1 "
bitfld.long 0 12. " K19 "  "0 ,1 "
bitfld.long 0 13. " K18 "  "0 ,1 "
bitfld.long 0 14. " K17 "  "0 ,1 "
bitfld.long 0 15. " K16 "  "0 ,1 "
bitfld.long 0 16. " K15 "  "0 ,1 "
bitfld.long 0 17. " K14 "  "0 ,1 "
bitfld.long 0 18. " K13 "  "0 ,1 "
bitfld.long 0 19. " K12 "  "0 ,1 "
bitfld.long 0 20. " K11 "  "0 ,1 "
bitfld.long 0 21. " K10 "  "0 ,1 "
bitfld.long 0 22. " K9 "  "0 ,1 "
bitfld.long 0 23. " K8 "  "0 ,1 "
bitfld.long 0 24. " K7 "  "0 ,1 "
bitfld.long 0 25. " K6 "  "0 ,1 "
bitfld.long 0 26. " K5 "  "0 ,1 "
bitfld.long 0 27. " K4 "  "0 ,1 "
bitfld.long 0 28. " K3 "  "0 ,1 "
bitfld.long 0 29. " K2 "  "0 ,1 "
bitfld.long 0 30. " K1 "  "0 ,1 "
bitfld.long 0 31. " K0 "  "0 ,1 "
tree.end

base sd:0xa03cb02c
tree "1K1R"
group 0--3
line.long 0 "K1R"
bitfld.long 0 0. " K63 "  "0 ,1 "
bitfld.long 0 1. " K62 "  "0 ,1 "
bitfld.long 0 2. " K61 "  "0 ,1 "
bitfld.long 0 3. " K60 "  "0 ,1 "
bitfld.long 0 4. " K59 "  "0 ,1 "
bitfld.long 0 5. " K58 "  "0 ,1 "
bitfld.long 0 6. " K57 "  "0 ,1 "
bitfld.long 0 7. " K56 "  "0 ,1 "
bitfld.long 0 8. " K55 "  "0 ,1 "
bitfld.long 0 9. " K54 "  "0 ,1 "
bitfld.long 0 10. " K53 "  "0 ,1 "
bitfld.long 0 11. " K52 "  "0 ,1 "
bitfld.long 0 12. " K51 "  "0 ,1 "
bitfld.long 0 13. " K50 "  "0 ,1 "
bitfld.long 0 14. " K49 "  "0 ,1 "
bitfld.long 0 15. " K48 "  "0 ,1 "
bitfld.long 0 16. " K47 "  "0 ,1 "
bitfld.long 0 17. " K46 "  "0 ,1 "
bitfld.long 0 18. " K45 "  "0 ,1 "
bitfld.long 0 19. " K44 "  "0 ,1 "
bitfld.long 0 20. " K43 "  "0 ,1 "
bitfld.long 0 21. " K42 "  "0 ,1 "
bitfld.long 0 22. " K41 "  "0 ,1 "
bitfld.long 0 23. " K40 "  "0 ,1 "
bitfld.long 0 24. " K39 "  "0 ,1 "
bitfld.long 0 25. " K38 "  "0 ,1 "
bitfld.long 0 26. " K37 "  "0 ,1 "
bitfld.long 0 27. " K36 "  "0 ,1 "
bitfld.long 0 28. " K35 "  "0 ,1 "
bitfld.long 0 29. " K34 "  "0 ,1 "
bitfld.long 0 30. " K33 "  "0 ,1 "
bitfld.long 0 31. " K32 "  "0 ,1 "
tree.end

base sd:0xa03cb030
tree "1K2L"
group 0--3
line.long 0 "K2L"
bitfld.long 0 0. " K95 "  "0 ,1 "
bitfld.long 0 1. " K94 "  "0 ,1 "
bitfld.long 0 2. " K93 "  "0 ,1 "
bitfld.long 0 3. " K92 "  "0 ,1 "
bitfld.long 0 4. " K91 "  "0 ,1 "
bitfld.long 0 5. " K90 "  "0 ,1 "
bitfld.long 0 6. " K89 "  "0 ,1 "
bitfld.long 0 7. " K88 "  "0 ,1 "
bitfld.long 0 8. " K87 "  "0 ,1 "
bitfld.long 0 9. " K86 "  "0 ,1 "
bitfld.long 0 10. " K85 "  "0 ,1 "
bitfld.long 0 11. " K84 "  "0 ,1 "
bitfld.long 0 12. " K83 "  "0 ,1 "
bitfld.long 0 13. " K82 "  "0 ,1 "
bitfld.long 0 14. " K81 "  "0 ,1 "
bitfld.long 0 15. " K80 "  "0 ,1 "
bitfld.long 0 16. " K79 "  "0 ,1 "
bitfld.long 0 17. " K78 "  "0 ,1 "
bitfld.long 0 18. " K77 "  "0 ,1 "
bitfld.long 0 19. " K76 "  "0 ,1 "
bitfld.long 0 20. " K75 "  "0 ,1 "
bitfld.long 0 21. " K74 "  "0 ,1 "
bitfld.long 0 22. " K73 "  "0 ,1 "
bitfld.long 0 23. " K72 "  "0 ,1 "
bitfld.long 0 24. " K71 "  "0 ,1 "
bitfld.long 0 25. " K70 "  "0 ,1 "
bitfld.long 0 26. " K69 "  "0 ,1 "
bitfld.long 0 27. " K68 "  "0 ,1 "
bitfld.long 0 28. " K67 "  "0 ,1 "
bitfld.long 0 29. " K66 "  "0 ,1 "
bitfld.long 0 30. " K65 "  "0 ,1 "
bitfld.long 0 31. " K64 "  "0 ,1 "
tree.end

base sd:0xa03cb034
tree "1K2R"
group 0--3
line.long 0 "K2R"
bitfld.long 0 0. " K127 "  "0 ,1 "
bitfld.long 0 1. " K126 "  "0 ,1 "
bitfld.long 0 2. " K125 "  "0 ,1 "
bitfld.long 0 3. " K124 "  "0 ,1 "
bitfld.long 0 4. " K123 "  "0 ,1 "
bitfld.long 0 5. " K122 "  "0 ,1 "
bitfld.long 0 6. " K121 "  "0 ,1 "
bitfld.long 0 7. " K120 "  "0 ,1 "
bitfld.long 0 8. " K119 "  "0 ,1 "
bitfld.long 0 9. " K118 "  "0 ,1 "
bitfld.long 0 10. " K117 "  "0 ,1 "
bitfld.long 0 11. " K116 "  "0 ,1 "
bitfld.long 0 12. " K115 "  "0 ,1 "
bitfld.long 0 13. " K114 "  "0 ,1 "
bitfld.long 0 14. " K113 "  "0 ,1 "
bitfld.long 0 15. " K112 "  "0 ,1 "
bitfld.long 0 16. " K111 "  "0 ,1 "
bitfld.long 0 17. " K110 "  "0 ,1 "
bitfld.long 0 18. " K109 "  "0 ,1 "
bitfld.long 0 19. " K108 "  "0 ,1 "
bitfld.long 0 20. " K107 "  "0 ,1 "
bitfld.long 0 21. " K106 "  "0 ,1 "
bitfld.long 0 22. " K105 "  "0 ,1 "
bitfld.long 0 23. " K104 "  "0 ,1 "
bitfld.long 0 24. " K103 "  "0 ,1 "
bitfld.long 0 25. " K102 "  "0 ,1 "
bitfld.long 0 26. " K101 "  "0 ,1 "
bitfld.long 0 27. " K100 "  "0 ,1 "
bitfld.long 0 28. " K99 "  "0 ,1 "
bitfld.long 0 29. " K98 "  "0 ,1 "
bitfld.long 0 30. " K97 "  "0 ,1 "
bitfld.long 0 31. " K96 "  "0 ,1 "
tree.end

base sd:0xa03cb038
tree "1K3L"
group 0--3
line.long 0 "K3L"
bitfld.long 0 0. " K159 "  "0 ,1 "
bitfld.long 0 1. " K158 "  "0 ,1 "
bitfld.long 0 2. " K157 "  "0 ,1 "
bitfld.long 0 3. " K156 "  "0 ,1 "
bitfld.long 0 4. " K155 "  "0 ,1 "
bitfld.long 0 5. " K154 "  "0 ,1 "
bitfld.long 0 6. " K153 "  "0 ,1 "
bitfld.long 0 7. " K152 "  "0 ,1 "
bitfld.long 0 8. " K151 "  "0 ,1 "
bitfld.long 0 9. " K150 "  "0 ,1 "
bitfld.long 0 10. " K149 "  "0 ,1 "
bitfld.long 0 11. " K148 "  "0 ,1 "
bitfld.long 0 12. " K147 "  "0 ,1 "
bitfld.long 0 13. " K146 "  "0 ,1 "
bitfld.long 0 14. " K145 "  "0 ,1 "
bitfld.long 0 15. " K144 "  "0 ,1 "
bitfld.long 0 16. " K143 "  "0 ,1 "
bitfld.long 0 17. " K142 "  "0 ,1 "
bitfld.long 0 18. " K141 "  "0 ,1 "
bitfld.long 0 19. " K140 "  "0 ,1 "
bitfld.long 0 20. " K139 "  "0 ,1 "
bitfld.long 0 21. " K138 "  "0 ,1 "
bitfld.long 0 22. " K137 "  "0 ,1 "
bitfld.long 0 23. " K136 "  "0 ,1 "
bitfld.long 0 24. " K135 "  "0 ,1 "
bitfld.long 0 25. " K134 "  "0 ,1 "
bitfld.long 0 26. " K133 "  "0 ,1 "
bitfld.long 0 27. " K132 "  "0 ,1 "
bitfld.long 0 28. " K131 "  "0 ,1 "
bitfld.long 0 29. " K130 "  "0 ,1 "
bitfld.long 0 30. " K129 "  "0 ,1 "
bitfld.long 0 31. " K128 "  "0 ,1 "
tree.end

base sd:0xa03cb03c
tree "1K3R"
group 0--3
line.long 0 "K3R"
bitfld.long 0 0. " K191 "  "0 ,1 "
bitfld.long 0 1. " K190 "  "0 ,1 "
bitfld.long 0 2. " K189 "  "0 ,1 "
bitfld.long 0 3. " K188 "  "0 ,1 "
bitfld.long 0 4. " K187 "  "0 ,1 "
bitfld.long 0 5. " K186 "  "0 ,1 "
bitfld.long 0 6. " K185 "  "0 ,1 "
bitfld.long 0 7. " K184 "  "0 ,1 "
bitfld.long 0 8. " K183 "  "0 ,1 "
bitfld.long 0 9. " K182 "  "0 ,1 "
bitfld.long 0 10. " K181 "  "0 ,1 "
bitfld.long 0 11. " K180 "  "0 ,1 "
bitfld.long 0 12. " K179 "  "0 ,1 "
bitfld.long 0 13. " K178 "  "0 ,1 "
bitfld.long 0 14. " K177 "  "0 ,1 "
bitfld.long 0 15. " K176 "  "0 ,1 "
bitfld.long 0 16. " K175 "  "0 ,1 "
bitfld.long 0 17. " K174 "  "0 ,1 "
bitfld.long 0 18. " K173 "  "0 ,1 "
bitfld.long 0 19. " K172 "  "0 ,1 "
bitfld.long 0 20. " K171 "  "0 ,1 "
bitfld.long 0 21. " K170 "  "0 ,1 "
bitfld.long 0 22. " K169 "  "0 ,1 "
bitfld.long 0 23. " K168 "  "0 ,1 "
bitfld.long 0 24. " K167 "  "0 ,1 "
bitfld.long 0 25. " K166 "  "0 ,1 "
bitfld.long 0 26. " K165 "  "0 ,1 "
bitfld.long 0 27. " K164 "  "0 ,1 "
bitfld.long 0 28. " K163 "  "0 ,1 "
bitfld.long 0 29. " K162 "  "0 ,1 "
bitfld.long 0 30. " K161 "  "0 ,1 "
bitfld.long 0 31. " K160 "  "0 ,1 "
tree.end

base sd:0xa03cb040
tree "1K4L"
group 0--3
line.long 0 "K4L"
bitfld.long 0 0. " K223 "  "0 ,1 "
bitfld.long 0 1. " K222 "  "0 ,1 "
bitfld.long 0 2. " K221 "  "0 ,1 "
bitfld.long 0 3. " K220 "  "0 ,1 "
bitfld.long 0 4. " K219 "  "0 ,1 "
bitfld.long 0 5. " K218 "  "0 ,1 "
bitfld.long 0 6. " K217 "  "0 ,1 "
bitfld.long 0 7. " K216 "  "0 ,1 "
bitfld.long 0 8. " K215 "  "0 ,1 "
bitfld.long 0 9. " K214 "  "0 ,1 "
bitfld.long 0 10. " K213 "  "0 ,1 "
bitfld.long 0 11. " K212 "  "0 ,1 "
bitfld.long 0 12. " K211 "  "0 ,1 "
bitfld.long 0 13. " K210 "  "0 ,1 "
bitfld.long 0 14. " K209 "  "0 ,1 "
bitfld.long 0 15. " K208 "  "0 ,1 "
bitfld.long 0 16. " K207 "  "0 ,1 "
bitfld.long 0 17. " K206 "  "0 ,1 "
bitfld.long 0 18. " K205 "  "0 ,1 "
bitfld.long 0 19. " K204 "  "0 ,1 "
bitfld.long 0 20. " K203 "  "0 ,1 "
bitfld.long 0 21. " K202 "  "0 ,1 "
bitfld.long 0 22. " K201 "  "0 ,1 "
bitfld.long 0 23. " K200 "  "0 ,1 "
bitfld.long 0 24. " K199 "  "0 ,1 "
bitfld.long 0 25. " K198 "  "0 ,1 "
bitfld.long 0 26. " K197 "  "0 ,1 "
bitfld.long 0 27. " K196 "  "0 ,1 "
bitfld.long 0 28. " K195 "  "0 ,1 "
bitfld.long 0 29. " K194 "  "0 ,1 "
bitfld.long 0 30. " K193 "  "0 ,1 "
bitfld.long 0 31. " K192 "  "0 ,1 "
tree.end

base sd:0xa03cb044
tree "1K4R"
group 0--3
line.long 0 "K4R"
bitfld.long 0 0. " K255 "  "0 ,1 "
bitfld.long 0 1. " K254 "  "0 ,1 "
bitfld.long 0 2. " K253 "  "0 ,1 "
bitfld.long 0 3. " K252 "  "0 ,1 "
bitfld.long 0 4. " K251 "  "0 ,1 "
bitfld.long 0 5. " K250 "  "0 ,1 "
bitfld.long 0 6. " K249 "  "0 ,1 "
bitfld.long 0 7. " K248 "  "0 ,1 "
bitfld.long 0 8. " K247 "  "0 ,1 "
bitfld.long 0 9. " K246 "  "0 ,1 "
bitfld.long 0 10. " K245 "  "0 ,1 "
bitfld.long 0 11. " K244 "  "0 ,1 "
bitfld.long 0 12. " K243 "  "0 ,1 "
bitfld.long 0 13. " K242 "  "0 ,1 "
bitfld.long 0 14. " K241 "  "0 ,1 "
bitfld.long 0 15. " K240 "  "0 ,1 "
bitfld.long 0 16. " K239 "  "0 ,1 "
bitfld.long 0 17. " K238 "  "0 ,1 "
bitfld.long 0 18. " K237 "  "0 ,1 "
bitfld.long 0 19. " K236 "  "0 ,1 "
bitfld.long 0 20. " K235 "  "0 ,1 "
bitfld.long 0 21. " K234 "  "0 ,1 "
bitfld.long 0 22. " K233 "  "0 ,1 "
bitfld.long 0 23. " K232 "  "0 ,1 "
bitfld.long 0 24. " K231 "  "0 ,1 "
bitfld.long 0 25. " K230 "  "0 ,1 "
bitfld.long 0 26. " K229 "  "0 ,1 "
bitfld.long 0 27. " K228 "  "0 ,1 "
bitfld.long 0 28. " K227 "  "0 ,1 "
bitfld.long 0 29. " K226 "  "0 ,1 "
bitfld.long 0 30. " K225 "  "0 ,1 "
bitfld.long 0 31. " K224 "  "0 ,1 "
tree.end

base sd:0xa03cb048
tree "1IV0L"
group 0--3
line.long 0 "IV0L"
bitfld.long 0 0. " IV32 "  "0 ,1 "
bitfld.long 0 1. " IV31 "  "0 ,1 "
bitfld.long 0 2. " IV30 "  "0 ,1 "
bitfld.long 0 3. " IV29 "  "0 ,1 "
bitfld.long 0 4. " IV28 "  "0 ,1 "
bitfld.long 0 5. " IV27 "  "0 ,1 "
bitfld.long 0 6. " IV26 "  "0 ,1 "
bitfld.long 0 7. " IV25 "  "0 ,1 "
bitfld.long 0 8. " IV24 "  "0 ,1 "
bitfld.long 0 9. " IV23 "  "0 ,1 "
bitfld.long 0 10. " IV22 "  "0 ,1 "
bitfld.long 0 11. " IV21 "  "0 ,1 "
bitfld.long 0 12. " IV20 "  "0 ,1 "
bitfld.long 0 13. " IV19 "  "0 ,1 "
bitfld.long 0 14. " IV18 "  "0 ,1 "
bitfld.long 0 15. " IV17 "  "0 ,1 "
bitfld.long 0 16. " IV16 "  "0 ,1 "
bitfld.long 0 17. " IV15 "  "0 ,1 "
bitfld.long 0 18. " IV14 "  "0 ,1 "
bitfld.long 0 19. " IV13 "  "0 ,1 "
bitfld.long 0 20. " IV12 "  "0 ,1 "
bitfld.long 0 21. " IV11 "  "0 ,1 "
bitfld.long 0 22. " IV10 "  "0 ,1 "
bitfld.long 0 23. " IV9 "  "0 ,1 "
bitfld.long 0 24. " IV8 "  "0 ,1 "
bitfld.long 0 25. " IV7 "  "0 ,1 "
bitfld.long 0 26. " IV6 "  "0 ,1 "
bitfld.long 0 27. " IV5 "  "0 ,1 "
bitfld.long 0 28. " IV4 "  "0 ,1 "
bitfld.long 0 29. " IV3 "  "0 ,1 "
bitfld.long 0 30. " IV2 "  "0 ,1 "
bitfld.long 0 31. " IV1 "  "0 ,1 "
tree.end

base sd:0xa03cb04c
tree "1IV0R"
group 0--3
line.long 0 "IV0R"
bitfld.long 0 0. " IV64 "  "0 ,1 "
bitfld.long 0 1. " IV63 "  "0 ,1 "
bitfld.long 0 2. " IV62 "  "0 ,1 "
bitfld.long 0 3. " IV61 "  "0 ,1 "
bitfld.long 0 4. " IV60 "  "0 ,1 "
bitfld.long 0 5. " IV59 "  "0 ,1 "
bitfld.long 0 6. " IV58 "  "0 ,1 "
bitfld.long 0 7. " IV57 "  "0 ,1 "
bitfld.long 0 8. " IV56 "  "0 ,1 "
bitfld.long 0 9. " IV55 "  "0 ,1 "
bitfld.long 0 10. " IV54 "  "0 ,1 "
bitfld.long 0 11. " IV53 "  "0 ,1 "
bitfld.long 0 12. " IV52 "  "0 ,1 "
bitfld.long 0 13. " IV51 "  "0 ,1 "
bitfld.long 0 14. " IV50 "  "0 ,1 "
bitfld.long 0 15. " IV49 "  "0 ,1 "
bitfld.long 0 16. " IV48 "  "0 ,1 "
bitfld.long 0 17. " IV47 "  "0 ,1 "
bitfld.long 0 18. " IV46 "  "0 ,1 "
bitfld.long 0 19. " IV45 "  "0 ,1 "
bitfld.long 0 20. " IV44 "  "0 ,1 "
bitfld.long 0 21. " IV43 "  "0 ,1 "
bitfld.long 0 22. " IV42 "  "0 ,1 "
bitfld.long 0 23. " IV41 "  "0 ,1 "
bitfld.long 0 24. " IV40 "  "0 ,1 "
bitfld.long 0 25. " IV39 "  "0 ,1 "
bitfld.long 0 26. " IV38 "  "0 ,1 "
bitfld.long 0 27. " IV37 "  "0 ,1 "
bitfld.long 0 28. " IV36 "  "0 ,1 "
bitfld.long 0 29. " IV35 "  "0 ,1 "
bitfld.long 0 30. " IV34 "  "0 ,1 "
bitfld.long 0 31. " IV33 "  "0 ,1 "
tree.end

base sd:0xa03cb050
tree "1IV1L"
group 0--3
line.long 0 "IV1L"
bitfld.long 0 0. " IV96 "  "0 ,1 "
bitfld.long 0 1. " IV95 "  "0 ,1 "
bitfld.long 0 2. " IV94 "  "0 ,1 "
bitfld.long 0 3. " IV93 "  "0 ,1 "
bitfld.long 0 4. " IV92 "  "0 ,1 "
bitfld.long 0 5. " IV91 "  "0 ,1 "
bitfld.long 0 6. " IV90 "  "0 ,1 "
bitfld.long 0 7. " IV89 "  "0 ,1 "
bitfld.long 0 8. " IV88 "  "0 ,1 "
bitfld.long 0 9. " IV87 "  "0 ,1 "
bitfld.long 0 10. " IV86 "  "0 ,1 "
bitfld.long 0 11. " IV85 "  "0 ,1 "
bitfld.long 0 12. " IV84 "  "0 ,1 "
bitfld.long 0 13. " IV83 "  "0 ,1 "
bitfld.long 0 14. " IV82 "  "0 ,1 "
bitfld.long 0 15. " IV81 "  "0 ,1 "
bitfld.long 0 16. " IV80 "  "0 ,1 "
bitfld.long 0 17. " IV79 "  "0 ,1 "
bitfld.long 0 18. " IV78 "  "0 ,1 "
bitfld.long 0 19. " IV77 "  "0 ,1 "
bitfld.long 0 20. " IV76 "  "0 ,1 "
bitfld.long 0 21. " IV75 "  "0 ,1 "
bitfld.long 0 22. " IV74 "  "0 ,1 "
bitfld.long 0 23. " IV73 "  "0 ,1 "
bitfld.long 0 24. " IV72 "  "0 ,1 "
bitfld.long 0 25. " IV71 "  "0 ,1 "
bitfld.long 0 26. " IV70 "  "0 ,1 "
bitfld.long 0 27. " IV69 "  "0 ,1 "
bitfld.long 0 28. " IV68 "  "0 ,1 "
bitfld.long 0 29. " IV67 "  "0 ,1 "
bitfld.long 0 30. " IV66 "  "0 ,1 "
bitfld.long 0 31. " IV65 "  "0 ,1 "
tree.end

base sd:0xa03cb054
tree "1IV1R"
group 0--3
line.long 0 "IV1R"
bitfld.long 0 0. " IV128 "  "0 ,1 "
bitfld.long 0 1. " IV127 "  "0 ,1 "
bitfld.long 0 2. " IV126 "  "0 ,1 "
bitfld.long 0 3. " IV125 "  "0 ,1 "
bitfld.long 0 4. " IV124 "  "0 ,1 "
bitfld.long 0 5. " IV123 "  "0 ,1 "
bitfld.long 0 6. " IV122 "  "0 ,1 "
bitfld.long 0 7. " IV121 "  "0 ,1 "
bitfld.long 0 8. " IV120 "  "0 ,1 "
bitfld.long 0 9. " IV119 "  "0 ,1 "
bitfld.long 0 10. " IV118 "  "0 ,1 "
bitfld.long 0 11. " IV117 "  "0 ,1 "
bitfld.long 0 12. " IV116 "  "0 ,1 "
bitfld.long 0 13. " IV115 "  "0 ,1 "
bitfld.long 0 14. " IV114 "  "0 ,1 "
bitfld.long 0 15. " IV113 "  "0 ,1 "
bitfld.long 0 16. " IV112 "  "0 ,1 "
bitfld.long 0 17. " IV111 "  "0 ,1 "
bitfld.long 0 18. " IV110 "  "0 ,1 "
bitfld.long 0 19. " IV109 "  "0 ,1 "
bitfld.long 0 20. " IV108 "  "0 ,1 "
bitfld.long 0 21. " IV107 "  "0 ,1 "
bitfld.long 0 22. " IV106 "  "0 ,1 "
bitfld.long 0 23. " IV105 "  "0 ,1 "
bitfld.long 0 24. " IV104 "  "0 ,1 "
bitfld.long 0 25. " IV103 "  "0 ,1 "
bitfld.long 0 26. " IV102 "  "0 ,1 "
bitfld.long 0 27. " IV101 "  "0 ,1 "
bitfld.long 0 28. " IV100 "  "0 ,1 "
bitfld.long 0 29. " IV99 "  "0 ,1 "
bitfld.long 0 30. " IV98 "  "0 ,1 "
bitfld.long 0 31. " IV97 "  "0 ,1 "
tree.end

base sd:0xa03cb080
tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0xa03cb084
tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMAIUTC "  "0 ,1 "
bitfld.long 0 1. " DMAOUTC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
tree.end

base sd:0xa03cb088
tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMAINBREQ "  "0 ,1 "
bitfld.long 0 1. " DMAOUTBREQ "  "0 ,1 "
bitfld.long 0 2. " DMAOUTSREQ "  "0 ,1 "
bitfld.long 0 3. " ININTR "  "0 ,1 "
bitfld.long 0 4. " OUTINTR "  "0 ,1 "
tree.end

base sd:0xa03cbfe0
tree "1CRYPPeriphID0"
rgroup 0--3
line.long 0 "CRYPPeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0xa03cbfe4
tree "1CRYPPeriphID1"
rgroup 0--3
line.long 0 "CRYPPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0xa03cbfe8
tree "1CRYPPeriphID2"
rgroup 0--3
line.long 0 "CRYPPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0xa03cbfec
tree "1CRYPPeriphID3"
rgroup 0--3
line.long 0 "CRYPPeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0xa03cbff0
tree "1CRYPPCellID0"
rgroup 0--3
line.long 0 "CRYPPCellID0"
bitfld.long 0 0.--7. " CRYPPCellID0 "  " "
tree.end

base sd:0xa03cbff4
tree "1CRYPPCellID1"
rgroup 0--3
line.long 0 "CRYPPCellID1"
bitfld.long 0 0.--7. " CRYPPCellID1 "  " "
tree.end

base sd:0xa03cbff8
tree "1CRYPPCellID2"
rgroup 0--3
line.long 0 "CRYPPCellID2"
bitfld.long 0 0.--7. " CRYPPCellID2 "  " "
tree.end

base sd:0xa03cbffc
tree "1CRYPPCellID3"
rgroup 0--3
line.long 0 "CRYPPCellID3"
bitfld.long 0 0.--7. " CRYPPCellID3 "  " "
tree.end

;tree.end

tree.end

;==============================================================
tree "CTI"
;==============================================================
base edap:0x80180000
tree "CTICONTROL"
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
tree.end

base edap:0x80180010
tree "CTIINTACK"
wgroup 0--3
line.long 0 "CTIINTACK"
bitfld.long 0 0.--7. " INTACK "  " "
tree.end

base edap:0x80180014
tree "CTIAPPSET"
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  " "
tree.end

base edap:0x80180018
tree "CTIAPPCLEAR"
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  " "
tree.end

base edap:0x8018001c
tree "CTIAPPPULSE"
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  " "
tree.end

base edap:0x80180020
tree "CTIINEN0"
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base edap:0x80180024
tree "CTIINEN1"
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base edap:0x80180028
tree "CTIINEN2"
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base edap:0x8018002c
tree "CTIINEN3"
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base edap:0x80180030
tree "CTIINEN4"
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base edap:0x80180034
tree "CTIINEN5"
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base edap:0x80180038
tree "CTIINEN6"
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base edap:0x8018003c
tree "CTIINEN7"
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base edap:0x801800a0
tree "CTIOUTEN0"
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base edap:0x801800a4
tree "CTIOUTEN1"
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base edap:0x801800a8
tree "CTIOUTEN2"
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base edap:0x801800ac
tree "CTIOUTEN3"
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base edap:0x801800b0
tree "CTIOUTEN4"
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base edap:0x801800b4
tree "CTIOUTEN5"
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base edap:0x801800b8
tree "CTIOUTEN6"
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base edap:0x801800bc
tree "CTIOUTEN7"
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base edap:0x80180130
tree "CTITRIGINSTATUS"
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
bitfld.long 0 0.--7. " TRIGINSTATUS "  " "
tree.end

base edap:0x80180134
tree "CTITRIGOUTSTATUS"
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
bitfld.long 0 0.--7. " TRIGOUTSTATUS "  " "
tree.end

base edap:0x80180138
tree "CTICHINSTATUS"
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  " "
tree.end

base edap:0x8018013c
tree "CTICHOUTSTATUS"
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  " "
tree.end

base edap:0x80180140
tree "CTIGATE"
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
tree.end

base edap:0x80180144
tree "ASICCTL"
group 0--3
line.long 0 "ASICCTL"
bitfld.long 0 0.--7. " ASICCTL "  " "
tree.end

base edap:0x80180edc
tree "ITCHINACK"
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  " "
tree.end

base edap:0x80180ee0
tree "ITTRIGINACK"
wgroup 0--3
line.long 0 "ITTRIGINACK"
bitfld.long 0 0.--7. " CTTRIGINACK "  " "
tree.end

base edap:0x80180ee4
tree "ITCHOUT"
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  " "
tree.end

base edap:0x80180ee8
tree "ITTRFLIN"
wgroup 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0.--7. " CTTRIGOUT "  " "
tree.end

base edap:0x80180eec
tree "ITCHOUTACK"
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  " "
tree.end

base edap:0x80180ef0
tree "ITTRIGOUTACK"
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
bitfld.long 0 0.--7. " CTTRIGOUTACK "  " "
tree.end

base edap:0x80180ef4
tree "ITCHIN"
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  " "
tree.end

base edap:0x80180ef8
tree "ITRIGIN"
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
tree.end

base edap:0x80180f00
tree "ITCTRL"
group 0--3
line.long 0 "ITCTRL"
bitfld.long 0 0. " ITCTRL "  "0 ,1 "
tree.end

base edap:0x80180fa0
tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  " "
tree.end

base edap:0x80180fa4
tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  " "
tree.end

base edap:0x80180fb0
tree "LAR"
wgroup 0--3
line.long 0 "LAR"
bitfld.long 0 0.--31. " LAR "  " "
tree.end

base edap:0x80180fb4
tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  " "
tree.end

base edap:0x80180fb8
tree "ASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  " "
tree.end

base edap:0x80180fc8
tree "DID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
tree.end

base edap:0x80180fcc
tree "DTIR"
rgroup 0--3
line.long 0 "DTIR"
bitfld.long 0 0.--7. " DTIR "  " "
tree.end

base edap:0x80180fd0
tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0.--7. " PERIPHERAL_ID4 "  " "
tree.end

base edap:0x80180fd4
tree "PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
tree.end

base edap:0x80180fd8
tree "PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
tree.end

base edap:0x80180fdc
tree "PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
tree.end

base edap:0x80180fe0
tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0.--7. " PERIPHERAL_ID0 "  " "
tree.end

base edap:0x80180fe4
tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0.--7. " PERIPHERAL_ID1 "  " "
tree.end

base edap:0x80180fe8
tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0.--7. " PERIPHERAL_ID2 "  " "
tree.end

base edap:0x80180fec
tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0.--7. " PERIPHERAL_ID3 "  " "
tree.end

base edap:0x80180ff0
tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
tree.end

base edap:0x80180ff4
tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0.--7. " COMPONENT_ID1 "  " "
tree.end

base edap:0x80180ff8
tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0.--7. " COMPONENT_ID2 "  " "
tree.end

base edap:0x80180ffc
tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0.--7. " COMPONENT_ID3 "  " "
tree.end

tree.end

;==============================================================
tree "DBAHN"
;==============================================================
base sd:0x80156000
tree "DENALI_CTL_00"
group 0--3
line.long 0 "DENALI_CTL_00"
bitfld.long 0 0. " ACTIVE_AGING "  "0 ,1 "
bitfld.long 0 8. " ADDR_CMP_EN "  "0 ,1 "
bitfld.long 0 16. " AP "  "0 ,1 "
bitfld.long 0 24. " AREFRESH "  "0 ,1 "
tree.end

base sd:0x80156004
tree "DENALI_CTL_01"
group 0--3
line.long 0 "DENALI_CTL_01"
bitfld.long 0 0. " AUTO_REFRESH_MODE "  "0 ,1 "
bitfld.long 0 8. " AXI0_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 16. " AXI1_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 24. " AXI2_BDW_OVFLOW "  "0 ,1 "
tree.end

base sd:0x80156008
tree "DENALI_CTL_02"
group 0--3
line.long 0 "DENALI_CTL_02"
bitfld.long 0 0. " AXI3_BDW_OVFLOW "  "0 ,1 "
bitfld.long 0 8. " BANK_SPLIT_EN "  "0 ,1 "
bitfld.long 0 16. " CONCURRENTAP "  "0 ,1 "
bitfld.long 0 24. " DLLLOCKREG "  "0 ,1 "
tree.end

base sd:0x8015600c
tree "DENALI_CTL_03"
group 0--3
line.long 0 "DENALI_CTL_03"
bitfld.long 0 0. " DLL_BYPASS_MODE "  "0 ,1 "
bitfld.long 0 8. " DRIVE_DQ_DQ "  "0 ,1 "
bitfld.long 0 16. " ENABLE_QUICK_SREFRESH "  "0 ,1 "
tree.end

base sd:0x80156010
tree "DENALI_CTL_04"
group 0--3
line.long 0 "DENALI_CTL_04"
bitfld.long 0 0. " FAST_WRITE "  "0 ,1 "
bitfld.long 0 8. " INTRPTAPBURST "  "0 ,1 "
bitfld.long 0 16. " INTRPTREADA "  "0 ,1 "
bitfld.long 0 24. " INTRPTWRITEA "  "0 ,1 "
tree.end

base sd:0x80156014
tree "DENALI_CTL_05"
group 0--3
line.long 0 "DENALI_CTL_05"
bitfld.long 0 0. " NO_CMD_INIT "  "0 ,1 "
bitfld.long 0 8. " PLACEMENT_EN "  "0 ,1 "
bitfld.long 0 16. " POWER_DOWN "  "0 ,1 "
bitfld.long 0 24. " PRIORITY_EN "  "0 ,1 "
tree.end

base sd:0x80156018
tree "DENALI_CTL_06"
group 0--3
line.long 0 "DENALI_CTL_06"
bitfld.long 0 0. " PWRUP_SREFRESH_EXIT "  "0 ,1 "
bitfld.long 0 8. " RD2RD_TURN "  "0 ,1 "
bitfld.long 0 16. " REDUC "  "0 ,1 "
bitfld.long 0 24. " REG_DIMM_ENABLE "  "0 ,1 "
tree.end

base sd:0x8015601c
tree "DENALI_CTL_07"
group 0--3
line.long 0 "DENALI_CTL_07"
bitfld.long 0 0. " RW_SAME_EN "  "0 ,1 "
bitfld.long 0 8. " SREFRESH "  "0 ,1 "
bitfld.long 0 16. " START "  "0 ,1 "
bitfld.long 0 24. " SWAP_EN "  "0 ,1 "
tree.end

base sd:0x80156020
tree "DENALI_CTL_08"
group 0--3
line.long 0 "DENALI_CTL_08"
bitfld.long 0 0. " TRAS_LOCKOUT "  "0 ,1 "
bitfld.long 0 8. " TREF_ENABLE "  "0 ,1 "
bitfld.long 0 16. " WRITEINTERP "  "0 ,1 "
bitfld.long 0 24. " WRITE_MODEREG "  "0 ,1 "
tree.end

base sd:0x80156024
tree "DENALI_CTL_09"
group 0--3
line.long 0 "DENALI_CTL_09"
bitfld.long 0 0. " WRLAT "  "0 ,1 "
bitfld.long 0 8.--9. " AXI0_FIFO_TYPE_REG "  " "
bitfld.long 0 16.--17. " AXI0_R_PRIORITY "  " "
bitfld.long 0 24.--25. " AXI0_W_PRIORITY "  " "
tree.end

base sd:0x80156028
tree "DENALI_CTL_10"
group 0--3
line.long 0 "DENALI_CTL_10"
bitfld.long 0 0.--1. " AXI1_FIFO_TYPE_REG "  " "
bitfld.long 0 8.--9. " AXI1_R_PRIORITY "  " "
bitfld.long 0 16.--17. " AXI1_W_PRIORITY "  " "
bitfld.long 0 24.--25. " AXI2_FIFO_TYPE_REG "  " "
tree.end

base sd:0x8015602c
tree "DENALI_CTL_11"
group 0--3
line.long 0 "DENALI_CTL_11"
bitfld.long 0 0.--1. " AXI2_R_PRIORITY "  " "
bitfld.long 0 8.--9. " AXI2_W_PRIORITY "  " "
bitfld.long 0 16.--17. " AXI3_FIFO_TYPE_REG "  " "
bitfld.long 0 24.--25. " AXI3_R_PRIORITY "  " "
tree.end

base sd:0x80156030
tree "DENALI_CTL_12"
group 0--3
line.long 0 "DENALI_CTL_12"
bitfld.long 0 0.--1. " AXI3_W_PRIORITY "  " "
bitfld.long 0 8.--9. " CS_MAP "  " "
bitfld.long 0 16.--17. " DRAM_CLK_DISABLE "  " "
bitfld.long 0 24.--25. " LOWPOWER_REFRESH_ENABLE "  " "
tree.end

base sd:0x80156034
tree "DENALI_CTL_13"
group 0--3
line.long 0 "DENALI_CTL_13"
bitfld.long 0 0.--1. " MAX_CS_REG "  " "
bitfld.long 0 8.--9. " TEMRS "  " "
bitfld.long 0 16.--17. " WRTPRCT_ENABLE "  " "
tree.end

base sd:0x80156038
tree "DENALI_CTL_14"
group 0--3
line.long 0 "DENALI_CTL_14"
bitfld.long 0 0.--2. " ARB_CMD_Q_THRESHOLD "  " "
bitfld.long 0 8.--10. " BSTLEN "  " "
bitfld.long 0 16.--18. " CASLAT "  " "
bitfld.long 0 24.--26. " CKE_DELAY "  " "
tree.end

base sd:0x8015603c
tree "DENALI_CTL_15"
group 0--3
line.long 0 "DENALI_CTL_15"
bitfld.long 0 8.--10. " PORT_DATA_ERROR_TYPE "  " "
bitfld.long 0 16.--18. " Q_FULLNESS "  " "
bitfld.long 0 24.--26. " TCKE "  " "
tree.end

base sd:0x80156040
tree "DENALI_CTL_16"
group 0--3
line.long 0 "DENALI_CTL_16"
bitfld.long 0 0.--2. " TDFI_CTRL_DELAY "  " "
bitfld.long 0 8.--10. " TDFI_DRAM_CLK_DISABLE "  " "
bitfld.long 0 16.--18. " TDFI_DRAM_CLK_ENABLE "  " "
bitfld.long 0 24.--26. " TRRD "  " "
tree.end

base sd:0x80156044
tree "DENALI_CTL_17"
group 0--3
line.long 0 "DENALI_CTL_17"
bitfld.long 0 0.--3. " TWTR "  " "
bitfld.long 0 8.--11. " AGE_COUNT "  " "
bitfld.long 0 24.--28. " CASLAT_LIN "  " "
tree.end

base sd:0x80156048
tree "DENALI_CTL_18"
group 0--3
line.long 0 "DENALI_CTL_18"
bitfld.long 0 0.--3. " CASLAT_LIN_GATE "  " "
bitfld.long 0 8.--11. " COMMAND_AGE_COUNT "  " "
bitfld.long 0 16.--19. " INITAREF "  " "
bitfld.long 0 24.--27. " MAX_COL_REG "  " "
tree.end

base sd:0x8015604c
tree "DENALI_CTL_19"
group 0--3
line.long 0 "DENALI_CTL_19"
bitfld.long 0 0.--3. " MAX_ROW_REG "  " "
bitfld.long 0 8.--11. " PORT_CMD_ERROR_TYPE "  " "
bitfld.long 0 16.--19. " TDAL "  " "
bitfld.long 0 24.--27. " TDFI_CTRLUPD_MIN "  " "
tree.end

base sd:0x80156050
tree "DENALI_CTL_20"
group 0--3
line.long 0 "DENALI_CTL_20"
bitfld.long 0 0.--3. " TDFI_PHY_RDLAT "  " "
bitfld.long 0 8.--11. " TDFI_PHY_WRLAT "  " "
bitfld.long 0 16.--19. " TDFI_PHY_WRLAT_BASE "  " "
bitfld.long 0 24.--27. " TDFI_RDDATA_EN "  " "
tree.end

base sd:0x80156054
tree "DENALI_CTL_21"
group 0--3
line.long 0 "DENALI_CTL_21"
bitfld.long 0 0.--4. " TDFI_RDDATA_EN_BASE "  " "
bitfld.long 0 8.--12. " TRP "  " "
bitfld.long 0 16.--20. " TWR_INT "  " "
bitfld.long 0 24.--30. " DLL_LOCK "  " "
tree.end

base sd:0x80156058
tree "DENALI_CTL_22"
group 0--3
line.long 0 "DENALI_CTL_22"
bitfld.long 0 0.--4. " LOWPOWER_AUTO_ENABLE "  " "
bitfld.long 0 8.--12. " LOWPOWER_CONTROL "  " "
bitfld.long 0 16.--21. " OUT_OF_RANGE_TYPE "  " "
bitfld.long 0 24.--28. " TMRD "  " "
tree.end

base sd:0x8015605c
tree "DENALI_CTL_23"
group 0--3
line.long 0 "DENALI_CTL_23"
bitfld.long 0 0.--5. " TRC "  " "
bitfld.long 0 8.--14. " AXI0_BDW "  " "
bitfld.long 0 16.--22. " AXI0_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI1_BDW "  " "
tree.end

base sd:0x80156060
tree "DENALI_CTL_24"
group 0--3
line.long 0 "DENALI_CTL_24"
bitfld.long 0 0.--6. " AXI1_CURRENT_BDW "  " "
bitfld.long 0 8.--14. " AXI2_BDW "  " "
bitfld.long 0 16.--22. " AXI2_CURRENT_BDW "  " "
bitfld.long 0 24.--30. " AXI3_BDW "  " "
tree.end

base sd:0x80156064
tree "DENALI_CTL_25"
rgroup 0--3
line.long 0 "DENALI_CTL_25"
bitfld.long 0 0.--6. " AXI3_CURRENT_BDW "  " "
bitfld.long 0 16.--22. " OUT_OF_RANGE_LENGTH "  " "
bitfld.long 0 24.--30. " WRTPRCT_ERROR_LENGTH "  " "
tree.end

base sd:0x80156068
tree "DENALI_CTL_26"
group 0--3
line.long 0 "DENALI_CTL_26"
bitfld.long 0 16.--23. " TRAS_MIN "  " "
bitfld.long 0 24.--31. " TRCD_INT "  " "
tree.end

base sd:0x8015606c
tree "DENALI_CTL_27"
group 0--3
line.long 0 "DENALI_CTL_27"
bitfld.long 0 0.--7. " TRFC "  " "
bitfld.long 0 8.--17. " OUT_OF_RANGE_SOURCE_ID "  " "
tree.end

base sd:0x80156070
tree "DENALI_CTL_28"
rgroup 0--3
line.long 0 "DENALI_CTL_28"
bitfld.long 0 0.--11. " PORT_CMD_ERROR_ID "  " "
bitfld.long 0 16.--27. " PORT_DATA_ERROR_ID "  " "
tree.end

base sd:0x80156074
tree "DENALI_CTL_29"
rgroup 0--3
line.long 0 "DENALI_CTL_29"
bitfld.long 0 0.--15. " TDFI_CTRLUPD_MAX "  " "
bitfld.long 0 16.--31. " TDFI_PHYUPD_RESP "  " "
tree.end

base sd:0x80156078
tree "DENALI_CTL_30"
group 0--3
line.long 0 "DENALI_CTL_30"
bitfld.long 0 0.--15. " TDFI_PHYUPD_TYPE0 "  " "
bitfld.long 0 16.--31. " TREF "  " "
tree.end

base sd:0x8015607c
tree "DENALI_CTL_31"
rgroup 0--3
line.long 0 "DENALI_CTL_31"
tree.end

base sd:0x80156080
tree "DENALI_CTL_32"
group 0--3
line.long 0 "DENALI_CTL_32"
bitfld.long 0 16.--31. " AXI0_EN_SIZE_LT_WIDTH_INSTR "  " "
tree.end

base sd:0x80156084
tree "DENALI_CTL_33"
group 0--3
line.long 0 "DENALI_CTL_33"
bitfld.long 0 0.--15. " AXI1_EN_SIZE_LT_WIDTH_INSTR "  " "
bitfld.long 0 16.--31. " AXI2_EN_SIZE_LT_WIDTH_INSTR "  " "
tree.end

base sd:0x80156088
tree "DENALI_CTL_34"
group 0--3
line.long 0 "DENALI_CTL_34"
bitfld.long 0 0.--15. " AXI3_EN_SIZE_LT_WIDTH_INSTR "  " "
bitfld.long 0 16.--31. " LOWPOWER_EXTERNAL_CNT "  " "
tree.end

base sd:0x8015608c
tree "DENALI_CTL_35"
group 0--3
line.long 0 "DENALI_CTL_35"
bitfld.long 0 0.--15. " LOWPOWER_INTERNAL_CNT "  " "
bitfld.long 0 16.--31. " LOWPOWER_POWER_DOWN_CNT "  " "
tree.end

base sd:0x80156090
tree "DENALI_CTL_36"
group 0--3
line.long 0 "DENALI_CTL_36"
bitfld.long 0 0.--15. " LOWPOWER_REFRESH_HOLD "  " "
bitfld.long 0 16.--31. " LOWPOWER_SELF_REFRESH_CNT "  " "
tree.end

base sd:0x80156094
tree "DENALI_CTL_37"
group 0--3
line.long 0 "DENALI_CTL_37"
bitfld.long 0 0.--15. " TDLL "  " "
bitfld.long 0 16.--31. " TPDEX "  " "
tree.end

base sd:0x80156098
tree "DENALI_CTL_38"
group 0--3
line.long 0 "DENALI_CTL_38"
bitfld.long 0 0.--15. " TRAS_MAX "  " "
bitfld.long 0 16.--31. " TXSNR "  " "
tree.end

base sd:0x8015609c
tree "DENALI_CTL_39"
group 0--3
line.long 0 "DENALI_CTL_39"
bitfld.long 0 0.--15. " TXSR "  " "
bitfld.long 0 16.--31. " VERSION "  " "
tree.end

base sd:0x801560a0
tree "DENALI_CTL_40"
group 0--3
line.long 0 "DENALI_CTL_40"
bitfld.long 0 0.--23. " TINIT "  " "
tree.end

base sd:0x801560a4
tree "DENALI_CTL_41"
rgroup 0--3
line.long 0 "DENALI_CTL_41"
bitfld.long 0 0.--31. " OUT_OF_RANGE_ADDR "  " "
tree.end

base sd:0x801560a8
tree "DENALI_CTL_42"
rgroup 0--3
line.long 0 "DENALI_CTL_42"
bitfld.long 0 0.--31. " PORT_CMD_ERROR_ADDR "  " "
tree.end

base sd:0x801560ac
tree "DENALI_CTL_43"
rgroup 0--3
line.long 0 "DENALI_CTL_43"
bitfld.long 0 0.--31. " WRTPRCT_ERROR_ADDRESS "  " "
tree.end

base sd:0x801560b0
tree "DENALI_CTL_44"
group 0--3
line.long 0 "DENALI_CTL_44"
bitfld.long 0 0.--31. " WRTPRCT_LOWER_ADDRESS_0 "  " "
tree.end

base sd:0x801560b4
tree "DENALI_CTL_45"
group 0--3
line.long 0 "DENALI_CTL_45"
bitfld.long 0 0.--31. " WRTPRCT_LOWER_ADDRESS_1 "  " "
tree.end

base sd:0x801560b8
tree "DENALI_CTL_46"
group 0--3
line.long 0 "DENALI_CTL_46"
bitfld.long 0 0.--31. " WRTPRCT_UPPER_ADDRESS_0 "  " "
tree.end

base sd:0x801560bc
tree "DENALI_CTL_47"
group 0--3
line.long 0 "DENALI_CTL_47"
bitfld.long 0 0.--31. " WRTPRCT_UPPER_ADDRESS_1 "  " "
tree.end

base sd:0x801560ec
tree "DENALI_CTL_59"
group 0--3
line.long 0 "DENALI_CTL_59"
bitfld.long 0 0.--31. " PHY_ADD "  " "
tree.end

base sd:0x801560f0
tree "DENALI_CTL_60"
group 0--3
line.long 0 "DENALI_CTL_60"
bitfld.long 0 0.--31. " PHY_CFG "  " "
tree.end

base sd:0x801560f4
tree "DENALI_CTL_61"
rgroup 0--3
line.long 0 "DENALI_CTL_61"
bitfld.long 0 0.--31. " PHY_STS "  " "
tree.end

base sd:0x801560f8
tree "DENALI_CTL_62"
rgroup 0--3
line.long 0 "DENALI_CTL_62"
tree.end

base sd:0x801560fc
tree "DENALI_CTL_63"
group 0--3
line.long 0 "DENALI_CTL_63"
bitfld.long 0 0.--2. " WRLAT_ADJ "  " "
bitfld.long 0 8.--10. " W2R_DIFFCS_DLY "  " "
bitfld.long 0 16.--18. " W2R_SAMECS_DLY "  " "
bitfld.long 0 24.--27. " DRAM_CLASS "  " "
tree.end

base sd:0x80156100
tree "DENALI_CTL_64"
group 0--3
line.long 0 "DENALI_CTL_64"
bitfld.long 0 0.--4. " RDLAT_ADJ "  " "
bitfld.long 0 8.--15. " DLL_RST_ADJ_DLY "  " "
bitfld.long 0 16.--23. " TMOD "  " "
tree.end

base sd:0x80156104
tree "DENALI_CTL_65"
group 0--3
line.long 0 "DENALI_CTL_65"
tree.end

base sd:0x80156108
tree "DENALI_CTL_66"
group 0--3
line.long 0 "DENALI_CTL_66"
tree.end

base sd:0x8015610c
tree "DENALI_CTL_67"
group 0--3
line.long 0 "DENALI_CTL_67"
bitfld.long 0 0.--15. " DLL_RST_DELAY "  " "
tree.end

base sd:0x80156120
tree "DENALI_CTL_72"
group 0--3
line.long 0 "DENALI_CTL_72"
bitfld.long 0 0.--31. " USER_DEF_REG_2 "  " "
tree.end

base sd:0x80156124
tree "DENALI_CTL_73"
group 0--3
line.long 0 "DENALI_CTL_73"
bitfld.long 0 26. " DEBUG_DFI_TRIGGER_IS_WRITE "  "0 ,1 "
bitfld.long 0 27. " DENALI_JTAG_CONTROL_ENABLE "  "0 ,1 "
bitfld.long 0 28. " DENALI_JTAG_TRSTN "  "0 ,1 "
bitfld.long 0 29. " DENALI_JTAG_TCK "  "0 ,1 "
bitfld.long 0 30. " DENALI_JTAG_TMS "  "0 ,1 "
bitfld.long 0 31. " DENALI_JTAG_TDI "  "0 ,1 "
tree.end

base sd:0x80156128
tree "DENALI_CTL_74"
group 0--3
line.long 0 "DENALI_CTL_74"
bitfld.long 0 0.--31. " USER_DEF_REG_RO_2 "  " "
tree.end

base sd:0x8015612c
tree "DENALI_CTL_75"
rgroup 0--3
line.long 0 "DENALI_CTL_75"
bitfld.long 0 30. " DFI_INIT_COMPLETE "  "0 ,1 "
bitfld.long 0 31. " DENALI_JTAG_TDO "  "0 ,1 "
tree.end

base sd:0x80156130
tree "DENALI_CTL_76"
rgroup 0--3
line.long 0 "DENALI_CTL_76"
bitfld.long 0 8. " DQS_N_EN "  "0 ,1 "
bitfld.long 0 24. " LPDDR2_S4 "  "0 ,1 "
tree.end

base sd:0x80156134
tree "DENALI_CTL_77"
group 0--3
line.long 0 "DENALI_CTL_77"
bitfld.long 0 0.--1. " TDQSCK_MAX "  " "
bitfld.long 0 8.--9. " TDQSCK_MIN "  " "
bitfld.long 0 24.--26. " R2R_DIFFCS_DLY "  " "
tree.end

base sd:0x80156138
tree "DENALI_CTL_78"
group 0--3
line.long 0 "DENALI_CTL_78"
bitfld.long 0 0.--1. " TDQSCK_MAX "  " "
bitfld.long 0 8.--9. " TDQSCK_MIN "  " "
bitfld.long 0 24.--28. " TCCD "  " "
tree.end

base sd:0x8015613c
tree "DENALI_CTL_79"
group 0--3
line.long 0 "DENALI_CTL_79"
bitfld.long 0 0.--2. " TRTP "  " "
bitfld.long 0 8.--10. " W2W_DIFFCS_DLY "  " "
bitfld.long 0 16.--18. " W2W_SAMECS_DLY "  " "
bitfld.long 0 24.--28. " TMRR "  " "
tree.end

base sd:0x80156140
tree "DENALI_CTL_80"
group 0--3
line.long 0 "DENALI_CTL_80"
bitfld.long 0 8.--11. " ZQ_ON_SREF_EXIT "  " "
bitfld.long 0 16.--19. " ZQ_REQ "  " "
bitfld.long 0 24.--29. " TFAW "  " "
tree.end

base sd:0x80156144
tree "DENALI_CTL_81"
group 0--3
line.long 0 "DENALI_CTL_81"
bitfld.long 0 0.--7. " REFRESH_PER_ZQ "  " "
bitfld.long 0 8.--17. " INT_MASK "  " "
tree.end

base sd:0x80156148
tree "DENALI_CTL_82"
group 0--3
line.long 0 "DENALI_CTL_82"
bitfld.long 0 0.--9. " INT_STATUS "  " "
bitfld.long 0 16.--27. " ZQCL "  " "
tree.end

base sd:0x8015614c
tree "DENALI_CTL_83"
group 0--3
line.long 0 "DENALI_CTL_83"
bitfld.long 0 0.--11. " ZQCS "  " "
bitfld.long 0 16.--27. " ZQINIT "  " "
tree.end

base sd:0x80156150
tree "DENALI_CTL_84"
group 0--3
line.long 0 "DENALI_CTL_84"
bitfld.long 0 0.--11. " ZQRESET "  " "
bitfld.long 0 16.--30. " MR0_DATA_0 "  " "
tree.end

base sd:0x80156154
tree "DENALI_CTL_85"
group 0--3
line.long 0 "DENALI_CTL_85"
bitfld.long 0 0.--14. " MR0_DATA_1 "  " "
bitfld.long 0 16.--30. " MR16_DATA_0 "  " "
tree.end

base sd:0x80156158
tree "DENALI_CTL_86"
group 0--3
line.long 0 "DENALI_CTL_86"
bitfld.long 0 0.--14. " MR16_DATA_1 "  " "
bitfld.long 0 16.--30. " MR17_DATA_0 "  " "
tree.end

base sd:0x8015615c
tree "DENALI_CTL_87"
group 0--3
line.long 0 "DENALI_CTL_87"
bitfld.long 0 0.--14. " MR17_DATA_1 "  " "
bitfld.long 0 16.--30. " MR1_DATA_0 "  " "
tree.end

base sd:0x80156160
tree "DENALI_CTL_88"
group 0--3
line.long 0 "DENALI_CTL_88"
bitfld.long 0 0.--14. " MR1_DATA_1 "  " "
bitfld.long 0 16.--30. " MR2_DATA_0 "  " "
tree.end

base sd:0x80156164
tree "DENALI_CTL_89"
group 0--3
line.long 0 "DENALI_CTL_89"
bitfld.long 0 0.--14. " MR2_DATA_1 "  " "
bitfld.long 0 16.--30. " MR3_DATA_0 "  " "
tree.end

base sd:0x80156168
tree "DENALI_CTL_90"
group 0--3
line.long 0 "DENALI_CTL_90"
bitfld.long 0 0.--14. " MR3_DATA_1 "  " "
bitfld.long 0 16.--31. " PERIPHERAL_MRR_DATA "  " "
tree.end

base sd:0x8015616c
tree "DENALI_CTL_91"
group 0--3
line.long 0 "DENALI_CTL_91"
bitfld.long 0 0.--16. " READ_MODEREG "  " "
tree.end

base sd:0x80156170
tree "DENALI_CTL_92"
group 0--3
line.long 0 "DENALI_CTL_92"
bitfld.long 0 0.--23. " TINIT3 "  " "
tree.end

base sd:0x80156174
tree "DENALI_CTL_93"
group 0--3
line.long 0 "DENALI_CTL_93"
bitfld.long 0 0.--23. " TINIT4 "  " "
tree.end

base sd:0x80156178
tree "DENALI_CTL_94"
group 0--3
line.long 0 "DENALI_CTL_94"
bitfld.long 0 0.--23. " TINIT5 "  " "
bitfld.long 0 24. " CONCURRENTAP_WR_ONLY "  "0 ,1 "
tree.end

base sd:0x8015617c
tree "DENALI_CTL_95"
group 0--3
line.long 0 "DENALI_CTL_95"
bitfld.long 0 0. " CONFIG_ERROR "  "0 ,1 "
bitfld.long 0 8. " EIGHT_BANK_MODE_0 "  "0 ,1 "
bitfld.long 0 16. " EIGHT_BANK_MODE_1 "  "0 ,1 "
bitfld.long 0 24. " RESYNC_DLL "  "0 ,1 "
tree.end

base sd:0x80156180
tree "DENALI_CTL_96"
group 0--3
line.long 0 "DENALI_CTL_96"
bitfld.long 0 0. " RESYNC_DLL_PER_AREF_EN "  "0 ,1 "
bitfld.long 0 8. " ZQCS_ROTATE "  "0 ,1 "
bitfld.long 0 16. " ZQ_IN_PROGRESS "  "0 ,1 "
bitfld.long 0 24.--26. " ADDR_PINS_0 "  " "
tree.end

base sd:0x80156184
tree "DENALI_CTL_97"
group 0--3
line.long 0 "DENALI_CTL_97"
bitfld.long 0 0.--2. " ADDR_PINS_1 "  " "
bitfld.long 0 8.--10. " COLUMN_SIZE_0 "  " "
bitfld.long 0 16.--18. " COLUMN_SIZE_1 "  " "
bitfld.long 0 24.--27. " APREBIT_0 "  " "
tree.end

base sd:0x80156188
tree "DENALI_CTL_98"
group 0--3
line.long 0 "DENALI_CTL_98"
bitfld.long 0 0.--3. " APREBIT_1 "  " "
bitfld.long 0 8.--12. " TRP_AB_0 "  " "
bitfld.long 0 16.--20. " TRP_AB_1 "  " "
tree.end

base sd:0x8015618c
tree "DENALI_CTL_99"
group 0--3
line.long 0 "DENALI_CTL_99"
bitfld.long 0 0.--8. " INT_ACK "  " "
bitfld.long 0 16.--31. " CS_MSK_0 "  " "
tree.end

base sd:0x80156190
tree "DENALI_CTL_100"
group 0--3
line.long 0 "DENALI_CTL_100"
bitfld.long 0 0.--15. " CS_MSK_1 "  " "
bitfld.long 0 16.--31. " CS_VAL_0 "  " "
tree.end

base sd:0x80156194
tree "DENALI_CTL_101"
group 0--3
line.long 0 "DENALI_CTL_101"
bitfld.long 0 0.--15. " CS_VAL_1 "  " "
bitfld.long 0 16.--18. " TBST_INT_INTERVAL "  " "
bitfld.long 0 24.--27. " CKSRE "  " "
tree.end

base sd:0x80156198
tree "DENALI_CTL_102"
group 0--3
line.long 0 "DENALI_CTL_102"
bitfld.long 0 0.--3. " CKSRX "  " "
bitfld.long 0 8.--12. " TCKESR "  " "
bitfld.long 0 16.--29. " TREF_INTERVAL "  " "
tree.end

base sd:0x8015619c
tree "DENALI_CTL_103"
group 0--3
line.long 0 "DENALI_CTL_103"
bitfld.long 0 0.--15. " TDFI_PHYUPD_TYPE1 "  " "
bitfld.long 0 16.--31. " TDFI_PHYUPD_TYPE2 "  " "
tree.end

base sd:0x801561a0
tree "DENALI_CTL_104"
group 0--3
line.long 0 "DENALI_CTL_104"
bitfld.long 0 0.--15. " TDFI_PHYUPD_TYPE3 "  " "
tree.end

base sd:0x801561a4
tree "DENALI_CTL_105"
group 0--3
line.long 0 "DENALI_CTL_105"
bitfld.long 0 0.--31. " USER_DEF_REG_10 "  " "
tree.end

base sd:0x801561a8
tree "DENALI_CTL_106"
group 0--3
line.long 0 "DENALI_CTL_106"
bitfld.long 0 0.--31. " USER_DEF_REG_11 "  " "
tree.end

base sd:0x801561ac
tree "DENALI_CTL_107"
group 0--3
line.long 0 "DENALI_CTL_107"
bitfld.long 0 0.--31. " USER_DEF_REG_12 "  " "
tree.end

base sd:0x801561b0
tree "DENALI_CTL_108"
group 0--3
line.long 0 "DENALI_CTL_108"
bitfld.long 0 0.--31. " USER_DEF_REG_13 "  " "
tree.end

base sd:0x801561b4
tree "DENALI_CTL_109"
group 0--3
line.long 0 "DENALI_CTL_109"
bitfld.long 0 0.--31. " USER_DEF_REG_14 "  " "
tree.end

base sd:0x801561b8
tree "DENALI_CTL_110"
group 0--3
line.long 0 "DENALI_CTL_110"
bitfld.long 0 0.--31. " USER_DEF_REG_15 "  " "
tree.end

base sd:0x801561bc
tree "DENALI_CTL_111"
group 0--3
line.long 0 "DENALI_CTL_111"
bitfld.long 0 0.--31. " USER_DEF_REG_16 "  " "
tree.end

base sd:0x801561c0
tree "DENALI_CTL_112"
group 0--3
line.long 0 "DENALI_CTL_112"
bitfld.long 0 0.--31. " USER_DEF_REG_17 "  " "
tree.end

base sd:0x801561c4
tree "DENALI_CTL_113"
group 0--3
line.long 0 "DENALI_CTL_113"
bitfld.long 0 0.--31. " USER_DEF_REG_18 "  " "
tree.end

base sd:0x801561c8
tree "DENALI_CTL_114"
group 0--3
line.long 0 "DENALI_CTL_114"
bitfld.long 0 0.--31. " USER_DEF_REG_19 "  " "
tree.end

base sd:0x801561cc
tree "DENALI_CTL_115"
group 0--3
line.long 0 "DENALI_CTL_115"
bitfld.long 0 0.--31. " USER_DEF_REG_20 "  " "
tree.end

base sd:0x801561d0
tree "DENALI_CTL_116"
group 0--3
line.long 0 "DENALI_CTL_116"
bitfld.long 0 0.--31. " USER_DEF_REG_21 "  " "
tree.end

base sd:0x801561d4
tree "DENALI_CTL_117"
group 0--3
line.long 0 "DENALI_CTL_117"
bitfld.long 0 0.--31. " USER_DEF_REG_22 "  " "
tree.end

base sd:0x801561d8
tree "DENALI_CTL_118"
group 0--3
line.long 0 "DENALI_CTL_118"
bitfld.long 0 0.--31. " USER_DEF_REG_23 "  " "
tree.end

base sd:0x801561dc
tree "DENALI_CTL_119"
group 0--3
line.long 0 "DENALI_CTL_119"
bitfld.long 0 0.--31. " USER_DEF_REG_24 "  " "
tree.end

base sd:0x801561e0
tree "DENALI_CTL_120"
group 0--3
line.long 0 "DENALI_CTL_120"
bitfld.long 0 0.--31. " USER_DEF_REG_25 "  " "
tree.end

base sd:0x801561e4
tree "DENALI_CTL_121"
group 0--3
line.long 0 "DENALI_CTL_121"
bitfld.long 0 0.--31. " USER_DEF_REG_26 "  " "
tree.end

base sd:0x801561e8
tree "DENALI_CTL_122"
group 0--3
line.long 0 "DENALI_CTL_122"
bitfld.long 0 0.--31. " USER_DEF_REG_27 "  " "
tree.end

base sd:0x801561ec
tree "DENALI_CTL_123"
group 0--3
line.long 0 "DENALI_CTL_123"
bitfld.long 0 0.--31. " USER_DEF_REG_28 "  " "
tree.end

base sd:0x801561f0
tree "DENALI_CTL_124"
group 0--3
line.long 0 "DENALI_CTL_124"
bitfld.long 0 0.--31. " USER_DEF_REG_29 "  " "
tree.end

base sd:0x801561f4
tree "DENALI_CTL_125"
group 0--3
line.long 0 "DENALI_CTL_125"
bitfld.long 0 0.--31. " USER_DEF_REG_30 "  " "
tree.end

base sd:0x801561f8
tree "DENALI_CTL_126"
group 0--3
line.long 0 "DENALI_CTL_126"
bitfld.long 0 0.--31. " USER_DEF_REG_31 "  " "
tree.end

base sd:0x801561fc
tree "DENALI_CTL_127"
group 0--3
line.long 0 "DENALI_CTL_127"
bitfld.long 0 0.--31. " USER_DEF_REG_4 "  " "
tree.end

base sd:0x80156200
tree "DENALI_CTL_128"
group 0--3
line.long 0 "DENALI_CTL_128"
bitfld.long 0 0.--31. " USER_DEF_REG_5 "  " "
tree.end

base sd:0x80156204
tree "DENALI_CTL_129"
group 0--3
line.long 0 "DENALI_CTL_129"
bitfld.long 0 0.--31. " USER_DEF_REG_6 "  " "
tree.end

base sd:0x80156208
tree "DENALI_CTL_130"
group 0--3
line.long 0 "DENALI_CTL_130"
bitfld.long 0 0.--31. " USER_DEF_REG_7 "  " "
tree.end

base sd:0x8015620c
tree "DENALI_CTL_131"
group 0--3
line.long 0 "DENALI_CTL_131"
bitfld.long 0 0.--31. " USER_DEF_REG_8 "  " "
tree.end

base sd:0x80156210
tree "DENALI_CTL_132"
group 0--3
line.long 0 "DENALI_CTL_132"
bitfld.long 0 0.--31. " USER_DEF_REG_9 "  " "
tree.end

base sd:0x80156244
tree "DENALI_CTL_145"
rgroup 0--3
line.long 0 "DENALI_CTL_145"
bitfld.long 0 0. " SECERR_INT_ACK "  "0 ,1 "
bitfld.long 0 4.--5. " SECERR_INT_MASK "  " "
bitfld.long 0 8.--9. " SECERR_INT_STATUS "  " "
bitfld.long 0 16.--31. " SECERR_COUNTER "  " "
tree.end

base sd:0x80156248
tree "DENALI_CTL_146"
rgroup 0--3
line.long 0 "DENALI_CTL_146"
bitfld.long 0 0.--31. " SECERR_ADDRESS "  " "
tree.end

base sd:0x8015624c
tree "DENALI_CTL_147"
rgroup 0--3
line.long 0 "DENALI_CTL_147"
bitfld.long 0 0.--9. " SECERR_ID "  " "
bitfld.long 0 10.--11. " SECERR_PORT "  " "
bitfld.long 0 16. " SECERR_TYPE "  "0 ,1 "
bitfld.long 0 24.--31. " SECERR_LENGTH "  " "
tree.end

tree.end

;==============================================================
tree "DMAC"
;==============================================================
base sd:0x801c0000
tree "GCC"
group 0--3
line.long 0 "GCC"
bitfld.long 0 0. " ENA "  "0 ,1 "
bitfld.long 0 1. " STAT "  "0 ,1 "
bitfld.long 0 8. " SE0 "  "0 ,1 "
bitfld.long 0 9. " DE0 "  "0 ,1 "
bitfld.long 0 10. " SE1 "  "0 ,1 "
bitfld.long 0 11. " DE1 "  "0 ,1 "
bitfld.long 0 12. " SE2 "  "0 ,1 "
bitfld.long 0 13. " DE2 "  "0 ,1 "
bitfld.long 0 14. " SE3 "  "0 ,1 "
bitfld.long 0 15. " DE3 "  "0 ,1 "
tree.end

base sd:0x801c0004
tree "PRTYP"
group 0--3
line.long 0 "PRTYP"
bitfld.long 0 0.--1. " CP0TYP "  " "
bitfld.long 0 2.--3. " CP1TYP "  " "
bitfld.long 0 4.--5. " CP2TYP "  " "
bitfld.long 0 6.--7. " CP3TYP "  " "
bitfld.long 0 8.--9. " CP4TYP "  " "
bitfld.long 0 10.--11. " CP5TYP "  " "
bitfld.long 0 12.--13. " CP6TYP "  " "
bitfld.long 0 14.--15. " CP7TYP "  " "
bitfld.long 0 16.--17. " CP8TYP "  " "
bitfld.long 0 18.--19. " CP9TYP "  " "
bitfld.long 0 20.--21. " CP10TYP "  " "
bitfld.long 0 22.--23. " CP11TYP "  " "
bitfld.long 0 24.--25. " CP12TYP "  " "
bitfld.long 0 26.--27. " CP13TYP "  " "
bitfld.long 0 28.--29. " CP14TYP "  " "
bitfld.long 0 30.--31. " CP15TYP "  " "
tree.end

base sd:0x801c0008
tree "PRSME"
group 0--3
line.long 0 "PRSME"
bitfld.long 0 0.--1. " PR0SEC "  " "
bitfld.long 0 2.--3. " PR2SEC "  " "
bitfld.long 0 4.--5. " PR4SEC "  " "
bitfld.long 0 6.--7. " PR6SEC "  " "
bitfld.long 0 8.--9. " PR8SEC "  " "
bitfld.long 0 10.--11. " PR10SEC "  " "
bitfld.long 0 12.--13. " PR12SEC "  " "
bitfld.long 0 14.--15. " PR14SEC "  " "
bitfld.long 0 16.--17. " PR16SEC "  " "
bitfld.long 0 18.--19. " PR18SEC "  " "
bitfld.long 0 20.--21. " PR20SEC "  " "
bitfld.long 0 22.--23. " PR22SEC "  " "
bitfld.long 0 24.--25. " PR24SEC "  " "
bitfld.long 0 26.--27. " PR26SEC "  " "
bitfld.long 0 28.--29. " PR28SEC "  " "
bitfld.long 0 30.--31. " PR30SEC "  " "
tree.end

base sd:0x801c000c
tree "PRSMO"
group 0--3
line.long 0 "PRSMO"
bitfld.long 0 0.--1. " PR1SEC "  " "
bitfld.long 0 2.--3. " PR3SEC "  " "
bitfld.long 0 4.--5. " PR5SEC "  " "
bitfld.long 0 6.--7. " PR7SEC "  " "
bitfld.long 0 8.--9. " PR9SEC "  " "
bitfld.long 0 10.--11. " PR11SEC "  " "
bitfld.long 0 12.--13. " PR13SEC "  " "
bitfld.long 0 14.--15. " PR15SEC "  " "
bitfld.long 0 16.--17. " PR17SEC "  " "
bitfld.long 0 18.--19. " PR19SEC "  " "
bitfld.long 0 20.--21. " PR21SEC "  " "
bitfld.long 0 22.--23. " PR23SEC "  " "
bitfld.long 0 24.--25. " PR25SEC "  " "
bitfld.long 0 26.--27. " PR27SEC "  " "
bitfld.long 0 28.--29. " PR29SEC "  " "
bitfld.long 0 30.--31. " PR31SEC "  " "
tree.end

base sd:0x801c0010
tree "PRMSE"
group 0--3
line.long 0 "PRMSE"
bitfld.long 0 0.--1. " PR0MOD "  " "
bitfld.long 0 2.--3. " PR2MOD "  " "
bitfld.long 0 4.--5. " PR4MOD "  " "
bitfld.long 0 6.--7. " PR6MOD "  " "
bitfld.long 0 8.--9. " PR8MOD "  " "
bitfld.long 0 10.--11. " PR10MOD "  " "
bitfld.long 0 12.--13. " PR12MOD "  " "
bitfld.long 0 14.--15. " PR14MOD "  " "
bitfld.long 0 16.--17. " PR16MOD "  " "
bitfld.long 0 18.--19. " PR18MOD "  " "
bitfld.long 0 20.--21. " PR20MOD "  " "
bitfld.long 0 22.--23. " PR22MOD "  " "
bitfld.long 0 24.--25. " PR24MOD "  " "
bitfld.long 0 26.--27. " PR26MOD "  " "
bitfld.long 0 28.--29. " PR28MOD "  " "
bitfld.long 0 30.--31. " PR30MOD "  " "
tree.end

base sd:0x801c0014
tree "PRMSO"
group 0--3
line.long 0 "PRMSO"
bitfld.long 0 0.--1. " PR1MOD "  " "
bitfld.long 0 2.--3. " PR3MOD "  " "
bitfld.long 0 4.--5. " PR5MOD "  " "
bitfld.long 0 6.--7. " PR7MOD "  " "
bitfld.long 0 8.--9. " PR9MOD "  " "
bitfld.long 0 10.--11. " PR11MOD "  " "
bitfld.long 0 12.--13. " PR13MOD "  " "
bitfld.long 0 14.--15. " PR15MOD "  " "
bitfld.long 0 16.--17. " PR17MOD "  " "
bitfld.long 0 18.--19. " PR19MOD "  " "
bitfld.long 0 20.--21. " PR21MOD "  " "
bitfld.long 0 22.--23. " PR23MOD "  " "
bitfld.long 0 24.--25. " PR25MOD "  " "
bitfld.long 0 26.--27. " PR27MOD "  " "
bitfld.long 0 28.--29. " PR29MOD "  " "
bitfld.long 0 30.--31. " PR31MOD "  " "
tree.end

base sd:0x801c0018
tree "PRMOE"
group 0--3
line.long 0 "PRMOE"
bitfld.long 0 0.--1. " PR0OPT "  " "
bitfld.long 0 2.--3. " PR2OPT "  " "
bitfld.long 0 4.--5. " PR4OPT "  " "
bitfld.long 0 6.--7. " PR6OPT "  " "
bitfld.long 0 8.--9. " PR8OPT "  " "
bitfld.long 0 10.--11. " PR10OPT "  " "
bitfld.long 0 12.--13. " PR12OPT "  " "
bitfld.long 0 14.--15. " PR14OPT "  " "
bitfld.long 0 16.--17. " PR16OPT "  " "
bitfld.long 0 18.--19. " PR18OPT "  " "
bitfld.long 0 20.--21. " PR20OPT "  " "
bitfld.long 0 22.--23. " PR22OPT "  " "
bitfld.long 0 24.--25. " PR24OPT "  " "
bitfld.long 0 26.--27. " PR26OPT "  " "
bitfld.long 0 28.--29. " PR28OPT "  " "
bitfld.long 0 30.--31. " PR30OPT "  " "
tree.end

base sd:0x801c001c
tree "PRMOO"
group 0--3
line.long 0 "PRMOO"
bitfld.long 0 0.--1. " PR1OPT "  " "
bitfld.long 0 2.--3. " PR3OPT "  " "
bitfld.long 0 4.--5. " PR5OPT "  " "
bitfld.long 0 6.--7. " PR7OPT "  " "
bitfld.long 0 8.--9. " PR9OPT "  " "
bitfld.long 0 10.--11. " PR11OPT "  " "
bitfld.long 0 12.--13. " PR13OPT "  " "
bitfld.long 0 14.--15. " PR15OPT "  " "
bitfld.long 0 16.--17. " PR17OPT "  " "
bitfld.long 0 18.--19. " PR19OPT "  " "
bitfld.long 0 20.--21. " PR21OPT "  " "
bitfld.long 0 22.--23. " PR23OPT "  " "
bitfld.long 0 24.--25. " PR25OPT "  " "
bitfld.long 0 26.--27. " PR27OPT "  " "
bitfld.long 0 28.--29. " PR29OPT "  " "
bitfld.long 0 30.--31. " PR31OPT "  " "
tree.end

base sd:0x801c0020
tree "LCPA"
group 0--3
line.long 0 "LCPA"
bitfld.long 0 11.--31. " LCPA "  " "
tree.end

base sd:0x801c0024
tree "LCLA"
group 0--3
line.long 0 "LCLA"
bitfld.long 0 18.--31. " LCLA "  " "
tree.end

base sd:0x801c0028
tree "SLCPA"
group 0--3
line.long 0 "SLCPA"
bitfld.long 0 11.--31. " SLCPA "  " "
tree.end

base sd:0x801c002c
tree "SLCLA"
group 0--3
line.long 0 "SLCLA"
bitfld.long 0 18.--31. " SLCLA "  " "
tree.end

base sd:0x801c0030
tree "SSEG1"
group 0--3
line.long 0 "SSEG1"
bitfld.long 0 0.--15. " SSSEL "  " "
bitfld.long 0 16.--31. " SSDEL "  " "
tree.end

base sd:0x801c0034
tree "SSEG2"
group 0--3
line.long 0 "SSEG2"
bitfld.long 0 0.--15. " SSSEL "  " "
bitfld.long 0 16.--31. " SSDEL "  " "
tree.end

base sd:0x801c0038
tree "SSEG3"
group 0--3
line.long 0 "SSEG3"
bitfld.long 0 0.--15. " SSSEL "  " "
bitfld.long 0 16.--31. " SSDEL "  " "
tree.end

base sd:0x801c003c
tree "SSEG4"
group 0--3
line.long 0 "SSEG4"
bitfld.long 0 0.--15. " SSSEL "  " "
bitfld.long 0 16.--31. " SSDEL "  " "
tree.end

base sd:0x801c0040
tree "SCEG1"
group 0--3
line.long 0 "SCEG1"
bitfld.long 0 0.--15. " SCSEL "  " "
bitfld.long 0 16.--31. " SCDEL "  " "
tree.end

base sd:0x801c0044
tree "SCEG2"
group 0--3
line.long 0 "SCEG2"
bitfld.long 0 0.--15. " SCSEL "  " "
bitfld.long 0 16.--31. " SCDEL "  " "
tree.end

base sd:0x801c0048
tree "SCEG3"
group 0--3
line.long 0 "SCEG3"
bitfld.long 0 0.--15. " SCSEL "  " "
bitfld.long 0 16.--31. " SCDEL "  " "
tree.end

base sd:0x801c004c
tree "SCEG4"
group 0--3
line.long 0 "SCEG4"
bitfld.long 0 0.--15. " SCSEL "  " "
bitfld.long 0 16.--31. " SCDEL "  " "
tree.end

base sd:0x801c0050
tree "ACTIVE"
group 0--3
line.long 0 "ACTIVE"
bitfld.long 0 0.--1. " PR0AS "  " "
bitfld.long 0 2.--3. " PR2AS "  " "
bitfld.long 0 4.--5. " PR4AS "  " "
bitfld.long 0 6.--7. " PR6AS "  " "
bitfld.long 0 8.--9. " PR8AS "  " "
bitfld.long 0 10.--11. " PR10AS "  " "
bitfld.long 0 12.--13. " PR12AS "  " "
bitfld.long 0 14.--15. " PR14AS "  " "
bitfld.long 0 16.--17. " PR16AS "  " "
bitfld.long 0 18.--19. " PR18AS "  " "
bitfld.long 0 20.--21. " PR20AS "  " "
bitfld.long 0 22.--23. " PR22AS "  " "
bitfld.long 0 24.--25. " PR24AS "  " "
bitfld.long 0 26.--27. " PR26AS "  " "
bitfld.long 0 28.--29. " PR28AS "  " "
bitfld.long 0 30.--31. " PR30AS "  " "
tree.end

base sd:0x801c0054
tree "ACTIVO"
group 0--3
line.long 0 "ACTIVO"
bitfld.long 0 0.--1. " PR1AS "  " "
bitfld.long 0 2.--3. " PR3AS "  " "
bitfld.long 0 4.--5. " PR5AS "  " "
bitfld.long 0 6.--7. " PR7AS "  " "
bitfld.long 0 8.--9. " PR9AS "  " "
bitfld.long 0 10.--11. " PR11AS "  " "
bitfld.long 0 12.--13. " PR13AS "  " "
bitfld.long 0 14.--15. " PR15AS "  " "
bitfld.long 0 16.--17. " PR17AS "  " "
bitfld.long 0 18.--19. " PR19AS "  " "
bitfld.long 0 20.--21. " PR21AS "  " "
bitfld.long 0 22.--23. " PR23AS "  " "
bitfld.long 0 24.--25. " PR25AS "  " "
bitfld.long 0 26.--27. " PR27AS "  " "
bitfld.long 0 28.--29. " PR29AS "  " "
bitfld.long 0 30.--31. " PR31AS "  " "
tree.end

base sd:0x801c0060
tree "PCMIS"
group 0--3
line.long 0 "PCMIS"
bitfld.long 0 0.--31. " PCMIS "  " "
tree.end

base sd:0x801c0064
tree "PCICR"
wgroup 0--3
line.long 0 "PCICR"
bitfld.long 0 0.--31. " PCICR "  " "
tree.end

base sd:0x801c0068
tree "PCTIS"
group 0--3
line.long 0 "PCTIS"
bitfld.long 0 0.--31. " PCTIS "  " "
tree.end

base sd:0x801c006c
tree "PCEIS"
group 0--3
line.long 0 "PCEIS"
bitfld.long 0 0.--31. " PCEIS "  " "
tree.end

base sd:0x801c0070
tree "SPCMIS"
group 0--3
line.long 0 "SPCMIS"
bitfld.long 0 0.--31. " SPCMIS "  " "
tree.end

base sd:0x801c0074
tree "SPCICR"
wgroup 0--3
line.long 0 "SPCICR"
bitfld.long 0 0.--31. " PCICR "  " "
tree.end

base sd:0x801c0078
tree "SPCTIS"
group 0--3
line.long 0 "SPCTIS"
bitfld.long 0 0.--31. " SPCTIS "  " "
tree.end

base sd:0x801c007c
tree "SPCEIS"
group 0--3
line.long 0 "SPCEIS"
bitfld.long 0 0.--31. " SPCEIS "  " "
tree.end

base sd:0x801c0080
tree "LCMIS1"
group 0--3
line.long 0 "LCMIS1"
bitfld.long 0 0.--31. " LCMIS "  " "
tree.end

base sd:0x801c0084
tree "LCMIS2"
group 0--3
line.long 0 "LCMIS2"
bitfld.long 0 0.--31. " LCMIS "  " "
tree.end

base sd:0x801c0088
tree "LCMIS3"
group 0--3
line.long 0 "LCMIS3"
bitfld.long 0 0.--31. " LCMIS "  " "
tree.end

base sd:0x801c008c
tree "LCMIS4"
group 0--3
line.long 0 "LCMIS4"
bitfld.long 0 0.--31. " LCMIS "  " "
tree.end

base sd:0x801c0090
tree "LCICR1"
wgroup 0--3
line.long 0 "LCICR1"
bitfld.long 0 0.--31. " LCICR "  " "
tree.end

base sd:0x801c0094
tree "LCICR2"
wgroup 0--3
line.long 0 "LCICR2"
bitfld.long 0 0.--31. " LCICR "  " "
tree.end

base sd:0x801c0098
tree "LCICR3"
wgroup 0--3
line.long 0 "LCICR3"
bitfld.long 0 0.--31. " LCICR "  " "
tree.end

base sd:0x801c009c
tree "LCICR4"
wgroup 0--3
line.long 0 "LCICR4"
bitfld.long 0 0.--31. " LCICR "  " "
tree.end

base sd:0x801c00a0
tree "LCTIS1"
group 0--3
line.long 0 "LCTIS1"
bitfld.long 0 0.--31. " LCTIS "  " "
tree.end

base sd:0x801c00a4
tree "LCTIS2"
group 0--3
line.long 0 "LCTIS2"
bitfld.long 0 0.--31. " LCTIS "  " "
tree.end

base sd:0x801c00a8
tree "LCTIS3"
group 0--3
line.long 0 "LCTIS3"
bitfld.long 0 0.--31. " LCTIS "  " "
tree.end

base sd:0x801c00ac
tree "LCTIS4"
group 0--3
line.long 0 "LCTIS4"
bitfld.long 0 0.--31. " LCTIS "  " "
tree.end

base sd:0x801c00b0
tree "LCEIS1"
group 0--3
line.long 0 "LCEIS1"
bitfld.long 0 0.--31. " LCEIS "  " "
tree.end

base sd:0x801c00b4
tree "LCEIS2"
group 0--3
line.long 0 "LCEIS2"
bitfld.long 0 0.--31. " LCEIS "  " "
tree.end

base sd:0x801c00b8
tree "LCEIS3"
group 0--3
line.long 0 "LCEIS3"
bitfld.long 0 0.--31. " LCEIS "  " "
tree.end

base sd:0x801c00bc
tree "LCEIS4"
group 0--3
line.long 0 "LCEIS4"
bitfld.long 0 0.--31. " LCEIS "  " "
tree.end

base sd:0x801c00c0
tree "SLCMIS1"
group 0--3
line.long 0 "SLCMIS1"
bitfld.long 0 0.--31. " SLCMIS "  " "
tree.end

base sd:0x801c00c4
tree "SLCMIS2"
group 0--3
line.long 0 "SLCMIS2"
bitfld.long 0 0.--31. " SLCMIS "  " "
tree.end

base sd:0x801c00c8
tree "SLCMIS3"
group 0--3
line.long 0 "SLCMIS3"
bitfld.long 0 0.--31. " SLCMIS "  " "
tree.end

base sd:0x801c00cc
tree "SLCMIS4"
group 0--3
line.long 0 "SLCMIS4"
bitfld.long 0 0.--31. " SLCMIS "  " "
tree.end

base sd:0x801c00d0
tree "SLCICR1"
wgroup 0--3
line.long 0 "SLCICR1"
bitfld.long 0 0.--31. " SLCICR "  " "
tree.end

base sd:0x801c00d4
tree "SLCICR2"
wgroup 0--3
line.long 0 "SLCICR2"
bitfld.long 0 0.--31. " SLCICR "  " "
tree.end

base sd:0x801c00d8
tree "SLCICR3"
wgroup 0--3
line.long 0 "SLCICR3"
bitfld.long 0 0.--31. " SLCICR "  " "
tree.end

base sd:0x801c00dc
tree "SLCICR4"
wgroup 0--3
line.long 0 "SLCICR4"
bitfld.long 0 0.--31. " SLCICR "  " "
tree.end

base sd:0x801c00e0
tree "SLCTIS1"
group 0--3
line.long 0 "SLCTIS1"
bitfld.long 0 0.--31. " SLCTIS "  " "
tree.end

base sd:0x801c00e4
tree "SLCTIS2"
group 0--3
line.long 0 "SLCTIS2"
bitfld.long 0 0.--31. " SLCTIS "  " "
tree.end

base sd:0x801c00e8
tree "SLCTIS3"
group 0--3
line.long 0 "SLCTIS3"
bitfld.long 0 0.--31. " SLCTIS "  " "
tree.end

base sd:0x801c00ec
tree "SLCTIS4"
group 0--3
line.long 0 "SLCTIS4"
bitfld.long 0 0.--31. " SLCTIS "  " "
tree.end

base sd:0x801c00f0
tree "SLCEIS1"
group 0--3
line.long 0 "SLCEIS1"
bitfld.long 0 0.--31. " SLCEIS "  " "
tree.end

base sd:0x801c00f4
tree "SLCEIS2"
group 0--3
line.long 0 "SLCEIS2"
bitfld.long 0 0.--31. " SLCEIS "  " "
tree.end

base sd:0x801c00f8
tree "SLCEIS3"
group 0--3
line.long 0 "SLCEIS3"
bitfld.long 0 0.--31. " SLCEIS "  " "
tree.end

base sd:0x801c00fc
tree "SLCEIS4"
group 0--3
line.long 0 "SLCEIS4"
bitfld.long 0 0.--31. " SLCEIS "  " "
tree.end

base sd:0x801c0100
tree "FSESS1"
group 0--3
line.long 0 "FSESS1"
bitfld.long 0 0.--31. " FSESS1 "  " "
tree.end

base sd:0x801c0104
tree "FSESS2"
group 0--3
line.long 0 "FSESS2"
bitfld.long 0 0.--31. " FSESS2 "  " "
tree.end

base sd:0x801c0108
tree "FSEBS1"
group 0--3
line.long 0 "FSEBS1"
bitfld.long 0 0.--31. " FSEBS1 "  " "
tree.end

base sd:0x801c010c
tree "FSEBS2"
group 0--3
line.long 0 "FSEBS2"
bitfld.long 0 0.--31. " FSEBS2 "  " "
tree.end

base sd:0x801c0110
tree "PSEG1"
group 0--3
line.long 0 "PSEG1"
bitfld.long 0 0.--15. " PSSEL1 "  " "
bitfld.long 0 16.--31. " PSDEL1 "  " "
tree.end

base sd:0x801c0114
tree "PSEG2"
group 0--3
line.long 0 "PSEG2"
bitfld.long 0 0.--15. " PSSEL2 "  " "
bitfld.long 0 16.--31. " PSDEL2 "  " "
tree.end

base sd:0x801c0118
tree "PSEG3"
group 0--3
line.long 0 "PSEG3"
bitfld.long 0 0.--15. " PSSEL3 "  " "
bitfld.long 0 16.--31. " PSDEL3 "  " "
tree.end

base sd:0x801c011c
tree "PSEG4"
group 0--3
line.long 0 "PSEG4"
bitfld.long 0 0.--15. " PSSEL4 "  " "
bitfld.long 0 16.--31. " PSDEL4 "  " "
tree.end

base sd:0x801c0120
tree "PCEG1"
group 0--3
line.long 0 "PCEG1"
bitfld.long 0 0.--15. " PCSEL1 "  " "
bitfld.long 0 16.--31. " PCDEL1 "  " "
tree.end

base sd:0x801c0124
tree "PCEG2"
group 0--3
line.long 0 "PCEG2"
bitfld.long 0 0.--15. " PCSEL2 "  " "
bitfld.long 0 16.--31. " PCDEL2 "  " "
tree.end

base sd:0x801c0128
tree "PCEG3"
group 0--3
line.long 0 "PCEG3"
bitfld.long 0 0.--15. " PCSEL3 "  " "
bitfld.long 0 16.--31. " PCDEL3 "  " "
tree.end

base sd:0x801c012c
tree "PCEG4"
group 0--3
line.long 0 "PCEG4"
bitfld.long 0 0.--15. " PCSEL4 "  " "
bitfld.long 0 16.--31. " PCDEL4 "  " "
tree.end

base sd:0x801c0130
tree "RSEG1"
group 0--3
line.long 0 "RSEG1"
bitfld.long 0 0.--15. " RSSEL1 "  " "
bitfld.long 0 16.--31. " RSDEL1 "  " "
tree.end

base sd:0x801c0134
tree "RSEG2"
group 0--3
line.long 0 "RSEG2"
bitfld.long 0 0.--15. " RSSEL2 "  " "
bitfld.long 0 16.--31. " RSDEL2 "  " "
tree.end

base sd:0x801c0138
tree "RSEG3"
group 0--3
line.long 0 "RSEG3"
bitfld.long 0 0.--15. " RSSEL3 "  " "
bitfld.long 0 16.--31. " RSDEL3 "  " "
tree.end

base sd:0x801c013c
tree "RSEG4"
group 0--3
line.long 0 "RSEG4"
bitfld.long 0 0.--15. " RSSEL4 "  " "
bitfld.long 0 16.--31. " RSDEL4 "  " "
tree.end

base sd:0x801c0140
tree "RCEG1"
group 0--3
line.long 0 "RCEG1"
bitfld.long 0 0.--15. " RCSEL1 "  " "
bitfld.long 0 16.--31. " RCDEL1 "  " "
tree.end

base sd:0x801c0144
tree "RCEG2"
group 0--3
line.long 0 "RCEG2"
bitfld.long 0 0.--15. " RCSEL2 "  " "
bitfld.long 0 16.--31. " RCDEL2 "  " "
tree.end

base sd:0x801c0148
tree "RCEG3"
group 0--3
line.long 0 "RCEG3"
bitfld.long 0 0.--15. " RCSEL3 "  " "
bitfld.long 0 16.--31. " RCDEL3 "  " "
tree.end

base sd:0x801c014c
tree "RCEG4"
group 0--3
line.long 0 "RCEG4"
bitfld.long 0 0.--15. " RCSEL4 "  " "
bitfld.long 0 16.--31. " RCDEL4 "  " "
tree.end

base sd:0x801c0fc4
tree "STTC"
group 0--3
line.long 0 "STTC"
bitfld.long 0 0.--31. " STTC1 "  " "
tree.end

base sd:0x801c0fc8
tree "STFU"
group 0--3
line.long 0 "STFU"
bitfld.long 0 0.--15. " RESULT "  " "
bitfld.long 0 16.--19. " LCELNB "  " "
bitfld.long 0 20. " SD "  "0 ,1 "
bitfld.long 0 21.--25. " PRSEL "  " "
bitfld.long 0 26.--27. " MSTSEL "  " "
bitfld.long 0 28.--30. " MODE "  " "
bitfld.long 0 31. " ENA "  "0 ,1 "
tree.end

base sd:0x801c0fcc
tree "ICFG"
rgroup 0--3
line.long 0 "ICFG"
bitfld.long 0 0.--2. " SCHNB "  " "
bitfld.long 0 3.--4. " MNB "  " "
bitfld.long 0 5.--6. " DBUFSZ "  " "
bitfld.long 0 7. " CPSZ "  "0 ,1 "
bitfld.long 0 8. " M1SZ "  "0 ,1 "
bitfld.long 0 9. " M2SZ "  "0 ,1 "
bitfld.long 0 10. " M3SZ "  "0 ,1 "
bitfld.long 0 11. " M4SZ "  "0 ,1 "
bitfld.long 0 12. " PTYP "  "0 ,1 "
bitfld.long 0 16.--19. " MODEN "  " "
tree.end

base sd:0x801c0fd0
tree "MPLUG0"
rgroup 0--3
line.long 0 "MPLUG0"
bitfld.long 0 0.--31. " MPLUG0 "  " "
tree.end

base sd:0x801c0fd4
tree "MPLUG1"
rgroup 0--3
line.long 0 "MPLUG1"
bitfld.long 0 0.--31. " MPLUG1 "  " "
tree.end

base sd:0x801c0fd8
tree "MPLUG2"
rgroup 0--3
line.long 0 "MPLUG2"
bitfld.long 0 0.--31. " MPLUG2 "  " "
tree.end

base sd:0x801c0fdc
tree "MPLUG3"
rgroup 0--3
line.long 0 "MPLUG3"
bitfld.long 0 0.--31. " MPLUG3 "  " "
tree.end

base sd:0x801c0fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PTNUM "  " "
tree.end

base sd:0x801c0fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PTNUM "  " "
bitfld.long 0 4.--7. " DES0 "  " "
tree.end

base sd:0x801c0fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " DES1 "  " "
bitfld.long 0 4.--7. " REV "  " "
tree.end

base sd:0x801c0fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " CONFIG "  " "
tree.end

base sd:0x801c0ff0
tree "CellID0"
rgroup 0--3
line.long 0 "CellID0"
bitfld.long 0 0.--7. " ID0 "  " "
tree.end

base sd:0x801c0ff4
tree "CellID1"
rgroup 0--3
line.long 0 "CellID1"
bitfld.long 0 0.--7. " ID1 "  " "
tree.end

base sd:0x801c0ff8
tree "CellID2"
rgroup 0--3
line.long 0 "CellID2"
bitfld.long 0 0.--7. " ID2 "  " "
tree.end

base sd:0x801c0ffc
tree "CellID3"
rgroup 0--3
line.long 0 "CellID3"
bitfld.long 0 0.--7. " ID3 "  " "
tree.end

base sd:0x801c0400
tree "SSCFG0"
group 0--3
line.long 0 "SSCFG0"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0410
tree "SDCFG0"
group 0--3
line.long 0 "SDCFG0"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0404
tree "SSELT0"
group 0--3
line.long 0 "SSELT0"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0414
tree "SDELT0"
group 0--3
line.long 0 "SDELT0"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0408
tree "SSPTR0"
group 0--3
line.long 0 "SSPTR0"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c0418
tree "SDPTR0"
group 0--3
line.long 0 "SDPTR0"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c040c
tree "SSLNK0"
group 0--3
line.long 0 "SSLNK0"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c041c
tree "SDLNK0"
group 0--3
line.long 0 "SDLNK0"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c0420
tree "SSCFG1"
group 0--3
line.long 0 "SSCFG1"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0430
tree "SDCFG1"
group 0--3
line.long 0 "SDCFG1"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0424
tree "SSELT1"
group 0--3
line.long 0 "SSELT1"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0434
tree "SDELT1"
group 0--3
line.long 0 "SDELT1"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0428
tree "SSPTR1"
group 0--3
line.long 0 "SSPTR1"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c0438
tree "SDPTR1"
group 0--3
line.long 0 "SDPTR1"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c042c
tree "SSLNK1"
group 0--3
line.long 0 "SSLNK1"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c043c
tree "SDLNK1"
group 0--3
line.long 0 "SDLNK1"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c0440
tree "SSCFG2"
group 0--3
line.long 0 "SSCFG2"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0450
tree "SDCFG2"
group 0--3
line.long 0 "SDCFG2"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0444
tree "SSELT2"
group 0--3
line.long 0 "SSELT2"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0454
tree "SDELT2"
group 0--3
line.long 0 "SDELT2"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0448
tree "SSPTR2"
group 0--3
line.long 0 "SSPTR2"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c0458
tree "SDPTR2"
group 0--3
line.long 0 "SDPTR2"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c044c
tree "SSLNK2"
group 0--3
line.long 0 "SSLNK2"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c045c
tree "SDLNK2"
group 0--3
line.long 0 "SDLNK2"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c0460
tree "SSCFG3"
group 0--3
line.long 0 "SSCFG3"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0470
tree "SDCFG3"
group 0--3
line.long 0 "SDCFG3"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0464
tree "SSELT3"
group 0--3
line.long 0 "SSELT3"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0474
tree "SDELT3"
group 0--3
line.long 0 "SDELT3"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0468
tree "SSPTR3"
group 0--3
line.long 0 "SSPTR3"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c0478
tree "SDPTR3"
group 0--3
line.long 0 "SDPTR3"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c046c
tree "SSLNK3"
group 0--3
line.long 0 "SSLNK3"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c047c
tree "SDLNK3"
group 0--3
line.long 0 "SDLNK3"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c0480
tree "SSCFG4"
group 0--3
line.long 0 "SSCFG4"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0490
tree "SDCFG4"
group 0--3
line.long 0 "SDCFG4"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0484
tree "SSELT4"
group 0--3
line.long 0 "SSELT4"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0494
tree "SDELT4"
group 0--3
line.long 0 "SDELT4"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0488
tree "SSPTR4"
group 0--3
line.long 0 "SSPTR4"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c0498
tree "SDPTR4"
group 0--3
line.long 0 "SDPTR4"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c048c
tree "SSLNK4"
group 0--3
line.long 0 "SSLNK4"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c049c
tree "SDLNK4"
group 0--3
line.long 0 "SDLNK4"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c04a0
tree "SSCFG5"
group 0--3
line.long 0 "SSCFG5"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c04b0
tree "SDCFG5"
group 0--3
line.long 0 "SDCFG5"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c04a4
tree "SSELT5"
group 0--3
line.long 0 "SSELT5"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c04b4
tree "SDELT5"
group 0--3
line.long 0 "SDELT5"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c04a8
tree "SSPTR5"
group 0--3
line.long 0 "SSPTR5"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c04b8
tree "SDPTR5"
group 0--3
line.long 0 "SDPTR5"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c04ac
tree "SSLNK5"
group 0--3
line.long 0 "SSLNK5"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c04bc
tree "SDLNK5"
group 0--3
line.long 0 "SDLNK5"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c04c0
tree "SSCFG6"
group 0--3
line.long 0 "SSCFG6"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c04d0
tree "SDCFG6"
group 0--3
line.long 0 "SDCFG6"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c04c4
tree "SSELT6"
group 0--3
line.long 0 "SSELT6"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c04d4
tree "SDELT6"
group 0--3
line.long 0 "SDELT6"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c04c8
tree "SSPTR6"
group 0--3
line.long 0 "SSPTR6"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c04d8
tree "SDPTR6"
group 0--3
line.long 0 "SDPTR6"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c04cc
tree "SSLNK6"
group 0--3
line.long 0 "SSLNK6"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c04dc
tree "SDLNK6"
group 0--3
line.long 0 "SDLNK6"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c04e0
tree "SSCFG7"
group 0--3
line.long 0 "SSCFG7"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c04f0
tree "SDCFG7"
group 0--3
line.long 0 "SDCFG7"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c04e4
tree "SSELT7"
group 0--3
line.long 0 "SSELT7"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c04f4
tree "SDELT7"
group 0--3
line.long 0 "SDELT7"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c04e8
tree "SSPTR7"
group 0--3
line.long 0 "SSPTR7"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c04f8
tree "SDPTR7"
group 0--3
line.long 0 "SDPTR7"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c04ec
tree "SSLNK7"
group 0--3
line.long 0 "SSLNK7"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c04fc
tree "SDLNK7"
group 0--3
line.long 0 "SDLNK7"
bitfld.long 0 0. " TCP "  "0 ,1 "
bitfld.long 0 1. " LMP "  "0 ,1 "
bitfld.long 0 2. " PRE "  "0 ,1 "
bitfld.long 0 3.--31. " LNK "  " "
tree.end

base sd:0x801c0800
tree "ESCFG0"
group 0--3
line.long 0 "ESCFG0"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0820
tree "EDCFG0"
group 0--3
line.long 0 "EDCFG0"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0804
tree "ESELT0"
group 0--3
line.long 0 "ESELT0"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0824
tree "EDELT0"
group 0--3
line.long 0 "EDELT0"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0808
tree "ESPTR0"
group 0--3
line.long 0 "ESPTR0"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c0828
tree "EDPTR0"
group 0--3
line.long 0 "EDPTR0"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c080c
tree "ESLNK0"
group 0--3
line.long 0 "ESLNK0"
bitfld.long 0 0.--31. " EXC "  " "
tree.end

base sd:0x801c082c
tree "EDLNK0"
group 0--3
line.long 0 "EDLNK0"
bitfld.long 0 0.--31. " EXC "  " "
tree.end

base sd:0x801c0810
tree "ESEXC0"
group 0--3
line.long 0 "ESEXC0"
bitfld.long 0 0.--15. " EXC "  " "
tree.end

base sd:0x801c0830
tree "EDEXC0"
group 0--3
line.long 0 "EDEXC0"
bitfld.long 0 0.--15. " EXC "  " "
tree.end

base sd:0x801c0814
tree "ESFRM0"
group 0--3
line.long 0 "ESFRM0"
bitfld.long 0 0.--15. " FIDX "  " "
bitfld.long 0 16.--31. " FCNT "  " "
tree.end

base sd:0x801c0834
tree "EDFRM0"
group 0--3
line.long 0 "EDFRM0"
bitfld.long 0 0.--15. " FIDX "  " "
bitfld.long 0 16.--31. " FCNT "  " "
tree.end

base sd:0x801c0818
tree "ESRLD0"
group 0--3
line.long 0 "ESRLD0"
bitfld.long 0 0.--15. " FRLD "  " "
bitfld.long 0 16.--31. " ERLD "  " "
tree.end

base sd:0x801c0838
tree "EDRLD0"
group 0--3
line.long 0 "EDRLD0"
bitfld.long 0 0.--15. " FRLD "  " "
bitfld.long 0 16.--31. " ERLD "  " "
tree.end

base sd:0x801c081c
tree "ESBLK0"
group 0--3
line.long 0 "ESBLK0"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
tree.end

base sd:0x801c083c
tree "EDBLK0"
group 0--3
line.long 0 "EDBLK0"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
tree.end

base sd:0x801c0840
tree "ESCFG1"
group 0--3
line.long 0 "ESCFG1"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0860
tree "EDCFG1"
group 0--3
line.long 0 "EDCFG1"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0844
tree "ESELT1"
group 0--3
line.long 0 "ESELT1"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0864
tree "EDELT1"
group 0--3
line.long 0 "EDELT1"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0848
tree "ESPTR1"
group 0--3
line.long 0 "ESPTR1"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c0868
tree "EDPTR1"
group 0--3
line.long 0 "EDPTR1"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c084c
tree "ESLNK1"
group 0--3
line.long 0 "ESLNK1"
bitfld.long 0 0.--31. " EXC "  " "
tree.end

base sd:0x801c086c
tree "EDLNK1"
group 0--3
line.long 0 "EDLNK1"
bitfld.long 0 0.--31. " EXC "  " "
tree.end

base sd:0x801c0850
tree "ESEXC1"
group 0--3
line.long 0 "ESEXC1"
bitfld.long 0 0.--15. " EXC "  " "
tree.end

base sd:0x801c0870
tree "EDEXC1"
group 0--3
line.long 0 "EDEXC1"
bitfld.long 0 0.--15. " EXC "  " "
tree.end

base sd:0x801c0854
tree "ESFRM1"
group 0--3
line.long 0 "ESFRM1"
bitfld.long 0 0.--15. " FIDX "  " "
bitfld.long 0 16.--31. " FCNT "  " "
tree.end

base sd:0x801c0874
tree "EDFRM1"
group 0--3
line.long 0 "EDFRM1"
bitfld.long 0 0.--15. " FIDX "  " "
bitfld.long 0 16.--31. " FCNT "  " "
tree.end

base sd:0x801c0858
tree "ESRLD1"
group 0--3
line.long 0 "ESRLD1"
bitfld.long 0 0.--15. " FRLD "  " "
bitfld.long 0 16.--31. " ERLD "  " "
tree.end

base sd:0x801c0878
tree "EDRLD1"
group 0--3
line.long 0 "EDRLD1"
bitfld.long 0 0.--15. " FRLD "  " "
bitfld.long 0 16.--31. " ERLD "  " "
tree.end

base sd:0x801c085c
tree "ESBLK1"
group 0--3
line.long 0 "ESBLK1"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
tree.end

base sd:0x801c087c
tree "EDBLK1"
group 0--3
line.long 0 "EDBLK1"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
tree.end

base sd:0x801c0880
tree "ESCFG2"
group 0--3
line.long 0 "ESCFG2"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c08a0
tree "EDCFG2"
group 0--3
line.long 0 "EDCFG2"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c0884
tree "ESELT2"
group 0--3
line.long 0 "ESELT2"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c08a4
tree "EDELT2"
group 0--3
line.long 0 "EDELT2"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c0888
tree "ESPTR2"
group 0--3
line.long 0 "ESPTR2"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c08a8
tree "EDPTR2"
group 0--3
line.long 0 "EDPTR2"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c088c
tree "ESLNK2"
group 0--3
line.long 0 "ESLNK2"
bitfld.long 0 0.--31. " EXC "  " "
tree.end

base sd:0x801c08ac
tree "EDLNK2"
group 0--3
line.long 0 "EDLNK2"
bitfld.long 0 0.--31. " EXC "  " "
tree.end

base sd:0x801c0890
tree "ESEXC2"
group 0--3
line.long 0 "ESEXC2"
bitfld.long 0 0.--15. " EXC "  " "
tree.end

base sd:0x801c08b0
tree "EDEXC2"
group 0--3
line.long 0 "EDEXC2"
bitfld.long 0 0.--15. " EXC "  " "
tree.end

base sd:0x801c0894
tree "ESFRM2"
group 0--3
line.long 0 "ESFRM2"
bitfld.long 0 0.--15. " FIDX "  " "
bitfld.long 0 16.--31. " FCNT "  " "
tree.end

base sd:0x801c08b4
tree "EDFRM2"
group 0--3
line.long 0 "EDFRM2"
bitfld.long 0 0.--15. " FIDX "  " "
bitfld.long 0 16.--31. " FCNT "  " "
tree.end

base sd:0x801c0898
tree "ESRLD2"
group 0--3
line.long 0 "ESRLD2"
bitfld.long 0 0.--15. " FRLD "  " "
bitfld.long 0 16.--31. " ERLD "  " "
tree.end

base sd:0x801c08b8
tree "EDRLD2"
group 0--3
line.long 0 "EDRLD2"
bitfld.long 0 0.--15. " FRLD "  " "
bitfld.long 0 16.--31. " ERLD "  " "
tree.end

base sd:0x801c089c
tree "ESBLK2"
group 0--3
line.long 0 "ESBLK2"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
tree.end

base sd:0x801c08bc
tree "EDBLK2"
group 0--3
line.long 0 "EDBLK2"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
tree.end

base sd:0x801c08c0
tree "ESCFG3"
group 0--3
line.long 0 "ESCFG3"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c08e0
tree "EDCFG3"
group 0--3
line.long 0 "EDCFG3"
bitfld.long 0 0.--3. " EVTL "  " "
bitfld.long 0 4.--5. " TM "  " "
bitfld.long 0 6. " LBE "  "0 ,1 "
bitfld.long 0 7. " PRI "  "0 ,1 "
bitfld.long 0 8.--9. " ESIZE "  " "
bitfld.long 0 10.--11. " PSIZE "  " "
bitfld.long 0 12. " PEN "  "0 ,1 "
bitfld.long 0 13. " EIM "  "0 ,1 "
bitfld.long 0 14. " TIM "  "0 ,1 "
bitfld.long 0 15. " MST "  "0 ,1 "
tree.end

base sd:0x801c08c4
tree "ESELT3"
group 0--3
line.long 0 "ESELT3"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c08e4
tree "EDELT3"
group 0--3
line.long 0 "EDELT3"
bitfld.long 0 0.--15. " EIDX "  " "
bitfld.long 0 16.--31. " ECNT "  " "
tree.end

base sd:0x801c08c8
tree "ESPTR3"
group 0--3
line.long 0 "ESPTR3"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c08e8
tree "EDPTR3"
group 0--3
line.long 0 "EDPTR3"
bitfld.long 0 0.--31. " PTR "  " "
tree.end

base sd:0x801c08cc
tree "ESLNK3"
group 0--3
line.long 0 "ESLNK3"
bitfld.long 0 0.--31. " EXC "  " "
tree.end

base sd:0x801c08ec
tree "EDLNK3"
group 0--3
line.long 0 "EDLNK3"
bitfld.long 0 0.--31. " EXC "  " "
tree.end

base sd:0x801c08d0
tree "ESEXC3"
group 0--3
line.long 0 "ESEXC3"
bitfld.long 0 0.--15. " EXC "  " "
tree.end

base sd:0x801c08f0
tree "EDEXC3"
group 0--3
line.long 0 "EDEXC3"
bitfld.long 0 0.--15. " EXC "  " "
tree.end

base sd:0x801c08d4
tree "ESFRM3"
group 0--3
line.long 0 "ESFRM3"
bitfld.long 0 0.--15. " FIDX "  " "
bitfld.long 0 16.--31. " FCNT "  " "
tree.end

base sd:0x801c08f4
tree "EDFRM3"
group 0--3
line.long 0 "EDFRM3"
bitfld.long 0 0.--15. " FIDX "  " "
bitfld.long 0 16.--31. " FCNT "  " "
tree.end

base sd:0x801c08d8
tree "ESRLD3"
group 0--3
line.long 0 "ESRLD3"
bitfld.long 0 0.--15. " FRLD "  " "
bitfld.long 0 16.--31. " ERLD "  " "
tree.end

base sd:0x801c08f8
tree "EDRLD3"
group 0--3
line.long 0 "EDRLD3"
bitfld.long 0 0.--15. " FRLD "  " "
bitfld.long 0 16.--31. " ERLD "  " "
tree.end

base sd:0x801c08dc
tree "ESBLK3"
group 0--3
line.long 0 "ESBLK3"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
tree.end

base sd:0x801c08fc
tree "EDBLK3"
group 0--3
line.long 0 "EDBLK3"
bitfld.long 0 0.--19. " BIDX "  " "
bitfld.long 0 20.--31. " BCNT "  " "
tree.end

tree.end

;==============================================================
;tree "DSI (3 instances)"
;==============================================================
base sd:0xa0353000
;********************************************
tree "DSI-2"
;********************************************
base sd:0xa0353000
tree "2MCTL_INTEGRATION_MODE"
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
tree.end

base sd:0xa0353004
tree "2MCTL_MAIN_DATA_CTL"
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF1_MODE "  "0 ,1 "
bitfld.long 0 2. " VID_EN "  "0 ,1 "
bitfld.long 0 3. " TVG_SEL "  "0 ,1 "
bitfld.long 0 4. " TBG_SEL "  "0 ,1 "
bitfld.long 0 5. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 6. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 7. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 8. " READ_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_EN "  "0 ,1 "
bitfld.long 0 10. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 11. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 12. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 13. " DISP_EOT_GEN "  "0 ,1 "
tree.end

base sd:0xa0353008
tree "2MCTL_MAIN_PHY_CTL"
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 2. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 3. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 6.--9. " WAIT_BURST_TIME "  " "
bitfld.long 0 10. " CLK_FORCE_STOP "  "0 ,1 "
tree.end

base sd:0xa035300c
tree "2MCTL_PLL_CTL"
group 0--3
line.long 0 "MCTL_PLL_CTL"
bitfld.long 0 0.--7. " PLL_MULT "  " "
bitfld.long 0 8.--13. " PLL_OUT_DIV "  " "
bitfld.long 0 14.--16. " PLL_IN_DIV "  " "
bitfld.long 0 17. " PLL_SEL_DIV2 "  "0 ,1 "
bitfld.long 0 18. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 31. " PLL_MASTER "  "0 ,1 "
tree.end

base sd:0xa0353010
tree "2MCTL_LANE_STS"
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  " "
bitfld.long 0 2.--4. " DATLANE1_STATE "  " "
bitfld.long 0 5.--6. " DATLANE2_STATE "  " "
tree.end

base sd:0xa0353014
tree "2MCTL_DPHY_TIMEOUT"
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT"
bitfld.long 0 0.--3. " CLK_DIV "  " "
bitfld.long 0 4.--17. " HSTX_TO_VAL "  " "
bitfld.long 0 18.--31. " LPRX_TO_VAL "  " "
tree.end

base sd:0xa0353018
tree "2MCTL_ULPOUT_TIME"
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
tree.end

base sd:0xa035301c
tree "2MCTL_DPHY_STATIC"
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6.--11. " UI_X4 "  " "
tree.end

base sd:0xa0353020
tree "2MCTL_MAIN_EN"
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 7. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 8. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " IF1_EN "  "0 ,1 "
bitfld.long 0 10. " IF2_EN "  "0 ,1 "
tree.end

base sd:0xa0353024
tree "2MCTL_MAIN_STS"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK "  "0 ,1 "
tree.end

base sd:0xa0353028
tree "2MCTL_DPHY_ERR"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2 "  "0 ,1 "
tree.end

base sd:0xa0353030
tree "2INT_VID_RDDATA"
group 0--3
line.long 0 "INT_VID_RDDATA"
bitfld.long 0 0.--15. " IF_DATA "  " "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
tree.end

base sd:0xa0353034
tree "2INT_VID_GNT"
group 0--3
line.long 0 "INT_VID_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
tree.end

base sd:0xa0353038
tree "2INT_CMD_RDDATA"
group 0--3
line.long 0 "INT_CMD_RDDATA"
bitfld.long 0 0.--15. " IF_DATA "  " "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
tree.end

base sd:0xa035303c
tree "2INT_CMD_GNT"
group 0--3
line.long 0 "INT_CMD_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
tree.end

base sd:0xa0353040
tree "2INT_INTERRUPT_CTL"
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
tree.end

base sd:0xa0353050
tree "2CMD_MODE_CTL"
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  " "
bitfld.long 0 2.--3. " IF2_ID "  " "
bitfld.long 0 4. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 5. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 6. " ARB_MODE "  "0 ,1 "
bitfld.long 0 7. " ARB_PRI "  "0 ,1 "
bitfld.long 0 8.--15. " FIL_VALUE "  " "
bitfld.long 0 16.--25. " TE_TIMEOUT "  " "
tree.end

base sd:0xa0353054
tree "2CMD_MODE_STS"
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING "  "0 ,1 "
tree.end

base sd:0xa0353060
tree "2DIRECT_CMD_SEND"
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
tree.end

base sd:0xa0353064
tree "2DIRECT_CMD_MAIN_SETTINGS"
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  " "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  " "
bitfld.long 0 14.--15. " CMD_ID "  " "
bitfld.long 0 16.--20. " CMD_SIZE "  " "
bitfld.long 0 21. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 24.--27. " TRIGGER_VAL "  " "
tree.end

base sd:0xa0353068
tree "2DIRECT_CMD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  " "
bitfld.long 0 16.--31. " ACK_VAL "  " "
tree.end

base sd:0xa035306c
tree "2DIRECT_CMD_RD_INIT"
group 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
bitfld.long 0 0.--15. " CMD_RD_INIT "  " "
tree.end

base sd:0xa0353070
tree "2DIRECT_CMD_WRDAT0"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT0"
bitfld.long 0 0.--7. " WRDAT0 "  " "
bitfld.long 0 8.--15. " WRDAT1 "  " "
bitfld.long 0 16.--23. " WRDAT2 "  " "
bitfld.long 0 24.--31. " WRDAT3 "  " "
tree.end

base sd:0xa0353074
tree "2DIRECT_CMD_WRDAT1"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT1"
bitfld.long 0 0.--7. " WRDAT4 "  " "
bitfld.long 0 8.--15. " WRDAT5 "  " "
bitfld.long 0 16.--23. " WRDAT6 "  " "
bitfld.long 0 24.--31. " WRDAT7 "  " "
tree.end

base sd:0xa0353078
tree "2DIRECT_CMD_WRDAT2"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT2"
bitfld.long 0 0.--7. " WRDAT8 "  " "
bitfld.long 0 8.--15. " WRDAT9 "  " "
bitfld.long 0 16.--23. " WRDAT10 "  " "
bitfld.long 0 24.--31. " WRDAT11 "  " "
tree.end

base sd:0xa035307c
tree "2DIRECT_CMD_WRDAT3"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT3"
bitfld.long 0 0.--7. " WRDAT12 "  " "
bitfld.long 0 8.--15. " WRDAT13 "  " "
bitfld.long 0 16.--23. " WRDAT14 "  " "
bitfld.long 0 24.--31. " WRDAT15 "  " "
tree.end

base sd:0xa0353080
tree "2DIRECT_CMD_RDDAT"
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
bitfld.long 0 0.--7. " RDDAT0 "  " "
bitfld.long 0 8.--15. " RDDAT1 "  " "
bitfld.long 0 16.--23. " RDDAT2 "  " "
bitfld.long 0 24.--31. " RDDAT3 "  " "
tree.end

base sd:0xa0353084
tree "2DIRECT_CMD_RD_PROPERTY"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
bitfld.long 0 0.--15. " RD_SIZE "  " "
bitfld.long 0 16.--17. " RD_ID "  " "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
tree.end

base sd:0xa0353088
tree "2DIRECT_CMD_RD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
tree.end

base sd:0xa0353090
tree "2VID_MAIN_CTL"
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  " "
bitfld.long 0 2.--3. " STOP_MODE "  " "
bitfld.long 0 4.--5. " VID_ID "  " "
bitfld.long 0 6.--11. " HEADER "  " "
bitfld.long 0 12.--13. " VID_PIXEL_MODE "  " "
bitfld.long 0 14. " BURST_MODE "  "0 ,1 "
bitfld.long 0 15. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 16. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 17.--18. " REG_BLKLINE_MODE "  " "
bitfld.long 0 19.--20. " REG_BLKEOL_MODE "  " "
bitfld.long 0 21.--22. " RECOVERY_MODE "  " "
tree.end

base sd:0xa0353094
tree "2VID_VSIZE"
group 0--3
line.long 0 "VID_VSIZE"
bitfld.long 0 0.--5. " VSA_LENGTH "  " "
bitfld.long 0 6.--11. " VBP_LENGTH "  " "
bitfld.long 0 12.--19. " VFP_LENGTH "  " "
bitfld.long 0 20.--30. " VACT_LENGTH "  " "
tree.end

base sd:0xa0353098
tree "2VID_HSIZE1"
group 0--3
line.long 0 "VID_HSIZE1"
bitfld.long 0 0.--9. " HSA_LENGTH "  " "
bitfld.long 0 10.--19. " HBP_LENGTH "  " "
bitfld.long 0 20.--30. " HFP_LENGTH "  " "
tree.end

base sd:0xa035309c
tree "2VID_HSIZE2"
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--12. " RGB_SIZE "  " "
tree.end

base sd:0xa03530a0
tree "2VID_BLKSIZE1"
group 0--3
line.long 0 "VID_BLKSIZE1"
bitfld.long 0 0.--12. " BLKLINE_EVENT_PCK "  " "
bitfld.long 0 13.--25. " BLKEOL_PCK "  " "
tree.end

base sd:0xa03530a4
tree "2VID_BLKSIZE2"
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
tree.end

base sd:0xa03530a8
tree "2VID_PCK_TIME"
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
tree.end

base sd:0xa03530ac
tree "2VID_DPHY_TIME"
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
tree.end

base sd:0xa03530b0
tree "2VID_ERR_COLOR"
group 0--3
line.long 0 "VID_ERR_COLOR"
bitfld.long 0 0.--7. " COL_RED "  " "
bitfld.long 0 8.--15. " COL_GREEN "  " "
bitfld.long 0 16.--23. " COL_BLUE "  " "
bitfld.long 0 24.--31. " PAD_VAL "  " "
tree.end

base sd:0xa03530b4
tree "2VID_VPOS"
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  " "
bitfld.long 0 2.--12. " LINE_VAL "  " "
tree.end

base sd:0xa03530b8
tree "2VID_HPOS"
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  " "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
tree.end

base sd:0xa03530bc
tree "2VID_MODE_STS"
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY "  "0 ,1 "
tree.end

base sd:0xa03530c0
tree "2VID_VCA_SETTING1"
group 0--3
line.long 0 "VID_VCA_SETTING1"
bitfld.long 0 0.--15. " MAX_BURST_LIMIT "  " "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
tree.end

base sd:0xa03530c4
tree "2VID_VCA_SETTING2"
group 0--3
line.long 0 "VID_VCA_SETTING2"
bitfld.long 0 0.--15. " EXACT_BURST_LIMIT "  " "
bitfld.long 0 16.--31. " MAX_LINE_LIMIT "  " "
tree.end

base sd:0xa03530c8
tree "2TVG_CTL"
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  " "
bitfld.long 0 3.--4. " TVG_MODE "  " "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  " "
tree.end

base sd:0xa03530cc
tree "2TVG_IMG_SIZE"
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--12. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--26. " TVG_NBLINE "  " "
tree.end

base sd:0xa03530d0
tree "2TVG_COLOR1"
group 0--3
line.long 0 "TVG_COLOR1"
bitfld.long 0 0.--7. " COL1_RED "  " "
bitfld.long 0 8.--15. " COL1_GREEN "  " "
bitfld.long 0 16.--23. " COL1_BLUE "  " "
tree.end

base sd:0xa03530d4
tree "2TVG_COLOR2"
group 0--3
line.long 0 "TVG_COLOR2"
bitfld.long 0 0.--7. " COL2_RED "  " "
bitfld.long 0 8.--15. " COL2_GREEN "  " "
bitfld.long 0 16.--23. " COL2_BLUE "  " "
tree.end

base sd:0xa03530d8
tree "2TVG_STS"
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
tree.end

base sd:0xa03530e0
tree "2TBG_CTL"
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  " "
tree.end

base sd:0xa03530e4
tree "2TBG_SETTING"
group 0--3
line.long 0 "TBG_SETTING"
bitfld.long 0 0.--15. " TBG_DATA "  " "
bitfld.long 0 16.--27. " TBG_CPT "  " "
tree.end

base sd:0xa03530e8
tree "2TBG_STS"
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
tree.end

base sd:0xa03530f0
tree "2MCTL_MAIN_STS_CTL"
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 21. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " CRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " VRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
tree.end

base sd:0xa03530f4
tree "2CMD_MODE_STS_CTL"
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SDI1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SDI2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 21. " CSM_RUNNING_EDGE "  "0 ,1 "
tree.end

base sd:0xa03530f8
tree "2DIRECT_CMD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
tree.end

base sd:0xa03530fc
tree "2DIRECT_CMD_RD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
tree.end

base sd:0xa0353100
tree "2VID_MODE_STS_CTL"
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGTH_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 26. " VSG_RECOVERY_EDGE "  "0 ,1 "
tree.end

base sd:0xa0353104
tree "2TG_STS_CTL"
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
tree.end

base sd:0xa0353108
tree "2MCTL_DPHY_ERR_CTL"
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL"
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 22. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 26. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 27. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 28. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 29. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 30. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 31. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
tree.end

base sd:0xa0353110
tree "2MCTL_MAIN_STS_CLR"
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
tree.end

base sd:0xa0353114
tree "2CMD_MODE_STS_CLR"
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_CLR "  "0 ,1 "
tree.end

base sd:0xa0353118
tree "2DIRECT_CMD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
tree.end

base sd:0xa035311c
tree "2DIRECT_CMD_RD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
tree.end

base sd:0xa0353120
tree "2VID_MODE_STS_CLR"
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_CLR "  "0 ,1 "
tree.end

base sd:0xa0353124
tree "2TG_STS_CLR"
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
tree.end

base sd:0xa0353128
tree "2MCTL_DPHY_ERR_CLR"
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
tree.end

base sd:0xa0353130
tree "2MCTL_MAIN_STS_FLAG"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
tree.end

base sd:0xa0353134
tree "2CMD_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_FLAG "  "0 ,1 "
tree.end

base sd:0xa0353138
tree "2DIRECT_CMD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
tree.end

base sd:0xa035313c
tree "2DIRECT_CMD_RD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
tree.end

base sd:0xa0353140
tree "2VID_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 10. " FLAG_VSG_RECOVERY "  "0 ,1 "
tree.end

base sd:0xa0353144
tree "2TG_STS_FLAG"
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
tree.end

base sd:0xa0353148
tree "2MCTL_DPHY_ERR_FLAG"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
tree.end

base sd:0xa0353150
tree "2DPHY_LANES_TRIM"
group 0--3
line.long 0 "DPHY_LANES_TRIM"
bitfld.long 0 0.--1. " DPHY_SKEW_DAT1 "  " "
bitfld.long 0 2. " DPHY_CD_OFF_DAT1 "  "0 ,1 "
bitfld.long 0 3. " DPHY_HSTX_SLEWRATE_DOWN_DAT1 "  "0 ,1 "
bitfld.long 0 4. " DPHY_HSTX_SLEWRATE_UP_DAT1 "  "0 ,1 "
bitfld.long 0 5. " DPHY_TEST_RESERVED_1_DAT1 "  "0 ,1 "
bitfld.long 0 6.--7. " DPHY_SKEW_CLK "  " "
bitfld.long 0 8.--9. " DPHY_LP_RX_VIL_CLK "  " "
bitfld.long 0 10.--11. " DPHY_LP_TX_SLEWRATE_CLK "  " "
bitfld.long 0 12. " DPHY_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 13. " DPHY_HSTX_SLEWRATE_DOWN_CLK "  "0 ,1 "
bitfld.long 0 14. " DPHY_HSTX_SLEWRATE_UP_CLK "  "0 ,1 "
bitfld.long 0 15. " DPHY_TEST_RESERVED_1_CLK "  "0 ,1 "
bitfld.long 0 16.--17. " DPHY_SKEW_DAT2 "  " "
bitfld.long 0 18. " DPHY_HSTX_SLEWRATE_DOWN_DAT2 "  "0 ,1 "
bitfld.long 0 19. " DPHY_HSTX_SLEWRATE_UP_DAT2 "  "0 ,1 "
bitfld.long 0 20. " DPHY_TEST_RESERVED_1_DAT2 "  "0 ,1 "
tree.end

base sd:0xa0353ff0
tree "2ID_REG"
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  " "
bitfld.long 0 4.--7. " X "  " "
bitfld.long 0 8.--11. " H "  " "
bitfld.long 0 12.--19. " PRODUCT_ID "  " "
bitfld.long 0 20.--31. " VENDOR_ID "  " "
tree.end

base sd:0xa0353ff4
tree "2IP_CONF"
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " FIFO_SIZE "  " "
tree.end

tree.end

base sd:0xa0352000
;********************************************
tree "DSI-1"
;********************************************
base sd:0xa0352000
tree "1MCTL_INTEGRATION_MODE"
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
tree.end

base sd:0xa0352004
tree "1MCTL_MAIN_DATA_CTL"
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF1_MODE "  "0 ,1 "
bitfld.long 0 2. " VID_EN "  "0 ,1 "
bitfld.long 0 3. " TVG_SEL "  "0 ,1 "
bitfld.long 0 4. " TBG_SEL "  "0 ,1 "
bitfld.long 0 5. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 6. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 7. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 8. " READ_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_EN "  "0 ,1 "
bitfld.long 0 10. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 11. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 12. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 13. " DISP_EOT_GEN "  "0 ,1 "
tree.end

base sd:0xa0352008
tree "1MCTL_MAIN_PHY_CTL"
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 2. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 3. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 6.--9. " WAIT_BURST_TIME "  " "
bitfld.long 0 10. " CLK_FORCE_STOP "  "0 ,1 "
tree.end

base sd:0xa035200c
tree "1MCTL_PLL_CTL"
group 0--3
line.long 0 "MCTL_PLL_CTL"
bitfld.long 0 0.--7. " PLL_MULT "  " "
bitfld.long 0 8.--13. " PLL_OUT_DIV "  " "
bitfld.long 0 14.--16. " PLL_IN_DIV "  " "
bitfld.long 0 17. " PLL_SEL_DIV2 "  "0 ,1 "
bitfld.long 0 18. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 31. " PLL_MASTER "  "0 ,1 "
tree.end

base sd:0xa0352010
tree "1MCTL_LANE_STS"
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  " "
bitfld.long 0 2.--4. " DATLANE1_STATE "  " "
bitfld.long 0 5.--6. " DATLANE2_STATE "  " "
tree.end

base sd:0xa0352014
tree "1MCTL_DPHY_TIMEOUT"
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT"
bitfld.long 0 0.--3. " CLK_DIV "  " "
bitfld.long 0 4.--17. " HSTX_TO_VAL "  " "
bitfld.long 0 18.--31. " LPRX_TO_VAL "  " "
tree.end

base sd:0xa0352018
tree "1MCTL_ULPOUT_TIME"
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
tree.end

base sd:0xa035201c
tree "1MCTL_DPHY_STATIC"
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6.--11. " UI_X4 "  " "
tree.end

base sd:0xa0352020
tree "1MCTL_MAIN_EN"
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 7. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 8. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " IF1_EN "  "0 ,1 "
bitfld.long 0 10. " IF2_EN "  "0 ,1 "
tree.end

base sd:0xa0352024
tree "1MCTL_MAIN_STS"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK "  "0 ,1 "
tree.end

base sd:0xa0352028
tree "1MCTL_DPHY_ERR"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2 "  "0 ,1 "
tree.end

base sd:0xa0352030
tree "1INT_VID_RDDATA"
group 0--3
line.long 0 "INT_VID_RDDATA"
bitfld.long 0 0.--15. " IF_DATA "  " "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
tree.end

base sd:0xa0352034
tree "1INT_VID_GNT"
group 0--3
line.long 0 "INT_VID_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
tree.end

base sd:0xa0352038
tree "1INT_CMD_RDDATA"
group 0--3
line.long 0 "INT_CMD_RDDATA"
bitfld.long 0 0.--15. " IF_DATA "  " "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
tree.end

base sd:0xa035203c
tree "1INT_CMD_GNT"
group 0--3
line.long 0 "INT_CMD_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
tree.end

base sd:0xa0352040
tree "1INT_INTERRUPT_CTL"
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
tree.end

base sd:0xa0352050
tree "1CMD_MODE_CTL"
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  " "
bitfld.long 0 2.--3. " IF2_ID "  " "
bitfld.long 0 4. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 5. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 6. " ARB_MODE "  "0 ,1 "
bitfld.long 0 7. " ARB_PRI "  "0 ,1 "
bitfld.long 0 8.--15. " FIL_VALUE "  " "
bitfld.long 0 16.--25. " TE_TIMEOUT "  " "
tree.end

base sd:0xa0352054
tree "1CMD_MODE_STS"
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING "  "0 ,1 "
tree.end

base sd:0xa0352060
tree "1DIRECT_CMD_SEND"
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
tree.end

base sd:0xa0352064
tree "1DIRECT_CMD_MAIN_SETTINGS"
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  " "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  " "
bitfld.long 0 14.--15. " CMD_ID "  " "
bitfld.long 0 16.--20. " CMD_SIZE "  " "
bitfld.long 0 21. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 24.--27. " TRIGGER_VAL "  " "
tree.end

base sd:0xa0352068
tree "1DIRECT_CMD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  " "
bitfld.long 0 16.--31. " ACK_VAL "  " "
tree.end

base sd:0xa035206c
tree "1DIRECT_CMD_RD_INIT"
group 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
bitfld.long 0 0.--15. " CMD_RD_INIT "  " "
tree.end

base sd:0xa0352070
tree "1DIRECT_CMD_WRDAT0"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT0"
bitfld.long 0 0.--7. " WRDAT0 "  " "
bitfld.long 0 8.--15. " WRDAT1 "  " "
bitfld.long 0 16.--23. " WRDAT2 "  " "
bitfld.long 0 24.--31. " WRDAT3 "  " "
tree.end

base sd:0xa0352074
tree "1DIRECT_CMD_WRDAT1"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT1"
bitfld.long 0 0.--7. " WRDAT4 "  " "
bitfld.long 0 8.--15. " WRDAT5 "  " "
bitfld.long 0 16.--23. " WRDAT6 "  " "
bitfld.long 0 24.--31. " WRDAT7 "  " "
tree.end

base sd:0xa0352078
tree "1DIRECT_CMD_WRDAT2"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT2"
bitfld.long 0 0.--7. " WRDAT8 "  " "
bitfld.long 0 8.--15. " WRDAT9 "  " "
bitfld.long 0 16.--23. " WRDAT10 "  " "
bitfld.long 0 24.--31. " WRDAT11 "  " "
tree.end

base sd:0xa035207c
tree "1DIRECT_CMD_WRDAT3"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT3"
bitfld.long 0 0.--7. " WRDAT12 "  " "
bitfld.long 0 8.--15. " WRDAT13 "  " "
bitfld.long 0 16.--23. " WRDAT14 "  " "
bitfld.long 0 24.--31. " WRDAT15 "  " "
tree.end

base sd:0xa0352080
tree "1DIRECT_CMD_RDDAT"
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
bitfld.long 0 0.--7. " RDDAT0 "  " "
bitfld.long 0 8.--15. " RDDAT1 "  " "
bitfld.long 0 16.--23. " RDDAT2 "  " "
bitfld.long 0 24.--31. " RDDAT3 "  " "
tree.end

base sd:0xa0352084
tree "1DIRECT_CMD_RD_PROPERTY"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
bitfld.long 0 0.--15. " RD_SIZE "  " "
bitfld.long 0 16.--17. " RD_ID "  " "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
tree.end

base sd:0xa0352088
tree "1DIRECT_CMD_RD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
tree.end

base sd:0xa0352090
tree "1VID_MAIN_CTL"
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  " "
bitfld.long 0 2.--3. " STOP_MODE "  " "
bitfld.long 0 4.--5. " VID_ID "  " "
bitfld.long 0 6.--11. " HEADER "  " "
bitfld.long 0 12.--13. " VID_PIXEL_MODE "  " "
bitfld.long 0 14. " BURST_MODE "  "0 ,1 "
bitfld.long 0 15. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 16. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 17.--18. " REG_BLKLINE_MODE "  " "
bitfld.long 0 19.--20. " REG_BLKEOL_MODE "  " "
bitfld.long 0 21.--22. " RECOVERY_MODE "  " "
tree.end

base sd:0xa0352094
tree "1VID_VSIZE"
group 0--3
line.long 0 "VID_VSIZE"
bitfld.long 0 0.--5. " VSA_LENGTH "  " "
bitfld.long 0 6.--11. " VBP_LENGTH "  " "
bitfld.long 0 12.--19. " VFP_LENGTH "  " "
bitfld.long 0 20.--30. " VACT_LENGTH "  " "
tree.end

base sd:0xa0352098
tree "1VID_HSIZE1"
group 0--3
line.long 0 "VID_HSIZE1"
bitfld.long 0 0.--9. " HSA_LENGTH "  " "
bitfld.long 0 10.--19. " HBP_LENGTH "  " "
bitfld.long 0 20.--30. " HFP_LENGTH "  " "
tree.end

base sd:0xa035209c
tree "1VID_HSIZE2"
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--12. " RGB_SIZE "  " "
tree.end

base sd:0xa03520a0
tree "1VID_BLKSIZE1"
group 0--3
line.long 0 "VID_BLKSIZE1"
bitfld.long 0 0.--12. " BLKLINE_EVENT_PCK "  " "
bitfld.long 0 13.--25. " BLKEOL_PCK "  " "
tree.end

base sd:0xa03520a4
tree "1VID_BLKSIZE2"
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
tree.end

base sd:0xa03520a8
tree "1VID_PCK_TIME"
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
tree.end

base sd:0xa03520ac
tree "1VID_DPHY_TIME"
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
tree.end

base sd:0xa03520b0
tree "1VID_ERR_COLOR"
group 0--3
line.long 0 "VID_ERR_COLOR"
bitfld.long 0 0.--7. " COL_RED "  " "
bitfld.long 0 8.--15. " COL_GREEN "  " "
bitfld.long 0 16.--23. " COL_BLUE "  " "
bitfld.long 0 24.--31. " PAD_VAL "  " "
tree.end

base sd:0xa03520b4
tree "1VID_VPOS"
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  " "
bitfld.long 0 2.--12. " LINE_VAL "  " "
tree.end

base sd:0xa03520b8
tree "1VID_HPOS"
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  " "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
tree.end

base sd:0xa03520bc
tree "1VID_MODE_STS"
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY "  "0 ,1 "
tree.end

base sd:0xa03520c0
tree "1VID_VCA_SETTING1"
group 0--3
line.long 0 "VID_VCA_SETTING1"
bitfld.long 0 0.--15. " MAX_BURST_LIMIT "  " "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
tree.end

base sd:0xa03520c4
tree "1VID_VCA_SETTING2"
group 0--3
line.long 0 "VID_VCA_SETTING2"
bitfld.long 0 0.--15. " EXACT_BURST_LIMIT "  " "
bitfld.long 0 16.--31. " MAX_LINE_LIMIT "  " "
tree.end

base sd:0xa03520c8
tree "1TVG_CTL"
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  " "
bitfld.long 0 3.--4. " TVG_MODE "  " "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  " "
tree.end

base sd:0xa03520cc
tree "1TVG_IMG_SIZE"
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--12. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--26. " TVG_NBLINE "  " "
tree.end

base sd:0xa03520d0
tree "1TVG_COLOR1"
group 0--3
line.long 0 "TVG_COLOR1"
bitfld.long 0 0.--7. " COL1_RED "  " "
bitfld.long 0 8.--15. " COL1_GREEN "  " "
bitfld.long 0 16.--23. " COL1_BLUE "  " "
tree.end

base sd:0xa03520d4
tree "1TVG_COLOR2"
group 0--3
line.long 0 "TVG_COLOR2"
bitfld.long 0 0.--7. " COL2_RED "  " "
bitfld.long 0 8.--15. " COL2_GREEN "  " "
bitfld.long 0 16.--23. " COL2_BLUE "  " "
tree.end

base sd:0xa03520d8
tree "1TVG_STS"
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
tree.end

base sd:0xa03520e0
tree "1TBG_CTL"
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  " "
tree.end

base sd:0xa03520e4
tree "1TBG_SETTING"
group 0--3
line.long 0 "TBG_SETTING"
bitfld.long 0 0.--15. " TBG_DATA "  " "
bitfld.long 0 16.--27. " TBG_CPT "  " "
tree.end

base sd:0xa03520e8
tree "1TBG_STS"
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
tree.end

base sd:0xa03520f0
tree "1MCTL_MAIN_STS_CTL"
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 21. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " CRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " VRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
tree.end

base sd:0xa03520f4
tree "1CMD_MODE_STS_CTL"
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SDI1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SDI2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 21. " CSM_RUNNING_EDGE "  "0 ,1 "
tree.end

base sd:0xa03520f8
tree "1DIRECT_CMD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
tree.end

base sd:0xa03520fc
tree "1DIRECT_CMD_RD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
tree.end

base sd:0xa0352100
tree "1VID_MODE_STS_CTL"
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGTH_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 26. " VSG_RECOVERY_EDGE "  "0 ,1 "
tree.end

base sd:0xa0352104
tree "1TG_STS_CTL"
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
tree.end

base sd:0xa0352108
tree "1MCTL_DPHY_ERR_CTL"
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL"
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 22. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 26. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 27. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 28. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 29. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 30. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 31. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
tree.end

base sd:0xa0352110
tree "1MCTL_MAIN_STS_CLR"
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
tree.end

base sd:0xa0352114
tree "1CMD_MODE_STS_CLR"
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_CLR "  "0 ,1 "
tree.end

base sd:0xa0352118
tree "1DIRECT_CMD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
tree.end

base sd:0xa035211c
tree "1DIRECT_CMD_RD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
tree.end

base sd:0xa0352120
tree "1VID_MODE_STS_CLR"
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_CLR "  "0 ,1 "
tree.end

base sd:0xa0352124
tree "1TG_STS_CLR"
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
tree.end

base sd:0xa0352128
tree "1MCTL_DPHY_ERR_CLR"
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
tree.end

base sd:0xa0352130
tree "1MCTL_MAIN_STS_FLAG"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
tree.end

base sd:0xa0352134
tree "1CMD_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_FLAG "  "0 ,1 "
tree.end

base sd:0xa0352138
tree "1DIRECT_CMD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
tree.end

base sd:0xa035213c
tree "1DIRECT_CMD_RD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
tree.end

base sd:0xa0352140
tree "1VID_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 10. " FLAG_VSG_RECOVERY "  "0 ,1 "
tree.end

base sd:0xa0352144
tree "1TG_STS_FLAG"
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
tree.end

base sd:0xa0352148
tree "1MCTL_DPHY_ERR_FLAG"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
tree.end

base sd:0xa0352150
tree "1DPHY_LANES_TRIM"
group 0--3
line.long 0 "DPHY_LANES_TRIM"
bitfld.long 0 0.--1. " DPHY_SKEW_DAT1 "  " "
bitfld.long 0 2. " DPHY_CD_OFF_DAT1 "  "0 ,1 "
bitfld.long 0 3. " DPHY_HSTX_SLEWRATE_DOWN_DAT1 "  "0 ,1 "
bitfld.long 0 4. " DPHY_HSTX_SLEWRATE_UP_DAT1 "  "0 ,1 "
bitfld.long 0 5. " DPHY_TEST_RESERVED_1_DAT1 "  "0 ,1 "
bitfld.long 0 6.--7. " DPHY_SKEW_CLK "  " "
bitfld.long 0 8.--9. " DPHY_LP_RX_VIL_CLK "  " "
bitfld.long 0 10.--11. " DPHY_LP_TX_SLEWRATE_CLK "  " "
bitfld.long 0 12. " DPHY_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 13. " DPHY_HSTX_SLEWRATE_DOWN_CLK "  "0 ,1 "
bitfld.long 0 14. " DPHY_HSTX_SLEWRATE_UP_CLK "  "0 ,1 "
bitfld.long 0 15. " DPHY_TEST_RESERVED_1_CLK "  "0 ,1 "
bitfld.long 0 16.--17. " DPHY_SKEW_DAT2 "  " "
bitfld.long 0 18. " DPHY_HSTX_SLEWRATE_DOWN_DAT2 "  "0 ,1 "
bitfld.long 0 19. " DPHY_HSTX_SLEWRATE_UP_DAT2 "  "0 ,1 "
bitfld.long 0 20. " DPHY_TEST_RESERVED_1_DAT2 "  "0 ,1 "
tree.end

base sd:0xa0352ff0
tree "1ID_REG"
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  " "
bitfld.long 0 4.--7. " X "  " "
bitfld.long 0 8.--11. " H "  " "
bitfld.long 0 12.--19. " PRODUCT_ID "  " "
bitfld.long 0 20.--31. " VENDOR_ID "  " "
tree.end

base sd:0xa0352ff4
tree "1IP_CONF"
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " FIFO_SIZE "  " "
tree.end

tree.end

base sd:0xa0351000
;********************************************
tree "DSI-0"
;********************************************
base sd:0xa0351000
tree "0MCTL_INTEGRATION_MODE"
group 0--3
line.long 0 "MCTL_INTEGRATION_MODE"
bitfld.long 0 0. " INT_MODE_EN "  "0 ,1 "
tree.end

base sd:0xa0351004
tree "0MCTL_MAIN_DATA_CTL"
group 0--3
line.long 0 "MCTL_MAIN_DATA_CTL"
bitfld.long 0 0. " LINK_EN "  "0 ,1 "
bitfld.long 0 1. " IF1_MODE "  "0 ,1 "
bitfld.long 0 2. " VID_EN "  "0 ,1 "
bitfld.long 0 3. " TVG_SEL "  "0 ,1 "
bitfld.long 0 4. " TBG_SEL "  "0 ,1 "
bitfld.long 0 5. " IF1_TE_EN "  "0 ,1 "
bitfld.long 0 6. " IF2_TE_EN "  "0 ,1 "
bitfld.long 0 7. " REG_TE_EN "  "0 ,1 "
bitfld.long 0 8. " READ_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_EN "  "0 ,1 "
bitfld.long 0 10. " DISP_GEN_ECC "  "0 ,1 "
bitfld.long 0 11. " DISP_GEN_CHECKSUM "  "0 ,1 "
bitfld.long 0 12. " HOST_EOT_GEN "  "0 ,1 "
bitfld.long 0 13. " DISP_EOT_GEN "  "0 ,1 "
tree.end

base sd:0xa0351008
tree "0MCTL_MAIN_PHY_CTL"
group 0--3
line.long 0 "MCTL_MAIN_PHY_CTL"
bitfld.long 0 0. " LANE2_EN "  "0 ,1 "
bitfld.long 0 1. " FORCE_STOP_MODE "  "0 ,1 "
bitfld.long 0 2. " CLK_CONTINUOUS "  "0 ,1 "
bitfld.long 0 3. " CLK_ULPM_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_ULPM_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_ULPM_EN "  "0 ,1 "
bitfld.long 0 6.--9. " WAIT_BURST_TIME "  " "
bitfld.long 0 10. " CLK_FORCE_STOP "  "0 ,1 "
tree.end

base sd:0xa035100c
tree "0MCTL_PLL_CTL"
group 0--3
line.long 0 "MCTL_PLL_CTL"
bitfld.long 0 0.--7. " PLL_MULT "  " "
bitfld.long 0 8.--13. " PLL_OUT_DIV "  " "
bitfld.long 0 14.--16. " PLL_IN_DIV "  " "
bitfld.long 0 17. " PLL_SEL_DIV2 "  "0 ,1 "
bitfld.long 0 18. " PLL_OUT_SEL "  "0 ,1 "
bitfld.long 0 31. " PLL_MASTER "  "0 ,1 "
tree.end

base sd:0xa0351010
tree "0MCTL_LANE_STS"
group 0--3
line.long 0 "MCTL_LANE_STS"
bitfld.long 0 0.--1. " CLKLANE_STATE "  " "
bitfld.long 0 2.--4. " DATLANE1_STATE "  " "
bitfld.long 0 5.--6. " DATLANE2_STATE "  " "
tree.end

base sd:0xa0351014
tree "0MCTL_DPHY_TIMEOUT"
group 0--3
line.long 0 "MCTL_DPHY_TIMEOUT"
bitfld.long 0 0.--3. " CLK_DIV "  " "
bitfld.long 0 4.--17. " HSTX_TO_VAL "  " "
bitfld.long 0 18.--31. " LPRX_TO_VAL "  " "
tree.end

base sd:0xa0351018
tree "0MCTL_ULPOUT_TIME"
group 0--3
line.long 0 "MCTL_ULPOUT_TIME"
bitfld.long 0 0.--8. " CKLANE_ULPOUT_TIME "  " "
bitfld.long 0 9.--17. " DATA_ULPOUT_TIME "  " "
tree.end

base sd:0xa035101c
tree "0MCTL_DPHY_STATIC"
group 0--3
line.long 0 "MCTL_DPHY_STATIC"
bitfld.long 0 0. " SWAP_PINS_CLK "  "0 ,1 "
bitfld.long 0 1. " HS_INVERT_CLK "  "0 ,1 "
bitfld.long 0 2. " SWAP_PINS_DAT1 "  "0 ,1 "
bitfld.long 0 3. " HS_INVERT_DAT1 "  "0 ,1 "
bitfld.long 0 4. " SWAP_PINS_DAT2 "  "0 ,1 "
bitfld.long 0 5. " HS_INVERT_DAT2 "  "0 ,1 "
bitfld.long 0 6.--11. " UI_X4 "  " "
tree.end

base sd:0xa0351020
tree "0MCTL_MAIN_EN"
group 0--3
line.long 0 "MCTL_MAIN_EN"
bitfld.long 0 0. " PLL_START "  "0 ,1 "
bitfld.long 0 3. " CKLANE_EN "  "0 ,1 "
bitfld.long 0 4. " DAT1_EN "  "0 ,1 "
bitfld.long 0 5. " DAT2_EN "  "0 ,1 "
bitfld.long 0 6. " CLKLANE_ULPM_REQ "  "0 ,1 "
bitfld.long 0 7. " DAT1_ULPM_REQ "  "0 ,1 "
bitfld.long 0 8. " DAT2_ULPM_REQ "  "0 ,1 "
bitfld.long 0 9. " IF1_EN "  "0 ,1 "
bitfld.long 0 10. " IF2_EN "  "0 ,1 "
tree.end

base sd:0xa0351024
tree "0MCTL_MAIN_STS"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS"
bitfld.long 0 0. " PLL_LCK "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK "  "0 ,1 "
tree.end

base sd:0xa0351028
tree "0MCTL_DPHY_ERR"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR"
bitfld.long 0 6. " ERR_ESC_1 "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2 "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1 "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2 "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1 "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2 "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1 "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2 "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1 "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2 "  "0 ,1 "
tree.end

base sd:0xa0351030
tree "0INT_VID_RDDATA"
group 0--3
line.long 0 "INT_VID_RDDATA"
bitfld.long 0 0.--15. " IF_DATA "  " "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
tree.end

base sd:0xa0351034
tree "0INT_VID_GNT"
group 0--3
line.long 0 "INT_VID_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
tree.end

base sd:0xa0351038
tree "0INT_CMD_RDDATA"
group 0--3
line.long 0 "INT_CMD_RDDATA"
bitfld.long 0 0.--15. " IF_DATA "  " "
bitfld.long 0 16. " IF_VALID "  "0 ,1 "
bitfld.long 0 17. " IF_START "  "0 ,1 "
bitfld.long 0 18. " IF_FRAME_SYNC "  "0 ,1 "
tree.end

base sd:0xa035103c
tree "0INT_CMD_GNT"
group 0--3
line.long 0 "INT_CMD_GNT"
bitfld.long 0 0. " IF_STALL "  "0 ,1 "
tree.end

base sd:0xa0351040
tree "0INT_INTERRUPT_CTL"
group 0--3
line.long 0 "INT_INTERRUPT_CTL"
bitfld.long 0 0. " INT_VAL "  "0 ,1 "
tree.end

base sd:0xa0351050
tree "0CMD_MODE_CTL"
group 0--3
line.long 0 "CMD_MODE_CTL"
bitfld.long 0 0.--1. " IF1_ID "  " "
bitfld.long 0 2.--3. " IF2_ID "  " "
bitfld.long 0 4. " IF1_LP_EN "  "0 ,1 "
bitfld.long 0 5. " IF2_LP_EN "  "0 ,1 "
bitfld.long 0 6. " ARB_MODE "  "0 ,1 "
bitfld.long 0 7. " ARB_PRI "  "0 ,1 "
bitfld.long 0 8.--15. " FIL_VALUE "  " "
bitfld.long 0 16.--25. " TE_TIMEOUT "  " "
tree.end

base sd:0xa0351054
tree "0CMD_MODE_STS"
rgroup 0--3
line.long 0 "CMD_MODE_STS"
bitfld.long 0 0. " ERR_NO_TE "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING "  "0 ,1 "
tree.end

base sd:0xa0351060
tree "0DIRECT_CMD_SEND"
wgroup 0--3
line.long 0 "DIRECT_CMD_SEND"
bitfld.long 0 0. " DIRECT_CMD_SEND "  "0 ,1 "
tree.end

base sd:0xa0351064
tree "0DIRECT_CMD_MAIN_SETTINGS"
group 0--3
line.long 0 "DIRECT_CMD_MAIN_SETTINGS"
bitfld.long 0 0.--2. " CMD_NAT "  " "
bitfld.long 0 3. " CMD_LONGNOTSHORT "  "0 ,1 "
bitfld.long 0 8.--13. " CMD_HEAD "  " "
bitfld.long 0 14.--15. " CMD_ID "  " "
bitfld.long 0 16.--20. " CMD_SIZE "  " "
bitfld.long 0 21. " CMD_LP_EN "  "0 ,1 "
bitfld.long 0 24.--27. " TRIGGER_VAL "  " "
tree.end

base sd:0xa0351068
tree "0DIRECT_CMD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS"
bitfld.long 0 0. " CMD_TRANSMISSION "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_RECEIVED "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR "  "0 ,1 "
bitfld.long 0 11.--14. " TRIGGER_VAL "  " "
bitfld.long 0 16.--31. " ACK_VAL "  " "
tree.end

base sd:0xa035106c
tree "0DIRECT_CMD_RD_INIT"
group 0--3
line.long 0 "DIRECT_CMD_RD_INIT"
bitfld.long 0 0.--15. " CMD_RD_INIT "  " "
tree.end

base sd:0xa0351070
tree "0DIRECT_CMD_WRDAT0"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT0"
bitfld.long 0 0.--7. " WRDAT0 "  " "
bitfld.long 0 8.--15. " WRDAT1 "  " "
bitfld.long 0 16.--23. " WRDAT2 "  " "
bitfld.long 0 24.--31. " WRDAT3 "  " "
tree.end

base sd:0xa0351074
tree "0DIRECT_CMD_WRDAT1"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT1"
bitfld.long 0 0.--7. " WRDAT4 "  " "
bitfld.long 0 8.--15. " WRDAT5 "  " "
bitfld.long 0 16.--23. " WRDAT6 "  " "
bitfld.long 0 24.--31. " WRDAT7 "  " "
tree.end

base sd:0xa0351078
tree "0DIRECT_CMD_WRDAT2"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT2"
bitfld.long 0 0.--7. " WRDAT8 "  " "
bitfld.long 0 8.--15. " WRDAT9 "  " "
bitfld.long 0 16.--23. " WRDAT10 "  " "
bitfld.long 0 24.--31. " WRDAT11 "  " "
tree.end

base sd:0xa035107c
tree "0DIRECT_CMD_WRDAT3"
group 0--3
line.long 0 "DIRECT_CMD_WRDAT3"
bitfld.long 0 0.--7. " WRDAT12 "  " "
bitfld.long 0 8.--15. " WRDAT13 "  " "
bitfld.long 0 16.--23. " WRDAT14 "  " "
bitfld.long 0 24.--31. " WRDAT15 "  " "
tree.end

base sd:0xa0351080
tree "0DIRECT_CMD_RDDAT"
rgroup 0--3
line.long 0 "DIRECT_CMD_RDDAT"
bitfld.long 0 0.--7. " RDDAT0 "  " "
bitfld.long 0 8.--15. " RDDAT1 "  " "
bitfld.long 0 16.--23. " RDDAT2 "  " "
bitfld.long 0 24.--31. " RDDAT3 "  " "
tree.end

base sd:0xa0351084
tree "0DIRECT_CMD_RD_PROPERTY"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_PROPERTY"
bitfld.long 0 0.--15. " RD_SIZE "  " "
bitfld.long 0 16.--17. " RD_ID "  " "
bitfld.long 0 18. " RD_DCSNOTGENERIC "  "0 ,1 "
tree.end

base sd:0xa0351088
tree "0DIRECT_CMD_RD_STS"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS"
bitfld.long 0 0. " ERR_FIXED "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR "  "0 ,1 "
tree.end

base sd:0xa0351090
tree "0VID_MAIN_CTL"
group 0--3
line.long 0 "VID_MAIN_CTL"
bitfld.long 0 0.--1. " START_MODE "  " "
bitfld.long 0 2.--3. " STOP_MODE "  " "
bitfld.long 0 4.--5. " VID_ID "  " "
bitfld.long 0 6.--11. " HEADER "  " "
bitfld.long 0 12.--13. " VID_PIXEL_MODE "  " "
bitfld.long 0 14. " BURST_MODE "  "0 ,1 "
bitfld.long 0 15. " SYNC_PULSE_ACTIVE "  "0 ,1 "
bitfld.long 0 16. " SYNC_PULSE_HORIZONTAL "  "0 ,1 "
bitfld.long 0 17.--18. " REG_BLKLINE_MODE "  " "
bitfld.long 0 19.--20. " REG_BLKEOL_MODE "  " "
bitfld.long 0 21.--22. " RECOVERY_MODE "  " "
tree.end

base sd:0xa0351094
tree "0VID_VSIZE"
group 0--3
line.long 0 "VID_VSIZE"
bitfld.long 0 0.--5. " VSA_LENGTH "  " "
bitfld.long 0 6.--11. " VBP_LENGTH "  " "
bitfld.long 0 12.--19. " VFP_LENGTH "  " "
bitfld.long 0 20.--30. " VACT_LENGTH "  " "
tree.end

base sd:0xa0351098
tree "0VID_HSIZE1"
group 0--3
line.long 0 "VID_HSIZE1"
bitfld.long 0 0.--9. " HSA_LENGTH "  " "
bitfld.long 0 10.--19. " HBP_LENGTH "  " "
bitfld.long 0 20.--30. " HFP_LENGTH "  " "
tree.end

base sd:0xa035109c
tree "0VID_HSIZE2"
group 0--3
line.long 0 "VID_HSIZE2"
bitfld.long 0 0.--12. " RGB_SIZE "  " "
tree.end

base sd:0xa03510a0
tree "0VID_BLKSIZE1"
group 0--3
line.long 0 "VID_BLKSIZE1"
bitfld.long 0 0.--12. " BLKLINE_EVENT_PCK "  " "
bitfld.long 0 13.--25. " BLKEOL_PCK "  " "
tree.end

base sd:0xa03510a4
tree "0VID_BLKSIZE2"
group 0--3
line.long 0 "VID_BLKSIZE2"
bitfld.long 0 0.--12. " BLKLINE_PULSE_PCK "  " "
tree.end

base sd:0xa03510a8
tree "0VID_PCK_TIME"
group 0--3
line.long 0 "VID_PCK_TIME"
bitfld.long 0 0.--12. " BLKEOL_DURATION "  " "
tree.end

base sd:0xa03510ac
tree "0VID_DPHY_TIME"
group 0--3
line.long 0 "VID_DPHY_TIME"
bitfld.long 0 0.--12. " REG_LINE_DURATION "  " "
bitfld.long 0 13.--23. " REG_WAKEUP_TIME "  " "
tree.end

base sd:0xa03510b0
tree "0VID_ERR_COLOR"
group 0--3
line.long 0 "VID_ERR_COLOR"
bitfld.long 0 0.--7. " COL_RED "  " "
bitfld.long 0 8.--15. " COL_GREEN "  " "
bitfld.long 0 16.--23. " COL_BLUE "  " "
bitfld.long 0 24.--31. " PAD_VAL "  " "
tree.end

base sd:0xa03510b4
tree "0VID_VPOS"
rgroup 0--3
line.long 0 "VID_VPOS"
bitfld.long 0 0.--1. " LINE_POS "  " "
bitfld.long 0 2.--12. " LINE_VAL "  " "
tree.end

base sd:0xa03510b8
tree "0VID_HPOS"
rgroup 0--3
line.long 0 "VID_HPOS"
bitfld.long 0 0.--2. " HORIZONTAL_POS "  " "
bitfld.long 0 3.--15. " HORIZONTAL_VAL "  " "
tree.end

base sd:0xa03510bc
tree "0VID_MODE_STS"
rgroup 0--3
line.long 0 "VID_MODE_STS"
bitfld.long 0 0. " VSG_RUNNING "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC "  "0 ,1 "
bitfld.long 0 4. " REG_ERR_SMALL_LENGTH "  "0 ,1 "
bitfld.long 0 5. " REG_ERR_SMALL_HEIGTH "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY "  "0 ,1 "
tree.end

base sd:0xa03510c0
tree "0VID_VCA_SETTING1"
group 0--3
line.long 0 "VID_VCA_SETTING1"
bitfld.long 0 0.--15. " MAX_BURST_LIMIT "  " "
bitfld.long 0 16. " BURST_LP "  "0 ,1 "
tree.end

base sd:0xa03510c4
tree "0VID_VCA_SETTING2"
group 0--3
line.long 0 "VID_VCA_SETTING2"
bitfld.long 0 0.--15. " EXACT_BURST_LIMIT "  " "
bitfld.long 0 16.--31. " MAX_LINE_LIMIT "  " "
tree.end

base sd:0xa03510c8
tree "0TVG_CTL"
group 0--3
line.long 0 "TVG_CTL"
bitfld.long 0 0. " TVG_RUN "  "0 ,1 "
bitfld.long 0 1.--2. " TVG_STOPMODE "  " "
bitfld.long 0 3.--4. " TVG_MODE "  " "
bitfld.long 0 5.--7. " TVG_STRIPE_SIZE "  " "
tree.end

base sd:0xa03510cc
tree "0TVG_IMG_SIZE"
group 0--3
line.long 0 "TVG_IMG_SIZE"
bitfld.long 0 0.--12. " TVG_LINE_SIZE "  " "
bitfld.long 0 16.--26. " TVG_NBLINE "  " "
tree.end

base sd:0xa03510d0
tree "0TVG_COLOR1"
group 0--3
line.long 0 "TVG_COLOR1"
bitfld.long 0 0.--7. " COL1_RED "  " "
bitfld.long 0 8.--15. " COL1_GREEN "  " "
bitfld.long 0 16.--23. " COL1_BLUE "  " "
tree.end

base sd:0xa03510d4
tree "0TVG_COLOR2"
group 0--3
line.long 0 "TVG_COLOR2"
bitfld.long 0 0.--7. " COL2_RED "  " "
bitfld.long 0 8.--15. " COL2_GREEN "  " "
bitfld.long 0 16.--23. " COL2_BLUE "  " "
tree.end

base sd:0xa03510d8
tree "0TVG_STS"
rgroup 0--3
line.long 0 "TVG_STS"
bitfld.long 0 0. " TVG_RUNNING "  "0 ,1 "
tree.end

base sd:0xa03510e0
tree "0TBG_CTL"
group 0--3
line.long 0 "TBG_CTL"
bitfld.long 0 0. " TBG_START "  "0 ,1 "
bitfld.long 0 1. " TBG_HS_REQ "  "0 ,1 "
bitfld.long 0 2. " TBG_DATA_SEL "  "0 ,1 "
bitfld.long 0 3.--4. " TBG_MODE "  " "
tree.end

base sd:0xa03510e4
tree "0TBG_SETTING"
group 0--3
line.long 0 "TBG_SETTING"
bitfld.long 0 0.--15. " TBG_DATA "  " "
bitfld.long 0 16.--27. " TBG_CPT "  " "
tree.end

base sd:0xa03510e8
tree "0TBG_STS"
rgroup 0--3
line.long 0 "TBG_STS"
bitfld.long 0 0. " TBG_STATUS "  "0 ,1 "
tree.end

base sd:0xa03510f0
tree "0MCTL_MAIN_STS_CTL"
group 0--3
line.long 0 "MCTL_MAIN_STS_CTL"
bitfld.long 0 0. " PLL_LOCK_EN "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_EN "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_EN "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_EN "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " PLL_LOCK_EDGE "  "0 ,1 "
bitfld.long 0 17. " CLKLANE_READY_EDGE "  "0 ,1 "
bitfld.long 0 18. " DAT1_READY_EDGE "  "0 ,1 "
bitfld.long 0 19. " DAT2_READY_EDGE "  "0 ,1 "
bitfld.long 0 20. " HSTX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 21. " LPRX_TO_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " CRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
bitfld.long 0 23. " VRS_UNTERM_PCK_ERR_EDGE "  "0 ,1 "
tree.end

base sd:0xa03510f4
tree "0CMD_MODE_STS_CTL"
group 0--3
line.long 0 "CMD_MODE_STS_CTL"
bitfld.long 0 0. " ERR_NO_TE_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_EN "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_NO_TE_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_TE_MISS_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_SDI1_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_SDI2_UNDERRUN_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_UNWANTED_RD_EDGE "  "0 ,1 "
bitfld.long 0 21. " CSM_RUNNING_EDGE "  "0 ,1 "
tree.end

base sd:0xa03510f8
tree "0DIRECT_CMD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_STS_CTL"
bitfld.long 0 0. " CMD_TRANSMISSION_EN "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_EN "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_EN "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_EN "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " CMD_TRANSMISSION_EDGE "  "0 ,1 "
bitfld.long 0 17. " WRITE_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 18. " TRIGGER_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 19. " READ_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 20. " ACKNOWLEDGE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 21. " ACKNOWLEDGE_WITH_ERR_EDGE "  "0 ,1 "
bitfld.long 0 22. " TRIGGER_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 23. " TE_RECEIVED_EDGE "  "0 ,1 "
bitfld.long 0 24. " BTA_COMPLETED_EDGE "  "0 ,1 "
bitfld.long 0 25. " BTA_FINISHED_EDGE "  "0 ,1 "
bitfld.long 0 26. " READ_COMPLETED_WITH_ERR_EDGE "  "0 ,1 "
tree.end

base sd:0xa03510fc
tree "0DIRECT_CMD_RD_STS_CTL"
group 0--3
line.long 0 "DIRECT_CMD_RD_STS_CTL"
bitfld.long 0 0. " ERR_FIXED_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_EN "  "0 ,1 "
bitfld.long 0 16. " ERR_FIXED_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_UNCORRECTABLE_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_CHECKSUM_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_UNDECODABLE_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_RECEIVE_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_OVERSIZE_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_MISSING_EOT_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_EOT_WITH_ERR_EDGE "  "0 ,1 "
tree.end

base sd:0xa0351100
tree "0VID_MODE_STS_CTL"
group 0--3
line.long 0 "VID_MODE_STS_CTL"
bitfld.long 0 0. " VSG_RUNNING_EN "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_EN "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_EN "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_EN "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_EN "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_EN "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_EN "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_EN "  "0 ,1 "
bitfld.long 0 16. " VSG_RUNNING_EDGE "  "0 ,1 "
bitfld.long 0 17. " ERR_MISSING_DATA_EDGE "  "0 ,1 "
bitfld.long 0 18. " ERR_MISSING_HSYNC_EDGE "  "0 ,1 "
bitfld.long 0 19. " ERR_MISSING_VSYNC_EDGE "  "0 ,1 "
bitfld.long 0 20. " ERR_SMALL_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 21. " ERR_SMALL_HEIGTH_EDGE "  "0 ,1 "
bitfld.long 0 22. " ERR_BURSTWRITE_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_LINEWRITE_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_LONGREAD_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_VRS_WRONG_LENGTH_EDGE "  "0 ,1 "
bitfld.long 0 26. " VSG_RECOVERY_EDGE "  "0 ,1 "
tree.end

base sd:0xa0351104
tree "0TG_STS_CTL"
group 0--3
line.long 0 "TG_STS_CTL"
bitfld.long 0 0. " TVG_STS_EN "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_EN "  "0 ,1 "
bitfld.long 0 16. " TVG_STS_EDGE "  "0 ,1 "
bitfld.long 0 17. " TBG_STS_EDGE "  "0 ,1 "
tree.end

base sd:0xa0351108
tree "0MCTL_DPHY_ERR_CTL"
group 0--3
line.long 0 "MCTL_DPHY_ERR_CTL"
bitfld.long 0 6. " ERR_ESC_1_EN "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_EN "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_EN "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_EN "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_EN "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_EN "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_EN "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_EN "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_EN "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_EN "  "0 ,1 "
bitfld.long 0 22. " ERR_ESC_1_EDGE "  "0 ,1 "
bitfld.long 0 23. " ERR_ESC_2_EDGE "  "0 ,1 "
bitfld.long 0 24. " ERR_SYNCESC_1_EDGE "  "0 ,1 "
bitfld.long 0 25. " ERR_SYNCESC_2_EDGE "  "0 ,1 "
bitfld.long 0 26. " ERR_CONTROL_1_EDGE "  "0 ,1 "
bitfld.long 0 27. " ERR_CONTROL_2_EDGE "  "0 ,1 "
bitfld.long 0 28. " ERR_CONT_LP0_1_EDGE "  "0 ,1 "
bitfld.long 0 29. " ERR_CONT_LP0_2_EDGE "  "0 ,1 "
bitfld.long 0 30. " ERR_CONT_LP1_1_EDGE "  "0 ,1 "
bitfld.long 0 31. " ERR_CONT_LP1_2_EDGE "  "0 ,1 "
tree.end

base sd:0xa0351110
tree "0MCTL_MAIN_STS_CLR"
wgroup 0--3
line.long 0 "MCTL_MAIN_STS_CLR"
bitfld.long 0 0. " PLL_LOCK_CLR "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_CLR "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_CLR "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_CLR "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_CLR "  "0 ,1 "
tree.end

base sd:0xa0351114
tree "0CMD_MODE_STS_CLR"
wgroup 0--3
line.long 0 "CMD_MODE_STS_CLR"
bitfld.long 0 0. " ERR_NO_TE_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_CLR "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_CLR "  "0 ,1 "
tree.end

base sd:0xa0351118
tree "0DIRECT_CMD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_STS_CLR"
bitfld.long 0 0. " CMD_TRANSMISSION_CLR "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 5. " ACKNOWLEDGE_WITH_ERR_CLR "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_CLR "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_CLR "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_CLR "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_CLR "  "0 ,1 "
tree.end

base sd:0xa035111c
tree "0DIRECT_CMD_RD_STS_CLR"
wgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_CLR"
bitfld.long 0 0. " ERR_FIXED_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_CLR "  "0 ,1 "
tree.end

base sd:0xa0351120
tree "0VID_MODE_STS_CLR"
wgroup 0--3
line.long 0 "VID_MODE_STS_CLR"
bitfld.long 0 0. " VSG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_CLR "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_CLR "  "0 ,1 "
bitfld.long 0 3. " ERR_MISSING_VSYNC_CLR "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_CLR "  "0 ,1 "
bitfld.long 0 6. " ERR_BURSTWRITE_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_LINEWRITE_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_CLR "  "0 ,1 "
bitfld.long 0 10. " VSG_RECOVERY_CLR "  "0 ,1 "
tree.end

base sd:0xa0351124
tree "0TG_STS_CLR"
wgroup 0--3
line.long 0 "TG_STS_CLR"
bitfld.long 0 0. " TVG_STS_CLR "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_CLR "  "0 ,1 "
tree.end

base sd:0xa0351128
tree "0MCTL_DPHY_ERR_CLR"
wgroup 0--3
line.long 0 "MCTL_DPHY_ERR_CLR"
bitfld.long 0 6. " ERR_ESC_1_CLR "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_CLR "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_CLR "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_CLR "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_CLR "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_CLR "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_CLR "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_CLR "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_CLR "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_CLR "  "0 ,1 "
tree.end

base sd:0xa0351130
tree "0MCTL_MAIN_STS_FLAG"
rgroup 0--3
line.long 0 "MCTL_MAIN_STS_FLAG"
bitfld.long 0 0. " PLL_LOCK_FLAG "  "0 ,1 "
bitfld.long 0 1. " CLKLANE_READY_FLAG "  "0 ,1 "
bitfld.long 0 2. " DAT1_READY_FLAG "  "0 ,1 "
bitfld.long 0 3. " DAT2_READY_FLAG "  "0 ,1 "
bitfld.long 0 4. " HSTX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 5. " LPRX_TO_ERR_FLAG "  "0 ,1 "
bitfld.long 0 6. " CRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
bitfld.long 0 7. " VRS_UNTERM_PCK_ERR_FLAG "  "0 ,1 "
tree.end

base sd:0xa0351134
tree "0CMD_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "CMD_MODE_STS_FLAG"
bitfld.long 0 0. " ERR_NO_TE_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_TE_MISS_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_SDI1_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_SDI2_UNDERRUN_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_UNWANTED_RD_FLAG "  "0 ,1 "
bitfld.long 0 5. " CSM_RUNNING_FLAG "  "0 ,1 "
tree.end

base sd:0xa0351138
tree "0DIRECT_CMD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_STS_FLAG"
bitfld.long 0 0. " CMD_TRANSMISSION_FLAG "  "0 ,1 "
bitfld.long 0 1. " WRITE_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 2. " TRIGGER_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 3. " READ_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 4. " ACKNOWLEDGE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 5. " ACK_WITH_ERR_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 6. " TRIGGER_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 7. " TE_RECEIVED_FLAG "  "0 ,1 "
bitfld.long 0 8. " BTA_COMPLETED_FLAG "  "0 ,1 "
bitfld.long 0 9. " BTA_FINISHED_FLAG "  "0 ,1 "
bitfld.long 0 10. " READ_COMPLETED_WITH_ERR_FLAG "  "0 ,1 "
tree.end

base sd:0xa035113c
tree "0DIRECT_CMD_RD_STS_FLAG"
rgroup 0--3
line.long 0 "DIRECT_CMD_RD_STS_FLAG"
bitfld.long 0 0. " ERR_FIXED_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_UNCORRECTABLE_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_CHECKSUM_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_UNDECODABLE_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_RECEIVE_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_OVERSIZE_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_MISSING_EOT_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_EOT_WITH_ERR_FLAG "  "0 ,1 "
tree.end

base sd:0xa0351140
tree "0VID_MODE_STS_FLAG"
rgroup 0--3
line.long 0 "VID_MODE_STS_FLAG"
bitfld.long 0 0. " VSG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " ERR_MISSING_DATA_FLAG "  "0 ,1 "
bitfld.long 0 2. " ERR_MISSING_HSYNC_FLAG "  "0 ,1 "
bitfld.long 0 3. " ERR_MISS_VSYNC_FLAG "  "0 ,1 "
bitfld.long 0 4. " ERR_SMALL_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 5. " ERR_SMALL_HEIGTH_FLAG "  "0 ,1 "
bitfld.long 0 6. " ERR_SHORTWRITE_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_LONGWRITE_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_LONGREAD_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_VRS_WRONG_LENGTH_FLAG "  "0 ,1 "
bitfld.long 0 10. " FLAG_VSG_RECOVERY "  "0 ,1 "
tree.end

base sd:0xa0351144
tree "0TG_STS_FLAG"
rgroup 0--3
line.long 0 "TG_STS_FLAG"
bitfld.long 0 0. " TVG_STS_FLAG "  "0 ,1 "
bitfld.long 0 1. " TBG_STS_FLAG "  "0 ,1 "
tree.end

base sd:0xa0351148
tree "0MCTL_DPHY_ERR_FLAG"
rgroup 0--3
line.long 0 "MCTL_DPHY_ERR_FLAG"
bitfld.long 0 6. " ERR_ESC_1_FLAG "  "0 ,1 "
bitfld.long 0 7. " ERR_ESC_2_FLAG "  "0 ,1 "
bitfld.long 0 8. " ERR_SYNCESC_1_FLAG "  "0 ,1 "
bitfld.long 0 9. " ERR_SYNCESC_2_FLAG "  "0 ,1 "
bitfld.long 0 10. " ERR_CONTROL_1_FLAG "  "0 ,1 "
bitfld.long 0 11. " ERR_CONTROL_2_FLAG "  "0 ,1 "
bitfld.long 0 12. " ERR_CONT_LP0_1_FLAG "  "0 ,1 "
bitfld.long 0 13. " ERR_CONT_LP0_2_FLAG "  "0 ,1 "
bitfld.long 0 14. " ERR_CONT_LP1_1_FLAG "  "0 ,1 "
bitfld.long 0 15. " ERR_CONT_LP1_2_FLAG "  "0 ,1 "
tree.end

base sd:0xa0351150
tree "0DPHY_LANES_TRIM"
group 0--3
line.long 0 "DPHY_LANES_TRIM"
bitfld.long 0 0.--1. " DPHY_SKEW_DAT1 "  " "
bitfld.long 0 2. " DPHY_CD_OFF_DAT1 "  "0 ,1 "
bitfld.long 0 3. " DPHY_HSTX_SLEWRATE_DOWN_DAT1 "  "0 ,1 "
bitfld.long 0 4. " DPHY_HSTX_SLEWRATE_UP_DAT1 "  "0 ,1 "
bitfld.long 0 5. " DPHY_TEST_RESERVED_1_DAT1 "  "0 ,1 "
bitfld.long 0 6.--7. " DPHY_SKEW_CLK "  " "
bitfld.long 0 8.--9. " DPHY_LP_RX_VIL_CLK "  " "
bitfld.long 0 10.--11. " DPHY_LP_TX_SLEWRATE_CLK "  " "
bitfld.long 0 12. " DPHY_SPECS_90_81B "  "0 ,1 "
bitfld.long 0 13. " DPHY_HSTX_SLEWRATE_DOWN_CLK "  "0 ,1 "
bitfld.long 0 14. " DPHY_HSTX_SLEWRATE_UP_CLK "  "0 ,1 "
bitfld.long 0 15. " DPHY_TEST_RESERVED_1_CLK "  "0 ,1 "
bitfld.long 0 16.--17. " DPHY_SKEW_DAT2 "  " "
bitfld.long 0 18. " DPHY_HSTX_SLEWRATE_DOWN_DAT2 "  "0 ,1 "
bitfld.long 0 19. " DPHY_HSTX_SLEWRATE_UP_DAT2 "  "0 ,1 "
bitfld.long 0 20. " DPHY_TEST_RESERVED_1_DAT2 "  "0 ,1 "
tree.end

base sd:0xa0351ff0
tree "0ID_REG"
rgroup 0--3
line.long 0 "ID_REG"
bitfld.long 0 0.--3. " Y "  " "
bitfld.long 0 4.--7. " X "  " "
bitfld.long 0 8.--11. " H "  " "
bitfld.long 0 12.--19. " PRODUCT_ID "  " "
bitfld.long 0 20.--31. " VENDOR_ID "  " "
tree.end

base sd:0xa0351ff4
tree "0IP_CONF"
rgroup 0--3
line.long 0 "IP_CONF"
bitfld.long 0 0.--5. " FIFO_SIZE "  " "
tree.end

;tree.end

tree.end

;==============================================================
tree "ETB11"
;==============================================================
base eapb:0x801a4004
tree "RAM_Depth"
rgroup 0--3
line.long 0 "RAM_Depth"
bitfld.long 0 0.--31. " RDP "  " "
tree.end

base eapb:0x801a400c
tree "Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " FULL "  "0 ,1 "
bitfld.long 0 1. " TRIGGERED "  "0 ,1 "
bitfld.long 0 2. " ACQCOMP "  "0 ,1 "
bitfld.long 0 3. " FTEMPTY "  "0 ,1 "
tree.end

base eapb:0x801a4010
tree "RAM_Data"
group 0--3
line.long 0 "RAM_Data"
bitfld.long 0 0.--31. " RAM_READ_DATA "  " "
tree.end

base eapb:0x801a4014
tree "RAM_Read_Pointer"
group 0--3
line.long 0 "RAM_Read_Pointer"
bitfld.long 0 0.--1. " RAM_Read_Pointer "  " "
tree.end

base eapb:0x801a4018
tree "RAM_Write_Pointer"
group 0--3
line.long 0 "RAM_Write_Pointer"
bitfld.long 0 0.--1. " RAM_Write_Pointer "  " "
tree.end

base eapb:0x801a401c
tree "Trigger_Counter"
group 0--3
line.long 0 "Trigger_Counter"
bitfld.long 0 0.--1. " Trigger_Counter "  " "
tree.end

base eapb:0x801a4020
tree "Control"
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " TRACECAPTEN "  "0 ,1 "
tree.end

base eapb:0x801a4024
tree "RAM_WRITE"
wgroup 0--3
line.long 0 "RAM_WRITE"
bitfld.long 0 0.--31. " RAM_WRITE_DATA "  " "
tree.end

base eapb:0x801a4300
tree "FFSR"
rgroup 0--3
line.long 0 "FFSR"
bitfld.long 0 0. " FLINPROG "  "0 ,1 "
bitfld.long 0 1. " FTSTOPPED "  "0 ,1 "
tree.end

base eapb:0x801a4304
tree "DESCRIPTION"
group 0--3
line.long 0 "DESCRIPTION"
bitfld.long 0 0. " ENFTC "  "0 ,1 "
bitfld.long 0 1. " ENFCONT "  "0 ,1 "
bitfld.long 0 4. " FONFLIN "  "0 ,1 "
bitfld.long 0 5. " FONTRIG "  "0 ,1 "
bitfld.long 0 6. " FONMAN "  "0 ,1 "
bitfld.long 0 8. " TRIGIN "  "0 ,1 "
bitfld.long 0 9. " TRIGEVT "  "0 ,1 "
bitfld.long 0 10. " TRGFL "  "0 ,1 "
bitfld.long 0 12. " STOPFL "  "0 ,1 "
bitfld.long 0 13. " STOPTRIG "  "0 ,1 "
tree.end

base eapb:0x801a4ee0
tree "ITMISCOP0"
group 0--3
line.long 0 "ITMISCOP0"
bitfld.long 0 0. " ACQCOMP "  "0 ,1 "
bitfld.long 0 1. " FULL "  "0 ,1 "
tree.end

base eapb:0x801a4ee4
tree "ITTRFLINACK"
group 0--3
line.long 0 "ITTRFLINACK"
bitfld.long 0 0. " TRIGNACK "  "0 ,1 "
bitfld.long 0 1. " FLUSHINACK "  "0 ,1 "
tree.end

base eapb:0x801a4ee8
tree "ITTRFLIN"
group 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0. " TRIGIN "  "0 ,1 "
bitfld.long 0 1. " FLUSHIN "  "0 ,1 "
tree.end

base eapb:0x801a4eec
tree "ITATBDATA0"
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ATDATA[0] "  "0 ,1 "
bitfld.long 0 1. " ATDATA[7] "  "0 ,1 "
bitfld.long 0 2. " ATDATA[15] "  "0 ,1 "
bitfld.long 0 3. " ATDATA[23] "  "0 ,1 "
bitfld.long 0 4. " ATDATA[31] "  "0 ,1 "
tree.end

base eapb:0x801a4ef0
tree "ITATBCTR2"
group 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ATREADYS "  "0 ,1 "
bitfld.long 0 1. " AFVALIDS "  "0 ,1 "
tree.end

base eapb:0x801a4ef4
tree "ITATBCTR1"
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0.--6. " ATID "  " "
tree.end

base eapb:0x801a4ef8
tree "ITATBCTR0"
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ATVALID "  "0 ,1 "
bitfld.long 0 1. " AFREADY "  "0 ,1 "
bitfld.long 0 8.--9. " ATBYTES "  " "
tree.end

base eapb:0x801a4f00
tree "IMCR"
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " IMCR "  "0 ,1 "
tree.end

base eapb:0x801a4fa0
tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0. " CTSR "  "0 ,1 "
tree.end

base eapb:0x801a4fa4
tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0. " CTCR "  "0 ,1 "
tree.end

base eapb:0x801a4fb0
tree "LAR"
group 0--3
line.long 0 "LAR"
bitfld.long 0 0. " LAR "  "0 ,1 "
tree.end

base eapb:0x801a4fb4
tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0. " LSR "  "0 ,1 "
tree.end

base eapb:0x801a4fb8
tree "ASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0. " ASR "  "0 ,1 "
tree.end

base eapb:0x801a4fc8
tree "DID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0. " DID "  "0 ,1 "
tree.end

base eapb:0x801a4fcc
tree "DTIR"
rgroup 0--3
line.long 0 "DTIR"
bitfld.long 0 0. " DTIR "  "0 ,1 "
tree.end

base eapb:0x801a4fd0
tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0. " PERIPHERAL_ID4 "  "0 ,1 "
tree.end

base eapb:0x801a4fd4
tree "PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
tree.end

base eapb:0x801a4fd8
tree "PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
tree.end

base eapb:0x801a4fdc
tree "PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
tree.end

base eapb:0x801a4fe0
tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0. " PERIPHERAL_ID0 "  "0 ,1 "
tree.end

base eapb:0x801a4fe4
tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0. " PERIPHERAL_ID1 "  "0 ,1 "
tree.end

base eapb:0x801a4fe8
tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0. " PERIPHERAL_ID2 "  "0 ,1 "
tree.end

base eapb:0x801a4fec
tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0. " PERIPHERAL_ID3 "  "0 ,1 "
tree.end

base eapb:0x801a4ff0
tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
tree.end

base eapb:0x801a4ff4
tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0. " COMPONENT_ID1 "  "0 ,1 "
tree.end

base eapb:0x801a4ff8
tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0. " COMPONENT_ID2 "  "0 ,1 "
tree.end

base eapb:0x801a4ffc
tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0. " COMPONENT_ID3 "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "FSMC"
;==============================================================
base sd:0x80000000
tree "FSMC_BCR0"
group 0--3
line.long 0 "FSMC_BCR0"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  " "
bitfld.long 0 4.--5. " MWID "  " "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
tree.end

base sd:0x80000008
tree "FSMC_BCR1"
group 0--3
line.long 0 "FSMC_BCR1"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  " "
bitfld.long 0 4.--5. " MWID "  " "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
tree.end

base sd:0x80000010
tree "FSMC_BCR2"
group 0--3
line.long 0 "FSMC_BCR2"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  " "
bitfld.long 0 4.--5. " MWID "  " "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
tree.end

base sd:0x80000018
tree "FSMC_BCR3"
group 0--3
line.long 0 "FSMC_BCR3"
bitfld.long 0 0. " MBKEN "  "0 ,1 "
bitfld.long 0 1. " MUXEN "  "0 ,1 "
bitfld.long 0 2.--3. " MTYP "  " "
bitfld.long 0 4.--5. " MWID "  " "
bitfld.long 0 6. " FRSTLVL "  "0 ,1 "
bitfld.long 0 7. " FWPRLVL "  "0 ,1 "
bitfld.long 0 8. " BURSTEN "  "0 ,1 "
bitfld.long 0 9. " WAITPOL "  "0 ,1 "
bitfld.long 0 10. " WRAPMOD "  "0 ,1 "
bitfld.long 0 11. " WAITCFG "  "0 ,1 "
bitfld.long 0 12. " WREN "  "0 ,1 "
bitfld.long 0 13. " WAITEN "  "0 ,1 "
bitfld.long 0 14. " EXTMOD "  "0 ,1 "
bitfld.long 0 15. " ASYNCWAIT "  "0 ,1 "
bitfld.long 0 19. " CBURSTRW "  "0 ,1 "
tree.end

base sd:0x80000004
tree "FSMC_BTR0"
group 0--3
line.long 0 "FSMC_BTR0"
bitfld.long 0 0.--3. " ADDSET "  " "
bitfld.long 0 4.--7. " ADDHOLD "  " "
bitfld.long 0 8.--15. " DATAST "  " "
bitfld.long 0 16.--19. " BUSTURN "  " "
bitfld.long 0 20.--23. " CLKDIV "  " "
bitfld.long 0 24.--27. " DATLAT "  " "
bitfld.long 0 28.--29. " ACCMOD "  " "
tree.end

base sd:0x8000000c
tree "FSMC_BTR1"
group 0--3
line.long 0 "FSMC_BTR1"
bitfld.long 0 0.--3. " ADDSET "  " "
bitfld.long 0 4.--7. " ADDHOLD "  " "
bitfld.long 0 8.--15. " DATAST "  " "
bitfld.long 0 16.--19. " BUSTURN "  " "
bitfld.long 0 20.--23. " CLKDIV "  " "
bitfld.long 0 24.--27. " DATLAT "  " "
bitfld.long 0 28.--29. " ACCMOD "  " "
tree.end

base sd:0x80000014
tree "FSMC_BTR2"
group 0--3
line.long 0 "FSMC_BTR2"
bitfld.long 0 0.--3. " ADDSET "  " "
bitfld.long 0 4.--7. " ADDHOLD "  " "
bitfld.long 0 8.--15. " DATAST "  " "
bitfld.long 0 16.--19. " BUSTURN "  " "
bitfld.long 0 20.--23. " CLKDIV "  " "
bitfld.long 0 24.--27. " DATLAT "  " "
bitfld.long 0 28.--29. " ACCMOD "  " "
tree.end

base sd:0x8000001c
tree "FSMC_BTR3"
group 0--3
line.long 0 "FSMC_BTR3"
bitfld.long 0 0.--3. " ADDSET "  " "
bitfld.long 0 4.--7. " ADDHOLD "  " "
bitfld.long 0 8.--15. " DATAST "  " "
bitfld.long 0 16.--19. " BUSTURN "  " "
bitfld.long 0 20.--23. " CLKDIV "  " "
bitfld.long 0 24.--27. " DATLAT "  " "
bitfld.long 0 28.--29. " ACCMOD "  " "
tree.end

base sd:0x80000040
tree "FSMC_PCR0"
group 0--3
line.long 0 "FSMC_PCR0"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  " "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  " "
bitfld.long 0 13.--16. " TAR "  " "
bitfld.long 0 17.--19. " ECCPS "  " "
tree.end

base sd:0x80000060
tree "FSMC_PCR1"
group 0--3
line.long 0 "FSMC_PCR1"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  " "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  " "
bitfld.long 0 13.--16. " TAR "  " "
bitfld.long 0 17.--19. " ECCPS "  " "
tree.end

base sd:0x80000080
tree "FSMC_PCR2"
group 0--3
line.long 0 "FSMC_PCR2"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  " "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  " "
bitfld.long 0 13.--16. " TAR "  " "
bitfld.long 0 17.--19. " ECCPS "  " "
tree.end

base sd:0x800000a0
tree "FSMC_PCR3"
group 0--3
line.long 0 "FSMC_PCR3"
bitfld.long 0 0. " PRST "  "0 ,1 "
bitfld.long 0 1. " PWAITEN "  "0 ,1 "
bitfld.long 0 2. " PBKEN "  "0 ,1 "
bitfld.long 0 3. " PTYP "  "0 ,1 "
bitfld.long 0 4.--5. " PWID "  " "
bitfld.long 0 6. " ECCEN "  "0 ,1 "
bitfld.long 0 7. " ECCPLEN "  "0 ,1 "
bitfld.long 0 8. " ADLOW "  "0 ,1 "
bitfld.long 0 9.--12. " TCLR "  " "
bitfld.long 0 13.--16. " TAR "  " "
bitfld.long 0 17.--19. " ECCPS "  " "
tree.end

base sd:0x80000044
tree "FSMC_SR0"
group 0--3
line.long 0 "FSMC_SR0"
bitfld.long 0 6. " FEMPT "  "0 ,1 "
tree.end

base sd:0x80000064
tree "FSMC_SR1"
group 0--3
line.long 0 "FSMC_SR1"
bitfld.long 0 6. " FEMPT "  "0 ,1 "
tree.end

base sd:0x80000048
tree "FSMC_PMEM0"
group 0--3
line.long 0 "FSMC_PMEM0"
bitfld.long 0 0.--7. " SET "  " "
bitfld.long 0 8.--15. " WAIT "  " "
bitfld.long 0 16.--23. " HOLD "  " "
bitfld.long 0 24.--31. " HIZ "  " "
tree.end

base sd:0x80000068
tree "FSMC_PMEM1"
group 0--3
line.long 0 "FSMC_PMEM1"
bitfld.long 0 0.--7. " SET "  " "
bitfld.long 0 8.--15. " WAIT "  " "
bitfld.long 0 16.--23. " HOLD "  " "
bitfld.long 0 24.--31. " HIZ "  " "
tree.end

base sd:0x80000088
tree "FSMC_PMEM2"
group 0--3
line.long 0 "FSMC_PMEM2"
bitfld.long 0 0.--7. " SET "  " "
bitfld.long 0 8.--15. " WAIT "  " "
bitfld.long 0 16.--23. " HOLD "  " "
bitfld.long 0 24.--31. " HIZ "  " "
tree.end

base sd:0x800000a8
tree "FSMC_PMEM3"
group 0--3
line.long 0 "FSMC_PMEM3"
bitfld.long 0 0.--7. " SET "  " "
bitfld.long 0 8.--15. " WAIT "  " "
bitfld.long 0 16.--23. " HOLD "  " "
bitfld.long 0 24.--31. " HIZ "  " "
tree.end

base sd:0x8000004c
tree "FSMC_PATT0"
group 0--3
line.long 0 "FSMC_PATT0"
bitfld.long 0 0.--7. " SET "  " "
bitfld.long 0 8.--15. " WAIT "  " "
bitfld.long 0 16.--23. " HOLD "  " "
bitfld.long 0 24.--31. " HIZ "  " "
tree.end

base sd:0x8000006c
tree "FSMC_PATT1"
group 0--3
line.long 0 "FSMC_PATT1"
bitfld.long 0 0.--7. " SET "  " "
bitfld.long 0 8.--15. " WAIT "  " "
bitfld.long 0 16.--23. " HOLD "  " "
bitfld.long 0 24.--31. " HIZ "  " "
tree.end

base sd:0x8000008c
tree "FSMC_PATT2"
group 0--3
line.long 0 "FSMC_PATT2"
bitfld.long 0 0.--7. " SET "  " "
bitfld.long 0 8.--15. " WAIT "  " "
bitfld.long 0 16.--23. " HOLD "  " "
bitfld.long 0 24.--31. " HIZ "  " "
tree.end

base sd:0x800000ac
tree "FSMC_PATT3"
group 0--3
line.long 0 "FSMC_PATT3"
bitfld.long 0 0.--7. " SET "  " "
bitfld.long 0 8.--15. " WAIT "  " "
bitfld.long 0 16.--23. " HOLD "  " "
bitfld.long 0 24.--31. " HIZ "  " "
tree.end

base sd:0x80000050
tree "FSMC_PIO0"
group 0--3
line.long 0 "FSMC_PIO0"
bitfld.long 0 0.--7. " SET "  " "
bitfld.long 0 8.--15. " WAIT "  " "
bitfld.long 0 16.--23. " HOLD "  " "
bitfld.long 0 24.--31. " HIZ "  " "
tree.end

base sd:0x80000070
tree "FSMC_PIO1"
group 0--3
line.long 0 "FSMC_PIO1"
bitfld.long 0 0.--7. " SET "  " "
bitfld.long 0 8.--15. " WAIT "  " "
bitfld.long 0 16.--23. " HOLD "  " "
bitfld.long 0 24.--31. " HIZ "  " "
tree.end

base sd:0x80000054
tree "FSMC_ECCR0"
group 0--3
line.long 0 "FSMC_ECCR0"
bitfld.long 0 0.--23. " ECC "  " "
tree.end

base sd:0x80000074
tree "FSMC_ECCR1"
group 0--3
line.long 0 "FSMC_ECCR1"
bitfld.long 0 0.--23. " ECC "  " "
tree.end

base sd:0x800000c0
tree "FSMC_ITCR"
group 0--3
line.long 0 "FSMC_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0x800000c4
tree "FSMC_ITIP0"
group 0--3
line.long 0 "FSMC_ITIP0"
bitfld.long 0 0.--31. " PCDAI "  " "
tree.end

base sd:0x800000c8
tree "FSMC_ITIP1"
group 0--3
line.long 0 "FSMC_ITIP1"
bitfld.long 0 0. " SMFBCLK "  "0 ,1 "
bitfld.long 0 1. " SMWAITn "  "0 ,1 "
bitfld.long 0 2.--3. " SMPCIRQ "  " "
bitfld.long 0 6. " SMPIOIS16n "  "0 ,1 "
bitfld.long 0 7.--8. " SMPCD "  " "
bitfld.long 0 11.--12. " ExtDefWidth "  " "
tree.end

base sd:0x800000cc
tree "FSMC_ITOP0"
group 0--3
line.long 0 "FSMC_ITOP0"
bitfld.long 0 0.--31. " PCDAO "  " "
tree.end

base sd:0x800000d0
tree "FSMC_ITOP1"
group 0--3
line.long 0 "FSMC_ITOP1"
bitfld.long 0 0.--25. " SMAD "  " "
bitfld.long 0 26. " PC0INTR "  "0 ,1 "
bitfld.long 0 27. " PC1INTR "  "0 ,1 "
bitfld.long 0 30. " SMOEN "  "0 ,1 "
bitfld.long 0 31. " SWWEN "  "0 ,1 "
tree.end

base sd:0x800000d4
tree "FSMC_ITOP2"
group 0--3
line.long 0 "FSMC_ITOP2"
bitfld.long 0 0. " SMPREGN "  "0 ,1 "
bitfld.long 0 1. " SMPRST0N "  "0 ,1 "
bitfld.long 0 2. " SMPRST1N "  "0 ,1 "
bitfld.long 0 5. " SMPCDIRN "  "0 ,1 "
bitfld.long 0 6. " SMPC1EN "  "0 ,1 "
bitfld.long 0 7. " SMPC2EN "  "0 ,1 "
bitfld.long 0 8. " SMPIORN "  "0 ,1 "
bitfld.long 0 9. " SMPIOWN "  "0 ,1 "
bitfld.long 0 10. " SMADVN "  "0 ,1 "
bitfld.long 0 11. " SMCKO "  "0 ,1 "
bitfld.long 0 12. " SMBE0n "  "0 ,1 "
bitfld.long 0 13. " SMBE1n "  "0 ,1 "
bitfld.long 0 14. " SMBE2n "  "0 ,1 "
bitfld.long 0 15. " SMBE3n "  "0 ,1 "
bitfld.long 0 16. " SMPS0N "  "0 ,1 "
bitfld.long 0 17. " SMPS1N "  "0 ,1 "
tree.end

base sd:0x800000d8
tree "FSMC_ITOP3"
group 0--3
line.long 0 "FSMC_ITOP3"
bitfld.long 0 0. " SMCS0N "  "0 ,1 "
bitfld.long 0 1. " SMCS1N "  "0 ,1 "
bitfld.long 0 2. " SMCS2N "  "0 ,1 "
bitfld.long 0 3. " SMCS3N "  "0 ,1 "
bitfld.long 0 4. " SMFWP0N "  "0 ,1 "
bitfld.long 0 5. " SMFWP1N "  "0 ,1 "
bitfld.long 0 6. " SMFWP2N "  "0 ,1 "
bitfld.long 0 7. " SMFWP3N "  "0 ,1 "
bitfld.long 0 8. " SMFRST0N "  "0 ,1 "
bitfld.long 0 9. " SMFRST1N "  "0 ,1 "
bitfld.long 0 10. " SMFRST2N "  "0 ,1 "
bitfld.long 0 11. " SMFRST3N "  "0 ,1 "
tree.end

base sd:0x80000100
tree "FSMC_BWTR0"
group 0--3
line.long 0 "FSMC_BWTR0"
bitfld.long 0 0.--3. " ADDSET "  " "
bitfld.long 0 4.--7. " ADDHOLD "  " "
bitfld.long 0 8.--15. " DATAST "  " "
bitfld.long 0 16.--19. " BUSTURN "  " "
bitfld.long 0 20.--23. " CLKDIV "  " "
bitfld.long 0 24.--27. " DATLAT "  " "
bitfld.long 0 28.--29. " ACCMOD "  " "
tree.end

base sd:0x80000108
tree "FSMC_BWTR1"
group 0--3
line.long 0 "FSMC_BWTR1"
bitfld.long 0 0.--3. " ADDSET "  " "
bitfld.long 0 4.--7. " ADDHOLD "  " "
bitfld.long 0 8.--15. " DATAST "  " "
bitfld.long 0 16.--19. " BUSTURN "  " "
bitfld.long 0 20.--23. " CLKDIV "  " "
bitfld.long 0 24.--27. " DATLAT "  " "
bitfld.long 0 28.--29. " ACCMOD "  " "
tree.end

base sd:0x80000110
tree "FSMC_BWTR2"
group 0--3
line.long 0 "FSMC_BWTR2"
bitfld.long 0 0.--3. " ADDSET "  " "
bitfld.long 0 4.--7. " ADDHOLD "  " "
bitfld.long 0 8.--15. " DATAST "  " "
bitfld.long 0 16.--19. " BUSTURN "  " "
bitfld.long 0 20.--23. " CLKDIV "  " "
bitfld.long 0 24.--27. " DATLAT "  " "
bitfld.long 0 28.--29. " ACCMOD "  " "
tree.end

base sd:0x80000fe0
tree "FSMC_PeriphID0"
rgroup 0--3
line.long 0 "FSMC_PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x80000fe4
tree "FSMC_PeriphID1"
rgroup 0--3
line.long 0 "FSMC_PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80000fe8
tree "FSMC_PeriphID2"
rgroup 0--3
line.long 0 "FSMC_PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80000fec
tree "FSMC_PeriphID3"
rgroup 0--3
line.long 0 "FSMC_PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80000ff0
tree "FSMC_PCellID0"
rgroup 0--3
line.long 0 "FSMC_PCellID0"
bitfld.long 0 0. " _PCellID0 "  "0 ,1 "
tree.end

base sd:0x80000ff4
tree "FSMC_PCellID1"
rgroup 0--3
line.long 0 "FSMC_PCellID1"
bitfld.long 0 0. " _BCRPCellID1 "  "0 ,1 "
tree.end

base sd:0x80000ff8
tree "FSMC_PCellID2"
rgroup 0--3
line.long 0 "FSMC_PCellID2"
bitfld.long 0 0. " _BCRPCellID2 "  "0 ,1 "
tree.end

base sd:0x80000ffc
tree "FSMC_PCellID3"
rgroup 0--3
line.long 0 "FSMC_PCellID3"
bitfld.long 0 0. " _BCRPCellID3 "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "GIC"
;==============================================================
base sd:0xa0410100
tree "CPU_ICR"
group 0--3
line.long 0 "CPU_ICR"
bitfld.long 0 0. " CPUICREN "  "0 ,1 "
bitfld.long 0 1. " CPUICRENNS "  "0 ,1 "
bitfld.long 0 2. " CPUICRACKCTL "  "0 ,1 "
bitfld.long 0 3. " CPUICRFIQEN "  "0 ,1 "
bitfld.long 0 4. " CPUICRSBPR "  "0 ,1 "
tree.end

base sd:0xa0410104
tree "PMR"
group 0--3
line.long 0 "PMR"
bitfld.long 0 3.--7. " PMRPRIORITY "  " "
tree.end

base sd:0xa0410108
tree "BPR"
group 0--3
line.long 0 "BPR"
bitfld.long 0 0.--2. " BPRBP "  " "
tree.end

base sd:0xa041010c
tree "IAR"
rgroup 0--3
line.long 0 "IAR"
bitfld.long 0 0.--9. " IARACKINTID "  " "
bitfld.long 0 10.--12. " IARSOURCECPUID "  " "
tree.end

base sd:0xa0410110
tree "EOIR"
wgroup 0--3
line.long 0 "EOIR"
bitfld.long 0 0.--9. " EOIREOIINTID "  " "
bitfld.long 0 10.--12. " EOIRSOURCECPUID "  " "
tree.end

base sd:0xa0410114
tree "RPR"
rgroup 0--3
line.long 0 "RPR"
bitfld.long 0 0.--7. " RPRPRIORITY "  " "
tree.end

base sd:0xa0410118
tree "HPIR"
rgroup 0--3
line.long 0 "HPIR"
bitfld.long 0 0.--9. " HPIRPENDINTID "  " "
bitfld.long 0 10.--12. " HPIRSOURCECPUID "  " "
tree.end

base sd:0xa041011c
tree "ANSBPR"
group 0--3
line.long 0 "ANSBPR"
bitfld.long 0 0.--2. " ANSBPRBP "  " "
tree.end

base sd:0xa04101fc
tree "CPU_IIIR"
rgroup 0--3
line.long 0 "CPU_IIIR"
bitfld.long 0 0.--11. " CPUIIIRIMPLEMENTOR "  " "
bitfld.long 0 12.--15. " CPUIIIRRN "  " "
bitfld.long 0 16.--19. " CPUIIIRAV "  " "
bitfld.long 0 20.--31. " CPUIIIRPN "  " "
tree.end

base sd:0xa0411000
tree "IDCR"
group 0--3
line.long 0 "IDCR"
bitfld.long 0 0. " IDCEN "  "0 ,1 "
bitfld.long 0 1. " IDCENS "  "0 ,1 "
tree.end

base sd:0xa0411004
tree "ICTR"
rgroup 0--3
line.long 0 "ICTR"
bitfld.long 0 0.--4. " ICTITLN "  " "
bitfld.long 0 5.--7. " ICTCPUN "  " "
bitfld.long 0 10. " ICTDOM "  "0 ,1 "
bitfld.long 0 11.--15. " ICTLSPI "  " "
tree.end

base sd:0xa0411008
tree "DIIR"
rgroup 0--3
line.long 0 "DIIR"
bitfld.long 0 0.--11. " DIIIMPL "  " "
bitfld.long 0 12.--23. " DIIRN "  " "
bitfld.long 0 24.--31. " DIIIMPL_DEFINED "  " "
tree.end

base sd:0xa0411080
tree "IS0R"
group 0--3
line.long 0 "IS0R"
bitfld.long 0 0.--31. " IS0 "  " "
tree.end

base sd:0xa0411084
tree "IS1R"
group 0--3
line.long 0 "IS1R"
bitfld.long 0 0.--31. " IS1 "  " "
tree.end

base sd:0xa0411088
tree "IS2R"
group 0--3
line.long 0 "IS2R"
bitfld.long 0 0.--31. " IS2 "  " "
tree.end

base sd:0xa041108c
tree "IS3R"
group 0--3
line.long 0 "IS3R"
bitfld.long 0 0.--31. " IS3 "  " "
tree.end

base sd:0xa0411090
tree "IS4R"
group 0--3
line.long 0 "IS4R"
bitfld.long 0 0.--31. " IS4 "  " "
tree.end

base sd:0xa0411094
tree "IS5R"
group 0--3
line.long 0 "IS5R"
bitfld.long 0 0.--31. " IS5 "  " "
tree.end

base sd:0xa0411098
tree "IS6R"
group 0--3
line.long 0 "IS6R"
bitfld.long 0 0.--31. " IS6 "  " "
tree.end

base sd:0xa041109c
tree "IS7R"
group 0--3
line.long 0 "IS7R"
bitfld.long 0 0.--31. " IS7 "  " "
tree.end

base sd:0xa04110a0
tree "IS8R"
group 0--3
line.long 0 "IS8R"
bitfld.long 0 0.--31. " IS8 "  " "
tree.end

base sd:0xa04110a4
tree "IS9R"
group 0--3
line.long 0 "IS9R"
bitfld.long 0 0.--31. " IS9 "  " "
tree.end

base sd:0xa04110a8
tree "IS10R"
group 0--3
line.long 0 "IS10R"
bitfld.long 0 0.--31. " IS10 "  " "
tree.end

base sd:0xa04110ac
tree "IS11R"
group 0--3
line.long 0 "IS11R"
bitfld.long 0 0.--31. " IS11 "  " "
tree.end

base sd:0xa04110b0
tree "IS12R"
group 0--3
line.long 0 "IS12R"
bitfld.long 0 0.--31. " IS12 "  " "
tree.end

base sd:0xa04110b4
tree "IS13R"
group 0--3
line.long 0 "IS13R"
bitfld.long 0 0.--31. " IS13 "  " "
tree.end

base sd:0xa04110b8
tree "IS14R"
group 0--3
line.long 0 "IS14R"
bitfld.long 0 0.--31. " IS14 "  " "
tree.end

base sd:0xa04110bc
tree "IS15R"
group 0--3
line.long 0 "IS15R"
bitfld.long 0 0.--31. " IS15 "  " "
tree.end

base sd:0xa04110c0
tree "IS16R"
group 0--3
line.long 0 "IS16R"
bitfld.long 0 0.--31. " IS16 "  " "
tree.end

base sd:0xa04110c4
tree "IS17R"
group 0--3
line.long 0 "IS17R"
bitfld.long 0 0.--31. " IS17 "  " "
tree.end

base sd:0xa04110c8
tree "IS18R"
group 0--3
line.long 0 "IS18R"
bitfld.long 0 0.--31. " IS18 "  " "
tree.end

base sd:0xa04110cc
tree "IS19R"
group 0--3
line.long 0 "IS19R"
bitfld.long 0 0.--31. " IS19 "  " "
tree.end

base sd:0xa04110d0
tree "IS20R"
group 0--3
line.long 0 "IS20R"
bitfld.long 0 0.--31. " IS20 "  " "
tree.end

base sd:0xa04110d4
tree "IS21R"
group 0--3
line.long 0 "IS21R"
bitfld.long 0 0.--31. " IS21 "  " "
tree.end

base sd:0xa04110d8
tree "IS22R"
group 0--3
line.long 0 "IS22R"
bitfld.long 0 0.--31. " IS22 "  " "
tree.end

base sd:0xa04110dc
tree "IS23R"
group 0--3
line.long 0 "IS23R"
bitfld.long 0 0.--31. " IS23 "  " "
tree.end

base sd:0xa04110e0
tree "IS24R"
group 0--3
line.long 0 "IS24R"
bitfld.long 0 0.--31. " IS24 "  " "
tree.end

base sd:0xa04110e4
tree "IS25R"
group 0--3
line.long 0 "IS25R"
bitfld.long 0 0.--31. " IS25 "  " "
tree.end

base sd:0xa04110e8
tree "IS26R"
group 0--3
line.long 0 "IS26R"
bitfld.long 0 0.--31. " IS26 "  " "
tree.end

base sd:0xa04110ec
tree "IS27R"
group 0--3
line.long 0 "IS27R"
bitfld.long 0 0.--31. " IS27 "  " "
tree.end

base sd:0xa04110f0
tree "IS28R"
group 0--3
line.long 0 "IS28R"
bitfld.long 0 0.--31. " IS28 "  " "
tree.end

base sd:0xa04110f4
tree "IS29R"
group 0--3
line.long 0 "IS29R"
bitfld.long 0 0.--31. " IS29 "  " "
tree.end

base sd:0xa04110f8
tree "IS30R"
group 0--3
line.long 0 "IS30R"
bitfld.long 0 0.--31. " IS30 "  " "
tree.end

base sd:0xa04110fc
tree "IS31R"
group 0--3
line.long 0 "IS31R"
bitfld.long 0 0.--31. " IS31 "  " "
tree.end

base sd:0xa0411100
tree "ES0R"
group 0--3
line.long 0 "ES0R"
bitfld.long 0 0.--31. " ES0 "  " "
tree.end

base sd:0xa0411104
tree "ES1R"
group 0--3
line.long 0 "ES1R"
bitfld.long 0 0.--31. " ES1 "  " "
tree.end

base sd:0xa0411108
tree "ES2R"
group 0--3
line.long 0 "ES2R"
bitfld.long 0 0.--31. " ES2 "  " "
tree.end

base sd:0xa041110c
tree "ES3R"
group 0--3
line.long 0 "ES3R"
bitfld.long 0 0.--31. " ES3 "  " "
tree.end

base sd:0xa0411110
tree "ES4R"
group 0--3
line.long 0 "ES4R"
bitfld.long 0 0.--31. " ES4 "  " "
tree.end

base sd:0xa0411114
tree "ES5R"
group 0--3
line.long 0 "ES5R"
bitfld.long 0 0.--31. " ES5 "  " "
tree.end

base sd:0xa0411118
tree "ES6R"
group 0--3
line.long 0 "ES6R"
bitfld.long 0 0.--31. " ES6 "  " "
tree.end

base sd:0xa041111c
tree "ES7R"
group 0--3
line.long 0 "ES7R"
bitfld.long 0 0.--31. " ES7 "  " "
tree.end

base sd:0xa0411120
tree "ES8R"
group 0--3
line.long 0 "ES8R"
bitfld.long 0 0.--31. " ES8 "  " "
tree.end

base sd:0xa0411124
tree "ES9R"
group 0--3
line.long 0 "ES9R"
bitfld.long 0 0.--31. " ES9 "  " "
tree.end

base sd:0xa0411128
tree "ES10R"
group 0--3
line.long 0 "ES10R"
bitfld.long 0 0.--31. " ES10 "  " "
tree.end

base sd:0xa041112c
tree "ES11R"
group 0--3
line.long 0 "ES11R"
bitfld.long 0 0.--31. " ES11 "  " "
tree.end

base sd:0xa0411130
tree "ES12R"
group 0--3
line.long 0 "ES12R"
bitfld.long 0 0.--31. " ES12 "  " "
tree.end

base sd:0xa0411134
tree "ES13R"
group 0--3
line.long 0 "ES13R"
bitfld.long 0 0.--31. " ES13 "  " "
tree.end

base sd:0xa0411138
tree "ES14R"
group 0--3
line.long 0 "ES14R"
bitfld.long 0 0.--31. " ES14 "  " "
tree.end

base sd:0xa041113c
tree "ES15R"
group 0--3
line.long 0 "ES15R"
bitfld.long 0 0.--31. " ES15 "  " "
tree.end

base sd:0xa0411140
tree "ES16R"
group 0--3
line.long 0 "ES16R"
bitfld.long 0 0.--31. " ES16 "  " "
tree.end

base sd:0xa0411144
tree "ES17R"
group 0--3
line.long 0 "ES17R"
bitfld.long 0 0.--31. " ES17 "  " "
tree.end

base sd:0xa0411148
tree "ES18R"
group 0--3
line.long 0 "ES18R"
bitfld.long 0 0.--31. " ES18 "  " "
tree.end

base sd:0xa041114c
tree "ES19R"
group 0--3
line.long 0 "ES19R"
bitfld.long 0 0.--31. " ES19 "  " "
tree.end

base sd:0xa0411150
tree "ES20R"
group 0--3
line.long 0 "ES20R"
bitfld.long 0 0.--31. " ES20 "  " "
tree.end

base sd:0xa0411154
tree "ES21R"
group 0--3
line.long 0 "ES21R"
bitfld.long 0 0.--31. " ES21 "  " "
tree.end

base sd:0xa0411158
tree "ES22R"
group 0--3
line.long 0 "ES22R"
bitfld.long 0 0.--31. " ES22 "  " "
tree.end

base sd:0xa041115c
tree "ES23R"
group 0--3
line.long 0 "ES23R"
bitfld.long 0 0.--31. " ES23 "  " "
tree.end

base sd:0xa0411160
tree "ES24R"
group 0--3
line.long 0 "ES24R"
bitfld.long 0 0.--31. " ES24 "  " "
tree.end

base sd:0xa0411164
tree "ES25R"
group 0--3
line.long 0 "ES25R"
bitfld.long 0 0.--31. " ES25 "  " "
tree.end

base sd:0xa0411168
tree "ES26R"
group 0--3
line.long 0 "ES26R"
bitfld.long 0 0.--31. " ES26 "  " "
tree.end

base sd:0xa041116c
tree "ES27R"
group 0--3
line.long 0 "ES27R"
bitfld.long 0 0.--31. " ES27 "  " "
tree.end

base sd:0xa0411170
tree "ES28R"
group 0--3
line.long 0 "ES28R"
bitfld.long 0 0.--31. " ES28 "  " "
tree.end

base sd:0xa0411174
tree "ES29R"
group 0--3
line.long 0 "ES29R"
bitfld.long 0 0.--31. " ES29 "  " "
tree.end

base sd:0xa0411178
tree "ES30R"
group 0--3
line.long 0 "ES30R"
bitfld.long 0 0.--31. " ES30 "  " "
tree.end

base sd:0xa041117c
tree "ES31R"
group 0--3
line.long 0 "ES31R"
bitfld.long 0 0.--31. " ES31 "  " "
tree.end

base sd:0xa0411180
tree "EC0R"
group 0--3
line.long 0 "EC0R"
bitfld.long 0 0.--31. " EC0 "  " "
tree.end

base sd:0xa0411184
tree "EC1R"
group 0--3
line.long 0 "EC1R"
bitfld.long 0 0.--31. " EC1 "  " "
tree.end

base sd:0xa0411188
tree "EC2R"
group 0--3
line.long 0 "EC2R"
bitfld.long 0 0.--31. " EC2 "  " "
tree.end

base sd:0xa041118c
tree "EC3R"
group 0--3
line.long 0 "EC3R"
bitfld.long 0 0.--31. " EC3 "  " "
tree.end

base sd:0xa0411190
tree "EC4R"
group 0--3
line.long 0 "EC4R"
bitfld.long 0 0.--31. " EC4 "  " "
tree.end

base sd:0xa0411194
tree "EC5R"
group 0--3
line.long 0 "EC5R"
bitfld.long 0 0.--31. " EC5 "  " "
tree.end

base sd:0xa0411198
tree "EC6R"
group 0--3
line.long 0 "EC6R"
bitfld.long 0 0.--31. " EC6 "  " "
tree.end

base sd:0xa041119c
tree "EC7R"
group 0--3
line.long 0 "EC7R"
bitfld.long 0 0.--31. " EC7 "  " "
tree.end

base sd:0xa04111a0
tree "EC8R"
group 0--3
line.long 0 "EC8R"
bitfld.long 0 0.--31. " EC8 "  " "
tree.end

base sd:0xa04111a4
tree "EC9R"
group 0--3
line.long 0 "EC9R"
bitfld.long 0 0.--31. " EC9 "  " "
tree.end

base sd:0xa04111a8
tree "EC10R"
group 0--3
line.long 0 "EC10R"
bitfld.long 0 0.--31. " EC10 "  " "
tree.end

base sd:0xa04111ac
tree "EC11R"
group 0--3
line.long 0 "EC11R"
bitfld.long 0 0.--31. " EC11 "  " "
tree.end

base sd:0xa04111b0
tree "EC12R"
group 0--3
line.long 0 "EC12R"
bitfld.long 0 0.--31. " EC12 "  " "
tree.end

base sd:0xa04111b4
tree "EC13R"
group 0--3
line.long 0 "EC13R"
bitfld.long 0 0.--31. " EC13 "  " "
tree.end

base sd:0xa04111b8
tree "EC14R"
group 0--3
line.long 0 "EC14R"
bitfld.long 0 0.--31. " EC14 "  " "
tree.end

base sd:0xa04111bc
tree "EC15R"
group 0--3
line.long 0 "EC15R"
bitfld.long 0 0.--31. " EC15 "  " "
tree.end

base sd:0xa04111c0
tree "EC16R"
group 0--3
line.long 0 "EC16R"
bitfld.long 0 0.--31. " EC16 "  " "
tree.end

base sd:0xa04111c4
tree "EC17R"
group 0--3
line.long 0 "EC17R"
bitfld.long 0 0.--31. " EC17 "  " "
tree.end

base sd:0xa04111c8
tree "EC18R"
group 0--3
line.long 0 "EC18R"
bitfld.long 0 0.--31. " EC18 "  " "
tree.end

base sd:0xa04111cc
tree "EC19R"
group 0--3
line.long 0 "EC19R"
bitfld.long 0 0.--31. " EC19 "  " "
tree.end

base sd:0xa04111d0
tree "EC20R"
group 0--3
line.long 0 "EC20R"
bitfld.long 0 0.--31. " EC20 "  " "
tree.end

base sd:0xa04111d4
tree "EC21R"
group 0--3
line.long 0 "EC21R"
bitfld.long 0 0.--31. " EC21 "  " "
tree.end

base sd:0xa04111d8
tree "EC22R"
group 0--3
line.long 0 "EC22R"
bitfld.long 0 0.--31. " EC22 "  " "
tree.end

base sd:0xa04111dc
tree "EC23R"
group 0--3
line.long 0 "EC23R"
bitfld.long 0 0.--31. " EC23 "  " "
tree.end

base sd:0xa04111e0
tree "EC24R"
group 0--3
line.long 0 "EC24R"
bitfld.long 0 0.--31. " EC24 "  " "
tree.end

base sd:0xa04111e4
tree "EC25R"
group 0--3
line.long 0 "EC25R"
bitfld.long 0 0.--31. " EC25 "  " "
tree.end

base sd:0xa04111e8
tree "EC26R"
group 0--3
line.long 0 "EC26R"
bitfld.long 0 0.--31. " EC26 "  " "
tree.end

base sd:0xa04111ec
tree "EC27R"
group 0--3
line.long 0 "EC27R"
bitfld.long 0 0.--31. " EC27 "  " "
tree.end

base sd:0xa04111f0
tree "EC28R"
group 0--3
line.long 0 "EC28R"
bitfld.long 0 0.--31. " EC28 "  " "
tree.end

base sd:0xa04111f4
tree "EC29R"
group 0--3
line.long 0 "EC29R"
bitfld.long 0 0.--31. " EC29 "  " "
tree.end

base sd:0xa04111f8
tree "EC30R"
group 0--3
line.long 0 "EC30R"
bitfld.long 0 0.--31. " EC30 "  " "
tree.end

base sd:0xa04111fc
tree "EC31R"
group 0--3
line.long 0 "EC31R"
bitfld.long 0 0.--31. " EC31 "  " "
tree.end

base sd:0xa0411200
tree "PS0R"
group 0--3
line.long 0 "PS0R"
bitfld.long 0 0.--31. " PS0 "  " "
tree.end

base sd:0xa0411204
tree "PS1R"
group 0--3
line.long 0 "PS1R"
bitfld.long 0 0.--31. " PS1 "  " "
tree.end

base sd:0xa0411208
tree "PS2R"
group 0--3
line.long 0 "PS2R"
bitfld.long 0 0.--31. " PS2 "  " "
tree.end

base sd:0xa041120c
tree "PS3R"
group 0--3
line.long 0 "PS3R"
bitfld.long 0 0.--31. " PS3 "  " "
tree.end

base sd:0xa0411210
tree "PS4R"
group 0--3
line.long 0 "PS4R"
bitfld.long 0 0.--31. " PS4 "  " "
tree.end

base sd:0xa0411214
tree "PS5R"
group 0--3
line.long 0 "PS5R"
bitfld.long 0 0.--31. " PS5 "  " "
tree.end

base sd:0xa0411218
tree "PS6R"
group 0--3
line.long 0 "PS6R"
bitfld.long 0 0.--31. " PS6 "  " "
tree.end

base sd:0xa041121c
tree "PS7R"
group 0--3
line.long 0 "PS7R"
bitfld.long 0 0.--31. " PS7 "  " "
tree.end

base sd:0xa0411220
tree "PS8R"
group 0--3
line.long 0 "PS8R"
bitfld.long 0 0.--31. " PS8 "  " "
tree.end

base sd:0xa0411224
tree "PS9R"
group 0--3
line.long 0 "PS9R"
bitfld.long 0 0.--31. " PS9 "  " "
tree.end

base sd:0xa0411228
tree "PS10R"
group 0--3
line.long 0 "PS10R"
bitfld.long 0 0.--31. " PS10 "  " "
tree.end

base sd:0xa041122c
tree "PS11R"
group 0--3
line.long 0 "PS11R"
bitfld.long 0 0.--31. " PS11 "  " "
tree.end

base sd:0xa0411230
tree "PS12R"
group 0--3
line.long 0 "PS12R"
bitfld.long 0 0.--31. " PS12 "  " "
tree.end

base sd:0xa0411234
tree "PS13R"
group 0--3
line.long 0 "PS13R"
bitfld.long 0 0.--31. " PS13 "  " "
tree.end

base sd:0xa0411238
tree "PS14R"
group 0--3
line.long 0 "PS14R"
bitfld.long 0 0.--31. " PS14 "  " "
tree.end

base sd:0xa041123c
tree "PS15R"
group 0--3
line.long 0 "PS15R"
bitfld.long 0 0.--31. " PS15 "  " "
tree.end

base sd:0xa0411240
tree "PS16R"
group 0--3
line.long 0 "PS16R"
bitfld.long 0 0.--31. " PS16 "  " "
tree.end

base sd:0xa0411244
tree "PS17R"
group 0--3
line.long 0 "PS17R"
bitfld.long 0 0.--31. " PS17 "  " "
tree.end

base sd:0xa0411248
tree "PS18R"
group 0--3
line.long 0 "PS18R"
bitfld.long 0 0.--31. " PS18 "  " "
tree.end

base sd:0xa041124c
tree "PS19R"
group 0--3
line.long 0 "PS19R"
bitfld.long 0 0.--31. " PS19 "  " "
tree.end

base sd:0xa0411250
tree "PS20R"
group 0--3
line.long 0 "PS20R"
bitfld.long 0 0.--31. " PS20 "  " "
tree.end

base sd:0xa0411254
tree "PS21R"
group 0--3
line.long 0 "PS21R"
bitfld.long 0 0.--31. " PS21 "  " "
tree.end

base sd:0xa0411258
tree "PS22R"
group 0--3
line.long 0 "PS22R"
bitfld.long 0 0.--31. " PS22 "  " "
tree.end

base sd:0xa041125c
tree "PS23R"
group 0--3
line.long 0 "PS23R"
bitfld.long 0 0.--31. " PS23 "  " "
tree.end

base sd:0xa0411260
tree "PS24R"
group 0--3
line.long 0 "PS24R"
bitfld.long 0 0.--31. " PS24 "  " "
tree.end

base sd:0xa0411264
tree "PS25R"
group 0--3
line.long 0 "PS25R"
bitfld.long 0 0.--31. " PS25 "  " "
tree.end

base sd:0xa0411268
tree "PS26R"
group 0--3
line.long 0 "PS26R"
bitfld.long 0 0.--31. " PS26 "  " "
tree.end

base sd:0xa041126c
tree "PS27R"
group 0--3
line.long 0 "PS27R"
bitfld.long 0 0.--31. " PS27 "  " "
tree.end

base sd:0xa0411270
tree "PS28R"
group 0--3
line.long 0 "PS28R"
bitfld.long 0 0.--31. " PS28 "  " "
tree.end

base sd:0xa0411274
tree "PS29R"
group 0--3
line.long 0 "PS29R"
bitfld.long 0 0.--31. " PS29 "  " "
tree.end

base sd:0xa0411278
tree "PS30R"
group 0--3
line.long 0 "PS30R"
bitfld.long 0 0.--31. " PS30 "  " "
tree.end

base sd:0xa041127c
tree "PS31R"
group 0--3
line.long 0 "PS31R"
bitfld.long 0 0.--31. " PS31 "  " "
tree.end

base sd:0xa0411280
tree "PC0R"
group 0--3
line.long 0 "PC0R"
bitfld.long 0 0.--31. " PC0 "  " "
tree.end

base sd:0xa0411284
tree "PC1R"
group 0--3
line.long 0 "PC1R"
bitfld.long 0 0.--31. " PC1 "  " "
tree.end

base sd:0xa0411288
tree "PC2R"
group 0--3
line.long 0 "PC2R"
bitfld.long 0 0.--31. " PC2 "  " "
tree.end

base sd:0xa041128c
tree "PC3R"
group 0--3
line.long 0 "PC3R"
bitfld.long 0 0.--31. " PC3 "  " "
tree.end

base sd:0xa0411290
tree "PC4R"
group 0--3
line.long 0 "PC4R"
bitfld.long 0 0.--31. " PC4 "  " "
tree.end

base sd:0xa0411294
tree "PC5R"
group 0--3
line.long 0 "PC5R"
bitfld.long 0 0.--31. " PC5 "  " "
tree.end

base sd:0xa0411298
tree "PC6R"
group 0--3
line.long 0 "PC6R"
bitfld.long 0 0.--31. " PC6 "  " "
tree.end

base sd:0xa041129c
tree "PC7R"
group 0--3
line.long 0 "PC7R"
bitfld.long 0 0.--31. " PC7 "  " "
tree.end

base sd:0xa04112a0
tree "PC8R"
group 0--3
line.long 0 "PC8R"
bitfld.long 0 0.--31. " PC8 "  " "
tree.end

base sd:0xa04112a4
tree "PC9R"
group 0--3
line.long 0 "PC9R"
bitfld.long 0 0.--31. " PC9 "  " "
tree.end

base sd:0xa04112a8
tree "PC10R"
group 0--3
line.long 0 "PC10R"
bitfld.long 0 0.--31. " PC10 "  " "
tree.end

base sd:0xa04112ac
tree "PC11R"
group 0--3
line.long 0 "PC11R"
bitfld.long 0 0.--31. " PC11 "  " "
tree.end

base sd:0xa04112b0
tree "PC12R"
group 0--3
line.long 0 "PC12R"
bitfld.long 0 0.--31. " PC12 "  " "
tree.end

base sd:0xa04112b4
tree "PC13R"
group 0--3
line.long 0 "PC13R"
bitfld.long 0 0.--31. " PC13 "  " "
tree.end

base sd:0xa04112b8
tree "PC14R"
group 0--3
line.long 0 "PC14R"
bitfld.long 0 0.--31. " PC14 "  " "
tree.end

base sd:0xa04112bc
tree "PC15R"
group 0--3
line.long 0 "PC15R"
bitfld.long 0 0.--31. " PC15 "  " "
tree.end

base sd:0xa04112c0
tree "PC16R"
group 0--3
line.long 0 "PC16R"
bitfld.long 0 0.--31. " PC16 "  " "
tree.end

base sd:0xa04112c4
tree "PC17R"
group 0--3
line.long 0 "PC17R"
bitfld.long 0 0.--31. " PC17 "  " "
tree.end

base sd:0xa04112c8
tree "PC18R"
group 0--3
line.long 0 "PC18R"
bitfld.long 0 0.--31. " PC18 "  " "
tree.end

base sd:0xa04112cc
tree "PC19R"
group 0--3
line.long 0 "PC19R"
bitfld.long 0 0.--31. " PC19 "  " "
tree.end

base sd:0xa04112d0
tree "PC20R"
group 0--3
line.long 0 "PC20R"
bitfld.long 0 0.--31. " PC20 "  " "
tree.end

base sd:0xa04112d4
tree "PC21R"
group 0--3
line.long 0 "PC21R"
bitfld.long 0 0.--31. " PC21 "  " "
tree.end

base sd:0xa04112d8
tree "PC22R"
group 0--3
line.long 0 "PC22R"
bitfld.long 0 0.--31. " PC22 "  " "
tree.end

base sd:0xa04112dc
tree "PC23R"
group 0--3
line.long 0 "PC23R"
bitfld.long 0 0.--31. " PC23 "  " "
tree.end

base sd:0xa04112e0
tree "PC24R"
group 0--3
line.long 0 "PC24R"
bitfld.long 0 0.--31. " PC24 "  " "
tree.end

base sd:0xa04112e4
tree "PC25R"
group 0--3
line.long 0 "PC25R"
bitfld.long 0 0.--31. " PC25 "  " "
tree.end

base sd:0xa04112e8
tree "PC26R"
group 0--3
line.long 0 "PC26R"
bitfld.long 0 0.--31. " PC26 "  " "
tree.end

base sd:0xa04112ec
tree "PC27R"
group 0--3
line.long 0 "PC27R"
bitfld.long 0 0.--31. " PC27 "  " "
tree.end

base sd:0xa04112f0
tree "PC28R"
group 0--3
line.long 0 "PC28R"
bitfld.long 0 0.--31. " PC28 "  " "
tree.end

base sd:0xa04112f4
tree "PC29R"
group 0--3
line.long 0 "PC29R"
bitfld.long 0 0.--31. " PC29 "  " "
tree.end

base sd:0xa04112f8
tree "PC30R"
group 0--3
line.long 0 "PC30R"
bitfld.long 0 0.--31. " PC30 "  " "
tree.end

base sd:0xa04112fc
tree "PC31R"
group 0--3
line.long 0 "PC31R"
bitfld.long 0 0.--31. " PC31 "  " "
tree.end

base sd:0xa0411300
tree "AS0R"
rgroup 0--3
line.long 0 "AS0R"
bitfld.long 0 0.--31. " AS0 "  " "
tree.end

base sd:0xa0411304
tree "AS1R"
rgroup 0--3
line.long 0 "AS1R"
bitfld.long 0 0.--31. " AS1 "  " "
tree.end

base sd:0xa0411308
tree "AS2R"
rgroup 0--3
line.long 0 "AS2R"
bitfld.long 0 0.--31. " AS2 "  " "
tree.end

base sd:0xa041130c
tree "AS3R"
rgroup 0--3
line.long 0 "AS3R"
bitfld.long 0 0.--31. " AS3 "  " "
tree.end

base sd:0xa0411310
tree "AS4R"
rgroup 0--3
line.long 0 "AS4R"
bitfld.long 0 0.--31. " AS4 "  " "
tree.end

base sd:0xa0411314
tree "AS5R"
rgroup 0--3
line.long 0 "AS5R"
bitfld.long 0 0.--31. " AS5 "  " "
tree.end

base sd:0xa0411318
tree "AS6R"
rgroup 0--3
line.long 0 "AS6R"
bitfld.long 0 0.--31. " AS6 "  " "
tree.end

base sd:0xa041131c
tree "AS7R"
rgroup 0--3
line.long 0 "AS7R"
bitfld.long 0 0.--31. " AS7 "  " "
tree.end

base sd:0xa0411320
tree "AS8R"
rgroup 0--3
line.long 0 "AS8R"
bitfld.long 0 0.--31. " AS8 "  " "
tree.end

base sd:0xa0411324
tree "AS9R"
rgroup 0--3
line.long 0 "AS9R"
bitfld.long 0 0.--31. " AS9 "  " "
tree.end

base sd:0xa0411328
tree "AS10R"
rgroup 0--3
line.long 0 "AS10R"
bitfld.long 0 0.--31. " AS10 "  " "
tree.end

base sd:0xa041132c
tree "AS11R"
rgroup 0--3
line.long 0 "AS11R"
bitfld.long 0 0.--31. " AS11 "  " "
tree.end

base sd:0xa0411330
tree "AS12R"
rgroup 0--3
line.long 0 "AS12R"
bitfld.long 0 0.--31. " AS12 "  " "
tree.end

base sd:0xa0411334
tree "AS13R"
rgroup 0--3
line.long 0 "AS13R"
bitfld.long 0 0.--31. " AS13 "  " "
tree.end

base sd:0xa0411338
tree "AS14R"
rgroup 0--3
line.long 0 "AS14R"
bitfld.long 0 0.--31. " AS14 "  " "
tree.end

base sd:0xa041133c
tree "AS15R"
rgroup 0--3
line.long 0 "AS15R"
bitfld.long 0 0.--31. " AS15 "  " "
tree.end

base sd:0xa0411340
tree "AS16R"
rgroup 0--3
line.long 0 "AS16R"
bitfld.long 0 0.--31. " AS16 "  " "
tree.end

base sd:0xa0411344
tree "AS17R"
rgroup 0--3
line.long 0 "AS17R"
bitfld.long 0 0.--31. " AS17 "  " "
tree.end

base sd:0xa0411348
tree "AS18R"
rgroup 0--3
line.long 0 "AS18R"
bitfld.long 0 0.--31. " AS18 "  " "
tree.end

base sd:0xa041134c
tree "AS19R"
rgroup 0--3
line.long 0 "AS19R"
bitfld.long 0 0.--31. " AS19 "  " "
tree.end

base sd:0xa0411350
tree "AS20R"
rgroup 0--3
line.long 0 "AS20R"
bitfld.long 0 0.--31. " AS20 "  " "
tree.end

base sd:0xa0411354
tree "AS21R"
rgroup 0--3
line.long 0 "AS21R"
bitfld.long 0 0.--31. " AS21 "  " "
tree.end

base sd:0xa0411358
tree "AS22R"
rgroup 0--3
line.long 0 "AS22R"
bitfld.long 0 0.--31. " AS22 "  " "
tree.end

base sd:0xa041135c
tree "AS23R"
rgroup 0--3
line.long 0 "AS23R"
bitfld.long 0 0.--31. " AS23 "  " "
tree.end

base sd:0xa0411360
tree "AS24R"
rgroup 0--3
line.long 0 "AS24R"
bitfld.long 0 0.--31. " AS24 "  " "
tree.end

base sd:0xa0411364
tree "AS25R"
rgroup 0--3
line.long 0 "AS25R"
bitfld.long 0 0.--31. " AS25 "  " "
tree.end

base sd:0xa0411368
tree "AS26R"
rgroup 0--3
line.long 0 "AS26R"
bitfld.long 0 0.--31. " AS26 "  " "
tree.end

base sd:0xa041136c
tree "AS27R"
rgroup 0--3
line.long 0 "AS27R"
bitfld.long 0 0.--31. " AS27 "  " "
tree.end

base sd:0xa0411370
tree "AS28R"
rgroup 0--3
line.long 0 "AS28R"
bitfld.long 0 0.--31. " AS28 "  " "
tree.end

base sd:0xa0411374
tree "AS29R"
rgroup 0--3
line.long 0 "AS29R"
bitfld.long 0 0.--31. " AS29 "  " "
tree.end

base sd:0xa0411378
tree "AS30R"
rgroup 0--3
line.long 0 "AS30R"
bitfld.long 0 0.--31. " AS30 "  " "
tree.end

base sd:0xa041137c
tree "AS31R"
rgroup 0--3
line.long 0 "AS31R"
bitfld.long 0 0.--31. " AS31 "  " "
tree.end

base sd:0xa0411400
tree "PL0R"
group 0--3
line.long 0 "PL0R"
bitfld.long 0 3.--7. " PL0IDNP0 "  " "
bitfld.long 0 11.--15. " PL0IDNP1 "  " "
bitfld.long 0 19.--23. " PL0IDNP2 "  " "
bitfld.long 0 27.--31. " PL0IDNP3 "  " "
tree.end

base sd:0xa0411404
tree "PL1R"
group 0--3
line.long 0 "PL1R"
bitfld.long 0 3.--7. " PL1IDNP0 "  " "
bitfld.long 0 11.--15. " PL1IDNP1 "  " "
bitfld.long 0 19.--23. " PL1IDNP2 "  " "
bitfld.long 0 27.--31. " PL1IDNP3 "  " "
tree.end

base sd:0xa0411408
tree "PL2R"
group 0--3
line.long 0 "PL2R"
bitfld.long 0 3.--7. " PL2IDNP0 "  " "
bitfld.long 0 11.--15. " PL2IDNP1 "  " "
bitfld.long 0 19.--23. " PL2IDNP2 "  " "
bitfld.long 0 27.--31. " PL2IDNP3 "  " "
tree.end

base sd:0xa041140c
tree "PL3R"
group 0--3
line.long 0 "PL3R"
bitfld.long 0 3.--7. " PL3IDNP0 "  " "
bitfld.long 0 11.--15. " PL3IDNP1 "  " "
bitfld.long 0 19.--23. " PL3IDNP2 "  " "
bitfld.long 0 27.--31. " PL3IDNP3 "  " "
tree.end

base sd:0xa0411410
tree "PL4R"
group 0--3
line.long 0 "PL4R"
bitfld.long 0 3.--7. " PL4IDNP0 "  " "
bitfld.long 0 11.--15. " PL4IDNP1 "  " "
bitfld.long 0 19.--23. " PL4IDNP2 "  " "
bitfld.long 0 27.--31. " PL4IDNP3 "  " "
tree.end

base sd:0xa0411414
tree "PL5R"
group 0--3
line.long 0 "PL5R"
bitfld.long 0 3.--7. " PL5IDNP0 "  " "
bitfld.long 0 11.--15. " PL5IDNP1 "  " "
bitfld.long 0 19.--23. " PL5IDNP2 "  " "
bitfld.long 0 27.--31. " PL5IDNP3 "  " "
tree.end

base sd:0xa0411418
tree "PL6R"
group 0--3
line.long 0 "PL6R"
bitfld.long 0 3.--7. " PL6IDNP0 "  " "
bitfld.long 0 11.--15. " PL6IDNP1 "  " "
bitfld.long 0 19.--23. " PL6IDNP2 "  " "
bitfld.long 0 27.--31. " PL6IDNP3 "  " "
tree.end

base sd:0xa041141c
tree "PL7R"
group 0--3
line.long 0 "PL7R"
bitfld.long 0 3.--7. " PL7IDNP0 "  " "
bitfld.long 0 11.--15. " PL7IDNP1 "  " "
bitfld.long 0 19.--23. " PL7IDNP2 "  " "
bitfld.long 0 27.--31. " PL7IDNP3 "  " "
tree.end

base sd:0xa0411420
tree "PL8R"
group 0--3
line.long 0 "PL8R"
bitfld.long 0 3.--7. " PL8IDNP0 "  " "
bitfld.long 0 11.--15. " PL8IDNP1 "  " "
bitfld.long 0 19.--23. " PL8IDNP2 "  " "
bitfld.long 0 27.--31. " PL8IDNP3 "  " "
tree.end

base sd:0xa0411424
tree "PL9R"
group 0--3
line.long 0 "PL9R"
bitfld.long 0 3.--7. " PL9IDNP0 "  " "
bitfld.long 0 11.--15. " PL9IDNP1 "  " "
bitfld.long 0 19.--23. " PL9IDNP2 "  " "
bitfld.long 0 27.--31. " PL9IDNP3 "  " "
tree.end

base sd:0xa0411428
tree "PL10R"
group 0--3
line.long 0 "PL10R"
bitfld.long 0 3.--7. " PL10IDNP0 "  " "
bitfld.long 0 11.--15. " PL10IDNP1 "  " "
bitfld.long 0 19.--23. " PL10IDNP2 "  " "
bitfld.long 0 27.--31. " PL10IDNP3 "  " "
tree.end

base sd:0xa041142c
tree "PL11R"
group 0--3
line.long 0 "PL11R"
bitfld.long 0 3.--7. " PL11IDNP0 "  " "
bitfld.long 0 11.--15. " PL11IDNP1 "  " "
bitfld.long 0 19.--23. " PL11IDNP2 "  " "
bitfld.long 0 27.--31. " PL11IDNP3 "  " "
tree.end

base sd:0xa0411430
tree "PL12R"
group 0--3
line.long 0 "PL12R"
bitfld.long 0 3.--7. " PL12IDNP0 "  " "
bitfld.long 0 11.--15. " PL12IDNP1 "  " "
bitfld.long 0 19.--23. " PL12IDNP2 "  " "
bitfld.long 0 27.--31. " PL12IDNP3 "  " "
tree.end

base sd:0xa0411434
tree "PL13R"
group 0--3
line.long 0 "PL13R"
bitfld.long 0 3.--7. " PL13IDNP0 "  " "
bitfld.long 0 11.--15. " PL13IDNP1 "  " "
bitfld.long 0 19.--23. " PL13IDNP2 "  " "
bitfld.long 0 27.--31. " PL13IDNP3 "  " "
tree.end

base sd:0xa0411438
tree "PL14R"
group 0--3
line.long 0 "PL14R"
bitfld.long 0 3.--7. " PL14IDNP0 "  " "
bitfld.long 0 11.--15. " PL14IDNP1 "  " "
bitfld.long 0 19.--23. " PL14IDNP2 "  " "
bitfld.long 0 27.--31. " PL14IDNP3 "  " "
tree.end

base sd:0xa041143c
tree "PL15R"
group 0--3
line.long 0 "PL15R"
bitfld.long 0 3.--7. " PL15IDNP0 "  " "
bitfld.long 0 11.--15. " PL15IDNP1 "  " "
bitfld.long 0 19.--23. " PL15IDNP2 "  " "
bitfld.long 0 27.--31. " PL15IDNP3 "  " "
tree.end

base sd:0xa0411440
tree "PL16R"
group 0--3
line.long 0 "PL16R"
bitfld.long 0 3.--7. " PL16IDNP0 "  " "
bitfld.long 0 11.--15. " PL16IDNP1 "  " "
bitfld.long 0 19.--23. " PL16IDNP2 "  " "
bitfld.long 0 27.--31. " PL16IDNP3 "  " "
tree.end

base sd:0xa0411444
tree "PL17R"
group 0--3
line.long 0 "PL17R"
bitfld.long 0 3.--7. " PL17IDNP0 "  " "
bitfld.long 0 11.--15. " PL17IDNP1 "  " "
bitfld.long 0 19.--23. " PL17IDNP2 "  " "
bitfld.long 0 27.--31. " PL17IDNP3 "  " "
tree.end

base sd:0xa0411448
tree "PL18R"
group 0--3
line.long 0 "PL18R"
bitfld.long 0 3.--7. " PL18IDNP0 "  " "
bitfld.long 0 11.--15. " PL18IDNP1 "  " "
bitfld.long 0 19.--23. " PL18IDNP2 "  " "
bitfld.long 0 27.--31. " PL18IDNP3 "  " "
tree.end

base sd:0xa041144c
tree "PL19R"
group 0--3
line.long 0 "PL19R"
bitfld.long 0 3.--7. " PL19IDNP0 "  " "
bitfld.long 0 11.--15. " PL19IDNP1 "  " "
bitfld.long 0 19.--23. " PL19IDNP2 "  " "
bitfld.long 0 27.--31. " PL19IDNP3 "  " "
tree.end

base sd:0xa0411450
tree "PL20R"
group 0--3
line.long 0 "PL20R"
bitfld.long 0 3.--7. " PL20IDNP0 "  " "
bitfld.long 0 11.--15. " PL20IDNP1 "  " "
bitfld.long 0 19.--23. " PL20IDNP2 "  " "
bitfld.long 0 27.--31. " PL20IDNP3 "  " "
tree.end

base sd:0xa0411454
tree "PL21R"
group 0--3
line.long 0 "PL21R"
bitfld.long 0 3.--7. " PL21IDNP0 "  " "
bitfld.long 0 11.--15. " PL21IDNP1 "  " "
bitfld.long 0 19.--23. " PL21IDNP2 "  " "
bitfld.long 0 27.--31. " PL21IDNP3 "  " "
tree.end

base sd:0xa0411458
tree "PL22R"
group 0--3
line.long 0 "PL22R"
bitfld.long 0 3.--7. " PL22IDNP0 "  " "
bitfld.long 0 11.--15. " PL22IDNP1 "  " "
bitfld.long 0 19.--23. " PL22IDNP2 "  " "
bitfld.long 0 27.--31. " PL22IDNP3 "  " "
tree.end

base sd:0xa041145c
tree "PL23R"
group 0--3
line.long 0 "PL23R"
bitfld.long 0 3.--7. " PL23IDNP0 "  " "
bitfld.long 0 11.--15. " PL23IDNP1 "  " "
bitfld.long 0 19.--23. " PL23IDNP2 "  " "
bitfld.long 0 27.--31. " PL23IDNP3 "  " "
tree.end

base sd:0xa0411460
tree "PL24R"
group 0--3
line.long 0 "PL24R"
bitfld.long 0 3.--7. " PL24IDNP0 "  " "
bitfld.long 0 11.--15. " PL24IDNP1 "  " "
bitfld.long 0 19.--23. " PL24IDNP2 "  " "
bitfld.long 0 27.--31. " PL24IDNP3 "  " "
tree.end

base sd:0xa0411464
tree "PL25R"
group 0--3
line.long 0 "PL25R"
bitfld.long 0 3.--7. " PL25IDNP0 "  " "
bitfld.long 0 11.--15. " PL25IDNP1 "  " "
bitfld.long 0 19.--23. " PL25IDNP2 "  " "
bitfld.long 0 27.--31. " PL25IDNP3 "  " "
tree.end

base sd:0xa0411468
tree "PL26R"
group 0--3
line.long 0 "PL26R"
bitfld.long 0 3.--7. " PL26IDNP0 "  " "
bitfld.long 0 11.--15. " PL26IDNP1 "  " "
bitfld.long 0 19.--23. " PL26IDNP2 "  " "
bitfld.long 0 27.--31. " PL26IDNP3 "  " "
tree.end

base sd:0xa041146c
tree "PL27R"
group 0--3
line.long 0 "PL27R"
bitfld.long 0 3.--7. " PL27IDNP0 "  " "
bitfld.long 0 11.--15. " PL27IDNP1 "  " "
bitfld.long 0 19.--23. " PL27IDNP2 "  " "
bitfld.long 0 27.--31. " PL27IDNP3 "  " "
tree.end

base sd:0xa0411470
tree "PL28R"
group 0--3
line.long 0 "PL28R"
bitfld.long 0 3.--7. " PL28IDNP0 "  " "
bitfld.long 0 11.--15. " PL28IDNP1 "  " "
bitfld.long 0 19.--23. " PL28IDNP2 "  " "
bitfld.long 0 27.--31. " PL28IDNP3 "  " "
tree.end

base sd:0xa0411474
tree "PL29R"
group 0--3
line.long 0 "PL29R"
bitfld.long 0 3.--7. " PL29IDNP0 "  " "
bitfld.long 0 11.--15. " PL29IDNP1 "  " "
bitfld.long 0 19.--23. " PL29IDNP2 "  " "
bitfld.long 0 27.--31. " PL29IDNP3 "  " "
tree.end

base sd:0xa0411478
tree "PL30R"
group 0--3
line.long 0 "PL30R"
bitfld.long 0 3.--7. " PL30IDNP0 "  " "
bitfld.long 0 11.--15. " PL30IDNP1 "  " "
bitfld.long 0 19.--23. " PL30IDNP2 "  " "
bitfld.long 0 27.--31. " PL30IDNP3 "  " "
tree.end

base sd:0xa041147c
tree "PL31R"
group 0--3
line.long 0 "PL31R"
bitfld.long 0 3.--7. " PL31IDNP0 "  " "
bitfld.long 0 11.--15. " PL31IDNP1 "  " "
bitfld.long 0 19.--23. " PL31IDNP2 "  " "
bitfld.long 0 27.--31. " PL31IDNP3 "  " "
tree.end

base sd:0xa0411800
tree "SPIT0R"
group 0--3
line.long 0 "SPIT0R"
bitfld.long 0 0.--7. " SPIT0INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT0INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT0INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT0INTIDNP3 "  " "
tree.end

base sd:0xa0411804
tree "SPIT1R"
group 0--3
line.long 0 "SPIT1R"
bitfld.long 0 0.--7. " SPIT1INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT1INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT1INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT1INTIDNP3 "  " "
tree.end

base sd:0xa0411808
tree "SPIT2R"
group 0--3
line.long 0 "SPIT2R"
bitfld.long 0 0.--7. " SPIT2INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT2INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT2INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT2INTIDNP3 "  " "
tree.end

base sd:0xa041180c
tree "SPIT3R"
group 0--3
line.long 0 "SPIT3R"
bitfld.long 0 0.--7. " SPIT3INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT3INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT3INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT3INTIDNP3 "  " "
tree.end

base sd:0xa0411810
tree "SPIT4R"
group 0--3
line.long 0 "SPIT4R"
bitfld.long 0 0.--7. " SPIT4INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT4INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT4INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT4INTIDNP3 "  " "
tree.end

base sd:0xa0411814
tree "SPIT5R"
group 0--3
line.long 0 "SPIT5R"
bitfld.long 0 0.--7. " SPIT5INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT5INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT5INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT5INTIDNP3 "  " "
tree.end

base sd:0xa0411818
tree "SPIT6R"
group 0--3
line.long 0 "SPIT6R"
bitfld.long 0 0.--7. " SPIT6INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT6INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT6INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT6INTIDNP3 "  " "
tree.end

base sd:0xa041181c
tree "SPIT7R"
group 0--3
line.long 0 "SPIT7R"
bitfld.long 0 0.--7. " SPIT7INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT7INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT7INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT7INTIDNP3 "  " "
tree.end

base sd:0xa0411820
tree "SPIT8R"
group 0--3
line.long 0 "SPIT8R"
bitfld.long 0 0.--7. " SPIT8INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT8INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT8INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT8INTIDNP3 "  " "
tree.end

base sd:0xa0411824
tree "SPIT9R"
group 0--3
line.long 0 "SPIT9R"
bitfld.long 0 0.--7. " SPIT9INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT9INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT9INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT9INTIDNP3 "  " "
tree.end

base sd:0xa0411828
tree "SPIT10R"
group 0--3
line.long 0 "SPIT10R"
bitfld.long 0 0.--7. " SPIT10INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT10INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT10INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT10INTIDNP3 "  " "
tree.end

base sd:0xa041182c
tree "SPIT11R"
group 0--3
line.long 0 "SPIT11R"
bitfld.long 0 0.--7. " SPIT11INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT11INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT11INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT11INTIDNP3 "  " "
tree.end

base sd:0xa0411830
tree "SPIT12R"
group 0--3
line.long 0 "SPIT12R"
bitfld.long 0 0.--7. " SPIT12INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT12INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT12INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT12INTIDNP3 "  " "
tree.end

base sd:0xa0411834
tree "SPIT13R"
group 0--3
line.long 0 "SPIT13R"
bitfld.long 0 0.--7. " SPIT13INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT13INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT13INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT13INTIDNP3 "  " "
tree.end

base sd:0xa0411838
tree "SPIT14R"
group 0--3
line.long 0 "SPIT14R"
bitfld.long 0 0.--7. " SPIT14INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT14INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT14INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT14INTIDNP3 "  " "
tree.end

base sd:0xa041183c
tree "SPIT15R"
group 0--3
line.long 0 "SPIT15R"
bitfld.long 0 0.--7. " SPIT15INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT15INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT15INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT15INTIDNP3 "  " "
tree.end

base sd:0xa0411840
tree "SPIT16R"
group 0--3
line.long 0 "SPIT16R"
bitfld.long 0 0.--7. " SPIT16INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT16INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT16INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT16INTIDNP3 "  " "
tree.end

base sd:0xa0411844
tree "SPIT17R"
group 0--3
line.long 0 "SPIT17R"
bitfld.long 0 0.--7. " SPIT17INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT17INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT17INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT17INTIDNP3 "  " "
tree.end

base sd:0xa0411848
tree "SPIT18R"
group 0--3
line.long 0 "SPIT18R"
bitfld.long 0 0.--7. " SPIT18INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT18INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT18INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT18INTIDNP3 "  " "
tree.end

base sd:0xa041184c
tree "SPIT19R"
group 0--3
line.long 0 "SPIT19R"
bitfld.long 0 0.--7. " SPIT19INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT19INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT19INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT19INTIDNP3 "  " "
tree.end

base sd:0xa0411850
tree "SPIT20R"
group 0--3
line.long 0 "SPIT20R"
bitfld.long 0 0.--7. " SPIT20INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT20INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT20INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT20INTIDNP3 "  " "
tree.end

base sd:0xa0411854
tree "SPIT21R"
group 0--3
line.long 0 "SPIT21R"
bitfld.long 0 0.--7. " SPIT21INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT21INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT21INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT21INTIDNP3 "  " "
tree.end

base sd:0xa0411858
tree "SPIT22R"
group 0--3
line.long 0 "SPIT22R"
bitfld.long 0 0.--7. " SPIT22INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT22INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT22INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT22INTIDNP3 "  " "
tree.end

base sd:0xa041185c
tree "SPIT23R"
group 0--3
line.long 0 "SPIT23R"
bitfld.long 0 0.--7. " SPIT23INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT23INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT23INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT23INTIDNP3 "  " "
tree.end

base sd:0xa0411860
tree "SPIT24R"
group 0--3
line.long 0 "SPIT24R"
bitfld.long 0 0.--7. " SPIT24INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT24INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT24INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT24INTIDNP3 "  " "
tree.end

base sd:0xa0411864
tree "SPIT25R"
group 0--3
line.long 0 "SPIT25R"
bitfld.long 0 0.--7. " SPIT25INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT25INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT25INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT25INTIDNP3 "  " "
tree.end

base sd:0xa0411868
tree "SPIT26R"
group 0--3
line.long 0 "SPIT26R"
bitfld.long 0 0.--7. " SPIT26INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT26INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT26INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT26INTIDNP3 "  " "
tree.end

base sd:0xa041186c
tree "SPIT27R"
group 0--3
line.long 0 "SPIT27R"
bitfld.long 0 0.--7. " SPIT27INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT27INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT27INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT27INTIDNP3 "  " "
tree.end

base sd:0xa0411870
tree "SPIT28R"
group 0--3
line.long 0 "SPIT28R"
bitfld.long 0 0.--7. " SPIT28INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT28INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT28INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT28INTIDNP3 "  " "
tree.end

base sd:0xa0411874
tree "SPIT29R"
group 0--3
line.long 0 "SPIT29R"
bitfld.long 0 0.--7. " SPIT29INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT29INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT29INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT29INTIDNP3 "  " "
tree.end

base sd:0xa0411878
tree "SPIT30R"
group 0--3
line.long 0 "SPIT30R"
bitfld.long 0 0.--7. " SPIT30INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT30INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT30INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT30INTIDNP3 "  " "
tree.end

base sd:0xa041187c
tree "SPIT31R"
group 0--3
line.long 0 "SPIT31R"
bitfld.long 0 0.--7. " SPIT31INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT31INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT31INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT31INTIDNP3 "  " "
tree.end

base sd:0xa0411880
tree "SPIT32R"
group 0--3
line.long 0 "SPIT32R"
bitfld.long 0 0.--7. " SPIT32INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT32INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT32INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT32INTIDNP3 "  " "
tree.end

base sd:0xa0411884
tree "SPIT33R"
group 0--3
line.long 0 "SPIT33R"
bitfld.long 0 0.--7. " SPIT33INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT33INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT33INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT33INTIDNP3 "  " "
tree.end

base sd:0xa0411888
tree "SPIT34R"
group 0--3
line.long 0 "SPIT34R"
bitfld.long 0 0.--7. " SPIT34INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT34INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT34INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT34INTIDNP3 "  " "
tree.end

base sd:0xa041188c
tree "SPIT35R"
group 0--3
line.long 0 "SPIT35R"
bitfld.long 0 0.--7. " SPIT35INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT35INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT35INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT35INTIDNP3 "  " "
tree.end

base sd:0xa0411890
tree "SPIT36R"
group 0--3
line.long 0 "SPIT36R"
bitfld.long 0 0.--7. " SPIT36INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT36INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT36INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT36INTIDNP3 "  " "
tree.end

base sd:0xa0411894
tree "SPIT37R"
group 0--3
line.long 0 "SPIT37R"
bitfld.long 0 0.--7. " SPIT37INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT37INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT37INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT37INTIDNP3 "  " "
tree.end

base sd:0xa0411898
tree "SPIT38R"
group 0--3
line.long 0 "SPIT38R"
bitfld.long 0 0.--7. " SPIT38INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT38INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT38INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT38INTIDNP3 "  " "
tree.end

base sd:0xa041189c
tree "SPIT39R"
group 0--3
line.long 0 "SPIT39R"
bitfld.long 0 0.--7. " SPIT39INTIDNP0 "  " "
bitfld.long 0 8.--15. " SPIT39INTIDNP1 "  " "
bitfld.long 0 16.--23. " SPIT39INTIDNP2 "  " "
bitfld.long 0 24.--31. " SPIT39INTIDNP3 "  " "
tree.end

base sd:0xa0411c00
tree "IC0R"
group 0--3
line.long 0 "IC0R"
bitfld.long 0 0.--31. " IC0 "  " "
tree.end

base sd:0xa0411c04
tree "IC1R"
group 0--3
line.long 0 "IC1R"
bitfld.long 0 0.--31. " IC1 "  " "
tree.end

base sd:0xa0411c08
tree "IC2R"
group 0--3
line.long 0 "IC2R"
bitfld.long 0 0.--31. " IC2 "  " "
tree.end

base sd:0xa0411c0c
tree "IC3R"
group 0--3
line.long 0 "IC3R"
bitfld.long 0 0.--31. " IC3 "  " "
tree.end

base sd:0xa0411c10
tree "IC4R"
group 0--3
line.long 0 "IC4R"
bitfld.long 0 0.--31. " IC4 "  " "
tree.end

base sd:0xa0411c14
tree "IC5R"
group 0--3
line.long 0 "IC5R"
bitfld.long 0 0.--31. " IC5 "  " "
tree.end

base sd:0xa0411c18
tree "IC6R"
group 0--3
line.long 0 "IC6R"
bitfld.long 0 0.--31. " IC6 "  " "
tree.end

base sd:0xa0411c1c
tree "IC7R"
group 0--3
line.long 0 "IC7R"
bitfld.long 0 0.--31. " IC7 "  " "
tree.end

base sd:0xa0411c20
tree "IC8R"
group 0--3
line.long 0 "IC8R"
bitfld.long 0 0.--31. " IC8 "  " "
tree.end

base sd:0xa0411c24
tree "IC9R"
group 0--3
line.long 0 "IC9R"
bitfld.long 0 0.--31. " IC9 "  " "
tree.end

base sd:0xa0411d00
tree "PPISR"
rgroup 0--3
line.long 0 "PPISR"
bitfld.long 0 12.--15. " PPISS "  " "
tree.end

base sd:0xa0411d04
tree "SPIS0R"
rgroup 0--3
line.long 0 "SPIS0R"
bitfld.long 0 0.--31. " SPIS0 "  " "
tree.end

base sd:0xa0411d08
tree "SPIS1R"
rgroup 0--3
line.long 0 "SPIS1R"
bitfld.long 0 0.--31. " SPIS1 "  " "
tree.end

base sd:0xa0411d0c
tree "SPIS2R"
rgroup 0--3
line.long 0 "SPIS2R"
bitfld.long 0 0.--31. " SPIS2 "  " "
tree.end

base sd:0xa0411d10
tree "SPIS3R"
rgroup 0--3
line.long 0 "SPIS3R"
bitfld.long 0 0.--31. " SPIS3 "  " "
tree.end

base sd:0xa0411d14
tree "SPIS4R"
rgroup 0--3
line.long 0 "SPIS4R"
bitfld.long 0 0.--31. " SPIS4 "  " "
tree.end

base sd:0xa0411d18
tree "SPIS5R"
rgroup 0--3
line.long 0 "SPIS5R"
bitfld.long 0 0.--31. " SPIS5 "  " "
tree.end

base sd:0xa0411d1c
tree "SPIS6R"
rgroup 0--3
line.long 0 "SPIS6R"
bitfld.long 0 0.--31. " SPIS6 "  " "
tree.end

base sd:0xa0411d20
tree "SPIS7R"
rgroup 0--3
line.long 0 "SPIS7R"
bitfld.long 0 0.--31. " SPIS7 "  " "
tree.end

base sd:0xa0411d24
tree "SPIS8R"
rgroup 0--3
line.long 0 "SPIS8R"
bitfld.long 0 0.--31. " SPIS8 "  " "
tree.end

base sd:0xa0411d28
tree "SPIS9R"
rgroup 0--3
line.long 0 "SPIS9R"
bitfld.long 0 0.--31. " SPIS9 "  " "
tree.end

base sd:0xa0411d2c
tree "SPIS10R"
rgroup 0--3
line.long 0 "SPIS10R"
bitfld.long 0 0.--31. " SPIS10 "  " "
tree.end

base sd:0xa0411d30
tree "SPIS11R"
rgroup 0--3
line.long 0 "SPIS11R"
bitfld.long 0 0.--31. " SPIS11 "  " "
tree.end

base sd:0xa0411d34
tree "SPIS12R"
rgroup 0--3
line.long 0 "SPIS12R"
bitfld.long 0 0.--31. " SPIS12 "  " "
tree.end

base sd:0xa0411d38
tree "SPIS13R"
rgroup 0--3
line.long 0 "SPIS13R"
bitfld.long 0 0.--31. " SPIS13 "  " "
tree.end

base sd:0xa0411d3c
tree "SPIS14R"
rgroup 0--3
line.long 0 "SPIS14R"
bitfld.long 0 0.--31. " SPIS14 "  " "
tree.end

base sd:0xa0411d40
tree "SPIS15R"
rgroup 0--3
line.long 0 "SPIS15R"
bitfld.long 0 0.--31. " SPIS15 "  " "
tree.end

base sd:0xa0411d44
tree "SPIS16R"
rgroup 0--3
line.long 0 "SPIS16R"
bitfld.long 0 0.--31. " SPIS16 "  " "
tree.end

base sd:0xa0411d48
tree "SPIS17R"
rgroup 0--3
line.long 0 "SPIS17R"
bitfld.long 0 0.--31. " SPIS17 "  " "
tree.end

base sd:0xa0411d4c
tree "SPIS18R"
rgroup 0--3
line.long 0 "SPIS18R"
bitfld.long 0 0.--31. " SPIS18 "  " "
tree.end

base sd:0xa0411d50
tree "SPIS19R"
rgroup 0--3
line.long 0 "SPIS19R"
bitfld.long 0 0.--31. " SPIS19 "  " "
tree.end

base sd:0xa0411d54
tree "SPIS20R"
rgroup 0--3
line.long 0 "SPIS20R"
bitfld.long 0 0.--31. " SPIS20 "  " "
tree.end

base sd:0xa0411d58
tree "SPIS21R"
rgroup 0--3
line.long 0 "SPIS21R"
bitfld.long 0 0.--31. " SPIS21 "  " "
tree.end

base sd:0xa0411d5c
tree "SPIS22R"
rgroup 0--3
line.long 0 "SPIS22R"
bitfld.long 0 0.--31. " SPIS22 "  " "
tree.end

base sd:0xa0411d60
tree "SPIS23R"
rgroup 0--3
line.long 0 "SPIS23R"
bitfld.long 0 0.--31. " SPIS23 "  " "
tree.end

base sd:0xa0411d64
tree "SPIS24R"
rgroup 0--3
line.long 0 "SPIS24R"
bitfld.long 0 0.--31. " SPIS24 "  " "
tree.end

base sd:0xa0411d68
tree "SPIS25R"
rgroup 0--3
line.long 0 "SPIS25R"
bitfld.long 0 0.--31. " SPIS25 "  " "
tree.end

base sd:0xa0411d6c
tree "SPIS26R"
rgroup 0--3
line.long 0 "SPIS26R"
bitfld.long 0 0.--31. " SPIS26 "  " "
tree.end

base sd:0xa0411d70
tree "SPIS27R"
rgroup 0--3
line.long 0 "SPIS27R"
bitfld.long 0 0.--31. " SPIS27 "  " "
tree.end

base sd:0xa0411d74
tree "SPIS28R"
rgroup 0--3
line.long 0 "SPIS28R"
bitfld.long 0 0.--31. " SPIS28 "  " "
tree.end

base sd:0xa0411d78
tree "SPIS29R"
rgroup 0--3
line.long 0 "SPIS29R"
bitfld.long 0 0.--31. " SPIS29 "  " "
tree.end

base sd:0xa0411d7c
tree "SPIS30R"
rgroup 0--3
line.long 0 "SPIS30R"
bitfld.long 0 0.--31. " SPIS30 "  " "
tree.end

base sd:0xa0411f00
tree "STIR"
wgroup 0--3
line.long 0 "STIR"
bitfld.long 0 0.--3. " STIINTID "  " "
bitfld.long 0 15. " STISATT "  "0 ,1 "
bitfld.long 0 16.--23. " STICPUTL "  " "
bitfld.long 0 24.--25. " STITLF "  " "
tree.end

base sd:0xa0411fe0
tree "PPLI0R"
rgroup 0--3
line.long 0 "PPLI0R"
bitfld.long 0 0.--11. " PPLI0PN "  " "
bitfld.long 0 12.--18. " PPLI0JEP106 "  " "
bitfld.long 0 19. " PPLI0JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI0REV "  " "
bitfld.long 0 24.--27. " PPLI0MODNUMBER "  " "
bitfld.long 0 28.--31. " PPLI0REVAND "  " "
tree.end

base sd:0xa0411fe4
tree "PPLI1R"
rgroup 0--3
line.long 0 "PPLI1R"
bitfld.long 0 0.--11. " PPLI1PN "  " "
bitfld.long 0 12.--18. " PPLI1JEP106 "  " "
bitfld.long 0 19. " PPLI1JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI1REV "  " "
bitfld.long 0 24.--27. " PPLI1MODNUMBER "  " "
bitfld.long 0 28.--31. " PPLI1REVAND "  " "
tree.end

base sd:0xa0411fe8
tree "PPLI2R"
rgroup 0--3
line.long 0 "PPLI2R"
bitfld.long 0 0.--11. " PPLI2PN "  " "
bitfld.long 0 12.--18. " PPLI2JEP106 "  " "
bitfld.long 0 19. " PPLI2JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI2REV "  " "
bitfld.long 0 24.--27. " PPLI2MODNUMBER "  " "
bitfld.long 0 28.--31. " PPLI2REVAND "  " "
tree.end

base sd:0xa0411fec
tree "PPLI3R"
rgroup 0--3
line.long 0 "PPLI3R"
bitfld.long 0 0.--11. " PPLI3PN "  " "
bitfld.long 0 12.--18. " PPLI3JEP106 "  " "
bitfld.long 0 19. " PPLI3JEDEC "  "0 ,1 "
bitfld.long 0 20.--23. " PPLI3REV "  " "
bitfld.long 0 24.--27. " PPLI3MODNUMBER "  " "
bitfld.long 0 28.--31. " PPLI3REVAND "  " "
tree.end

base sd:0xa0411ff0
tree "PCI0R"
rgroup 0--3
line.long 0 "PCI0R"
bitfld.long 0 0.--7. " PCI0CID0 "  " "
bitfld.long 0 8.--15. " PCI0CID1 "  " "
bitfld.long 0 16.--23. " PCI0CID2 "  " "
bitfld.long 0 24.--31. " PCI0CID3 "  " "
tree.end

base sd:0xa0411ff4
tree "PCI1R"
rgroup 0--3
line.long 0 "PCI1R"
bitfld.long 0 0.--7. " PCI1CID0 "  " "
bitfld.long 0 8.--15. " PCI1CID1 "  " "
bitfld.long 0 16.--23. " PCI1CID2 "  " "
bitfld.long 0 24.--31. " PCI1CID3 "  " "
tree.end

base sd:0xa0411ff8
tree "PCI2R"
rgroup 0--3
line.long 0 "PCI2R"
bitfld.long 0 0.--7. " PCI2CID0 "  " "
bitfld.long 0 8.--15. " PCI2CID1 "  " "
bitfld.long 0 16.--23. " PCI2CID2 "  " "
bitfld.long 0 24.--31. " PCI2CID3 "  " "
tree.end

base sd:0xa0411ffc
tree "PCI3R"
rgroup 0--3
line.long 0 "PCI3R"
bitfld.long 0 0.--7. " PCI3CID0 "  " "
bitfld.long 0 8.--15. " PCI3CID1 "  " "
bitfld.long 0 16.--23. " PCI3CID2 "  " "
bitfld.long 0 24.--31. " PCI3CID3 "  " "
tree.end

tree.end

;==============================================================
tree "GPIO0"
;==============================================================
base sd:0x8012e000
tree "DAT"
group 0--3
line.long 0 "DAT"
bitfld.long 0 0.--31. " GPDAT "  " "
tree.end

base sd:0x8012e004
tree "DATS"
group 0--3
line.long 0 "DATS"
bitfld.long 0 0.--31. " GPDATS "  " "
tree.end

base sd:0x8012e008
tree "DATC"
group 0--3
line.long 0 "DATC"
bitfld.long 0 0.--31. " GPDATC "  " "
tree.end

base sd:0x8012e00c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
bitfld.long 0 0.--31. " PDIS "  " "
tree.end

base sd:0x8012e010
tree "DIR"
group 0--3
line.long 0 "DIR"
bitfld.long 0 0.--31. " GPDIR "  " "
tree.end

base sd:0x8012e014
tree "DIRS"
group 0--3
line.long 0 "DIRS"
bitfld.long 0 0.--31. " GPDIRS "  " "
tree.end

base sd:0x8012e018
tree "DIRC"
group 0--3
line.long 0 "DIRC"
bitfld.long 0 0.--31. " GPDIRC "  " "
tree.end

base sd:0x8012e01c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
bitfld.long 0 0.--31. " SLPM "  " "
tree.end

base sd:0x8012e020
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
bitfld.long 0 0.--31. " GPAFSA "  " "
tree.end

base sd:0x8012e024
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
bitfld.long 0 0.--31. " GPAFSB "  " "
tree.end

base sd:0x8012e028
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
bitfld.long 0 0.--31. " LOWEMI "  " "
tree.end

base sd:0x8012e040
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
bitfld.long 0 0.--31. " RIMSC "  " "
tree.end

base sd:0x8012e044
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
bitfld.long 0 0.--31. " FIMSC "  " "
tree.end

base sd:0x8012e048
tree "IS"
rgroup 0--3
line.long 0 "IS"
bitfld.long 0 0.--31. " GPIS "  " "
tree.end

base sd:0x8012e04c
tree "IC"
group 0--3
line.long 0 "IC"
bitfld.long 0 0.--31. " GPIC "  " "
tree.end

base sd:0x8012e050
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
bitfld.long 0 0.--31. " RWMSC "  " "
tree.end

base sd:0x8012e054
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
bitfld.long 0 0.--31. " FWMSC "  " "
tree.end

base sd:0x8012e058
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
bitfld.long 0 0.--31. " WKS "  " "
tree.end

base sd:0x8012e7e0
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0x8012e7e4
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " GPIOINTR "  "0 ,1 "
bitfld.long 0 1. " GPIOWKUP "  "0 ,1 "
tree.end

base sd:0x8012e7e8
tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  " "
tree.end

base sd:0x8012efe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x8012efe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x8012efe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x8012efec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x8012eff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " GPIOPCellID0 "  " "
tree.end

base sd:0x8012eff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " GPIOPCellID1 "  " "
tree.end

base sd:0x8012eff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " GPIOPCellID2 "  " "
tree.end

base sd:0x8012effc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " GPIOPCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "GPIO1"
;==============================================================
base sd:0x8012e080
tree "DAT"
group 0--3
line.long 0 "DAT"
bitfld.long 0 0.--31. " GPDAT "  " "
tree.end

base sd:0x8012e084
tree "DATS"
group 0--3
line.long 0 "DATS"
bitfld.long 0 0.--31. " GPDATS "  " "
tree.end

base sd:0x8012e088
tree "DATC"
group 0--3
line.long 0 "DATC"
bitfld.long 0 0.--31. " GPDATC "  " "
tree.end

base sd:0x8012e08c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
bitfld.long 0 0.--31. " PDIS "  " "
tree.end

base sd:0x8012e090
tree "DIR"
group 0--3
line.long 0 "DIR"
bitfld.long 0 0.--31. " GPDIR "  " "
tree.end

base sd:0x8012e094
tree "DIRS"
group 0--3
line.long 0 "DIRS"
bitfld.long 0 0.--31. " GPDIRS "  " "
tree.end

base sd:0x8012e098
tree "DIRC"
group 0--3
line.long 0 "DIRC"
bitfld.long 0 0.--31. " GPDIRC "  " "
tree.end

base sd:0x8012e09c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
bitfld.long 0 0.--31. " SLPM "  " "
tree.end

base sd:0x8012e0a0
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
bitfld.long 0 0.--31. " GPAFSA "  " "
tree.end

base sd:0x8012e0a4
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
bitfld.long 0 0.--31. " GPAFSB "  " "
tree.end

base sd:0x8012e0a8
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
bitfld.long 0 0.--31. " LOWEMI "  " "
tree.end

base sd:0x8012e0c0
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
bitfld.long 0 0.--31. " RIMSC "  " "
tree.end

base sd:0x8012e0c4
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
bitfld.long 0 0.--31. " FIMSC "  " "
tree.end

base sd:0x8012e0c8
tree "IS"
rgroup 0--3
line.long 0 "IS"
bitfld.long 0 0.--31. " GPIS "  " "
tree.end

base sd:0x8012e0cc
tree "IC"
group 0--3
line.long 0 "IC"
bitfld.long 0 0.--31. " GPIC "  " "
tree.end

base sd:0x8012e0d0
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
bitfld.long 0 0.--31. " RWMSC "  " "
tree.end

base sd:0x8012e0d4
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
bitfld.long 0 0.--31. " FWMSC "  " "
tree.end

base sd:0x8012e0d8
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
bitfld.long 0 0.--31. " WKS "  " "
tree.end

tree.end

;==============================================================
tree "GPIO2"
;==============================================================
base sd:0x8000e000
tree "DAT"
group 0--3
line.long 0 "DAT"
bitfld.long 0 0.--31. " GPDAT "  " "
tree.end

base sd:0x8000e004
tree "DATS"
group 0--3
line.long 0 "DATS"
bitfld.long 0 0.--31. " GPDATS "  " "
tree.end

base sd:0x8000e008
tree "DATC"
group 0--3
line.long 0 "DATC"
bitfld.long 0 0.--31. " GPDATC "  " "
tree.end

base sd:0x8000e00c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
bitfld.long 0 0.--31. " PDIS "  " "
tree.end

base sd:0x8000e010
tree "DIR"
group 0--3
line.long 0 "DIR"
bitfld.long 0 0.--31. " GPDIR "  " "
tree.end

base sd:0x8000e014
tree "DIRS"
group 0--3
line.long 0 "DIRS"
bitfld.long 0 0.--31. " GPDIRS "  " "
tree.end

base sd:0x8000e018
tree "DIRC"
group 0--3
line.long 0 "DIRC"
bitfld.long 0 0.--31. " GPDIRC "  " "
tree.end

base sd:0x8000e01c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
bitfld.long 0 0.--31. " SLPM "  " "
tree.end

base sd:0x8000e020
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
bitfld.long 0 0.--31. " GPAFSA "  " "
tree.end

base sd:0x8000e024
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
bitfld.long 0 0.--31. " GPAFSB "  " "
tree.end

base sd:0x8000e028
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
bitfld.long 0 0.--31. " LOWEMI "  " "
tree.end

base sd:0x8000e040
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
bitfld.long 0 0.--31. " RIMSC "  " "
tree.end

base sd:0x8000e044
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
bitfld.long 0 0.--31. " FIMSC "  " "
tree.end

base sd:0x8000e048
tree "IS"
rgroup 0--3
line.long 0 "IS"
bitfld.long 0 0.--31. " GPIS "  " "
tree.end

base sd:0x8000e04c
tree "IC"
group 0--3
line.long 0 "IC"
bitfld.long 0 0.--31. " GPIC "  " "
tree.end

base sd:0x8000e050
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
bitfld.long 0 0.--31. " RWMSC "  " "
tree.end

base sd:0x8000e054
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
bitfld.long 0 0.--31. " FWMSC "  " "
tree.end

base sd:0x8000e058
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
bitfld.long 0 0.--31. " WKS "  " "
tree.end

base sd:0x8000e7e0
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0x8000e7e4
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " GPIOINTR "  "0 ,1 "
bitfld.long 0 1. " GPIOWKUP "  "0 ,1 "
tree.end

base sd:0x8000e7e8
tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  " "
tree.end

base sd:0x8000efe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x8000efe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x8000efe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x8000efec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x8000eff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " GPIOPCellID0 "  " "
tree.end

base sd:0x8000eff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " GPIOPCellID1 "  " "
tree.end

base sd:0x8000eff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " GPIOPCellID2 "  " "
tree.end

base sd:0x8000effc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " GPIOPCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "GPIO3"
;==============================================================
base sd:0x8000e080
tree "DAT"
group 0--3
line.long 0 "DAT"
bitfld.long 0 0.--31. " GPDAT "  " "
tree.end

base sd:0x8000e084
tree "DATS"
group 0--3
line.long 0 "DATS"
bitfld.long 0 0.--31. " GPDATS "  " "
tree.end

base sd:0x8000e088
tree "DATC"
group 0--3
line.long 0 "DATC"
bitfld.long 0 0.--31. " GPDATC "  " "
tree.end

base sd:0x8000e08c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
bitfld.long 0 0.--31. " PDIS "  " "
tree.end

base sd:0x8000e090
tree "DIR"
group 0--3
line.long 0 "DIR"
bitfld.long 0 0.--31. " GPDIR "  " "
tree.end

base sd:0x8000e094
tree "DIRS"
group 0--3
line.long 0 "DIRS"
bitfld.long 0 0.--31. " GPDIRS "  " "
tree.end

base sd:0x8000e098
tree "DIRC"
group 0--3
line.long 0 "DIRC"
bitfld.long 0 0.--31. " GPDIRC "  " "
tree.end

base sd:0x8000e09c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
bitfld.long 0 0.--31. " SLPM "  " "
tree.end

base sd:0x8000e0a0
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
bitfld.long 0 0.--31. " GPAFSA "  " "
tree.end

base sd:0x8000e0a4
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
bitfld.long 0 0.--31. " GPAFSB "  " "
tree.end

base sd:0x8000e0a8
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
bitfld.long 0 0.--31. " LOWEMI "  " "
tree.end

base sd:0x8000e0c0
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
bitfld.long 0 0.--31. " RIMSC "  " "
tree.end

base sd:0x8000e0c4
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
bitfld.long 0 0.--31. " FIMSC "  " "
tree.end

base sd:0x8000e0c8
tree "IS"
rgroup 0--3
line.long 0 "IS"
bitfld.long 0 0.--31. " GPIS "  " "
tree.end

base sd:0x8000e0cc
tree "IC"
group 0--3
line.long 0 "IC"
bitfld.long 0 0.--31. " GPIC "  " "
tree.end

base sd:0x8000e0d0
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
bitfld.long 0 0.--31. " RWMSC "  " "
tree.end

base sd:0x8000e0d4
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
bitfld.long 0 0.--31. " FWMSC "  " "
tree.end

base sd:0x8000e0d8
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
bitfld.long 0 0.--31. " WKS "  " "
tree.end

tree.end

;==============================================================
tree "GPIO4"
;==============================================================
base sd:0x8000e100
tree "DAT"
group 0--3
line.long 0 "DAT"
bitfld.long 0 0.--31. " GPDAT "  " "
tree.end

base sd:0x8000e104
tree "DATS"
group 0--3
line.long 0 "DATS"
bitfld.long 0 0.--31. " GPDATS "  " "
tree.end

base sd:0x8000e108
tree "DATC"
group 0--3
line.long 0 "DATC"
bitfld.long 0 0.--31. " GPDATC "  " "
tree.end

base sd:0x8000e10c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
bitfld.long 0 0.--31. " PDIS "  " "
tree.end

base sd:0x8000e110
tree "DIR"
group 0--3
line.long 0 "DIR"
bitfld.long 0 0.--31. " GPDIR "  " "
tree.end

base sd:0x8000e114
tree "DIRS"
group 0--3
line.long 0 "DIRS"
bitfld.long 0 0.--31. " GPDIRS "  " "
tree.end

base sd:0x8000e118
tree "DIRC"
group 0--3
line.long 0 "DIRC"
bitfld.long 0 0.--31. " GPDIRC "  " "
tree.end

base sd:0x8000e11c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
bitfld.long 0 0.--31. " SLPM "  " "
tree.end

base sd:0x8000e120
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
bitfld.long 0 0.--31. " GPAFSA "  " "
tree.end

base sd:0x8000e124
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
bitfld.long 0 0.--31. " GPAFSB "  " "
tree.end

base sd:0x8000e128
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
bitfld.long 0 0.--31. " LOWEMI "  " "
tree.end

base sd:0x8000e140
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
bitfld.long 0 0.--31. " RIMSC "  " "
tree.end

base sd:0x8000e144
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
bitfld.long 0 0.--31. " FIMSC "  " "
tree.end

base sd:0x8000e148
tree "IS"
rgroup 0--3
line.long 0 "IS"
bitfld.long 0 0.--31. " GPIS "  " "
tree.end

base sd:0x8000e14c
tree "IC"
group 0--3
line.long 0 "IC"
bitfld.long 0 0.--31. " GPIC "  " "
tree.end

base sd:0x8000e150
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
bitfld.long 0 0.--31. " RWMSC "  " "
tree.end

base sd:0x8000e154
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
bitfld.long 0 0.--31. " FWMSC "  " "
tree.end

base sd:0x8000e158
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
bitfld.long 0 0.--31. " WKS "  " "
tree.end

tree.end

;==============================================================
tree "GPIO5"
;==============================================================
base sd:0x8000e180
tree "DAT"
group 0--3
line.long 0 "DAT"
bitfld.long 0 0.--31. " GPDAT "  " "
tree.end

base sd:0x8000e184
tree "DATS"
group 0--3
line.long 0 "DATS"
bitfld.long 0 0.--31. " GPDATS "  " "
tree.end

base sd:0x8000e188
tree "DATC"
group 0--3
line.long 0 "DATC"
bitfld.long 0 0.--31. " GPDATC "  " "
tree.end

base sd:0x8000e18c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
bitfld.long 0 0.--31. " PDIS "  " "
tree.end

base sd:0x8000e190
tree "DIR"
group 0--3
line.long 0 "DIR"
bitfld.long 0 0.--31. " GPDIR "  " "
tree.end

base sd:0x8000e194
tree "DIRS"
group 0--3
line.long 0 "DIRS"
bitfld.long 0 0.--31. " GPDIRS "  " "
tree.end

base sd:0x8000e198
tree "DIRC"
group 0--3
line.long 0 "DIRC"
bitfld.long 0 0.--31. " GPDIRC "  " "
tree.end

base sd:0x8000e19c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
bitfld.long 0 0.--31. " SLPM "  " "
tree.end

base sd:0x8000e1a0
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
bitfld.long 0 0.--31. " GPAFSA "  " "
tree.end

base sd:0x8000e1a4
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
bitfld.long 0 0.--31. " GPAFSB "  " "
tree.end

base sd:0x8000e1a8
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
bitfld.long 0 0.--31. " LOWEMI "  " "
tree.end

base sd:0x8000e1c0
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
bitfld.long 0 0.--31. " RIMSC "  " "
tree.end

base sd:0x8000e1c4
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
bitfld.long 0 0.--31. " FIMSC "  " "
tree.end

base sd:0x8000e1c8
tree "IS"
rgroup 0--3
line.long 0 "IS"
bitfld.long 0 0.--31. " GPIS "  " "
tree.end

base sd:0x8000e1cc
tree "IC"
group 0--3
line.long 0 "IC"
bitfld.long 0 0.--31. " GPIC "  " "
tree.end

base sd:0x8000e1d0
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
bitfld.long 0 0.--31. " RWMSC "  " "
tree.end

base sd:0x8000e1d4
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
bitfld.long 0 0.--31. " FWMSC "  " "
tree.end

base sd:0x8000e1d8
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
bitfld.long 0 0.--31. " WKS "  " "
tree.end

tree.end

;==============================================================
tree "GPIO6"
;==============================================================
base sd:0x8011e000
tree "DAT"
group 0--3
line.long 0 "DAT"
bitfld.long 0 0.--31. " GPDAT "  " "
tree.end

base sd:0x8011e004
tree "DATS"
group 0--3
line.long 0 "DATS"
bitfld.long 0 0.--31. " GPDATS "  " "
tree.end

base sd:0x8011e008
tree "DATC"
group 0--3
line.long 0 "DATC"
bitfld.long 0 0.--31. " GPDATC "  " "
tree.end

base sd:0x8011e00c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
bitfld.long 0 0.--31. " PDIS "  " "
tree.end

base sd:0x8011e010
tree "DIR"
group 0--3
line.long 0 "DIR"
bitfld.long 0 0.--31. " GPDIR "  " "
tree.end

base sd:0x8011e014
tree "DIRS"
group 0--3
line.long 0 "DIRS"
bitfld.long 0 0.--31. " GPDIRS "  " "
tree.end

base sd:0x8011e018
tree "DIRC"
group 0--3
line.long 0 "DIRC"
bitfld.long 0 0.--31. " GPDIRC "  " "
tree.end

base sd:0x8011e01c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
bitfld.long 0 0.--31. " SLPM "  " "
tree.end

base sd:0x8011e020
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
bitfld.long 0 0.--31. " GPAFSA "  " "
tree.end

base sd:0x8011e024
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
bitfld.long 0 0.--31. " GPAFSB "  " "
tree.end

base sd:0x8011e028
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
bitfld.long 0 0.--31. " LOWEMI "  " "
tree.end

base sd:0x8011e040
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
bitfld.long 0 0.--31. " RIMSC "  " "
tree.end

base sd:0x8011e044
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
bitfld.long 0 0.--31. " FIMSC "  " "
tree.end

base sd:0x8011e048
tree "IS"
rgroup 0--3
line.long 0 "IS"
bitfld.long 0 0.--31. " GPIS "  " "
tree.end

base sd:0x8011e04c
tree "IC"
group 0--3
line.long 0 "IC"
bitfld.long 0 0.--31. " GPIC "  " "
tree.end

base sd:0x8011e050
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
bitfld.long 0 0.--31. " RWMSC "  " "
tree.end

base sd:0x8011e054
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
bitfld.long 0 0.--31. " FWMSC "  " "
tree.end

base sd:0x8011e058
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
bitfld.long 0 0.--31. " WKS "  " "
tree.end

base sd:0x8011e7e0
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0x8011e7e4
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " GPIOINTR "  "0 ,1 "
bitfld.long 0 1. " GPIOWKUP "  "0 ,1 "
tree.end

base sd:0x8011e7e8
tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  " "
tree.end

base sd:0x8011efe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x8011efe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x8011efe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x8011efec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x8011eff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " GPIOPCellID0 "  " "
tree.end

base sd:0x8011eff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " GPIOPCellID1 "  " "
tree.end

base sd:0x8011eff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " GPIOPCellID2 "  " "
tree.end

base sd:0x8011effc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " GPIOPCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "GPIO7"
;==============================================================
base sd:0x8011e080
tree "DAT"
group 0--3
line.long 0 "DAT"
bitfld.long 0 0.--31. " GPDAT "  " "
tree.end

base sd:0x8011e084
tree "DATS"
group 0--3
line.long 0 "DATS"
bitfld.long 0 0.--31. " GPDATS "  " "
tree.end

base sd:0x8011e088
tree "DATC"
group 0--3
line.long 0 "DATC"
bitfld.long 0 0.--31. " GPDATC "  " "
tree.end

base sd:0x8011e08c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
bitfld.long 0 0.--31. " PDIS "  " "
tree.end

base sd:0x8011e090
tree "DIR"
group 0--3
line.long 0 "DIR"
bitfld.long 0 0.--31. " GPDIR "  " "
tree.end

base sd:0x8011e094
tree "DIRS"
group 0--3
line.long 0 "DIRS"
bitfld.long 0 0.--31. " GPDIRS "  " "
tree.end

base sd:0x8011e098
tree "DIRC"
group 0--3
line.long 0 "DIRC"
bitfld.long 0 0.--31. " GPDIRC "  " "
tree.end

base sd:0x8011e09c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
bitfld.long 0 0.--31. " SLPM "  " "
tree.end

base sd:0x8011e0a0
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
bitfld.long 0 0.--31. " GPAFSA "  " "
tree.end

base sd:0x8011e0a4
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
bitfld.long 0 0.--31. " GPAFSB "  " "
tree.end

base sd:0x8011e0a8
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
bitfld.long 0 0.--31. " LOWEMI "  " "
tree.end

base sd:0x8011e0c0
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
bitfld.long 0 0.--31. " RIMSC "  " "
tree.end

base sd:0x8011e0c4
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
bitfld.long 0 0.--31. " FIMSC "  " "
tree.end

base sd:0x8011e0c8
tree "IS"
rgroup 0--3
line.long 0 "IS"
bitfld.long 0 0.--31. " GPIS "  " "
tree.end

base sd:0x8011e0cc
tree "IC"
group 0--3
line.long 0 "IC"
bitfld.long 0 0.--31. " GPIC "  " "
tree.end

base sd:0x8011e0d0
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
bitfld.long 0 0.--31. " RWMSC "  " "
tree.end

base sd:0x8011e0d4
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
bitfld.long 0 0.--31. " FWMSC "  " "
tree.end

base sd:0x8011e0d8
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
bitfld.long 0 0.--31. " WKS "  " "
tree.end

tree.end

;==============================================================
tree "GPIO8"
;==============================================================
base sd:0xa03fe000
tree "DAT"
group 0--3
line.long 0 "DAT"
bitfld.long 0 0.--31. " GPDAT "  " "
tree.end

base sd:0xa03fe004
tree "DATS"
group 0--3
line.long 0 "DATS"
bitfld.long 0 0.--31. " GPDATS "  " "
tree.end

base sd:0xa03fe008
tree "DATC"
group 0--3
line.long 0 "DATC"
bitfld.long 0 0.--31. " GPDATC "  " "
tree.end

base sd:0xa03fe00c
tree "PDIS"
group 0--3
line.long 0 "PDIS"
bitfld.long 0 0.--31. " PDIS "  " "
tree.end

base sd:0xa03fe010
tree "DIR"
group 0--3
line.long 0 "DIR"
bitfld.long 0 0.--31. " GPDIR "  " "
tree.end

base sd:0xa03fe014
tree "DIRS"
group 0--3
line.long 0 "DIRS"
bitfld.long 0 0.--31. " GPDIRS "  " "
tree.end

base sd:0xa03fe018
tree "DIRC"
group 0--3
line.long 0 "DIRC"
bitfld.long 0 0.--31. " GPDIRC "  " "
tree.end

base sd:0xa03fe01c
tree "SLPM"
group 0--3
line.long 0 "SLPM"
bitfld.long 0 0.--31. " SLPM "  " "
tree.end

base sd:0xa03fe020
tree "AFSELA"
group 0--3
line.long 0 "AFSELA"
bitfld.long 0 0.--31. " GPAFSA "  " "
tree.end

base sd:0xa03fe024
tree "AFSELB"
group 0--3
line.long 0 "AFSELB"
bitfld.long 0 0.--31. " GPAFSB "  " "
tree.end

base sd:0xa03fe028
tree "LOWEMI"
group 0--3
line.long 0 "LOWEMI"
bitfld.long 0 0.--31. " LOWEMI "  " "
tree.end

base sd:0xa03fe040
tree "RIMSC"
group 0--3
line.long 0 "RIMSC"
bitfld.long 0 0.--31. " RIMSC "  " "
tree.end

base sd:0xa03fe044
tree "FIMSC"
group 0--3
line.long 0 "FIMSC"
bitfld.long 0 0.--31. " FIMSC "  " "
tree.end

base sd:0xa03fe048
tree "IS"
rgroup 0--3
line.long 0 "IS"
bitfld.long 0 0.--31. " GPIS "  " "
tree.end

base sd:0xa03fe04c
tree "IC"
group 0--3
line.long 0 "IC"
bitfld.long 0 0.--31. " GPIC "  " "
tree.end

base sd:0xa03fe050
tree "RWMSC"
group 0--3
line.long 0 "RWMSC"
bitfld.long 0 0.--31. " RWMSC "  " "
tree.end

base sd:0xa03fe054
tree "FWMSC"
group 0--3
line.long 0 "FWMSC"
bitfld.long 0 0.--31. " FWMSC "  " "
tree.end

base sd:0xa03fe058
tree "WKS"
rgroup 0--3
line.long 0 "WKS"
bitfld.long 0 0.--31. " WKS "  " "
tree.end

base sd:0xa03fe7e0
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0xa03fe7e4
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " GPIOINTR "  "0 ,1 "
bitfld.long 0 1. " GPIOWKUP "  "0 ,1 "
tree.end

base sd:0xa03fe7e8
tree "CLKDIV"
group 0--3
line.long 0 "CLKDIV"
bitfld.long 0 0.--1. " CLKDIV "  " "
tree.end

base sd:0xa03fefe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0xa03fefe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0xa03fefe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0xa03fefec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0xa03feff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " GPIOPCellID0 "  " "
tree.end

base sd:0xa03feff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " GPIOPCellID1 "  " "
tree.end

base sd:0xa03feff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " GPIOPCellID2 "  " "
tree.end

base sd:0xa03feffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " GPIOPCellID3 "  " "
tree.end

tree.end

;==============================================================
;tree "HASH (2 instances)"
;==============================================================
base sd:0xa03c1000
;********************************************
tree "HASH-0"
;********************************************
base sd:0xa03c1000
tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SECn "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " INIT "  "0 ,1 "
bitfld.long 0 3. " DMAE "  "0 ,1 "
bitfld.long 0 4.--5. " DATAFORM "  " "
bitfld.long 0 6. " MODE "  "0 ,1 "
bitfld.long 0 7. " ALGO "  "0 ,1 "
bitfld.long 0 8.--11. " NBW "  " "
bitfld.long 0 12. " DINF "  "0 ,1 "
bitfld.long 0 16. " LKEY "  "0 ,1 "
tree.end

base sd:0xa03c1004
tree "0DIN"
group 0--3
line.long 0 "DIN"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0xa03c1008
tree "0STR"
group 0--3
line.long 0 "STR"
bitfld.long 0 0.--4. " NBLW "  " "
bitfld.long 0 8. " DCAL "  "0 ,1 "
tree.end

base sd:0xa03c100c
tree "0H0"
group 0--3
line.long 0 "H0"
bitfld.long 0 0.--31. " H0 "  " "
tree.end

base sd:0xa03c1010
tree "0H1"
group 0--3
line.long 0 "H1"
bitfld.long 0 0.--31. " H1 "  " "
tree.end

base sd:0xa03c1014
tree "0H2"
group 0--3
line.long 0 "H2"
bitfld.long 0 0.--31. " H2 "  " "
tree.end

base sd:0xa03c1018
tree "0H3"
group 0--3
line.long 0 "H3"
bitfld.long 0 0.--31. " H3 "  " "
tree.end

base sd:0xa03c101c
tree "0H4"
group 0--3
line.long 0 "H4"
bitfld.long 0 0.--31. " H4 "  " "
tree.end

base sd:0xa03c1020
tree "0H5"
group 0--3
line.long 0 "H5"
bitfld.long 0 0.--31. " H5 "  " "
tree.end

base sd:0xa03c1024
tree "0H6"
group 0--3
line.long 0 "H6"
bitfld.long 0 0.--31. " H6 "  " "
tree.end

base sd:0xa03c1028
tree "0H7"
group 0--3
line.long 0 "H7"
bitfld.long 0 0.--31. " H7 "  " "
tree.end

base sd:0xa03c1100
tree "0CSR0"
group 0--3
line.long 0 "CSR0"
bitfld.long 0 0.--31. " W0 "  " "
tree.end

base sd:0xa03c1104
tree "0CSR1"
group 0--3
line.long 0 "CSR1"
bitfld.long 0 0.--31. " W1 "  " "
tree.end

base sd:0xa03c1108
tree "0CSR2"
group 0--3
line.long 0 "CSR2"
bitfld.long 0 0.--31. " W2 "  " "
tree.end

base sd:0xa03c110c
tree "0CSR3"
group 0--3
line.long 0 "CSR3"
bitfld.long 0 0.--31. " W3 "  " "
tree.end

base sd:0xa03c1110
tree "0CSR4"
group 0--3
line.long 0 "CSR4"
bitfld.long 0 0.--31. " W4 "  " "
tree.end

base sd:0xa03c1114
tree "0CSR5"
group 0--3
line.long 0 "CSR5"
bitfld.long 0 0.--31. " W5 "  " "
tree.end

base sd:0xa03c1118
tree "0CSR6"
group 0--3
line.long 0 "CSR6"
bitfld.long 0 0.--31. " W6 "  " "
tree.end

base sd:0xa03c111c
tree "0CSR7"
group 0--3
line.long 0 "CSR7"
bitfld.long 0 0.--31. " W7 "  " "
tree.end

base sd:0xa03c1120
tree "0CSR8"
group 0--3
line.long 0 "CSR8"
bitfld.long 0 0.--31. " W8 "  " "
tree.end

base sd:0xa03c1124
tree "0CSR9"
group 0--3
line.long 0 "CSR9"
bitfld.long 0 0.--31. " W9 "  " "
tree.end

base sd:0xa03c1128
tree "0CSR10"
group 0--3
line.long 0 "CSR10"
bitfld.long 0 0.--31. " W10 "  " "
tree.end

base sd:0xa03c112c
tree "0CSR11"
group 0--3
line.long 0 "CSR11"
bitfld.long 0 0.--31. " W11 "  " "
tree.end

base sd:0xa03c1130
tree "0CSR12"
group 0--3
line.long 0 "CSR12"
bitfld.long 0 0.--31. " W12 "  " "
tree.end

base sd:0xa03c1134
tree "0CSR13"
group 0--3
line.long 0 "CSR13"
bitfld.long 0 0.--31. " W13 "  " "
tree.end

base sd:0xa03c1138
tree "0CSR14"
group 0--3
line.long 0 "CSR14"
bitfld.long 0 0.--31. " W14 "  " "
tree.end

base sd:0xa03c113c
tree "0CSR15"
group 0--3
line.long 0 "CSR15"
bitfld.long 0 0.--31. " W15 "  " "
tree.end

base sd:0xa03c1140
tree "0CSR16"
group 0--3
line.long 0 "CSR16"
bitfld.long 0 0.--31. " W16 "  " "
tree.end

base sd:0xa03c1144
tree "0CSR17"
group 0--3
line.long 0 "CSR17"
bitfld.long 0 0.--31. " W17 "  " "
tree.end

base sd:0xa03c1148
tree "0CSR18"
group 0--3
line.long 0 "CSR18"
bitfld.long 0 0.--31. " W18 "  " "
tree.end

base sd:0xa03c114c
tree "0CSR19"
group 0--3
line.long 0 "CSR19"
bitfld.long 0 0.--31. " W19 "  " "
tree.end

base sd:0xa03c1150
tree "0CSR20"
group 0--3
line.long 0 "CSR20"
bitfld.long 0 0.--31. " W20 "  " "
tree.end

base sd:0xa03c1154
tree "0CSR21"
group 0--3
line.long 0 "CSR21"
bitfld.long 0 0.--31. " W21 "  " "
tree.end

base sd:0xa03c1158
tree "0CSR22"
group 0--3
line.long 0 "CSR22"
bitfld.long 0 0.--31. " W22 "  " "
tree.end

base sd:0xa03c115c
tree "0CSR23"
group 0--3
line.long 0 "CSR23"
bitfld.long 0 0.--31. " W23 "  " "
tree.end

base sd:0xa03c1160
tree "0CSR24"
group 0--3
line.long 0 "CSR24"
bitfld.long 0 0.--31. " W24 "  " "
tree.end

base sd:0xa03c1164
tree "0CSR25"
group 0--3
line.long 0 "CSR25"
bitfld.long 0 0.--31. " W25 "  " "
tree.end

base sd:0xa03c1168
tree "0CSR26"
group 0--3
line.long 0 "CSR26"
bitfld.long 0 0.--31. " W26 "  " "
tree.end

base sd:0xa03c116c
tree "0CSR27"
group 0--3
line.long 0 "CSR27"
bitfld.long 0 0.--31. " W27 "  " "
tree.end

base sd:0xa03c1170
tree "0CSR28"
group 0--3
line.long 0 "CSR28"
bitfld.long 0 0.--31. " W28 "  " "
tree.end

base sd:0xa03c1174
tree "0CSR29"
group 0--3
line.long 0 "CSR29"
bitfld.long 0 0.--31. " W29 "  " "
tree.end

base sd:0xa03c1178
tree "0CSR30"
group 0--3
line.long 0 "CSR30"
bitfld.long 0 0.--31. " W30 "  " "
tree.end

base sd:0xa03c117c
tree "0CSR31"
group 0--3
line.long 0 "CSR31"
bitfld.long 0 0.--31. " W31 "  " "
tree.end

base sd:0xa03c1180
tree "0CSR32"
group 0--3
line.long 0 "CSR32"
bitfld.long 0 0.--31. " W32 "  " "
tree.end

base sd:0xa03c1184
tree "0CSR33"
group 0--3
line.long 0 "CSR33"
bitfld.long 0 0.--31. " W33 "  " "
tree.end

base sd:0xa03c1188
tree "0CSR34"
group 0--3
line.long 0 "CSR34"
bitfld.long 0 0.--31. " W34 "  " "
tree.end

base sd:0xa03c118c
tree "0CSR35"
group 0--3
line.long 0 "CSR35"
bitfld.long 0 0.--31. " W35 "  " "
tree.end

base sd:0xa03c1190
tree "0CSR36"
group 0--3
line.long 0 "CSR36"
bitfld.long 0 0.--31. " W36 "  " "
tree.end

base sd:0xa03c1194
tree "0CSR37"
group 0--3
line.long 0 "CSR37"
bitfld.long 0 0.--31. " W37 "  " "
tree.end

base sd:0xa03c1198
tree "0CSR38"
group 0--3
line.long 0 "CSR38"
bitfld.long 0 0.--31. " W38 "  " "
tree.end

base sd:0xa03c119c
tree "0CSR39"
group 0--3
line.long 0 "CSR39"
bitfld.long 0 0.--31. " W39 "  " "
tree.end

base sd:0xa03c11a0
tree "0CSR40"
group 0--3
line.long 0 "CSR40"
bitfld.long 0 0.--31. " W40 "  " "
tree.end

base sd:0xa03c11a4
tree "0CSR41"
group 0--3
line.long 0 "CSR41"
bitfld.long 0 0.--31. " W41 "  " "
tree.end

base sd:0xa03c11a8
tree "0CSR42"
group 0--3
line.long 0 "CSR42"
bitfld.long 0 0.--31. " W42 "  " "
tree.end

base sd:0xa03c11ac
tree "0CSR43"
group 0--3
line.long 0 "CSR43"
bitfld.long 0 0.--31. " W43 "  " "
tree.end

base sd:0xa03c11b0
tree "0CSR44"
group 0--3
line.long 0 "CSR44"
bitfld.long 0 0.--31. " W44 "  " "
tree.end

base sd:0xa03c11b4
tree "0CSR45"
group 0--3
line.long 0 "CSR45"
bitfld.long 0 0.--31. " W45 "  " "
tree.end

base sd:0xa03c11b8
tree "0CSR46"
group 0--3
line.long 0 "CSR46"
bitfld.long 0 0.--31. " W46 "  " "
tree.end

base sd:0xa03c11bc
tree "0CSR47"
group 0--3
line.long 0 "CSR47"
bitfld.long 0 0.--31. " W47 "  " "
tree.end

base sd:0xa03c11c0
tree "0CSR48"
group 0--3
line.long 0 "CSR48"
bitfld.long 0 0.--31. " W48 "  " "
tree.end

base sd:0xa03c11c4
tree "0CSR49"
group 0--3
line.long 0 "CSR49"
bitfld.long 0 0.--31. " W49 "  " "
tree.end

base sd:0xa03c11c8
tree "0CSR50"
group 0--3
line.long 0 "CSR50"
bitfld.long 0 0.--31. " W50 "  " "
tree.end

base sd:0xa03c11cc
tree "0CSR51"
group 0--3
line.long 0 "CSR51"
bitfld.long 0 0.--31. " W51 "  " "
tree.end

base sd:0xa03c10f8
tree "0CSFULL"
group 0--3
line.long 0 "CSFULL"
bitfld.long 0 0.--31. " W40 "  " "
tree.end

base sd:0xa03c10fc
tree "0CSDATAIN"
group 0--3
line.long 0 "CSDATAIN"
bitfld.long 0 0.--31. " W41 "  " "
tree.end

base sd:0xa03c1080
tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0xa03c1084
tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR "  "0 ,1 "
bitfld.long 0 1. " DMATC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
tree.end

base sd:0xa03c1088
tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMABREQ "  "0 ,1 "
tree.end

base sd:0xa03c1fe0
tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0xa03c1fe4
tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0xa03c1fe8
tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0xa03c1fec
tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0xa03c1ff0
tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " PCellID0 "  " "
tree.end

base sd:0xa03c1ff4
tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " PCellID1 "  " "
tree.end

base sd:0xa03c1ff8
tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " PCellID2 "  " "
tree.end

base sd:0xa03c1ffc
tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " PCellID3 "  " "
tree.end

tree.end

base sd:0xa03c2000
;********************************************
tree "HASH-1"
;********************************************
base sd:0xa03c2000
tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SECn "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " INIT "  "0 ,1 "
bitfld.long 0 3. " DMAE "  "0 ,1 "
bitfld.long 0 4.--5. " DATAFORM "  " "
bitfld.long 0 6. " MODE "  "0 ,1 "
bitfld.long 0 7. " ALGO "  "0 ,1 "
bitfld.long 0 8.--11. " NBW "  " "
bitfld.long 0 12. " DINF "  "0 ,1 "
bitfld.long 0 16. " LKEY "  "0 ,1 "
tree.end

base sd:0xa03c2004
tree "1DIN"
group 0--3
line.long 0 "DIN"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0xa03c2008
tree "1STR"
group 0--3
line.long 0 "STR"
bitfld.long 0 0.--4. " NBLW "  " "
bitfld.long 0 8. " DCAL "  "0 ,1 "
tree.end

base sd:0xa03c200c
tree "1H0"
group 0--3
line.long 0 "H0"
bitfld.long 0 0.--31. " H0 "  " "
tree.end

base sd:0xa03c2010
tree "1H1"
group 0--3
line.long 0 "H1"
bitfld.long 0 0.--31. " H1 "  " "
tree.end

base sd:0xa03c2014
tree "1H2"
group 0--3
line.long 0 "H2"
bitfld.long 0 0.--31. " H2 "  " "
tree.end

base sd:0xa03c2018
tree "1H3"
group 0--3
line.long 0 "H3"
bitfld.long 0 0.--31. " H3 "  " "
tree.end

base sd:0xa03c201c
tree "1H4"
group 0--3
line.long 0 "H4"
bitfld.long 0 0.--31. " H4 "  " "
tree.end

base sd:0xa03c2020
tree "1H5"
group 0--3
line.long 0 "H5"
bitfld.long 0 0.--31. " H5 "  " "
tree.end

base sd:0xa03c2024
tree "1H6"
group 0--3
line.long 0 "H6"
bitfld.long 0 0.--31. " H6 "  " "
tree.end

base sd:0xa03c2028
tree "1H7"
group 0--3
line.long 0 "H7"
bitfld.long 0 0.--31. " H7 "  " "
tree.end

base sd:0xa03c2100
tree "1CSR0"
group 0--3
line.long 0 "CSR0"
bitfld.long 0 0.--31. " W0 "  " "
tree.end

base sd:0xa03c2104
tree "1CSR1"
group 0--3
line.long 0 "CSR1"
bitfld.long 0 0.--31. " W1 "  " "
tree.end

base sd:0xa03c2108
tree "1CSR2"
group 0--3
line.long 0 "CSR2"
bitfld.long 0 0.--31. " W2 "  " "
tree.end

base sd:0xa03c210c
tree "1CSR3"
group 0--3
line.long 0 "CSR3"
bitfld.long 0 0.--31. " W3 "  " "
tree.end

base sd:0xa03c2110
tree "1CSR4"
group 0--3
line.long 0 "CSR4"
bitfld.long 0 0.--31. " W4 "  " "
tree.end

base sd:0xa03c2114
tree "1CSR5"
group 0--3
line.long 0 "CSR5"
bitfld.long 0 0.--31. " W5 "  " "
tree.end

base sd:0xa03c2118
tree "1CSR6"
group 0--3
line.long 0 "CSR6"
bitfld.long 0 0.--31. " W6 "  " "
tree.end

base sd:0xa03c211c
tree "1CSR7"
group 0--3
line.long 0 "CSR7"
bitfld.long 0 0.--31. " W7 "  " "
tree.end

base sd:0xa03c2120
tree "1CSR8"
group 0--3
line.long 0 "CSR8"
bitfld.long 0 0.--31. " W8 "  " "
tree.end

base sd:0xa03c2124
tree "1CSR9"
group 0--3
line.long 0 "CSR9"
bitfld.long 0 0.--31. " W9 "  " "
tree.end

base sd:0xa03c2128
tree "1CSR10"
group 0--3
line.long 0 "CSR10"
bitfld.long 0 0.--31. " W10 "  " "
tree.end

base sd:0xa03c212c
tree "1CSR11"
group 0--3
line.long 0 "CSR11"
bitfld.long 0 0.--31. " W11 "  " "
tree.end

base sd:0xa03c2130
tree "1CSR12"
group 0--3
line.long 0 "CSR12"
bitfld.long 0 0.--31. " W12 "  " "
tree.end

base sd:0xa03c2134
tree "1CSR13"
group 0--3
line.long 0 "CSR13"
bitfld.long 0 0.--31. " W13 "  " "
tree.end

base sd:0xa03c2138
tree "1CSR14"
group 0--3
line.long 0 "CSR14"
bitfld.long 0 0.--31. " W14 "  " "
tree.end

base sd:0xa03c213c
tree "1CSR15"
group 0--3
line.long 0 "CSR15"
bitfld.long 0 0.--31. " W15 "  " "
tree.end

base sd:0xa03c2140
tree "1CSR16"
group 0--3
line.long 0 "CSR16"
bitfld.long 0 0.--31. " W16 "  " "
tree.end

base sd:0xa03c2144
tree "1CSR17"
group 0--3
line.long 0 "CSR17"
bitfld.long 0 0.--31. " W17 "  " "
tree.end

base sd:0xa03c2148
tree "1CSR18"
group 0--3
line.long 0 "CSR18"
bitfld.long 0 0.--31. " W18 "  " "
tree.end

base sd:0xa03c214c
tree "1CSR19"
group 0--3
line.long 0 "CSR19"
bitfld.long 0 0.--31. " W19 "  " "
tree.end

base sd:0xa03c2150
tree "1CSR20"
group 0--3
line.long 0 "CSR20"
bitfld.long 0 0.--31. " W20 "  " "
tree.end

base sd:0xa03c2154
tree "1CSR21"
group 0--3
line.long 0 "CSR21"
bitfld.long 0 0.--31. " W21 "  " "
tree.end

base sd:0xa03c2158
tree "1CSR22"
group 0--3
line.long 0 "CSR22"
bitfld.long 0 0.--31. " W22 "  " "
tree.end

base sd:0xa03c215c
tree "1CSR23"
group 0--3
line.long 0 "CSR23"
bitfld.long 0 0.--31. " W23 "  " "
tree.end

base sd:0xa03c2160
tree "1CSR24"
group 0--3
line.long 0 "CSR24"
bitfld.long 0 0.--31. " W24 "  " "
tree.end

base sd:0xa03c2164
tree "1CSR25"
group 0--3
line.long 0 "CSR25"
bitfld.long 0 0.--31. " W25 "  " "
tree.end

base sd:0xa03c2168
tree "1CSR26"
group 0--3
line.long 0 "CSR26"
bitfld.long 0 0.--31. " W26 "  " "
tree.end

base sd:0xa03c216c
tree "1CSR27"
group 0--3
line.long 0 "CSR27"
bitfld.long 0 0.--31. " W27 "  " "
tree.end

base sd:0xa03c2170
tree "1CSR28"
group 0--3
line.long 0 "CSR28"
bitfld.long 0 0.--31. " W28 "  " "
tree.end

base sd:0xa03c2174
tree "1CSR29"
group 0--3
line.long 0 "CSR29"
bitfld.long 0 0.--31. " W29 "  " "
tree.end

base sd:0xa03c2178
tree "1CSR30"
group 0--3
line.long 0 "CSR30"
bitfld.long 0 0.--31. " W30 "  " "
tree.end

base sd:0xa03c217c
tree "1CSR31"
group 0--3
line.long 0 "CSR31"
bitfld.long 0 0.--31. " W31 "  " "
tree.end

base sd:0xa03c2180
tree "1CSR32"
group 0--3
line.long 0 "CSR32"
bitfld.long 0 0.--31. " W32 "  " "
tree.end

base sd:0xa03c2184
tree "1CSR33"
group 0--3
line.long 0 "CSR33"
bitfld.long 0 0.--31. " W33 "  " "
tree.end

base sd:0xa03c2188
tree "1CSR34"
group 0--3
line.long 0 "CSR34"
bitfld.long 0 0.--31. " W34 "  " "
tree.end

base sd:0xa03c218c
tree "1CSR35"
group 0--3
line.long 0 "CSR35"
bitfld.long 0 0.--31. " W35 "  " "
tree.end

base sd:0xa03c2190
tree "1CSR36"
group 0--3
line.long 0 "CSR36"
bitfld.long 0 0.--31. " W36 "  " "
tree.end

base sd:0xa03c2194
tree "1CSR37"
group 0--3
line.long 0 "CSR37"
bitfld.long 0 0.--31. " W37 "  " "
tree.end

base sd:0xa03c2198
tree "1CSR38"
group 0--3
line.long 0 "CSR38"
bitfld.long 0 0.--31. " W38 "  " "
tree.end

base sd:0xa03c219c
tree "1CSR39"
group 0--3
line.long 0 "CSR39"
bitfld.long 0 0.--31. " W39 "  " "
tree.end

base sd:0xa03c21a0
tree "1CSR40"
group 0--3
line.long 0 "CSR40"
bitfld.long 0 0.--31. " W40 "  " "
tree.end

base sd:0xa03c21a4
tree "1CSR41"
group 0--3
line.long 0 "CSR41"
bitfld.long 0 0.--31. " W41 "  " "
tree.end

base sd:0xa03c21a8
tree "1CSR42"
group 0--3
line.long 0 "CSR42"
bitfld.long 0 0.--31. " W42 "  " "
tree.end

base sd:0xa03c21ac
tree "1CSR43"
group 0--3
line.long 0 "CSR43"
bitfld.long 0 0.--31. " W43 "  " "
tree.end

base sd:0xa03c21b0
tree "1CSR44"
group 0--3
line.long 0 "CSR44"
bitfld.long 0 0.--31. " W44 "  " "
tree.end

base sd:0xa03c21b4
tree "1CSR45"
group 0--3
line.long 0 "CSR45"
bitfld.long 0 0.--31. " W45 "  " "
tree.end

base sd:0xa03c21b8
tree "1CSR46"
group 0--3
line.long 0 "CSR46"
bitfld.long 0 0.--31. " W46 "  " "
tree.end

base sd:0xa03c21bc
tree "1CSR47"
group 0--3
line.long 0 "CSR47"
bitfld.long 0 0.--31. " W47 "  " "
tree.end

base sd:0xa03c21c0
tree "1CSR48"
group 0--3
line.long 0 "CSR48"
bitfld.long 0 0.--31. " W48 "  " "
tree.end

base sd:0xa03c21c4
tree "1CSR49"
group 0--3
line.long 0 "CSR49"
bitfld.long 0 0.--31. " W49 "  " "
tree.end

base sd:0xa03c21c8
tree "1CSR50"
group 0--3
line.long 0 "CSR50"
bitfld.long 0 0.--31. " W50 "  " "
tree.end

base sd:0xa03c21cc
tree "1CSR51"
group 0--3
line.long 0 "CSR51"
bitfld.long 0 0.--31. " W51 "  " "
tree.end

base sd:0xa03c20f8
tree "1CSFULL"
group 0--3
line.long 0 "CSFULL"
bitfld.long 0 0.--31. " W40 "  " "
tree.end

base sd:0xa03c20fc
tree "1CSDATAIN"
group 0--3
line.long 0 "CSDATAIN"
bitfld.long 0 0.--31. " W41 "  " "
tree.end

base sd:0xa03c2080
tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0xa03c2084
tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR "  "0 ,1 "
bitfld.long 0 1. " DMATC "  "0 ,1 "
bitfld.long 0 2. " SECMOD "  "0 ,1 "
tree.end

base sd:0xa03c2088
tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " DMABREQ "  "0 ,1 "
tree.end

base sd:0xa03c2fe0
tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0xa03c2fe4
tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0xa03c2fe8
tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0xa03c2fec
tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0xa03c2ff0
tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " PCellID0 "  " "
tree.end

base sd:0xa03c2ff4
tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " PCellID1 "  " "
tree.end

base sd:0xa03c2ff8
tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " PCellID2 "  " "
tree.end

base sd:0xa03c2ffc
tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " PCellID3 "  " "
tree.end

;tree.end

tree.end

;==============================================================
tree "HSEM"
;==============================================================
base sd:0x80140000
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PROT2 "  "0 ,1 "
tree.end

base sd:0x80140008
tree "R0"
group 0--3
line.long 0 "R0"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x8014000c
tree "R1"
group 0--3
line.long 0 "R1"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140010
tree "R2"
group 0--3
line.long 0 "R2"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140014
tree "R3"
group 0--3
line.long 0 "R3"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140018
tree "R4"
group 0--3
line.long 0 "R4"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x8014001c
tree "R5"
group 0--3
line.long 0 "R5"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140020
tree "R6"
group 0--3
line.long 0 "R6"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140024
tree "R7"
group 0--3
line.long 0 "R7"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140028
tree "R8"
group 0--3
line.long 0 "R8"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x8014002c
tree "R9"
group 0--3
line.long 0 "R9"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140030
tree "R10"
group 0--3
line.long 0 "R10"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140034
tree "R11"
group 0--3
line.long 0 "R11"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140038
tree "R12"
group 0--3
line.long 0 "R12"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x8014003c
tree "R13"
group 0--3
line.long 0 "R13"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140040
tree "R14"
group 0--3
line.long 0 "R14"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140044
tree "R15"
group 0--3
line.long 0 "R15"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140048
tree "R16"
group 0--3
line.long 0 "R16"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x8014004c
tree "R17"
group 0--3
line.long 0 "R17"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140050
tree "R18"
group 0--3
line.long 0 "R18"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140054
tree "R19"
group 0--3
line.long 0 "R19"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140058
tree "R20"
group 0--3
line.long 0 "R20"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x8014005c
tree "R21"
group 0--3
line.long 0 "R21"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140060
tree "R22"
group 0--3
line.long 0 "R22"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140064
tree "R23"
group 0--3
line.long 0 "R23"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140068
tree "R24"
group 0--3
line.long 0 "R24"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x8014006c
tree "R25"
group 0--3
line.long 0 "R25"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140070
tree "R26"
group 0--3
line.long 0 "R26"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140074
tree "R27"
group 0--3
line.long 0 "R27"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140078
tree "R28"
group 0--3
line.long 0 "R28"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x8014007c
tree "R29"
group 0--3
line.long 0 "R29"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140080
tree "R30"
group 0--3
line.long 0 "R30"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140084
tree "R31"
group 0--3
line.long 0 "R31"
bitfld.long 0 0.--3. " HSEMDAT "  " "
bitfld.long 0 4. " INTSA "  "0 ,1 "
bitfld.long 0 5. " INTSB "  "0 ,1 "
bitfld.long 0 6. " INTSC "  "0 ,1 "
bitfld.long 0 7. " INTSD "  "0 ,1 "
bitfld.long 0 8. " INTSE "  "0 ,1 "
bitfld.long 0 16.--21. " HSEMDAT2 "  " "
tree.end

base sd:0x80140090
tree "ICRALL"
wgroup 0--3
line.long 0 "ICRALL"
bitfld.long 0 0. " HSEMICALL0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICALL1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICALL2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICALL3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICALL4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICALL5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICALL6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICALL7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICALL8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICALL9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICALL10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICALL11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICALL12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICALL13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICALL14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICALL15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICALL16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICALL17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICALL18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICALL19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICALL20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICALL21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICALL22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICALL23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICALL24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICALL25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICALL26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICALL27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICALL28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICALL29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICALL30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICALL31 "  "0 ,1 "
tree.end

base sd:0x801400a0
tree "IMSCA"
group 0--3
line.long 0 "IMSCA"
bitfld.long 0 0. " HSEMIMA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMA31 "  "0 ,1 "
tree.end

base sd:0x801400a4
tree "RISA"
rgroup 0--3
line.long 0 "RISA"
bitfld.long 0 0. " HSEMRISA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISA31 "  "0 ,1 "
tree.end

base sd:0x801400a8
tree "MISA"
rgroup 0--3
line.long 0 "MISA"
bitfld.long 0 0. " HSEMMISA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISA31 "  "0 ,1 "
tree.end

base sd:0x801400ac
tree "ICRA"
wgroup 0--3
line.long 0 "ICRA"
bitfld.long 0 0. " HSEMICA0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICA1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICA2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICA3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICA4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICA5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICA6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICA7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICA8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICA9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICA10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICA11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICA12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICA13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICA14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICA15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICA16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICA17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICA18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICA19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICA20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICA21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICA22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICA23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICA24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICA25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICA26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICA27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICA28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICA29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICA30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICA31 "  "0 ,1 "
tree.end

base sd:0x801400b0
tree "IMSCB"
group 0--3
line.long 0 "IMSCB"
bitfld.long 0 0. " HSEMIMB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMB31 "  "0 ,1 "
tree.end

base sd:0x801400b4
tree "RISB"
rgroup 0--3
line.long 0 "RISB"
bitfld.long 0 0. " HSEMRISB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISB31 "  "0 ,1 "
tree.end

base sd:0x801400b8
tree "MISB"
rgroup 0--3
line.long 0 "MISB"
bitfld.long 0 0. " HSEMMISB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISB31 "  "0 ,1 "
tree.end

base sd:0x801400bc
tree "ICRB"
wgroup 0--3
line.long 0 "ICRB"
bitfld.long 0 0. " HSEMICB0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICB1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICB2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICB3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICB4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICB5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICB6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICB7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICB8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICB9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICB10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICB11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICB12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICB13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICB14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICB15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICB16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICB17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICB18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICB19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICB20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICB21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICB22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICB23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICB24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICB25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICB26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICB27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICB28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICB29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICB30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICB31 "  "0 ,1 "
tree.end

base sd:0x801400c0
tree "IMSCC"
group 0--3
line.long 0 "IMSCC"
bitfld.long 0 0. " HSEMIMC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMC31 "  "0 ,1 "
tree.end

base sd:0x801400c4
tree "RISC"
rgroup 0--3
line.long 0 "RISC"
bitfld.long 0 0. " HSEMRISC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISC31 "  "0 ,1 "
tree.end

base sd:0x801400c8
tree "MISC"
rgroup 0--3
line.long 0 "MISC"
bitfld.long 0 0. " HSEMMISC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISC31 "  "0 ,1 "
tree.end

base sd:0x801400cc
tree "ICRC"
wgroup 0--3
line.long 0 "ICRC"
bitfld.long 0 0. " HSEMICC0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICC1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICC2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICC3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICC4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICC5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICC6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICC7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICC8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICC9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICC10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICC11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICC12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICC13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICC14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICC15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICC16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICC17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICC18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICC19 "  "0 ,1 "
bitfld.long 0 20. " HSEMICC20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICC21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICC22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICC23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICC24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICC25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICC26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICC27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICC28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICC29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICC30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICC31 "  "0 ,1 "
tree.end

base sd:0x801400d0
tree "IMSCD"
group 0--3
line.long 0 "IMSCD"
bitfld.long 0 0. " HSEMIMD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIMD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIMD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIMD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIMD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIMD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIMD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIMD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIMD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIMD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIMD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIMD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIMD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIMD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIMD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIMD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIMD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIMD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIMD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIMD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIMD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIMD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIMD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIMD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIMD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIMD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIMD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIMD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIMD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIMD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIMD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIMD31 "  "0 ,1 "
tree.end

base sd:0x801400d4
tree "RISD"
rgroup 0--3
line.long 0 "RISD"
bitfld.long 0 0. " HSEMRISD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISD31 "  "0 ,1 "
tree.end

base sd:0x801400d8
tree "MISD"
rgroup 0--3
line.long 0 "MISD"
bitfld.long 0 0. " HSEMMISD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISD20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISD31 "  "0 ,1 "
tree.end

base sd:0x801400dc
tree "ICRD"
wgroup 0--3
line.long 0 "ICRD"
bitfld.long 0 0. " HSEMICD0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICD1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICD2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICD3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICD4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICD5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICD6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICD7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICD8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICD9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICD10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICD11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICD12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICD13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICD14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICD15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICD16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICD17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICD18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICD19 "  "0 ,1 "
bitfld.long 0 20. " HSEMID20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICD21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICD22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICD23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICD24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICD25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICD26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICD27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICD28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICD29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICD30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICD31 "  "0 ,1 "
tree.end

base sd:0x801400e0
tree "IMSCE"
group 0--3
line.long 0 "IMSCE"
bitfld.long 0 0. " HSEMIME0 "  "0 ,1 "
bitfld.long 0 1. " HSEMIME1 "  "0 ,1 "
bitfld.long 0 2. " HSEMIME2 "  "0 ,1 "
bitfld.long 0 3. " HSEMIME3 "  "0 ,1 "
bitfld.long 0 4. " HSEMIME4 "  "0 ,1 "
bitfld.long 0 5. " HSEMIME5 "  "0 ,1 "
bitfld.long 0 6. " HSEMIME6 "  "0 ,1 "
bitfld.long 0 7. " HSEMIME7 "  "0 ,1 "
bitfld.long 0 8. " HSEMIME8 "  "0 ,1 "
bitfld.long 0 9. " HSEMIME9 "  "0 ,1 "
bitfld.long 0 10. " HSEMIME10 "  "0 ,1 "
bitfld.long 0 11. " HSEMIME11 "  "0 ,1 "
bitfld.long 0 12. " HSEMIME12 "  "0 ,1 "
bitfld.long 0 13. " HSEMIME13 "  "0 ,1 "
bitfld.long 0 14. " HSEMIME14 "  "0 ,1 "
bitfld.long 0 15. " HSEMIME15 "  "0 ,1 "
bitfld.long 0 16. " HSEMIME16 "  "0 ,1 "
bitfld.long 0 17. " HSEMIME17 "  "0 ,1 "
bitfld.long 0 18. " HSEMIME18 "  "0 ,1 "
bitfld.long 0 19. " HSEMIME19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIME20 "  "0 ,1 "
bitfld.long 0 21. " HSEMIME21 "  "0 ,1 "
bitfld.long 0 22. " HSEMIME22 "  "0 ,1 "
bitfld.long 0 23. " HSEMIME23 "  "0 ,1 "
bitfld.long 0 24. " HSEMIME24 "  "0 ,1 "
bitfld.long 0 25. " HSEMIME25 "  "0 ,1 "
bitfld.long 0 26. " HSEMIME26 "  "0 ,1 "
bitfld.long 0 27. " HSEMIME27 "  "0 ,1 "
bitfld.long 0 28. " HSEMIME28 "  "0 ,1 "
bitfld.long 0 29. " HSEMIME29 "  "0 ,1 "
bitfld.long 0 30. " HSEMIME30 "  "0 ,1 "
bitfld.long 0 31. " HSEMIME31 "  "0 ,1 "
tree.end

base sd:0x801400e4
tree "RISE"
rgroup 0--3
line.long 0 "RISE"
bitfld.long 0 0. " HSEMRISE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMRISE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMRISE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMRISE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMRISE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMRISE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMRISE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMRISE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMRISE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMRISE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMRISE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMRISE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMRISE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMRISE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMRISE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMRISE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMRISE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMRISE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMRISE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMRISE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMRISE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMRISE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMRISE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMRISE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMRISE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMRISE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMRISE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMRISE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMRISE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMRISE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMRISE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMRISE31 "  "0 ,1 "
tree.end

base sd:0x801400e8
tree "MISE"
rgroup 0--3
line.long 0 "MISE"
bitfld.long 0 0. " HSEMMISE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMMISE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMMISE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMMISE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMMISE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMMISE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMMISE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMMISE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMMISE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMMISE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMMISE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMMISE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMMISE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMMISE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMMISE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMMISE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMMISE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMMISE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMMISE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMMISE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMMISE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMMISE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMMISE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMMISE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMMISE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMMISE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMMISE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMMISE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMMISE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMMISE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMMISE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMMISE31 "  "0 ,1 "
tree.end

base sd:0x801400ec
tree "ICRE"
wgroup 0--3
line.long 0 "ICRE"
bitfld.long 0 0. " HSEMICE0 "  "0 ,1 "
bitfld.long 0 1. " HSEMICE1 "  "0 ,1 "
bitfld.long 0 2. " HSEMICE2 "  "0 ,1 "
bitfld.long 0 3. " HSEMICE3 "  "0 ,1 "
bitfld.long 0 4. " HSEMICE4 "  "0 ,1 "
bitfld.long 0 5. " HSEMICE5 "  "0 ,1 "
bitfld.long 0 6. " HSEMICE6 "  "0 ,1 "
bitfld.long 0 7. " HSEMICE7 "  "0 ,1 "
bitfld.long 0 8. " HSEMICE8 "  "0 ,1 "
bitfld.long 0 9. " HSEMICE9 "  "0 ,1 "
bitfld.long 0 10. " HSEMICE10 "  "0 ,1 "
bitfld.long 0 11. " HSEMICE11 "  "0 ,1 "
bitfld.long 0 12. " HSEMICE12 "  "0 ,1 "
bitfld.long 0 13. " HSEMICE13 "  "0 ,1 "
bitfld.long 0 14. " HSEMICE14 "  "0 ,1 "
bitfld.long 0 15. " HSEMICE15 "  "0 ,1 "
bitfld.long 0 16. " HSEMICE16 "  "0 ,1 "
bitfld.long 0 17. " HSEMICE17 "  "0 ,1 "
bitfld.long 0 18. " HSEMICE18 "  "0 ,1 "
bitfld.long 0 19. " HSEMICE19 "  "0 ,1 "
bitfld.long 0 20. " HSEMIE20 "  "0 ,1 "
bitfld.long 0 21. " HSEMICE21 "  "0 ,1 "
bitfld.long 0 22. " HSEMICE22 "  "0 ,1 "
bitfld.long 0 23. " HSEMICE23 "  "0 ,1 "
bitfld.long 0 24. " HSEMICE24 "  "0 ,1 "
bitfld.long 0 25. " HSEMICE25 "  "0 ,1 "
bitfld.long 0 26. " HSEMICE26 "  "0 ,1 "
bitfld.long 0 27. " HSEMICE27 "  "0 ,1 "
bitfld.long 0 28. " HSEMICE28 "  "0 ,1 "
bitfld.long 0 29. " HSEMICE29 "  "0 ,1 "
bitfld.long 0 30. " HSEMICE30 "  "0 ,1 "
bitfld.long 0 31. " HSEMICE31 "  "0 ,1 "
tree.end

base sd:0x80140100
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0x80140108
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " HSEMINTRA "  "0 ,1 "
bitfld.long 0 1. " HSEMINTRB "  "0 ,1 "
bitfld.long 0 2. " HSEMINTRC "  "0 ,1 "
bitfld.long 0 3. " HSEMINTRD "  "0 ,1 "
bitfld.long 0 4. " HSEMINTRE "  "0 ,1 "
tree.end

base sd:0x80140fe0
tree "HSEMPeriphID0"
rgroup 0--3
line.long 0 "HSEMPeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x80140fe4
tree "HSEMPeriphID1"
rgroup 0--3
line.long 0 "HSEMPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80140fe8
tree "HSEMPeriphID2"
rgroup 0--3
line.long 0 "HSEMPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80140fec
tree "HSEMPeriphID3"
rgroup 0--3
line.long 0 "HSEMPeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80140ff0
tree "HSEMPCellID0"
rgroup 0--3
line.long 0 "HSEMPCellID0"
bitfld.long 0 0.--7. " HSEMPCellID0 "  " "
tree.end

base sd:0x80140ff4
tree "HSEMPCellID1"
rgroup 0--3
line.long 0 "HSEMPCellID1"
bitfld.long 0 0.--7. " HSEMPCellID1 "  " "
tree.end

base sd:0x80140ff8
tree "HSEMPCellID2"
rgroup 0--3
line.long 0 "HSEMPCellID2"
bitfld.long 0 0.--7. " HSEMPCellID2 "  " "
tree.end

base sd:0x80140ffc
tree "HSEMPCellID3"
rgroup 0--3
line.long 0 "HSEMPCellID3"
bitfld.long 0 0.--7. " HSEMPCellID3 "  " "
tree.end

tree.end

;==============================================================
;tree "HSI2C (5 instances)"
;==============================================================
base sd:0x80122000
;********************************************
tree "HSI2C-1"
;********************************************
base sd:0x80122000
tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  " "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  " "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  " "
bitfld.long 0 15. " FS "  "0 ,1 "
tree.end

base sd:0x80122004
tree "1SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  " "
bitfld.long 0 16.--31. " SLSU "  " "
tree.end

base sd:0x80122008
tree "1HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  " "
tree.end

base sd:0x8012200c
tree "1MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  " "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  " "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
tree.end

base sd:0x80122010
tree "1TFR"
wgroup 0--3
line.long 0 "TFR"
bitfld.long 0 0.--7. " TDATA "  " "
tree.end

base sd:0x80122014
tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  " "
bitfld.long 0 2.--3. " STATUS "  " "
bitfld.long 0 4.--6. " CAUSE "  " "
bitfld.long 0 7.--8. " TYPE "  " "
bitfld.long 0 9.--19. " LENGTH "  " "
tree.end

base sd:0x80122018
tree "1RFR"
rgroup 0--3
line.long 0 "RFR"
bitfld.long 0 0.--7. " RDATA "  " "
tree.end

base sd:0x8012201c
tree "1TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  " "
tree.end

base sd:0x80122020
tree "1RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  " "
tree.end

base sd:0x80122024
tree "1DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  " "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  " "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
tree.end

base sd:0x80122028
tree "1BRCR"
group 0--3
line.long 0 "BRCR"
bitfld.long 0 0.--15. " BRCNT2 "  " "
bitfld.long 0 16.--31. " BRCNT1 "  " "
tree.end

base sd:0x8012202c
tree "1IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
tree.end

base sd:0x80122030
tree "1RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
tree.end

base sd:0x80122034
tree "1MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
tree.end

base sd:0x80122038
tree "1ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
tree.end

base sd:0x8012203c
tree "1I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
tree.end

base sd:0x80122040
tree "1I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
tree.end

base sd:0x80122044
tree "1I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
tree.end

base sd:0x80122048
tree "1I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
bitfld.long 0 0.--31. " TESTDATA "  " "
tree.end

base sd:0x8012204c
tree "1I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
tree.end

base sd:0x80122050
tree "1I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base sd:0x80122054
tree "1I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base sd:0x80122058
tree "1I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base sd:0x8012205c
tree "1I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base sd:0x80122fe0
tree "1PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80122fe4
tree "1PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80122fe8
tree "1PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80122fec
tree "1PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80122ff0
tree "1PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
bitfld.long 0 0.--7. " I2CPCellID0 "  " "
tree.end

base sd:0x80122ff4
tree "1PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
bitfld.long 0 0.--7. " I2CPCellID1 "  " "
tree.end

base sd:0x80122ff8
tree "1PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
bitfld.long 0 0.--7. " I2CPCellID2 "  " "
tree.end

base sd:0x80122ffc
tree "1PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
bitfld.long 0 0.--7. " I2CPCellID3 "  " "
tree.end

tree.end

base sd:0x80128000
;********************************************
tree "HSI2C-2"
;********************************************
base sd:0x80128000
tree "2CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  " "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  " "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  " "
bitfld.long 0 15. " FS "  "0 ,1 "
tree.end

base sd:0x80128004
tree "2SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  " "
bitfld.long 0 16.--31. " SLSU "  " "
tree.end

base sd:0x80128008
tree "2HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  " "
tree.end

base sd:0x8012800c
tree "2MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  " "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  " "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
tree.end

base sd:0x80128010
tree "2TFR"
wgroup 0--3
line.long 0 "TFR"
bitfld.long 0 0.--7. " TDATA "  " "
tree.end

base sd:0x80128014
tree "2SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  " "
bitfld.long 0 2.--3. " STATUS "  " "
bitfld.long 0 4.--6. " CAUSE "  " "
bitfld.long 0 7.--8. " TYPE "  " "
bitfld.long 0 9.--19. " LENGTH "  " "
tree.end

base sd:0x80128018
tree "2RFR"
rgroup 0--3
line.long 0 "RFR"
bitfld.long 0 0.--7. " RDATA "  " "
tree.end

base sd:0x8012801c
tree "2TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  " "
tree.end

base sd:0x80128020
tree "2RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  " "
tree.end

base sd:0x80128024
tree "2DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  " "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  " "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
tree.end

base sd:0x80128028
tree "2BRCR"
group 0--3
line.long 0 "BRCR"
bitfld.long 0 0.--15. " BRCNT2 "  " "
bitfld.long 0 16.--31. " BRCNT1 "  " "
tree.end

base sd:0x8012802c
tree "2IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
tree.end

base sd:0x80128030
tree "2RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
tree.end

base sd:0x80128034
tree "2MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
tree.end

base sd:0x80128038
tree "2ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
tree.end

base sd:0x8012803c
tree "2I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
tree.end

base sd:0x80128040
tree "2I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
tree.end

base sd:0x80128044
tree "2I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
tree.end

base sd:0x80128048
tree "2I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
bitfld.long 0 0.--31. " TESTDATA "  " "
tree.end

base sd:0x8012804c
tree "2I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
tree.end

base sd:0x80128050
tree "2I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base sd:0x80128054
tree "2I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base sd:0x80128058
tree "2I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base sd:0x8012805c
tree "2I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base sd:0x80128fe0
tree "2PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80128fe4
tree "2PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80128fe8
tree "2PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80128fec
tree "2PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80128ff0
tree "2PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
bitfld.long 0 0.--7. " I2CPCellID0 "  " "
tree.end

base sd:0x80128ff4
tree "2PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
bitfld.long 0 0.--7. " I2CPCellID1 "  " "
tree.end

base sd:0x80128ff8
tree "2PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
bitfld.long 0 0.--7. " I2CPCellID2 "  " "
tree.end

base sd:0x80128ffc
tree "2PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
bitfld.long 0 0.--7. " I2CPCellID3 "  " "
tree.end

tree.end

base sd:0x8012a000
;********************************************
tree "HSI2C-4"
;********************************************
base sd:0x8012a000
tree "4CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  " "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  " "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  " "
bitfld.long 0 15. " FS "  "0 ,1 "
tree.end

base sd:0x8012a004
tree "4SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  " "
bitfld.long 0 16.--31. " SLSU "  " "
tree.end

base sd:0x8012a008
tree "4HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  " "
tree.end

base sd:0x8012a00c
tree "4MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  " "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  " "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
tree.end

base sd:0x8012a010
tree "4TFR"
wgroup 0--3
line.long 0 "TFR"
bitfld.long 0 0.--7. " TDATA "  " "
tree.end

base sd:0x8012a014
tree "4SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  " "
bitfld.long 0 2.--3. " STATUS "  " "
bitfld.long 0 4.--6. " CAUSE "  " "
bitfld.long 0 7.--8. " TYPE "  " "
bitfld.long 0 9.--19. " LENGTH "  " "
tree.end

base sd:0x8012a018
tree "4RFR"
rgroup 0--3
line.long 0 "RFR"
bitfld.long 0 0.--7. " RDATA "  " "
tree.end

base sd:0x8012a01c
tree "4TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  " "
tree.end

base sd:0x8012a020
tree "4RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  " "
tree.end

base sd:0x8012a024
tree "4DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  " "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  " "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
tree.end

base sd:0x8012a028
tree "4BRCR"
group 0--3
line.long 0 "BRCR"
bitfld.long 0 0.--15. " BRCNT2 "  " "
bitfld.long 0 16.--31. " BRCNT1 "  " "
tree.end

base sd:0x8012a02c
tree "4IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
tree.end

base sd:0x8012a030
tree "4RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
tree.end

base sd:0x8012a034
tree "4MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
tree.end

base sd:0x8012a038
tree "4ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
tree.end

base sd:0x8012a03c
tree "4I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
tree.end

base sd:0x8012a040
tree "4I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
tree.end

base sd:0x8012a044
tree "4I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
tree.end

base sd:0x8012a048
tree "4I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
bitfld.long 0 0.--31. " TESTDATA "  " "
tree.end

base sd:0x8012a04c
tree "4I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
tree.end

base sd:0x8012a050
tree "4I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base sd:0x8012a054
tree "4I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base sd:0x8012a058
tree "4I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base sd:0x8012a05c
tree "4I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base sd:0x8012afe0
tree "4PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x8012afe4
tree "4PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x8012afe8
tree "4PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x8012afec
tree "4PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x8012aff0
tree "4PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
bitfld.long 0 0.--7. " I2CPCellID0 "  " "
tree.end

base sd:0x8012aff4
tree "4PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
bitfld.long 0 0.--7. " I2CPCellID1 "  " "
tree.end

base sd:0x8012aff8
tree "4PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
bitfld.long 0 0.--7. " I2CPCellID2 "  " "
tree.end

base sd:0x8012affc
tree "4PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
bitfld.long 0 0.--7. " I2CPCellID3 "  " "
tree.end

tree.end

base sd:0x80110000
;********************************************
tree "HSI2C-3"
;********************************************
base sd:0x80110000
tree "3CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  " "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  " "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  " "
bitfld.long 0 15. " FS "  "0 ,1 "
tree.end

base sd:0x80110004
tree "3SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  " "
bitfld.long 0 16.--31. " SLSU "  " "
tree.end

base sd:0x80110008
tree "3HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  " "
tree.end

base sd:0x8011000c
tree "3MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  " "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  " "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
tree.end

base sd:0x80110010
tree "3TFR"
wgroup 0--3
line.long 0 "TFR"
bitfld.long 0 0.--7. " TDATA "  " "
tree.end

base sd:0x80110014
tree "3SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  " "
bitfld.long 0 2.--3. " STATUS "  " "
bitfld.long 0 4.--6. " CAUSE "  " "
bitfld.long 0 7.--8. " TYPE "  " "
bitfld.long 0 9.--19. " LENGTH "  " "
tree.end

base sd:0x80110018
tree "3RFR"
rgroup 0--3
line.long 0 "RFR"
bitfld.long 0 0.--7. " RDATA "  " "
tree.end

base sd:0x8011001c
tree "3TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  " "
tree.end

base sd:0x80110020
tree "3RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  " "
tree.end

base sd:0x80110024
tree "3DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  " "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  " "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
tree.end

base sd:0x80110028
tree "3BRCR"
group 0--3
line.long 0 "BRCR"
bitfld.long 0 0.--15. " BRCNT2 "  " "
bitfld.long 0 16.--31. " BRCNT1 "  " "
tree.end

base sd:0x8011002c
tree "3IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
tree.end

base sd:0x80110030
tree "3RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
tree.end

base sd:0x80110034
tree "3MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
tree.end

base sd:0x80110038
tree "3ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
tree.end

base sd:0x8011003c
tree "3I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
tree.end

base sd:0x80110040
tree "3I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
tree.end

base sd:0x80110044
tree "3I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
tree.end

base sd:0x80110048
tree "3I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
bitfld.long 0 0.--31. " TESTDATA "  " "
tree.end

base sd:0x8011004c
tree "3I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
tree.end

base sd:0x80110050
tree "3I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base sd:0x80110054
tree "3I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base sd:0x80110058
tree "3I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base sd:0x8011005c
tree "3I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base sd:0x80110fe0
tree "3PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80110fe4
tree "3PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80110fe8
tree "3PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80110fec
tree "3PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80110ff0
tree "3PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
bitfld.long 0 0.--7. " I2CPCellID0 "  " "
tree.end

base sd:0x80110ff4
tree "3PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
bitfld.long 0 0.--7. " I2CPCellID1 "  " "
tree.end

base sd:0x80110ff8
tree "3PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
bitfld.long 0 0.--7. " I2CPCellID2 "  " "
tree.end

base sd:0x80110ffc
tree "3PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
bitfld.long 0 0.--7. " I2CPCellID3 "  " "
tree.end

tree.end

base sd:0x80004000
;********************************************
tree "HSI2C-0"
;********************************************
base sd:0x80004000
tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PE "  "0 ,1 "
bitfld.long 0 1.--2. " OM "  " "
bitfld.long 0 3. " SAM "  "0 ,1 "
bitfld.long 0 4.--5. " SM "  " "
bitfld.long 0 6. " SGCM "  "0 ,1 "
bitfld.long 0 7. " FTX "  "0 ,1 "
bitfld.long 0 8. " FRX "  "0 ,1 "
bitfld.long 0 9. " DMA_TX_EN "  "0 ,1 "
bitfld.long 0 10. " DMA_RX_EN "  "0 ,1 "
bitfld.long 0 11. " DMA_SLE "  "0 ,1 "
bitfld.long 0 12. " LM "  "0 ,1 "
bitfld.long 0 13.--14. " FON "  " "
bitfld.long 0 15. " FS "  "0 ,1 "
tree.end

base sd:0x80004004
tree "0SCR"
group 0--3
line.long 0 "SCR"
bitfld.long 0 0.--6. " SA7 "  " "
bitfld.long 0 7.--9. " ESA10 "  " "
bitfld.long 0 16.--31. " SLSU "  " "
tree.end

base sd:0x80004008
tree "0HSMCR"
group 0--3
line.long 0 "HSMCR"
bitfld.long 0 0.--2. " MC "  " "
tree.end

base sd:0x8000400c
tree "0MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " OP "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--10. " EA10 "  " "
bitfld.long 0 11. " SB "  "0 ,1 "
bitfld.long 0 12.--13. " AM "  " "
bitfld.long 0 14. " P "  "0 ,1 "
bitfld.long 0 15.--25. " LENGTH "  " "
tree.end

base sd:0x80004010
tree "0TFR"
wgroup 0--3
line.long 0 "TFR"
bitfld.long 0 0.--7. " TDATA "  " "
tree.end

base sd:0x80004014
tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0.--1. " OP "  " "
bitfld.long 0 2.--3. " STATUS "  " "
bitfld.long 0 4.--6. " CAUSE "  " "
bitfld.long 0 7.--8. " TYPE "  " "
bitfld.long 0 9.--19. " LENGTH "  " "
tree.end

base sd:0x80004018
tree "0RFR"
rgroup 0--3
line.long 0 "RFR"
bitfld.long 0 0.--7. " RDATA "  " "
tree.end

base sd:0x8000401c
tree "0TFTR"
group 0--3
line.long 0 "TFTR"
bitfld.long 0 0.--3. " THRESHOLD_TX "  " "
tree.end

base sd:0x80004020
tree "0RFTR"
group 0--3
line.long 0 "RFTR"
bitfld.long 0 0.--3. " THRESHOLD_RX "  " "
tree.end

base sd:0x80004024
tree "0DMAR"
group 0--3
line.long 0 "DMAR"
bitfld.long 0 0.--2. " SBSIZE_RX "  " "
bitfld.long 0 3. " BURST_RX "  "0 ,1 "
bitfld.long 0 8.--10. " DBSIZE_TX "  " "
bitfld.long 0 11. " BURST_TX "  "0 ,1 "
tree.end

base sd:0x80004028
tree "0BRCR"
group 0--3
line.long 0 "BRCR"
bitfld.long 0 0.--15. " BRCNT2 "  " "
bitfld.long 0 16.--31. " BRCNT1 "  " "
tree.end

base sd:0x8000402c
tree "0IMSCR"
group 0--3
line.long 0 "IMSCR"
bitfld.long 0 0. " TXFEM "  "0 ,1 "
bitfld.long 0 1. " TXFNEM "  "0 ,1 "
bitfld.long 0 2. " TXFFM "  "0 ,1 "
bitfld.long 0 3. " TXFOVRM "  "0 ,1 "
bitfld.long 0 4. " RXFEM "  "0 ,1 "
bitfld.long 0 5. " RXFNFM "  "0 ,1 "
bitfld.long 0 6. " RXFFM "  "0 ,1 "
bitfld.long 0 16. " RFSRM "  "0 ,1 "
bitfld.long 0 17. " RFSEM "  "0 ,1 "
bitfld.long 0 18. " WTSRM "  "0 ,1 "
bitfld.long 0 19. " MTDM "  "0 ,1 "
bitfld.long 0 20. " STDM "  "0 ,1 "
bitfld.long 0 24. " MALM "  "0 ,1 "
bitfld.long 0 25. " BERRM "  "0 ,1 "
bitfld.long 0 28. " MTDWSM "  "0 ,1 "
tree.end

base sd:0x80004030
tree "0RISR"
rgroup 0--3
line.long 0 "RISR"
bitfld.long 0 0. " TXFE "  "0 ,1 "
bitfld.long 0 1. " TXFNE "  "0 ,1 "
bitfld.long 0 2. " TXFF "  "0 ,1 "
bitfld.long 0 3. " TXFOVR "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " RXFNF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 16. " RFSR "  "0 ,1 "
bitfld.long 0 17. " RFSE "  "0 ,1 "
bitfld.long 0 18. " WTSR "  "0 ,1 "
bitfld.long 0 19. " MTD "  "0 ,1 "
bitfld.long 0 20. " STD "  "0 ,1 "
bitfld.long 0 24. " MAL "  "0 ,1 "
bitfld.long 0 25. " BERR "  "0 ,1 "
bitfld.long 0 28. " MTDWS "  "0 ,1 "
tree.end

base sd:0x80004034
tree "0MISR"
group 0--3
line.long 0 "MISR"
bitfld.long 0 0. " TXFEMIS "  "0 ,1 "
bitfld.long 0 1. " TXFNEMIS "  "0 ,1 "
bitfld.long 0 2. " TXFFMIS "  "0 ,1 "
bitfld.long 0 3. " TXFOVRMIS "  "0 ,1 "
bitfld.long 0 4. " RXFEMIS "  "0 ,1 "
bitfld.long 0 5. " RXFNFMIS "  "0 ,1 "
bitfld.long 0 6. " RXFFMIS "  "0 ,1 "
bitfld.long 0 16. " RFSRMIS "  "0 ,1 "
bitfld.long 0 17. " RFSEMIS "  "0 ,1 "
bitfld.long 0 18. " WTSRMIS "  "0 ,1 "
bitfld.long 0 19. " MTDMIS "  "0 ,1 "
bitfld.long 0 20. " STDMIS "  "0 ,1 "
bitfld.long 0 24. " MALMIS "  "0 ,1 "
bitfld.long 0 25. " BERRMIS "  "0 ,1 "
bitfld.long 0 28. " MTDWSMIS "  "0 ,1 "
tree.end

base sd:0x80004038
tree "0ICR"
rgroup 0--3
line.long 0 "ICR"
bitfld.long 0 3. " TXFOVRIC "  "0 ,1 "
bitfld.long 0 16. " RFSRIC "  "0 ,1 "
bitfld.long 0 17. " RFSEIC "  "0 ,1 "
bitfld.long 0 18. " WTSRIC "  "0 ,1 "
bitfld.long 0 19. " MTDIC "  "0 ,1 "
bitfld.long 0 20. " STDIC "  "0 ,1 "
bitfld.long 0 24. " MALIC "  "0 ,1 "
bitfld.long 0 25. " BERRIC "  "0 ,1 "
bitfld.long 0 28. " MTDWSIC "  "0 ,1 "
tree.end

base sd:0x8000403c
tree "0I2C_ITCR"
group 0--3
line.long 0 "I2C_ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " FIFOTEST "  "0 ,1 "
tree.end

base sd:0x80004040
tree "0I2C_ITIP"
group 0--3
line.long 0 "I2C_ITIP"
bitfld.long 0 0. " SDAIN "  "0 ,1 "
bitfld.long 0 1. " SCLIN "  "0 ,1 "
bitfld.long 0 4. " DMACLRRX "  "0 ,1 "
bitfld.long 0 5. " DMATCRX "  "0 ,1 "
bitfld.long 0 6. " DMACLRTX "  "0 ,1 "
bitfld.long 0 7. " DMATCTX "  "0 ,1 "
bitfld.long 0 15. " TSTNOIVCLK "  "0 ,1 "
bitfld.long 0 16.--25. " HWSADDR "  " "
tree.end

base sd:0x80004044
tree "0I2C_ITOP"
group 0--3
line.long 0 "I2C_ITOP"
bitfld.long 0 0. " SDAOUT "  "0 ,1 "
bitfld.long 0 1. " SCLOUT "  "0 ,1 "
bitfld.long 0 2. " ENCPSPUHS "  "0 ,1 "
bitfld.long 0 4. " DMABREQRX "  "0 ,1 "
bitfld.long 0 5. " DMASREQRX "  "0 ,1 "
bitfld.long 0 6. " DMABRETX "  "0 ,1 "
bitfld.long 0 15. " INTGBL "  "0 ,1 "
tree.end

base sd:0x80004048
tree "0I2C_TDR"
group 0--3
line.long 0 "I2C_TDR"
bitfld.long 0 0.--31. " TESTDATA "  " "
tree.end

base sd:0x8000404c
tree "0I2C_THDDAT"
group 0--3
line.long 0 "I2C_THDDAT"
bitfld.long 0 0.--8. " I2C_THDDAT "  " "
tree.end

base sd:0x80004050
tree "0I2C_THDSTA_FST_STD"
group 0--3
line.long 0 "I2C_THDSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base sd:0x80004054
tree "0I2C_THDSTA_FMP_HS"
group 0--3
line.long 0 "I2C_THDSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base sd:0x80004058
tree "0I2C_TSUSTA_FST_STD"
group 0--3
line.long 0 "I2C_TSUSTA_FST_STD"
bitfld.long 0 0.--8. " I2C_THDSTA_STD "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_FST "  " "
tree.end

base sd:0x8000405c
tree "0I2C_TSUSTA_FMP_HS"
group 0--3
line.long 0 "I2C_TSUSTA_FMP_HS"
bitfld.long 0 0.--8. " I2C_THDSTA_FMP "  " "
bitfld.long 0 16.--24. " I2C_THDSTA_HS "  " "
tree.end

base sd:0x80004fe0
tree "0PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80004fe4
tree "0PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80004fe8
tree "0PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80004fec
tree "0PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80004ff0
tree "0PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
bitfld.long 0 0.--7. " I2CPCellID0 "  " "
tree.end

base sd:0x80004ff4
tree "0PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
bitfld.long 0 0.--7. " I2CPCellID1 "  " "
tree.end

base sd:0x80004ff8
tree "0PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
bitfld.long 0 0.--7. " I2CPCellID2 "  " "
tree.end

base sd:0x80004ffc
tree "0PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
bitfld.long 0 0.--7. " I2CPCellID3 "  " "
tree.end

;tree.end

tree.end

;==============================================================
tree "HSIR"
;==============================================================
base sd:0x8011b000
tree "ID"
group 0--3
line.long 0 "ID"
bitfld.long 0 0.--31. " ID "  " "
tree.end

base sd:0x8011b004
tree "MODE"
group 0--3
line.long 0 "MODE"
bitfld.long 0 0.--2. " MODE "  " "
tree.end

base sd:0x8011b008
tree "RXSTATE"
group 0--3
line.long 0 "RXSTATE"
bitfld.long 0 0.--1. " RXSTATE "  " "
tree.end

base sd:0x8011b00c
tree "BUFSTATE"
group 0--3
line.long 0 "BUFSTATE"
bitfld.long 0 0. " BUFSTATE0 "  "0 ,1 "
bitfld.long 0 1. " BUFSTATE1 "  "0 ,1 "
bitfld.long 0 2. " BUFSTATE2 "  "0 ,1 "
bitfld.long 0 3. " BUFSTATE3 "  "0 ,1 "
bitfld.long 0 4. " BUFSTATE4 "  "0 ,1 "
bitfld.long 0 5. " BUFSTATE5 "  "0 ,1 "
bitfld.long 0 6. " BUFSTATE6 "  "0 ,1 "
bitfld.long 0 7. " BUFSTATE7 "  "0 ,1 "
tree.end

base sd:0x8011b010
tree "THRESHOLD"
group 0--3
line.long 0 "THRESHOLD"
bitfld.long 0 0.--5. " THRESHOLD "  " "
tree.end

base sd:0x8011b018
tree "DETECTOR"
group 0--3
line.long 0 "DETECTOR"
bitfld.long 0 0. " DETECTOR "  "0 ,1 "
tree.end

base sd:0x8011b01c
tree "EXCEPTION"
group 0--3
line.long 0 "EXCEPTION"
bitfld.long 0 0. " TIMEOUT "  "0 ,1 "
bitfld.long 0 1. " OVERRUN "  "0 ,1 "
bitfld.long 0 2. " BREAK "  "0 ,1 "
tree.end

base sd:0x8011b020
tree "ACKNOWLEDGE"
wgroup 0--3
line.long 0 "ACKNOWLEDGE"
bitfld.long 0 0. " ACKTIMEOUT "  "0 ,1 "
bitfld.long 0 1. " ACKOVERRUN "  "0 ,1 "
bitfld.long 0 2. " ACKBREAK "  "0 ,1 "
tree.end

base sd:0x8011b024
tree "CHANNELS"
group 0--3
line.long 0 "CHANNELS"
bitfld.long 0 0.--3. " CHANNELS "  " "
tree.end

base sd:0x8011b028
tree "REALTIME"
group 0--3
line.long 0 "REALTIME"
bitfld.long 0 0. " REALTIME0 "  "0 ,1 "
bitfld.long 0 1. " REALTIME1 "  "0 ,1 "
bitfld.long 0 2. " REALTIME2 "  "0 ,1 "
bitfld.long 0 3. " REALTIME3 "  "0 ,1 "
bitfld.long 0 4. " REALTIME4 "  "0 ,1 "
bitfld.long 0 5. " REALTIME5 "  "0 ,1 "
bitfld.long 0 6. " REALTIME6 "  "0 ,1 "
bitfld.long 0 7. " REALTIME7 "  "0 ,1 "
tree.end

base sd:0x8011b02c
tree "OVERRUN"
group 0--3
line.long 0 "OVERRUN"
bitfld.long 0 0. " OVERRUN0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUN1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUN2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUN3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUN4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUN5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUN6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUN7 "  "0 ,1 "
tree.end

base sd:0x8011b030
tree "OVERRUNACK"
rgroup 0--3
line.long 0 "OVERRUNACK"
bitfld.long 0 0. " OVERRUNACK0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUNACK1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUNACK2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUNACK3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUNACK4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUNACK5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUNACK6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUNACK7 "  "0 ,1 "
tree.end

base sd:0x8011b034
tree "PREAMBLE"
group 0--3
line.long 0 "PREAMBLE"
bitfld.long 0 0.--23. " PREAMBLE "  " "
tree.end

base sd:0x8011b038
tree "PIPEGAUGE"
group 0--3
line.long 0 "PIPEGAUGE"
bitfld.long 0 0.--1. " PIPEGAUGE "  " "
tree.end

base sd:0x8011b03c
tree "STATICCONFID"
group 0--3
line.long 0 "STATICCONFID"
bitfld.long 0 0.--2. " LOG2MAXCHANNELS_C "  " "
bitfld.long 0 3.--6. " LOG2BUFFERSIZE_C "  " "
bitfld.long 0 7.--10. " LOG2QUEUELENGH_C "  " "
bitfld.long 0 11.--13. " LOG2CHIPSIZE_C "  " "
tree.end

base sd:0x8011b080
tree "BUFFER0"
group 0--3
line.long 0 "BUFFER0"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011b084
tree "BUFFER1"
group 0--3
line.long 0 "BUFFER1"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011b088
tree "BUFFER2"
group 0--3
line.long 0 "BUFFER2"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011b08c
tree "BUFFER3"
group 0--3
line.long 0 "BUFFER3"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011b090
tree "BUFFER4"
group 0--3
line.long 0 "BUFFER4"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011b094
tree "BUFFER5"
group 0--3
line.long 0 "BUFFER5"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011b098
tree "BUFFER6"
group 0--3
line.long 0 "BUFFER6"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011b09c
tree "BUFFER7"
group 0--3
line.long 0 "BUFFER7"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011b0c0
tree "FRAMELEN0"
group 0--3
line.long 0 "FRAMELEN0"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011b0c4
tree "FRAMELEN1"
group 0--3
line.long 0 "FRAMELEN1"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011b0c8
tree "FRAMELEN2"
group 0--3
line.long 0 "FRAMELEN2"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011b0cc
tree "FRAMELEN3"
group 0--3
line.long 0 "FRAMELEN3"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011b0d0
tree "FRAMELEN4"
group 0--3
line.long 0 "FRAMELEN4"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011b0d4
tree "FRAMELEN5"
group 0--3
line.long 0 "FRAMELEN5"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011b0d8
tree "FRAMELEN6"
group 0--3
line.long 0 "FRAMELEN6"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011b0dc
tree "FRAMELEN7"
group 0--3
line.long 0 "FRAMELEN7"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011b100
tree "BASE0"
group 0--3
line.long 0 "BASE0"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011b104
tree "BASE1"
group 0--3
line.long 0 "BASE1"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011b108
tree "BASE2"
group 0--3
line.long 0 "BASE2"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011b10c
tree "BASE3"
group 0--3
line.long 0 "BASE3"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011b110
tree "BASE4"
group 0--3
line.long 0 "BASE4"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011b114
tree "BASE5"
group 0--3
line.long 0 "BASE5"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011b118
tree "BASE6"
group 0--3
line.long 0 "BASE6"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011b11c
tree "BASE7"
group 0--3
line.long 0 "BASE7"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011b140
tree "SPAN0"
group 0--3
line.long 0 "SPAN0"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011b144
tree "SPAN1"
group 0--3
line.long 0 "SPAN1"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011b148
tree "SPAN2"
group 0--3
line.long 0 "SPAN2"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011b14c
tree "SPAN3"
group 0--3
line.long 0 "SPAN3"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011b150
tree "SPAN4"
group 0--3
line.long 0 "SPAN4"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011b154
tree "SPAN5"
group 0--3
line.long 0 "SPAN5"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011b158
tree "SPAN6"
group 0--3
line.long 0 "SPAN6"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011b15c
tree "SPAN7"
group 0--3
line.long 0 "SPAN7"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011b180
tree "GAUGE0"
group 0--3
line.long 0 "GAUGE0"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011b184
tree "GAUGE1"
group 0--3
line.long 0 "GAUGE1"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011b188
tree "GAUGE2"
group 0--3
line.long 0 "GAUGE2"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011b18c
tree "GAUGE3"
group 0--3
line.long 0 "GAUGE3"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011b190
tree "GAUGE4"
group 0--3
line.long 0 "GAUGE4"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011b194
tree "GAUGE5"
group 0--3
line.long 0 "GAUGE5"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011b198
tree "GAUGE6"
group 0--3
line.long 0 "GAUGE6"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011b19c
tree "GAUGE7"
group 0--3
line.long 0 "GAUGE7"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011b1c0
tree "WATERMARK0"
group 0--3
line.long 0 "WATERMARK0"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011b1c4
tree "WATERMARK1"
group 0--3
line.long 0 "WATERMARK1"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011b1c8
tree "WATERMARK2"
group 0--3
line.long 0 "WATERMARK2"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011b1cc
tree "WATERMARK3"
group 0--3
line.long 0 "WATERMARK3"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011b1d0
tree "WATERMARK4"
group 0--3
line.long 0 "WATERMARK4"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011b1d4
tree "WATERMARK5"
group 0--3
line.long 0 "WATERMARK5"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011b1d8
tree "WATERMARK6"
group 0--3
line.long 0 "WATERMARK6"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011b1dc
tree "WATERMARK7"
group 0--3
line.long 0 "WATERMARK7"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011b1e0
tree "FRAMEBURSTCNT"
group 0--3
line.long 0 "FRAMEBURSTCNT"
bitfld.long 0 0.--7. " FRAMEBURSTCNT "  " "
tree.end

base sd:0x8011b200
tree "DMAEN"
group 0--3
line.long 0 "DMAEN"
bitfld.long 0 0. " DMAEN0 "  "0 ,1 "
bitfld.long 0 1. " DMAEN1 "  "0 ,1 "
bitfld.long 0 2. " DMAEN2 "  "0 ,1 "
bitfld.long 0 3. " DMAEN3 "  "0 ,1 "
bitfld.long 0 4. " DMAEN4 "  "0 ,1 "
bitfld.long 0 5. " DMAEN5 "  "0 ,1 "
bitfld.long 0 6. " DMAEN6 "  "0 ,1 "
bitfld.long 0 7. " DMAEN7 "  "0 ,1 "
tree.end

base sd:0x8011b204
tree "WMARKMIS"
rgroup 0--3
line.long 0 "WMARKMIS"
bitfld.long 0 0. " WATERMIS0 "  "0 ,1 "
bitfld.long 0 1. " WATERMIS1 "  "0 ,1 "
bitfld.long 0 2. " WATERMIS2 "  "0 ,1 "
bitfld.long 0 3. " WATERMIS3 "  "0 ,1 "
bitfld.long 0 4. " WATERMIS4 "  "0 ,1 "
bitfld.long 0 5. " WATERMIS5 "  "0 ,1 "
bitfld.long 0 6. " WATERMIS6 "  "0 ,1 "
bitfld.long 0 7. " WATERMIS7 "  "0 ,1 "
tree.end

base sd:0x8011b208
tree "WMARKIM"
group 0--3
line.long 0 "WMARKIM"
bitfld.long 0 0. " WMARKIM0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIM1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIM2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIM3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIM4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIM5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIM6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIM7 "  "0 ,1 "
tree.end

base sd:0x8011b20c
tree "WMARKIC"
wgroup 0--3
line.long 0 "WMARKIC"
bitfld.long 0 0. " WMARKIC0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIC1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIC2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIC3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIC4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIC5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIC6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIC7 "  "0 ,1 "
tree.end

base sd:0x8011b210
tree "WMARKID"
group 0--3
line.long 0 "WMARKID"
bitfld.long 0 0. " WMARKID0 "  "0 ,1 "
bitfld.long 0 1. " WMARKID1 "  "0 ,1 "
bitfld.long 0 2. " WMARKID2 "  "0 ,1 "
bitfld.long 0 3. " WMARKID3 "  "0 ,1 "
bitfld.long 0 4. " WMARKID4 "  "0 ,1 "
bitfld.long 0 5. " WMARKID5 "  "0 ,1 "
bitfld.long 0 6. " WMARKID6 "  "0 ,1 "
bitfld.long 0 7. " WMARKID7 "  "0 ,1 "
tree.end

base sd:0x8011b214
tree "OVERRUNMIS"
rgroup 0--3
line.long 0 "OVERRUNMIS"
bitfld.long 0 0. " OVERRUNMIS0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUNMIS1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUNMIS2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUNMIS3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUNMIS4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUNMIS5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUNMIS6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUNMIS7 "  "0 ,1 "
tree.end

base sd:0x8011b218
tree "OVERRUNIM"
group 0--3
line.long 0 "OVERRUNIM"
bitfld.long 0 0. " OVERRUNIM0 "  "0 ,1 "
bitfld.long 0 1. " OVERRUNIM1 "  "0 ,1 "
bitfld.long 0 2. " OVERRUNIM2 "  "0 ,1 "
bitfld.long 0 3. " OVERRUNIM3 "  "0 ,1 "
bitfld.long 0 4. " OVERRUNIM4 "  "0 ,1 "
bitfld.long 0 5. " OVERRUNIM5 "  "0 ,1 "
bitfld.long 0 6. " OVERRUNIM6 "  "0 ,1 "
bitfld.long 0 7. " OVERRUNIM7 "  "0 ,1 "
tree.end

base sd:0x8011b21c
tree "EXCEPMIS"
rgroup 0--3
line.long 0 "EXCEPMIS"
bitfld.long 0 0. " TIMEOUTMIS "  "0 ,1 "
bitfld.long 0 1. " OVERRUNMIS "  "0 ,1 "
bitfld.long 0 2. " BREAKMIS "  "0 ,1 "
tree.end

base sd:0x8011b224
tree "WMARKIS"
group 0--3
line.long 0 "WMARKIS"
bitfld.long 0 0. " MARKIS0 "  "0 ,1 "
bitfld.long 0 1. " MARKIS1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIS2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIS3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIS4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIS5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIS6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIS7 "  "0 ,1 "
tree.end

base sd:0x8011b220
tree "EXCEPIM"
group 0--3
line.long 0 "EXCEPIM"
bitfld.long 0 0. " TIMEOUTIM "  "0 ,1 "
bitfld.long 0 1. " OVERRUNIM "  "0 ,1 "
bitfld.long 0 2. " BREAKIM "  "0 ,1 "
tree.end

base sd:0x8011bd00
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0x8011bd04
tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR0 "  "0 ,1 "
bitfld.long 0 1. " DMACLR1 "  "0 ,1 "
bitfld.long 0 2. " DMACLR2 "  "0 ,1 "
bitfld.long 0 3. " DMACLR3 "  "0 ,1 "
bitfld.long 0 4. " DMACLR4 "  "0 ,1 "
bitfld.long 0 5. " DMACLR5 "  "0 ,1 "
bitfld.long 0 6. " DMACLR6 "  "0 ,1 "
bitfld.long 0 7. " DMACLR7 "  "0 ,1 "
bitfld.long 0 16. " DATA "  "0 ,1 "
bitfld.long 0 17. " FLAG "  "0 ,1 "
tree.end

base sd:0x8011bd08
tree "ITOP1"
group 0--3
line.long 0 "ITOP1"
bitfld.long 0 0.--7. " DMABREQ "  " "
bitfld.long 0 16.--23. " DMASREQ "  " "
tree.end

base sd:0x8011bd0c
tree "ITOP2"
group 0--3
line.long 0 "ITOP2"
bitfld.long 0 0. " WMARKD0INT "  "0 ,1 "
bitfld.long 0 1. " WMARKD1INT "  "0 ,1 "
bitfld.long 0 2. " EXCEPINT "  "0 ,1 "
bitfld.long 0 16. " READY "  "0 ,1 "
tree.end

base sd:0x8011bd10
tree "ITOP3"
group 0--3
line.long 0 "ITOP3"
bitfld.long 0 0.--7. " OVERRUNINT "  " "
tree.end

base sd:0x8011bfe0
tree "PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
bitfld.long 0 0.--7. " PARTMUMBER0 "  " "
tree.end

base sd:0x8011bfe4
tree "PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " PARTNUMBER1 "  " "
bitfld.long 0 4.--7. " DESIGNER0 "  " "
tree.end

base sd:0x8011bfe8
tree "PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " DESIGNER1 "  " "
bitfld.long 0 4.--7. " REVISION "  " "
tree.end

base sd:0x8011bfec
tree "PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
bitfld.long 0 0.--7. " CONFIGURATION "  " "
tree.end

base sd:0x8011bff0
tree "PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
bitfld.long 0 0.--7. " PCELLID0 "  " "
tree.end

base sd:0x8011bff4
tree "PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
bitfld.long 0 0.--7. " PCELLID1 "  " "
tree.end

base sd:0x8011bff8
tree "PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
bitfld.long 0 0.--7. " PCELLID2 "  " "
tree.end

base sd:0x8011bffc
tree "PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
bitfld.long 0 0.--7. " PCELLID3 "  " "
tree.end

tree.end

;==============================================================
tree "HSIT"
;==============================================================
base sd:0x8011c000
tree "ID"
group 0--3
line.long 0 "ID"
bitfld.long 0 0.--31. " ID "  " "
tree.end

base sd:0x8011c004
tree "MODE"
group 0--3
line.long 0 "MODE"
bitfld.long 0 0.--1. " MODE "  " "
tree.end

base sd:0x8011c008
tree "TXSTATE"
group 0--3
line.long 0 "TXSTATE"
bitfld.long 0 0.--2. " TXSTATE "  " "
tree.end

base sd:0x8011c00c
tree "IOSTATE"
group 0--3
line.long 0 "IOSTATE"
bitfld.long 0 0. " DSTATE "  "0 ,1 "
bitfld.long 0 1. " FSTATE "  "0 ,1 "
bitfld.long 0 2. " RSTATE "  "0 ,1 "
tree.end

base sd:0x8011c010
tree "BUFSTATE"
group 0--3
line.long 0 "BUFSTATE"
bitfld.long 0 0. " BUFSTATE0 "  "0 ,1 "
bitfld.long 0 1. " BUFSTATE1 "  "0 ,1 "
bitfld.long 0 2. " BUFSTATE2 "  "0 ,1 "
bitfld.long 0 3. " BUFSTATE3 "  "0 ,1 "
bitfld.long 0 4. " BUFSTATE4 "  "0 ,1 "
bitfld.long 0 5. " BUFSTATE5 "  "0 ,1 "
bitfld.long 0 6. " BUFSTATE6 "  "0 ,1 "
bitfld.long 0 7. " BUFSTATE7 "  "0 ,1 "
tree.end

base sd:0x8011c014
tree "DIVISOR"
group 0--3
line.long 0 "DIVISOR"
bitfld.long 0 0.--23. " DIVISOR "  " "
tree.end

base sd:0x8011c01c
tree "BREAK"
group 0--3
line.long 0 "BREAK"
bitfld.long 0 0. " BREAK "  "0 ,1 "
tree.end

base sd:0x8011c020
tree "CHANNELS"
group 0--3
line.long 0 "CHANNELS"
bitfld.long 0 0.--3. " CHANNELS "  " "
tree.end

base sd:0x8011c024
tree "FLUSHBITS"
group 0--3
line.long 0 "FLUSHBITS"
bitfld.long 0 0.--5. " FLUSHBITS "  " "
tree.end

base sd:0x8011c028
tree "PRIORITY"
group 0--3
line.long 0 "PRIORITY"
bitfld.long 0 0. " PRIORITY0 "  "0 ,1 "
bitfld.long 0 1. " PRIORITY1 "  "0 ,1 "
bitfld.long 0 2. " PRIORITY2 "  "0 ,1 "
bitfld.long 0 3. " PRIORITY3 "  "0 ,1 "
bitfld.long 0 4. " PRIORITY4 "  "0 ,1 "
bitfld.long 0 5. " PRIORITY5 "  "0 ,1 "
bitfld.long 0 6. " PRIORITY6 "  "0 ,1 "
bitfld.long 0 7. " PRIORITY7 "  "0 ,1 "
tree.end

base sd:0x8011c02c
tree "STATICCONFID"
group 0--3
line.long 0 "STATICCONFID"
bitfld.long 0 0.--2. " LOG2MAXCHANNELS_C "  " "
bitfld.long 0 3.--6. " LOG2BUFFERSIZE_C "  " "
tree.end

base sd:0x8011c034
tree "DATASWAP"
group 0--3
line.long 0 "DATASWAP"
bitfld.long 0 0.--1. " DATASWAP "  " "
tree.end

base sd:0x8011c080
tree "FRAMELEN0"
group 0--3
line.long 0 "FRAMELEN0"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011c084
tree "FRAMELEN1"
group 0--3
line.long 0 "FRAMELEN1"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011c088
tree "FRAMELEN2"
group 0--3
line.long 0 "FRAMELEN2"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011c08c
tree "FRAMELEN3"
group 0--3
line.long 0 "FRAMELEN3"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011c090
tree "FRAMELEN4"
group 0--3
line.long 0 "FRAMELEN4"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011c094
tree "FRAMELEN5"
group 0--3
line.long 0 "FRAMELEN5"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011c098
tree "FRAMELEN6"
group 0--3
line.long 0 "FRAMELEN6"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011c09c
tree "FRAMELEN7"
group 0--3
line.long 0 "FRAMELEN7"
bitfld.long 0 0.--4. " FRAMELEN "  " "
tree.end

base sd:0x8011c0c0
tree "BUFFER0"
group 0--3
line.long 0 "BUFFER0"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011c0c4
tree "BUFFER1"
group 0--3
line.long 0 "BUFFER1"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011c0c8
tree "BUFFER2"
group 0--3
line.long 0 "BUFFER2"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011c0cc
tree "BUFFER3"
group 0--3
line.long 0 "BUFFER3"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011c0d0
tree "BUFFER4"
group 0--3
line.long 0 "BUFFER4"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011c0d4
tree "BUFFER5"
group 0--3
line.long 0 "BUFFER5"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011c0d8
tree "BUFFER6"
group 0--3
line.long 0 "BUFFER6"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011c0dc
tree "BUFFER7"
group 0--3
line.long 0 "BUFFER7"
bitfld.long 0 0.--31. " BUFFER "  " "
tree.end

base sd:0x8011c100
tree "BASE0"
group 0--3
line.long 0 "BASE0"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011c104
tree "BASE1"
group 0--3
line.long 0 "BASE1"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011c108
tree "BASE2"
group 0--3
line.long 0 "BASE2"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011c10c
tree "BASE3"
group 0--3
line.long 0 "BASE3"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011c110
tree "BASE4"
group 0--3
line.long 0 "BASE4"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011c114
tree "BASE5"
group 0--3
line.long 0 "BASE5"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011c118
tree "BASE6"
group 0--3
line.long 0 "BASE6"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011c11c
tree "BASE7"
group 0--3
line.long 0 "BASE7"
bitfld.long 0 0.--4. " BASE "  " "
tree.end

base sd:0x8011c140
tree "SPAN0"
group 0--3
line.long 0 "SPAN0"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011c144
tree "SPAN1"
group 0--3
line.long 0 "SPAN1"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011c148
tree "SPAN2"
group 0--3
line.long 0 "SPAN2"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011c14c
tree "SPAN3"
group 0--3
line.long 0 "SPAN3"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011c150
tree "SPAN4"
group 0--3
line.long 0 "SPAN4"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011c154
tree "SPAN5"
group 0--3
line.long 0 "SPAN5"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011c158
tree "SPAN6"
group 0--3
line.long 0 "SPAN6"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011c15c
tree "SPAN7"
group 0--3
line.long 0 "SPAN7"
bitfld.long 0 0.--4. " SPAN "  " "
tree.end

base sd:0x8011c180
tree "GAUGE0"
group 0--3
line.long 0 "GAUGE0"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011c184
tree "GAUGE1"
group 0--3
line.long 0 "GAUGE1"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011c188
tree "GAUGE2"
group 0--3
line.long 0 "GAUGE2"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011c18c
tree "GAUGE3"
group 0--3
line.long 0 "GAUGE3"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011c190
tree "GAUGE4"
group 0--3
line.long 0 "GAUGE4"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011c194
tree "GAUGE5"
group 0--3
line.long 0 "GAUGE5"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011c198
tree "GAUGE6"
group 0--3
line.long 0 "GAUGE6"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011c19c
tree "GAUGE7"
group 0--3
line.long 0 "GAUGE7"
bitfld.long 0 0.--4. " GAUGE "  " "
tree.end

base sd:0x8011c1c0
tree "WATERMARK0"
group 0--3
line.long 0 "WATERMARK0"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011c1c4
tree "WATERMARK1"
group 0--3
line.long 0 "WATERMARK1"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011c1c8
tree "WATERMARK2"
group 0--3
line.long 0 "WATERMARK2"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011c1cc
tree "WATERMARK3"
group 0--3
line.long 0 "WATERMARK3"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011c1d0
tree "WATERMARK4"
group 0--3
line.long 0 "WATERMARK4"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011c1d4
tree "WATERMARK5"
group 0--3
line.long 0 "WATERMARK5"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011c1d8
tree "WATERMARK6"
group 0--3
line.long 0 "WATERMARK6"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011c1dc
tree "WATERMARK7"
group 0--3
line.long 0 "WATERMARK7"
bitfld.long 0 0.--4. " WATERMARK "  " "
tree.end

base sd:0x8011c200
tree "DMAEN"
group 0--3
line.long 0 "DMAEN"
bitfld.long 0 0. " DMAEN0 "  "0 ,1 "
bitfld.long 0 1. " DMAEN1 "  "0 ,1 "
bitfld.long 0 2. " DMAEN2 "  "0 ,1 "
bitfld.long 0 3. " DMAEN3 "  "0 ,1 "
bitfld.long 0 4. " DMAEN4 "  "0 ,1 "
bitfld.long 0 5. " DMAEN5 "  "0 ,1 "
bitfld.long 0 6. " DMAEN6 "  "0 ,1 "
bitfld.long 0 7. " DMAEN7 "  "0 ,1 "
tree.end

base sd:0x8011c204
tree "WMARKMIS"
rgroup 0--3
line.long 0 "WMARKMIS"
bitfld.long 0 0. " WMARKMIS0 "  "0 ,1 "
bitfld.long 0 1. " WMARKMIS1 "  "0 ,1 "
bitfld.long 0 2. " WMARKMIS2 "  "0 ,1 "
bitfld.long 0 3. " WMARKMIS3 "  "0 ,1 "
bitfld.long 0 4. " WMARKMIS4 "  "0 ,1 "
bitfld.long 0 5. " WMARKMIS5 "  "0 ,1 "
bitfld.long 0 6. " WMARKMIS6 "  "0 ,1 "
bitfld.long 0 7. " WMARKMIS7 "  "0 ,1 "
tree.end

base sd:0x8011c208
tree "WMARKIM"
group 0--3
line.long 0 "WMARKIM"
bitfld.long 0 0. " WMARKIM0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIM1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIM2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIM3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIM4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIM5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIM6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIM7 "  "0 ,1 "
tree.end

base sd:0x8011c20c
tree "WMARKIC"
wgroup 0--3
line.long 0 "WMARKIC"
bitfld.long 0 0. " WMARKIC0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIC1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIC2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIC3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIC4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIC5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIC6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIC7 "  "0 ,1 "
tree.end

base sd:0x8011c210
tree "WMARKID"
group 0--3
line.long 0 "WMARKID"
bitfld.long 0 0. " WMARKID0 "  "0 ,1 "
bitfld.long 0 1. " WMARKID1 "  "0 ,1 "
bitfld.long 0 2. " WMARKID2 "  "0 ,1 "
bitfld.long 0 3. " WMARKID3 "  "0 ,1 "
bitfld.long 0 4. " WMARKID4 "  "0 ,1 "
bitfld.long 0 5. " WMARKID5 "  "0 ,1 "
bitfld.long 0 6. " WMARKID6 "  "0 ,1 "
bitfld.long 0 7. " WMARKID7 "  "0 ,1 "
tree.end

base sd:0x8011c214
tree "WMARKIS"
group 0--3
line.long 0 "WMARKIS"
bitfld.long 0 0. " WMARKIS0 "  "0 ,1 "
bitfld.long 0 1. " WMARKIS1 "  "0 ,1 "
bitfld.long 0 2. " WMARKIS2 "  "0 ,1 "
bitfld.long 0 3. " WMARKIS3 "  "0 ,1 "
bitfld.long 0 4. " WMARKIS4 "  "0 ,1 "
bitfld.long 0 5. " WMARKIS5 "  "0 ,1 "
bitfld.long 0 6. " WMARKIS6 "  "0 ,1 "
bitfld.long 0 7. " WMARKIS7 "  "0 ,1 "
tree.end

base sd:0x8011cd00
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0x8011cd04
tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " DMACLR0 "  "0 ,1 "
bitfld.long 0 1. " DMACLR1 "  "0 ,1 "
bitfld.long 0 2. " DMACLR2 "  "0 ,1 "
bitfld.long 0 3. " DMACLR3 "  "0 ,1 "
bitfld.long 0 4. " DMACLR4 "  "0 ,1 "
bitfld.long 0 5. " DMACLR5 "  "0 ,1 "
bitfld.long 0 6. " DMACLR6 "  "0 ,1 "
bitfld.long 0 7. " DMACLR7 "  "0 ,1 "
bitfld.long 0 16. " READY "  "0 ,1 "
tree.end

base sd:0x8011cd08
tree "ITOP1"
group 0--3
line.long 0 "ITOP1"
bitfld.long 0 0.--7. " DMABREQ "  " "
bitfld.long 0 16.--23. " DMASREQ "  " "
tree.end

base sd:0x8011cd0c
tree "ITOP2"
group 0--3
line.long 0 "ITOP2"
bitfld.long 0 0. " WMARKD0INT "  "0 ,1 "
bitfld.long 0 1. " WMARKD1INT "  "0 ,1 "
bitfld.long 0 16. " DATA "  "0 ,1 "
bitfld.long 0 17. " FLAG "  "0 ,1 "
tree.end

base sd:0x8011cfe0
tree "PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
bitfld.long 0 0.--7. " PARTNUMBER0 "  " "
tree.end

base sd:0x8011cfe4
tree "PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--3. " PARTNUMBER1 "  " "
bitfld.long 0 4.--7. " DESIGNER0 "  " "
tree.end

base sd:0x8011cfe8
tree "PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--3. " DESIGNER1 "  " "
bitfld.long 0 4.--7. " REVISION "  " "
tree.end

base sd:0x8011cfec
tree "PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
bitfld.long 0 0.--7. " CONFIGURATION "  " "
tree.end

base sd:0x8011cff0
tree "PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
bitfld.long 0 0.--7. " PCELLID0 "  " "
tree.end

base sd:0x8011cff4
tree "PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
bitfld.long 0 0.--7. " PCELLID1 "  " "
tree.end

base sd:0x8011cff8
tree "PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
bitfld.long 0 0.--7. " PCELLID2 "  " "
tree.end

base sd:0x8011cffc
tree "PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
bitfld.long 0 0.--7. " PCELLID3 "  " "
tree.end

tree.end

;==============================================================
tree "ICN"
;==============================================================
base sd:0x81000000
tree "NODE_HIBW1_ESRAM_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81000004
tree "NODE_HIBW1_ESRAM_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81000008
tree "NODE_HIBW1_ESRAM_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81000024
tree "NODE_HIBW1_ESRAM_IN_0_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000028
tree "NODE_HIBW1_ESRAM_IN_0_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x8100002c
tree "NODE_HIBW1_ESRAM_IN_0_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_0_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000030
tree "NODE_HIBW1_ESRAM_IN_1_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000034
tree "NODE_HIBW1_ESRAM_IN_1_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000038
tree "NODE_HIBW1_ESRAM_IN_1_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_1_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x8100003c
tree "NODE_HIBW1_ESRAM_IN_2_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_2_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000040
tree "NODE_HIBW1_ESRAM_IN_2_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_2_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000044
tree "NODE_HIBW1_ESRAM_IN_2_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_ESRAM_IN_2_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000400
tree "NODE_HIBW1_DDR_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81000404
tree "NODE_HIBW1_DDR_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81000408
tree "NODE_HIBW1_DDR_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81000424
tree "NODE_HIBW1_DDR_IN_0_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000428
tree "NODE_HIBW1_DDR_IN_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x8100042c
tree "NODE_HIBW1_DDR_IN_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_IN_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000430
tree "NODE_HIBW1_DDR_OUT_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW1_DDR_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--3. " priority "  " "
tree.end

base sd:0x81000800
tree "NODE_HIBW2_ESRAM_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81000804
tree "NODE_HIBW2_ESRAM_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81000818
tree "NODE_HIBW2_ESRAM_IN_0_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x8100081c
tree "NODE_HIBW2_ESRAM_IN_0_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000820
tree "NODE_HIBW2_ESRAM_IN_0_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_0_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000824
tree "NODE_HIBW2_ESRAM_IN_1_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000828
tree "NODE_HIBW2_ESRAM_IN_1_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x8100082c
tree "NODE_HIBW2_ESRAM_IN_1_ARB_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_ESRAM_IN_1_ARB_3_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000c00
tree "NODE_HIBW2_DDR_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81000c04
tree "NODE_HIBW2_DDR_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81000c08
tree "NODE_HIBW2_DDR_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81000c24
tree "NODE_HIBW2_DDR_IN_0_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000c28
tree "NODE_HIBW2_DDR_IN_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000c2c
tree "NODE_HIBW2_DDR_IN_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_IN_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81000c30
tree "NODE_HIBW2_DDR_OUT_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_HIBW2_DDR_OUT_0_PRIORITY_REG"
bitfld.long 0 0.--3. " priority "  " "
tree.end

base sd:0x81001000
tree "NODE_ESRAM0_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81001004
tree "NODE_ESRAM0_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81001008
tree "NODE_ESRAM0_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x8100100c
tree "NODE_ESRAM0_IN_3_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_3_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81001030
tree "NODE_ESRAM0_IN_0_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_0_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001034
tree "NODE_ESRAM0_IN_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001038
tree "NODE_ESRAM0_IN_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x8100103c
tree "NODE_ESRAM0_IN_3_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM0_IN_3_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001400
tree "NODE_ESRAM1_2_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81001404
tree "NODE_ESRAM1_2_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81001408
tree "NODE_ESRAM1_2_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x8100140c
tree "NODE_ESRAM1_2_IN_3_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_3_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81001430
tree "NODE_ESRAM1_2_IN_0_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001434
tree "NODE_ESRAM1_2_IN_0_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001438
tree "NODE_ESRAM1_2_IN_1_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x8100143c
tree "NODE_ESRAM1_2_IN_1_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001440
tree "NODE_ESRAM1_2_IN_2_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_2_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001444
tree "NODE_ESRAM1_2_IN_2_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_2_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001448
tree "NODE_ESRAM1_2_IN_3_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_3_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x8100144c
tree "NODE_ESRAM1_2_IN_3_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM1_2_IN_3_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001800
tree "NODE_ESRAM3_4_IN_0_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_0_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81001804
tree "NODE_ESRAM3_4_IN_1_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_1_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81001808
tree "NODE_ESRAM3_4_IN_2_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_2_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x8100180c
tree "NODE_ESRAM3_4_IN_3_PRIORITY_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_3_PRIORITY_REG"
bitfld.long 0 0.--4. " priority "  " "
bitfld.long 0 5. " IT_rule "  "0 ,1 "
tree.end

base sd:0x81001830
tree "NODE_ESRAM3_4_IN_0_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_0_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001834
tree "NODE_ESRAM3_4_IN_0_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_0_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001838
tree "NODE_ESRAM3_4_IN_1_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_1_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x8100183c
tree "NODE_ESRAM3_4_IN_1_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_1_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001840
tree "NODE_ESRAM3_4_IN_2_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_2_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001844
tree "NODE_ESRAM3_4_IN_2_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_2_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x81001848
tree "NODE_ESRAM3_4_IN_3_ARB_1_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_3_ARB_1_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

base sd:0x8100184c
tree "NODE_ESRAM3_4_IN_3_ARB_2_LIMIT_REG"
group 0--3
line.long 0 "NODE_ESRAM3_4_IN_3_ARB_2_LIMIT_REG"
bitfld.long 0 0.--3. " new_priority "  " "
bitfld.long 0 4.--11. " Frame_size "  " "
bitfld.long 0 12.--16. " Limit "  " "
tree.end

tree.end

;==============================================================
tree "MCDE"
;==============================================================
base sd:0xa0350000
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 15. " IFIFOCTRLEN "  "0 ,1 "
bitfld.long 0 30. " AUTOCLKG_EN "  "0 ,1 "
bitfld.long 0 31. " MCDEEN "  "0 ,1 "
tree.end

base sd:0xa0350004
tree "CONF0"
group 0--3
line.long 0 "CONF0"
bitfld.long 0 0. " SYNCMUX0 "  "0 ,1 "
bitfld.long 0 1. " SYNCMUX1 "  "0 ,1 "
bitfld.long 0 2. " SYNCMUX2 "  "0 ,1 "
bitfld.long 0 3. " SYNCMUX3 "  "0 ,1 "
bitfld.long 0 4. " SYNCMUX4 "  "0 ,1 "
bitfld.long 0 5. " SYNCMUX5 "  "0 ,1 "
bitfld.long 0 6. " SYNCMUX6 "  "0 ,1 "
bitfld.long 0 7. " SYNCMUX7 "  "0 ,1 "
bitfld.long 0 12.--14. " IFIFOCTRLWTRMRKLVL "  " "
bitfld.long 0 16.--18. " OUTMUX0 "  " "
bitfld.long 0 19.--21. " OUTMUX1 "  " "
bitfld.long 0 22.--24. " OUTMUX2 "  " "
bitfld.long 0 25.--27. " OUTMUX3 "  " "
bitfld.long 0 28.--30. " OUTMUX4 "  " "
tree.end

base sd:0xa0350008
tree "SSP"
group 0--3
line.long 0 "SSP"
bitfld.long 0 0.--7. " SSPDATA "  " "
bitfld.long 0 8. " SSPCMD "  "0 ,1 "
bitfld.long 0 16. " SSPEN "  "0 ,1 "
tree.end

base sd:0xa0350100
tree "AIS"
group 0--3
line.long 0 "AIS"
bitfld.long 0 0. " MCDEPPI "  "0 ,1 "
bitfld.long 0 1. " MCDEOVLI "  "0 ,1 "
bitfld.long 0 2. " MCDECHNLI "  "0 ,1 "
bitfld.long 0 3. " MCDEERRI "  "0 ,1 "
bitfld.long 0 4. " DSI0AI "  "0 ,1 "
bitfld.long 0 5. " DSI1AI "  "0 ,1 "
bitfld.long 0 6. " DSI2AI "  "0 ,1 "
tree.end

base sd:0xa0350104
tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " VCMPAIM "  "0 ,1 "
bitfld.long 0 1. " VCMPBIM "  "0 ,1 "
bitfld.long 0 2. " VSCC0IM "  "0 ,1 "
bitfld.long 0 3. " VSCC1IM "  "0 ,1 "
bitfld.long 0 4. " VCMPC0IM "  "0 ,1 "
bitfld.long 0 5. " VCMPC1IM "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDIM "  " "
tree.end

base sd:0xa0350108
tree "IMSCOVL"
group 0--3
line.long 0 "IMSCOVL"
bitfld.long 0 0.--15. " OVLRDIM "  " "
bitfld.long 0 16.--31. " OVLFDIM "  " "
tree.end

base sd:0xa035010c
tree "IMSCCHNL"
group 0--3
line.long 0 "IMSCCHNL"
bitfld.long 0 0.--15. " CHNLRDIM "  " "
bitfld.long 0 16.--31. " CHNLAIM "  " "
tree.end

base sd:0xa0350110
tree "IMSCERR"
group 0--3
line.long 0 "IMSCERR"
bitfld.long 0 0. " FUAIM "  "0 ,1 "
bitfld.long 0 1. " FUBIM "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDIM "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFEIM "  " "
bitfld.long 0 5.--6. " ROTBFEIM "  " "
bitfld.long 0 7. " FUC0IM "  "0 ,1 "
bitfld.long 0 8. " FUC1IM "  "0 ,1 "
bitfld.long 0 16.--31. " OVLFERRIM "  " "
tree.end

base sd:0xa0350114
tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " VCMPARIS "  "0 ,1 "
bitfld.long 0 1. " VCMPBRIS "  "0 ,1 "
bitfld.long 0 2. " VSCC0RIS "  "0 ,1 "
bitfld.long 0 3. " VSCC1RIS "  "0 ,1 "
bitfld.long 0 4. " VCMPC0RIS "  "0 ,1 "
bitfld.long 0 5. " VCMPC1RIS "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDRIS "  " "
tree.end

base sd:0xa0350118
tree "RISOVL"
rgroup 0--3
line.long 0 "RISOVL"
bitfld.long 0 0.--15. " OVLRDRIS "  " "
bitfld.long 0 16.--31. " OVLFDRIS "  " "
tree.end

base sd:0xa035011c
tree "RISCHNL"
rgroup 0--3
line.long 0 "RISCHNL"
bitfld.long 0 0.--15. " CHNLRDRIS "  " "
bitfld.long 0 16.--31. " CHNLARIS "  " "
tree.end

base sd:0xa0350120
tree "RISERR"
rgroup 0--3
line.long 0 "RISERR"
bitfld.long 0 0. " FUARIS "  "0 ,1 "
bitfld.long 0 1. " FUBRIS "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDRIS "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFERIS "  " "
bitfld.long 0 5.--6. " ROTBFERIS "  " "
bitfld.long 0 7. " FUC0RIS "  "0 ,1 "
bitfld.long 0 8. " FUC1RIS "  "0 ,1 "
bitfld.long 0 16.--31. " OVLFERRIS "  " "
tree.end

base sd:0xa0350124
tree "MIS"
group 0--3
line.long 0 "MIS"
bitfld.long 0 0. " VCMPAMIS "  "0 ,1 "
bitfld.long 0 1. " VCMPBMIS "  "0 ,1 "
bitfld.long 0 2. " VSCC0MIS "  "0 ,1 "
bitfld.long 0 3. " VSCC1MIS "  "0 ,1 "
bitfld.long 0 4. " VCMPC0MIS "  "0 ,1 "
bitfld.long 0 5. " VCMPC1MIS "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDMIS "  " "
tree.end

base sd:0xa0350128
tree "MISOVL"
group 0--3
line.long 0 "MISOVL"
bitfld.long 0 0.--15. " OVLRDMIS "  " "
bitfld.long 0 16.--31. " OVLFDMIS "  " "
tree.end

base sd:0xa035012c
tree "MISCHNL"
group 0--3
line.long 0 "MISCHNL"
bitfld.long 0 0.--15. " CHNLRDMIS "  " "
bitfld.long 0 16.--31. " CHNLAMIS "  " "
tree.end

base sd:0xa0350130
tree "MISERR"
group 0--3
line.long 0 "MISERR"
bitfld.long 0 0. " FUAMIS "  "0 ,1 "
bitfld.long 0 1. " FUBMIS "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDMIS "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFEMIS "  " "
bitfld.long 0 5.--6. " ROTBFEMIS "  " "
bitfld.long 0 7. " FUC0MIS "  "0 ,1 "
bitfld.long 0 8. " FUC1MIS "  "0 ,1 "
bitfld.long 0 16.--31. " OVLFERMIS "  " "
tree.end

base sd:0xa0350134
tree "SIS"
group 0--3
line.long 0 "SIS"
bitfld.long 0 0. " VCMPASIS "  "0 ,1 "
bitfld.long 0 1. " VCMPBSIS "  "0 ,1 "
bitfld.long 0 2. " VSCC0SIS "  "0 ,1 "
bitfld.long 0 3. " VSCC1SIS "  "0 ,1 "
bitfld.long 0 4. " VCMPC0SIS "  "0 ,1 "
bitfld.long 0 5. " VCMPC1SIS "  "0 ,1 "
bitfld.long 0 6.--7. " ROTFDSIS "  " "
tree.end

base sd:0xa0350138
tree "SISOVL"
group 0--3
line.long 0 "SISOVL"
bitfld.long 0 0.--15. " OVLRDSIS "  " "
bitfld.long 0 16.--31. " OVLFDSIS "  " "
tree.end

base sd:0xa035013c
tree "SISCHNL"
group 0--3
line.long 0 "SISCHNL"
bitfld.long 0 0.--15. " CHNLRDSIS "  " "
bitfld.long 0 16.--31. " CHNLASIS "  " "
tree.end

base sd:0xa0350140
tree "SISERR"
group 0--3
line.long 0 "SISERR"
bitfld.long 0 0. " FUASIS "  "0 ,1 "
bitfld.long 0 1. " FUBSIS "  "0 ,1 "
bitfld.long 0 2. " SCHBLCKDSIS "  "0 ,1 "
bitfld.long 0 3.--4. " ROTAFESIS "  " "
bitfld.long 0 5.--6. " ROTBFESIS "  " "
bitfld.long 0 7. " FUC0SIS "  "0 ,1 "
bitfld.long 0 8. " FUC1SIS "  "0 ,1 "
bitfld.long 0 16.--31. " OVLFERSIS "  " "
tree.end

base sd:0xa03501fc
tree "PID"
group 0--3
line.long 0 "PID"
bitfld.long 0 0.--7. " METALFIX_VERSION "  " "
bitfld.long 0 8.--15. " DEVELOPMENT_VERSION "  " "
bitfld.long 0 16.--23. " MINOR_VERSION "  " "
bitfld.long 0 24.--31. " MAJOR_VERSION "  " "
tree.end

base sd:0xa0350200
tree "EXTSRC0A0"
group 0--3
line.long 0 "EXTSRC0A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
tree.end

base sd:0xa0350204
tree "EXTSRC0A1"
group 0--3
line.long 0 "EXTSRC0A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
tree.end

base sd:0xa035020c
tree "EXTSRC0CONF"
group 0--3
line.long 0 "EXTSRC0CONF"
bitfld.long 0 0.--1. " BUF_ID "  " "
bitfld.long 0 2.--3. " BUF_NB "  " "
bitfld.long 0 4.--7. " PRI_OVLID "  " "
bitfld.long 0 8.--11. " BPP "  " "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
tree.end

base sd:0xa0350210
tree "EXTSRC0CR"
group 0--3
line.long 0 "EXTSRC0CR"
bitfld.long 0 0.--1. " SEL_MOD "  " "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
tree.end

base sd:0xa0350220
tree "EXTSRC1A0"
group 0--3
line.long 0 "EXTSRC1A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
tree.end

base sd:0xa0350224
tree "EXTSRC1A1"
group 0--3
line.long 0 "EXTSRC1A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
tree.end

base sd:0xa035022c
tree "EXTSRC1CONF"
group 0--3
line.long 0 "EXTSRC1CONF"
bitfld.long 0 0.--1. " BUF_ID "  " "
bitfld.long 0 2.--3. " BUF_NB "  " "
bitfld.long 0 4.--7. " PRI_OVLID "  " "
bitfld.long 0 8.--11. " BPP "  " "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
tree.end

base sd:0xa0350230
tree "EXTSRC1CR"
group 0--3
line.long 0 "EXTSRC1CR"
bitfld.long 0 0.--1. " SEL_MOD "  " "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
tree.end

base sd:0xa0350240
tree "EXTSRC2A0"
group 0--3
line.long 0 "EXTSRC2A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
tree.end

base sd:0xa0350244
tree "EXTSRC2A1"
group 0--3
line.long 0 "EXTSRC2A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
tree.end

base sd:0xa035024c
tree "EXTSRC2CONF"
group 0--3
line.long 0 "EXTSRC2CONF"
bitfld.long 0 0.--1. " BUF_ID "  " "
bitfld.long 0 2.--3. " BUF_NB "  " "
bitfld.long 0 4.--7. " PRI_OVLID "  " "
bitfld.long 0 8.--11. " BPP "  " "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
tree.end

base sd:0xa0350250
tree "EXTSRC2CR"
group 0--3
line.long 0 "EXTSRC2CR"
bitfld.long 0 0.--1. " SEL_MOD "  " "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
tree.end

base sd:0xa0350260
tree "EXTSRC3A0"
group 0--3
line.long 0 "EXTSRC3A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
tree.end

base sd:0xa0350264
tree "EXTSRC3A1"
group 0--3
line.long 0 "EXTSRC3A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
tree.end

base sd:0xa035026c
tree "EXTSRC3CONF"
group 0--3
line.long 0 "EXTSRC3CONF"
bitfld.long 0 0.--1. " BUF_ID "  " "
bitfld.long 0 2.--3. " BUF_NB "  " "
bitfld.long 0 4.--7. " PRI_OVLID "  " "
bitfld.long 0 8.--11. " BPP "  " "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
tree.end

base sd:0xa0350270
tree "EXTSRC3CR"
group 0--3
line.long 0 "EXTSRC3CR"
bitfld.long 0 0.--1. " SEL_MOD "  " "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
tree.end

base sd:0xa0350280
tree "EXTSRC4A0"
group 0--3
line.long 0 "EXTSRC4A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
tree.end

base sd:0xa0350284
tree "EXTSRC4A1"
group 0--3
line.long 0 "EXTSRC4A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
tree.end

base sd:0xa035028c
tree "EXTSRC4CONF"
group 0--3
line.long 0 "EXTSRC4CONF"
bitfld.long 0 0.--1. " BUF_ID "  " "
bitfld.long 0 2.--3. " BUF_NB "  " "
bitfld.long 0 4.--7. " PRI_OVLID "  " "
bitfld.long 0 8.--11. " BPP "  " "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
tree.end

base sd:0xa0350290
tree "EXTSRC4CR"
group 0--3
line.long 0 "EXTSRC4CR"
bitfld.long 0 0.--1. " SEL_MOD "  " "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
tree.end

base sd:0xa03502a0
tree "EXTSRC5A0"
group 0--3
line.long 0 "EXTSRC5A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
tree.end

base sd:0xa03502a4
tree "EXTSRC5A1"
group 0--3
line.long 0 "EXTSRC5A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
tree.end

base sd:0xa03502ac
tree "EXTSRC5CONF"
group 0--3
line.long 0 "EXTSRC5CONF"
bitfld.long 0 0.--1. " BUF_ID "  " "
bitfld.long 0 2.--3. " BUF_NB "  " "
bitfld.long 0 4.--7. " PRI_OVLID "  " "
bitfld.long 0 8.--11. " BPP "  " "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
tree.end

base sd:0xa03502b0
tree "EXTSRC5CR"
group 0--3
line.long 0 "EXTSRC5CR"
bitfld.long 0 0.--1. " SEL_MOD "  " "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
tree.end

base sd:0xa03502c0
tree "EXTSRC6A0"
group 0--3
line.long 0 "EXTSRC6A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
tree.end

base sd:0xa03502c4
tree "EXTSRC6A1"
group 0--3
line.long 0 "EXTSRC6A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
tree.end

base sd:0xa03502c8
tree "EXTSRC6A2"
group 0--3
line.long 0 "EXTSRC6A2"
bitfld.long 0 0.--2. " BASEADDRESS2_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS2_MSB "  " "
tree.end

base sd:0xa03502cc
tree "EXTSRC6CONF"
group 0--3
line.long 0 "EXTSRC6CONF"
bitfld.long 0 0.--1. " BUF_ID "  " "
bitfld.long 0 2.--3. " BUF_NB "  " "
bitfld.long 0 4.--7. " PRI_OVLID "  " "
bitfld.long 0 8.--11. " BPP "  " "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
tree.end

base sd:0xa03502d0
tree "EXTSRC6CR"
group 0--3
line.long 0 "EXTSRC6CR"
bitfld.long 0 0.--1. " SEL_MOD "  " "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
tree.end

base sd:0xa03502e0
tree "EXTSRC7A0"
group 0--3
line.long 0 "EXTSRC7A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
tree.end

base sd:0xa03502e4
tree "EXTSRC7A1"
group 0--3
line.long 0 "EXTSRC7A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
tree.end

base sd:0xa03502ec
tree "EXTSRC7CONF"
group 0--3
line.long 0 "EXTSRC7CONF"
bitfld.long 0 0.--1. " BUF_ID "  " "
bitfld.long 0 2.--3. " BUF_NB "  " "
bitfld.long 0 4.--7. " PRI_OVLID "  " "
bitfld.long 0 8.--11. " BPP "  " "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
tree.end

base sd:0xa03502f0
tree "EXTSRC7CR"
group 0--3
line.long 0 "EXTSRC7CR"
bitfld.long 0 0.--1. " SEL_MOD "  " "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
tree.end

base sd:0xa0350300
tree "EXTSRC8A0"
group 0--3
line.long 0 "EXTSRC8A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
tree.end

base sd:0xa0350304
tree "EXTSRC8A1"
group 0--3
line.long 0 "EXTSRC8A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
tree.end

base sd:0xa035030c
tree "EXTSRC8CONF"
group 0--3
line.long 0 "EXTSRC8CONF"
bitfld.long 0 0.--1. " BUF_ID "  " "
bitfld.long 0 2.--3. " BUF_NB "  " "
bitfld.long 0 4.--7. " PRI_OVLID "  " "
bitfld.long 0 8.--11. " BPP "  " "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
tree.end

base sd:0xa0350310
tree "EXTSRC8CR"
group 0--3
line.long 0 "EXTSRC8CR"
bitfld.long 0 0.--1. " SEL_MOD "  " "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
tree.end

base sd:0xa0350320
tree "EXTSRC9A0"
group 0--3
line.long 0 "EXTSRC9A0"
bitfld.long 0 0.--2. " BASEADDRESS0_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS0_MSB "  " "
tree.end

base sd:0xa0350324
tree "EXTSRC9A1"
group 0--3
line.long 0 "EXTSRC9A1"
bitfld.long 0 0.--2. " BASEADDRESS1_LSB "  " "
bitfld.long 0 3.--31. " BASEADDRESS1_MSB "  " "
tree.end

base sd:0xa035032c
tree "EXTSRC9CONF"
group 0--3
line.long 0 "EXTSRC9CONF"
bitfld.long 0 0.--1. " BUF_ID "  " "
bitfld.long 0 2.--3. " BUF_NB "  " "
bitfld.long 0 4.--7. " PRI_OVLID "  " "
bitfld.long 0 8.--11. " BPP "  " "
bitfld.long 0 12. " BGR "  "0 ,1 "
bitfld.long 0 13. " BEBO "  "0 ,1 "
bitfld.long 0 14. " BEPO "  "0 ,1 "
tree.end

base sd:0xa0350330
tree "EXTSRC9CR"
group 0--3
line.long 0 "EXTSRC9CR"
bitfld.long 0 0.--1. " SEL_MOD "  " "
bitfld.long 0 2. " MULTIOVL_CTRL "  "0 ,1 "
bitfld.long 0 3. " FS_DIV_DISABLE "  "0 ,1 "
bitfld.long 0 4. " FORCE_FS_DIV "  "0 ,1 "
tree.end

base sd:0xa0350400
tree "OVL0CR"
group 0--3
line.long 0 "OVL0CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  " "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
bitfld.long 0 8.--15. " FETCH_ROPC "  " "
bitfld.long 0 16.--19. " STBPRIO "  " "
bitfld.long 0 20.--23. " BURSTSIZE "  " "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  " "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  " "
tree.end

base sd:0xa0350404
tree "OVL0CONF"
group 0--3
line.long 0 "OVL0CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  " "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base sd:0xa0350408
tree "OVL0CONF2"
group 0--3
line.long 0 "OVL0CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  " "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
tree.end

base sd:0xa035040c
tree "OVL0JINC"
group 0--3
line.long 0 "OVL0JINC"
bitfld.long 0 0.--31. " LJINC "  " "
tree.end

base sd:0xa0350410
tree "OVL0CROP"
group 0--3
line.long 0 "OVL0CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
tree.end

base sd:0xa0350414
tree "OVL0COMP"
group 0--3
line.long 0 "OVL0COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  " "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  " "
tree.end

base sd:0xa0350420
tree "OVL1CR"
group 0--3
line.long 0 "OVL1CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  " "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
bitfld.long 0 8.--15. " FETCH_ROPC "  " "
bitfld.long 0 16.--19. " STBPRIO "  " "
bitfld.long 0 20.--23. " BURSTSIZE "  " "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  " "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  " "
tree.end

base sd:0xa0350424
tree "OVL1CONF"
group 0--3
line.long 0 "OVL1CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  " "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base sd:0xa0350428
tree "OVL1CONF2"
group 0--3
line.long 0 "OVL1CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  " "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
tree.end

base sd:0xa035042c
tree "OVL1JINC"
group 0--3
line.long 0 "OVL1JINC"
bitfld.long 0 0.--31. " LJINC "  " "
tree.end

base sd:0xa0350430
tree "OVL1CROP"
group 0--3
line.long 0 "OVL1CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
tree.end

base sd:0xa0350434
tree "OVL1COMP"
group 0--3
line.long 0 "OVL1COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  " "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  " "
tree.end

base sd:0xa0350440
tree "OVL2CR"
group 0--3
line.long 0 "OVL2CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  " "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
bitfld.long 0 8.--15. " FETCH_ROPC "  " "
bitfld.long 0 16.--19. " STBPRIO "  " "
bitfld.long 0 20.--23. " BURSTSIZE "  " "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  " "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  " "
tree.end

base sd:0xa0350444
tree "OVL2CONF"
group 0--3
line.long 0 "OVL2CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  " "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base sd:0xa0350448
tree "OVL2CONF2"
group 0--3
line.long 0 "OVL2CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  " "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
tree.end

base sd:0xa035044c
tree "OVL2JINC"
group 0--3
line.long 0 "OVL2JINC"
bitfld.long 0 0.--31. " LJINC "  " "
tree.end

base sd:0xa0350450
tree "OVL2CROP"
group 0--3
line.long 0 "OVL2CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
tree.end

base sd:0xa0350454
tree "OVL2COMP"
group 0--3
line.long 0 "OVL2COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  " "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  " "
tree.end

base sd:0xa0350460
tree "OVL3CR"
group 0--3
line.long 0 "OVL3CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  " "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
bitfld.long 0 8.--15. " FETCH_ROPC "  " "
bitfld.long 0 16.--19. " STBPRIO "  " "
bitfld.long 0 20.--23. " BURSTSIZE "  " "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  " "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  " "
tree.end

base sd:0xa0350464
tree "OVL3CONF"
group 0--3
line.long 0 "OVL3CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  " "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base sd:0xa0350468
tree "OVL3CONF2"
group 0--3
line.long 0 "OVL3CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  " "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
tree.end

base sd:0xa035046c
tree "OVL3JINC"
group 0--3
line.long 0 "OVL3JINC"
bitfld.long 0 0.--31. " LJINC "  " "
tree.end

base sd:0xa0350470
tree "OVL3CROP"
group 0--3
line.long 0 "OVL3CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
tree.end

base sd:0xa0350474
tree "OVL3COMP"
group 0--3
line.long 0 "OVL3COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  " "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  " "
tree.end

base sd:0xa0350480
tree "OVL4CR"
group 0--3
line.long 0 "OVL4CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  " "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
bitfld.long 0 8.--15. " FETCH_ROPC "  " "
bitfld.long 0 16.--19. " STBPRIO "  " "
bitfld.long 0 20.--23. " BURSTSIZE "  " "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  " "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  " "
tree.end

base sd:0xa0350484
tree "OVL4CONF"
group 0--3
line.long 0 "OVL4CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  " "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base sd:0xa0350488
tree "OVL4CONF2"
group 0--3
line.long 0 "OVL4CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  " "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
tree.end

base sd:0xa035048c
tree "OVL4JINC"
group 0--3
line.long 0 "OVL4JINC"
bitfld.long 0 0.--31. " LJINC "  " "
tree.end

base sd:0xa0350490
tree "OVL4CROP"
group 0--3
line.long 0 "OVL4CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
tree.end

base sd:0xa0350494
tree "OVL4COMP"
group 0--3
line.long 0 "OVL4COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  " "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  " "
tree.end

base sd:0xa03504a0
tree "OVL5CR"
group 0--3
line.long 0 "OVL5CR"
bitfld.long 0 0. " OVLEN "  "0 ,1 "
bitfld.long 0 1.--2. " COLCCTRL "  " "
bitfld.long 0 3. " CKEYEN "  "0 ,1 "
bitfld.long 0 4. " ALPHAPMEN "  "0 ,1 "
bitfld.long 0 5. " OVLF "  "0 ,1 "
bitfld.long 0 6. " OVLR "  "0 ,1 "
bitfld.long 0 7. " OVLB "  "0 ,1 "
bitfld.long 0 8.--15. " FETCH_ROPC "  " "
bitfld.long 0 16.--19. " STBPRIO "  " "
bitfld.long 0 20.--23. " BURSTSIZE "  " "
bitfld.long 0 24.--27. " MAXOUTSTANDING "  " "
bitfld.long 0 28.--31. " ROTBURSTSIZE "  " "
tree.end

base sd:0xa03504a4
tree "OVL5CONF"
group 0--3
line.long 0 "OVL5CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 11.--14. " EXTSRC_ID "  " "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base sd:0xa03504a8
tree "OVL5CONF2"
group 0--3
line.long 0 "OVL5CONF2"
bitfld.long 0 0. " BP "  "0 ,1 "
bitfld.long 0 1.--8. " ALPHAVALUE "  " "
bitfld.long 0 9. " OPQ "  "0 ,1 "
bitfld.long 0 10.--15. " PIXOFF "  " "
bitfld.long 0 16.--28. " PIXELFETCHERWATERMARKLEVEL "  " "
tree.end

base sd:0xa03504ac
tree "OVL5JINC"
group 0--3
line.long 0 "OVL5JINC"
bitfld.long 0 0.--31. " LJINC "  " "
tree.end

base sd:0xa03504b0
tree "OVL5CROP"
group 0--3
line.long 0 "OVL5CROP"
bitfld.long 0 0.--21. " TMRGN "  " "
bitfld.long 0 22.--31. " LMRGN "  " "
tree.end

base sd:0xa03504b4
tree "OVL5COMP"
group 0--3
line.long 0 "OVL5COMP"
bitfld.long 0 0.--10. " XPOS "  " "
bitfld.long 0 11.--14. " CH_ID "  " "
bitfld.long 0 16.--26. " YPOS "  " "
bitfld.long 0 27.--30. " Z "  " "
tree.end

base sd:0xa0350600
tree "CHNL0CONF"
group 0--3
line.long 0 "CHNL0CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base sd:0xa0350604
tree "CHNL0STAT"
group 0--3
line.long 0 "CHNL0STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
tree.end

base sd:0xa0350608
tree "CHNL0SYNCMOD"
group 0--3
line.long 0 "CHNL0SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  " "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  " "
tree.end

base sd:0xa035060c
tree "CHNL0SYNCHSW"
wgroup 0--3
line.long 0 "CHNL0SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
tree.end

base sd:0xa0350610
tree "CHNL0BCKCL"
group 0--3
line.long 0 "CHNL0BCKCL"
bitfld.long 0 0.--7. " B "  " "
bitfld.long 0 8.--15. " G "  " "
bitfld.long 0 16.--23. " R "  " "
tree.end

base sd:0xa0350614
tree "CHNL0MUXING"
group 0--3
line.long 0 "CHNL0MUXING"
bitfld.long 0 0.--2. " FIFOID "  " "
tree.end

base sd:0xa0350620
tree "CHNL1CONF"
group 0--3
line.long 0 "CHNL1CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base sd:0xa0350624
tree "CHNL1STAT"
group 0--3
line.long 0 "CHNL1STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
tree.end

base sd:0xa0350628
tree "CHNL1SYNCMOD"
group 0--3
line.long 0 "CHNL1SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  " "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  " "
tree.end

base sd:0xa035062c
tree "CHNL1SYNCHSW"
wgroup 0--3
line.long 0 "CHNL1SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
tree.end

base sd:0xa0350630
tree "CHNL1BCKCL"
group 0--3
line.long 0 "CHNL1BCKCL"
bitfld.long 0 0.--7. " B "  " "
bitfld.long 0 8.--15. " G "  " "
bitfld.long 0 16.--23. " R "  " "
tree.end

base sd:0xa0350634
tree "CHNL1MUXING"
group 0--3
line.long 0 "CHNL1MUXING"
bitfld.long 0 0.--2. " FIFOID "  " "
tree.end

base sd:0xa0350640
tree "CHNL2CONF"
group 0--3
line.long 0 "CHNL2CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base sd:0xa0350644
tree "CHNL2STAT"
group 0--3
line.long 0 "CHNL2STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
tree.end

base sd:0xa0350648
tree "CHNL2SYNCMOD"
group 0--3
line.long 0 "CHNL2SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  " "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  " "
tree.end

base sd:0xa035064c
tree "CHNL2SYNCHSW"
wgroup 0--3
line.long 0 "CHNL2SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
tree.end

base sd:0xa0350650
tree "CHNL2BCKCL"
group 0--3
line.long 0 "CHNL2BCKCL"
bitfld.long 0 0.--7. " B "  " "
bitfld.long 0 8.--15. " G "  " "
bitfld.long 0 16.--23. " R "  " "
tree.end

base sd:0xa0350654
tree "CHNL2MUXING"
group 0--3
line.long 0 "CHNL2MUXING"
bitfld.long 0 0.--2. " FIFOID "  " "
tree.end

base sd:0xa0350660
tree "CHNL3CONF"
group 0--3
line.long 0 "CHNL3CONF"
bitfld.long 0 0.--10. " PPL "  " "
bitfld.long 0 16.--26. " LPF "  " "
tree.end

base sd:0xa0350664
tree "CHNL3STAT"
group 0--3
line.long 0 "CHNL3STAT"
bitfld.long 0 0. " CHNLRD "  "0 ,1 "
bitfld.long 0 1. " CHNLA "  "0 ,1 "
bitfld.long 0 16. " CHNLBLBCKGND_EN "  "0 ,1 "
tree.end

base sd:0xa0350668
tree "CHNL3SYNCMOD"
group 0--3
line.long 0 "CHNL3SYNCMOD"
bitfld.long 0 0.--1. " SRC_SYNCH "  " "
bitfld.long 0 2.--4. " OUT_SYNCH_SRC "  " "
tree.end

base sd:0xa035066c
tree "CHNL3SYNCHSW"
wgroup 0--3
line.long 0 "CHNL3SYNCHSW"
bitfld.long 0 0. " SW_TRIG "  "0 ,1 "
tree.end

base sd:0xa0350670
tree "CHNL3BCKCL"
group 0--3
line.long 0 "CHNL3BCKCL"
bitfld.long 0 0.--7. " B "  " "
bitfld.long 0 8.--15. " G "  " "
bitfld.long 0 16.--23. " R "  " "
tree.end

base sd:0xa0350674
tree "CHNL3MUXING"
group 0--3
line.long 0 "CHNL3MUXING"
bitfld.long 0 0.--2. " FIFOID "  " "
tree.end

base sd:0xa0350800
tree "CRA0"
group 0--3
line.long 0 "CRA0"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 1. " POWEREN "  "0 ,1 "
bitfld.long 0 2. " BLENDEN "  "0 ,1 "
bitfld.long 0 3. " AFLICKEN "  "0 ,1 "
bitfld.long 0 4. " PALEN "  "0 ,1 "
bitfld.long 0 5. " DITHEN "  "0 ,1 "
bitfld.long 0 6. " GAMEN "  "0 ,1 "
bitfld.long 0 7.--9. " KEYCTRL "  " "
bitfld.long 0 10. " BLENDCTRL "  "0 ,1 "
bitfld.long 0 11.--12. " FLICKMODE "  " "
bitfld.long 0 13. " FLICKFORMAT "  "0 ,1 "
bitfld.long 0 14. " PALMODE "  "0 ,1 "
bitfld.long 0 15. " OLEDEN "  "0 ,1 "
bitfld.long 0 16.--23. " ALPHABLEND "  " "
bitfld.long 0 24. " ROTEN "  "0 ,1 "
tree.end

base sd:0xa0350804
tree "CRA1"
group 0--3
line.long 0 "CRA1"
bitfld.long 0 0.--9. " PCD "  " "
bitfld.long 0 10.--12. " CLKSEL "  " "
bitfld.long 0 13.--16. " CDWIN "  " "
bitfld.long 0 25.--28. " OUTBPP "  " "
bitfld.long 0 29. " BCD "  "0 ,1 "
bitfld.long 0 30. " CLKTYPE "  "0 ,1 "
tree.end

base sd:0xa0350808
tree "COLKEYA"
group 0--3
line.long 0 "COLKEYA"
bitfld.long 0 0.--7. " KEYB "  " "
bitfld.long 0 8.--15. " KEYG "  " "
bitfld.long 0 16.--23. " KEYR "  " "
bitfld.long 0 24.--31. " KEYA "  " "
tree.end

base sd:0xa035080c
tree "FCOLKEYA"
group 0--3
line.long 0 "FCOLKEYA"
bitfld.long 0 0.--7. " FKEYB "  " "
bitfld.long 0 8.--15. " FKEYG "  " "
bitfld.long 0 16.--23. " FKEYR "  " "
bitfld.long 0 24.--31. " FKEYA "  " "
tree.end

base sd:0xa0350810
tree "RGBCONV1A"
group 0--3
line.long 0 "RGBCONV1A"
bitfld.long 0 0.--10. " YR_GREEN "  " "
bitfld.long 0 16.--26. " YR_RED "  " "
tree.end

base sd:0xa0350814
tree "RGBCONV2A"
group 0--3
line.long 0 "RGBCONV2A"
bitfld.long 0 0.--10. " CR_RED "  " "
bitfld.long 0 16.--26. " YR_BLUE "  " "
tree.end

base sd:0xa0350818
tree "RGBCONV3A"
group 0--3
line.long 0 "RGBCONV3A"
bitfld.long 0 0.--10. " CR_BLUE "  " "
bitfld.long 0 16.--26. " CR_GREEN "  " "
tree.end

base sd:0xa035081c
tree "RGBCONV4A"
group 0--3
line.long 0 "RGBCONV4A"
bitfld.long 0 0.--10. " CB_GREEN "  " "
bitfld.long 0 16.--26. " CB_RED "  " "
tree.end

base sd:0xa0350820
tree "RGBCONV5A"
group 0--3
line.long 0 "RGBCONV5A"
bitfld.long 0 0.--10. " OFF_RED "  " "
bitfld.long 0 16.--26. " CB_BLUE "  " "
tree.end

base sd:0xa0350824
tree "RGBCONV6A"
group 0--3
line.long 0 "RGBCONV6A"
bitfld.long 0 0.--10. " OFF_BLUE "  " "
bitfld.long 0 16.--26. " OFF_GREEN "  " "
tree.end

base sd:0xa0350828
tree "FFCOEF0A"
group 0--3
line.long 0 "FFCOEF0A"
bitfld.long 0 0.--7. " COEFF0_N1 "  " "
bitfld.long 0 8.--15. " COEFF0_N2 "  " "
bitfld.long 0 16.--23. " COEFF0_N3 "  " "
bitfld.long 0 24.--27. " T0 "  " "
tree.end

base sd:0xa035082c
tree "FFCOEF1A"
group 0--3
line.long 0 "FFCOEF1A"
bitfld.long 0 0.--7. " COEFF1_N1 "  " "
bitfld.long 0 8.--15. " COEFF1_N2 "  " "
bitfld.long 0 16.--23. " COEFF1_N3 "  " "
bitfld.long 0 24.--27. " T1 "  " "
tree.end

base sd:0xa0350830
tree "FFCOEF2A"
group 0--3
line.long 0 "FFCOEF2A"
bitfld.long 0 0.--7. " COEFF2_N1 "  " "
bitfld.long 0 8.--15. " COEFF2_N2 "  " "
bitfld.long 0 16.--23. " COEFF2_N3 "  " "
bitfld.long 0 24.--27. " T2 "  " "
tree.end

base sd:0xa0350834
tree "WDATAA"
group 0--3
line.long 0 "WDATAA"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
tree.end

base sd:0xa0350838
tree "TVCRA"
group 0--3
line.long 0 "TVCRA"
bitfld.long 0 0. " SEL_MOD "  "0 ,1 "
bitfld.long 0 1. " INTEREN "  "0 ,1 "
bitfld.long 0 2. " IFIELD "  "0 ,1 "
bitfld.long 0 3.--5. " TVMODE "  " "
bitfld.long 0 6.--7. " SDTVMODE "  " "
bitfld.long 0 8. " AVRGEN "  "0 ,1 "
bitfld.long 0 9. " CKINV "  "0 ,1 "
tree.end

base sd:0xa035083c
tree "TVBL1A"
group 0--3
line.long 0 "TVBL1A"
bitfld.long 0 0.--10. " BEL1 "  " "
bitfld.long 0 16.--26. " BSL1 "  " "
tree.end

base sd:0xa0350840
tree "TVISLA"
group 0--3
line.long 0 "TVISLA"
bitfld.long 0 0.--10. " FSL1 "  " "
bitfld.long 0 16.--26. " FSL2 "  " "
tree.end

base sd:0xa0350844
tree "TVDVOA"
group 0--3
line.long 0 "TVDVOA"
bitfld.long 0 0.--10. " DVO1 "  " "
bitfld.long 0 16.--26. " DVO2 "  " "
tree.end

base sd:0xa035084c
tree "TVTIM1A"
group 0--3
line.long 0 "TVTIM1A"
bitfld.long 0 0.--10. " DHO "  " "
tree.end

base sd:0xa0350850
tree "TVLBALWA"
group 0--3
line.long 0 "TVLBALWA"
bitfld.long 0 0.--10. " LBW "  " "
bitfld.long 0 16.--26. " ALW "  " "
tree.end

base sd:0xa0350854
tree "TVBL2A"
group 0--3
line.long 0 "TVBL2A"
bitfld.long 0 0.--10. " BEL2 "  " "
bitfld.long 0 16.--26. " BSL2 "  " "
tree.end

base sd:0xa0350858
tree "TVBLUA"
group 0--3
line.long 0 "TVBLUA"
bitfld.long 0 0.--7. " TVBLU "  " "
bitfld.long 0 8.--15. " TVBCB "  " "
bitfld.long 0 16.--23. " TVBCR "  " "
tree.end

base sd:0xa0350860
tree "LCDTIM1A"
group 0--3
line.long 0 "LCDTIM1A"
bitfld.long 0 19. " IVP "  "0 ,1 "
bitfld.long 0 20. " IVS "  "0 ,1 "
bitfld.long 0 21. " IHS "  "0 ,1 "
bitfld.long 0 22. " IPC "  "0 ,1 "
bitfld.long 0 23. " IOE "  "0 ,1 "
tree.end

base sd:0xa0350864
tree "DITCTRLA"
group 0--3
line.long 0 "DITCTRLA"
bitfld.long 0 0. " TEMP "  "0 ,1 "
bitfld.long 0 1. " COMP "  "0 ,1 "
bitfld.long 0 2.--3. " MODE "  " "
bitfld.long 0 4. " MASK "  "0 ,1 "
bitfld.long 0 5.--9. " FOFFX "  " "
bitfld.long 0 10.--14. " FOFFY "  " "
tree.end

base sd:0xa0350868
tree "DITOFFA"
group 0--3
line.long 0 "DITOFFA"
bitfld.long 0 0.--4. " XG "  " "
bitfld.long 0 8.--12. " YG "  " "
bitfld.long 0 16.--20. " XB "  " "
bitfld.long 0 24.--28. " YB "  " "
tree.end

base sd:0xa035086c
tree "PAL0A"
group 0--3
line.long 0 "PAL0A"
bitfld.long 0 0.--11. " BLUE "  " "
bitfld.long 0 16.--27. " GREEN "  " "
tree.end

base sd:0xa0350870
tree "PAL1A"
group 0--3
line.long 0 "PAL1A"
bitfld.long 0 0.--11. " RED "  " "
tree.end

base sd:0xa0350874
tree "ROTADD0A"
group 0--3
line.long 0 "ROTADD0A"
bitfld.long 0 0.--2. " ROTADD0_LSB "  " "
bitfld.long 0 3.--31. " ROTADD0_MSB "  " "
tree.end

base sd:0xa0350878
tree "ROTADD1A"
group 0--3
line.long 0 "ROTADD1A"
bitfld.long 0 0.--2. " ROTADD1_LSB "  " "
bitfld.long 0 3.--31. " ROTADD1_MSB "  " "
tree.end

base sd:0xa035087c
tree "ROTACONF"
group 0--3
line.long 0 "ROTACONF"
bitfld.long 0 0.--2. " ROTBURSTSIZE "  " "
bitfld.long 0 3. " ROTDIR "  "0 ,1 "
bitfld.long 0 4.--5. " WR_MAXOUT "  " "
bitfld.long 0 6.--7. " RD_MAXOUT "  " "
bitfld.long 0 8.--14. " STRIP_WIDTH "  " "
bitfld.long 0 15. " SINGLE_BUF "  "0 ,1 "
bitfld.long 0 16.--23. " WR_ROPC "  " "
bitfld.long 0 24.--31. " RD_ROPC "  " "
tree.end

base sd:0xa0350880
tree "SYNCHCONFA"
group 0--3
line.long 0 "SYNCHCONFA"
bitfld.long 0 0.--1. " HWREQVEVENT "  " "
bitfld.long 0 2.--15. " HWREQVCNT "  " "
bitfld.long 0 16.--17. " SWINTVEVENT "  " "
bitfld.long 0 18.--31. " SWINTVCNT "  " "
tree.end

base sd:0xa0350884
tree "CTRLA"
group 0--3
line.long 0 "CTRLA"
bitfld.long 0 0.--9. " FIFOWTRMRK "  " "
bitfld.long 0 12. " FIFOEMPTY "  "0 ,1 "
bitfld.long 0 13. " FIFOFULL "  "0 ,1 "
bitfld.long 0 16.--18. " FORMID "  " "
bitfld.long 0 20.--22. " FORMTYPE "  " "
tree.end

base sd:0xa0350888
tree "GAM0A"
group 0--3
line.long 0 "GAM0A"
bitfld.long 0 0.--23. " BLUE "  " "
tree.end

base sd:0xa035088c
tree "GAM1A"
group 0--3
line.long 0 "GAM1A"
bitfld.long 0 0.--23. " GREEN "  " "
tree.end

base sd:0xa0350890
tree "GAM2A"
group 0--3
line.long 0 "GAM2A"
bitfld.long 0 0.--23. " RED "  " "
tree.end

base sd:0xa0350894
tree "OLEDCONV1A"
group 0--3
line.long 0 "OLEDCONV1A"
bitfld.long 0 0.--13. " ALPHA_RED "  " "
bitfld.long 0 16.--29. " ALPHA_GREEN "  " "
tree.end

base sd:0xa0350898
tree "OLEDCONV2A"
group 0--3
line.long 0 "OLEDCONV2A"
bitfld.long 0 0.--13. " ALPHA_BLUE "  " "
bitfld.long 0 16.--29. " BETA_RED "  " "
tree.end

base sd:0xa035089c
tree "OLEDCONV3A"
group 0--3
line.long 0 "OLEDCONV3A"
bitfld.long 0 0.--13. " BETA_GREEN "  " "
bitfld.long 0 16.--29. " BETA_BLUE "  " "
tree.end

base sd:0xa03508a0
tree "OLEDCONV4A"
group 0--3
line.long 0 "OLEDCONV4A"
bitfld.long 0 0.--13. " GAMMA_RED "  " "
bitfld.long 0 16.--29. " GAMMA_GREEN "  " "
tree.end

base sd:0xa03508a4
tree "OLEDCONV5A"
group 0--3
line.long 0 "OLEDCONV5A"
bitfld.long 0 0.--13. " GAMMA_BLUE "  " "
bitfld.long 0 16.--29. " OFF_RED "  " "
tree.end

base sd:0xa03508a8
tree "OLEDCONV6A"
group 0--3
line.long 0 "OLEDCONV6A"
bitfld.long 0 0.--13. " OFF_GREEN "  " "
bitfld.long 0 16.--29. " OFF_BLUE "  " "
tree.end

base sd:0xa0350a00
tree "CRB0"
group 0--3
line.long 0 "CRB0"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 1. " POWEREN "  "0 ,1 "
bitfld.long 0 2. " BLENDEN "  "0 ,1 "
bitfld.long 0 3. " AFLICKEN "  "0 ,1 "
bitfld.long 0 4. " PALEN "  "0 ,1 "
bitfld.long 0 5. " DITHEN "  "0 ,1 "
bitfld.long 0 6. " GAMEN "  "0 ,1 "
bitfld.long 0 7.--9. " KEYCTRL "  " "
bitfld.long 0 10. " BLENDCTRL "  "0 ,1 "
bitfld.long 0 11.--12. " FLICKMODE "  " "
bitfld.long 0 13. " FLICKFORMAT "  "0 ,1 "
bitfld.long 0 14. " PALMODE "  "0 ,1 "
bitfld.long 0 15. " OLEDEN "  "0 ,1 "
bitfld.long 0 16.--23. " ALPHABLEND "  " "
bitfld.long 0 24. " ROTEN "  "0 ,1 "
tree.end

base sd:0xa0350a04
tree "CRB1"
group 0--3
line.long 0 "CRB1"
bitfld.long 0 0.--9. " PCD "  " "
bitfld.long 0 10.--12. " CLKSEL "  " "
bitfld.long 0 13.--16. " CDWIN "  " "
bitfld.long 0 25.--28. " OUTBPP "  " "
bitfld.long 0 29. " BCD "  "0 ,1 "
bitfld.long 0 30. " CLKTYPE "  "0 ,1 "
tree.end

base sd:0xa0350a08
tree "COLKEYB"
group 0--3
line.long 0 "COLKEYB"
bitfld.long 0 0.--7. " KEYB "  " "
bitfld.long 0 8.--15. " KEYG "  " "
bitfld.long 0 16.--23. " KEYR "  " "
bitfld.long 0 24.--31. " KEYA "  " "
tree.end

base sd:0xa0350a0c
tree "FCOLKEYB"
group 0--3
line.long 0 "FCOLKEYB"
bitfld.long 0 0.--7. " FKEYB "  " "
bitfld.long 0 8.--15. " FKEYG "  " "
bitfld.long 0 16.--23. " FKEYR "  " "
bitfld.long 0 24.--31. " FKEYA "  " "
tree.end

base sd:0xa0350a10
tree "RGBCONV1B"
group 0--3
line.long 0 "RGBCONV1B"
bitfld.long 0 0.--10. " YR_GREEN "  " "
bitfld.long 0 16.--26. " YR_RED "  " "
tree.end

base sd:0xa0350a14
tree "RGBCONV2B"
group 0--3
line.long 0 "RGBCONV2B"
bitfld.long 0 0.--10. " CR_RED "  " "
bitfld.long 0 16.--26. " YR_BLUE "  " "
tree.end

base sd:0xa0350a18
tree "RGBCONV3B"
group 0--3
line.long 0 "RGBCONV3B"
bitfld.long 0 0.--10. " CR_BLUE "  " "
bitfld.long 0 16.--26. " CR_GREEN "  " "
tree.end

base sd:0xa0350a1c
tree "RGBCONV4B"
group 0--3
line.long 0 "RGBCONV4B"
bitfld.long 0 0.--10. " CB_GREEN "  " "
bitfld.long 0 16.--26. " CB_RED "  " "
tree.end

base sd:0xa0350a20
tree "RGBCONV5B"
group 0--3
line.long 0 "RGBCONV5B"
bitfld.long 0 0.--10. " OFF_RED "  " "
bitfld.long 0 16.--26. " CB_BLUE "  " "
tree.end

base sd:0xa0350a24
tree "RGBCONV6B"
group 0--3
line.long 0 "RGBCONV6B"
bitfld.long 0 0.--10. " OFF_BLUE "  " "
bitfld.long 0 16.--26. " OFF_GREEN "  " "
tree.end

base sd:0xa0350a34
tree "WDATAB"
group 0--3
line.long 0 "WDATAB"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
tree.end

base sd:0xa0350a38
tree "TVCRB"
group 0--3
line.long 0 "TVCRB"
bitfld.long 0 0. " SEL_MOD "  "0 ,1 "
bitfld.long 0 1. " INTEREN "  "0 ,1 "
bitfld.long 0 2. " IFIELD "  "0 ,1 "
bitfld.long 0 3.--5. " TVMODE "  " "
bitfld.long 0 6.--7. " SDTVMODE "  " "
bitfld.long 0 8. " AVRGEN "  "0 ,1 "
bitfld.long 0 9. " CKINV "  "0 ,1 "
tree.end

base sd:0xa0350a3c
tree "TVBL1B"
group 0--3
line.long 0 "TVBL1B"
bitfld.long 0 0.--10. " BEL1 "  " "
bitfld.long 0 16.--26. " BSL1 "  " "
tree.end

base sd:0xa0350a40
tree "TVISLB"
group 0--3
line.long 0 "TVISLB"
bitfld.long 0 0.--10. " FSL1 "  " "
bitfld.long 0 16.--26. " FSL2 "  " "
tree.end

base sd:0xa0350a44
tree "TVDVOB"
group 0--3
line.long 0 "TVDVOB"
bitfld.long 0 0.--10. " DVO1 "  " "
bitfld.long 0 16.--26. " DVO2 "  " "
tree.end

base sd:0xa0350a4c
tree "TVTIM1B"
group 0--3
line.long 0 "TVTIM1B"
bitfld.long 0 0.--10. " DHO "  " "
tree.end

base sd:0xa0350a50
tree "TVLBALWB"
group 0--3
line.long 0 "TVLBALWB"
bitfld.long 0 0.--10. " LBW "  " "
bitfld.long 0 16.--26. " ALW "  " "
tree.end

base sd:0xa0350a54
tree "TVBL2B"
group 0--3
line.long 0 "TVBL2B"
bitfld.long 0 0.--10. " BEL2 "  " "
bitfld.long 0 16.--26. " BSL2 "  " "
tree.end

base sd:0xa0350a58
tree "TVBLUB"
group 0--3
line.long 0 "TVBLUB"
bitfld.long 0 0.--7. " TVBLU "  " "
bitfld.long 0 8.--15. " TVBCB "  " "
bitfld.long 0 16.--23. " TVBCR "  " "
tree.end

base sd:0xa0350a60
tree "LCDTIM1B"
group 0--3
line.long 0 "LCDTIM1B"
bitfld.long 0 19. " IVP "  "0 ,1 "
bitfld.long 0 20. " IVS "  "0 ,1 "
bitfld.long 0 21. " IHS "  "0 ,1 "
bitfld.long 0 22. " IPC "  "0 ,1 "
bitfld.long 0 23. " IOE "  "0 ,1 "
tree.end

base sd:0xa0350a64
tree "DITCTRLB"
group 0--3
line.long 0 "DITCTRLB"
bitfld.long 0 0. " TEMP "  "0 ,1 "
bitfld.long 0 1. " COMP "  "0 ,1 "
bitfld.long 0 2.--3. " MODE "  " "
bitfld.long 0 4. " MASK "  "0 ,1 "
bitfld.long 0 5.--9. " FOFFX "  " "
bitfld.long 0 10.--14. " FOFFY "  " "
tree.end

base sd:0xa0350a68
tree "DITOFFB"
group 0--3
line.long 0 "DITOFFB"
bitfld.long 0 0.--4. " XG "  " "
bitfld.long 0 8.--12. " YG "  " "
bitfld.long 0 16.--20. " XB "  " "
bitfld.long 0 24.--28. " YB "  " "
tree.end

base sd:0xa0350a6c
tree "PAL0B"
group 0--3
line.long 0 "PAL0B"
bitfld.long 0 0.--11. " BLUE "  " "
bitfld.long 0 16.--27. " GREEN "  " "
tree.end

base sd:0xa0350a70
tree "PAL1B"
group 0--3
line.long 0 "PAL1B"
bitfld.long 0 0.--11. " RED "  " "
tree.end

base sd:0xa0350a74
tree "ROTADD0B"
group 0--3
line.long 0 "ROTADD0B"
bitfld.long 0 0.--2. " ROTADD0_LSB "  " "
bitfld.long 0 3.--31. " ROTADD0_MSB "  " "
tree.end

base sd:0xa0350a78
tree "ROTADD1B"
group 0--3
line.long 0 "ROTADD1B"
bitfld.long 0 0.--2. " ROTADD1_LSB "  " "
bitfld.long 0 3.--31. " ROTADD1_MSB "  " "
tree.end

base sd:0xa0350a7c
tree "ROTBCONF"
group 0--3
line.long 0 "ROTBCONF"
bitfld.long 0 0.--2. " ROTBURSTSIZE "  " "
bitfld.long 0 3. " ROTDIR "  "0 ,1 "
bitfld.long 0 4.--5. " WR_MAXOUT "  " "
bitfld.long 0 6.--7. " RD_MAXOUT "  " "
bitfld.long 0 8.--14. " STRIP_WIDTH "  " "
bitfld.long 0 15. " SINGLE_BUF "  "0 ,1 "
bitfld.long 0 16.--23. " WR_ROPC "  " "
bitfld.long 0 24.--31. " RD_ROPC "  " "
tree.end

base sd:0xa0350a80
tree "SYNCHCONFB"
group 0--3
line.long 0 "SYNCHCONFB"
bitfld.long 0 0.--1. " HWREQVEVENT "  " "
bitfld.long 0 2.--15. " HWREQVCNT "  " "
bitfld.long 0 16.--17. " SWINTVEVENT "  " "
bitfld.long 0 18.--31. " SWINTVCNT "  " "
tree.end

base sd:0xa0350a84
tree "CTRLB"
group 0--3
line.long 0 "CTRLB"
bitfld.long 0 0.--9. " FIFOWTRMRK "  " "
bitfld.long 0 12. " FIFOEMPTY "  "0 ,1 "
bitfld.long 0 13. " FIFOFULL "  "0 ,1 "
bitfld.long 0 16.--18. " FORMID "  " "
bitfld.long 0 20.--22. " FORMTYPE "  " "
tree.end

base sd:0xa0350a88
tree "GAM0B"
group 0--3
line.long 0 "GAM0B"
bitfld.long 0 0.--23. " BLUE "  " "
tree.end

base sd:0xa0350a8c
tree "GAM1B"
group 0--3
line.long 0 "GAM1B"
bitfld.long 0 0.--23. " GREEN "  " "
tree.end

base sd:0xa0350a90
tree "GAM2B"
group 0--3
line.long 0 "GAM2B"
bitfld.long 0 0.--23. " RED "  " "
tree.end

base sd:0xa0350a94
tree "OLEDCONV1B"
group 0--3
line.long 0 "OLEDCONV1B"
bitfld.long 0 0.--13. " ALPHA_RED "  " "
bitfld.long 0 16.--29. " ALPHA_GREEN "  " "
tree.end

base sd:0xa0350a98
tree "OLEDCONV2B"
group 0--3
line.long 0 "OLEDCONV2B"
bitfld.long 0 0.--13. " ALPHA_BLUE "  " "
bitfld.long 0 16.--29. " BETA_RED "  " "
tree.end

base sd:0xa0350a9c
tree "OLEDCONV3B"
group 0--3
line.long 0 "OLEDCONV3B"
bitfld.long 0 0.--13. " BETA_GREEN "  " "
bitfld.long 0 16.--29. " BETA_BLUE "  " "
tree.end

base sd:0xa0350aa0
tree "OLEDCONV4B"
group 0--3
line.long 0 "OLEDCONV4B"
bitfld.long 0 0.--13. " GAMMA_RED "  " "
bitfld.long 0 16.--29. " GAMMA_GREEN "  " "
tree.end

base sd:0xa0350aa4
tree "OLEDCONV5B"
group 0--3
line.long 0 "OLEDCONV5B"
bitfld.long 0 0.--13. " GAMMA_BLUE "  " "
bitfld.long 0 16.--29. " OFF_RED "  " "
tree.end

base sd:0xa0350aa8
tree "OLEDCONV6B"
group 0--3
line.long 0 "OLEDCONV6B"
bitfld.long 0 0.--13. " OFF_GREEN "  " "
bitfld.long 0 16.--29. " OFF_BLUE "  " "
tree.end

base sd:0xa0350c00
tree "CRC"
group 0--3
line.long 0 "CRC"
bitfld.long 0 0. " FLOEN "  "0 ,1 "
bitfld.long 0 1. " POWEREN "  "0 ,1 "
bitfld.long 0 2. " C1EN "  "0 ,1 "
bitfld.long 0 3. " C2EN "  "0 ,1 "
bitfld.long 0 4. " WMLVL1 "  "0 ,1 "
bitfld.long 0 5. " WMLVL2 "  "0 ,1 "
bitfld.long 0 6. " SYNCSEL "  "0 ,1 "
bitfld.long 0 7. " SYCEN0 "  "0 ,1 "
bitfld.long 0 8. " SYCEN1 "  "0 ,1 "
bitfld.long 0 9. " SIZE1 "  "0 ,1 "
bitfld.long 0 10. " SIZE2 "  "0 ,1 "
bitfld.long 0 11. " INBAND1 "  "0 ,1 "
bitfld.long 0 12. " INBAND2 "  "0 ,1 "
bitfld.long 0 13.--14. " CLKSEL "  " "
bitfld.long 0 15. " YUVCONVC1EN "  "0 ,1 "
bitfld.long 0 16. " CS1EN "  "0 ,1 "
bitfld.long 0 17. " CS2EN "  "0 ,1 "
bitfld.long 0 18. " RESEN "  "0 ,1 "
bitfld.long 0 19. " CS1POL "  "0 ,1 "
bitfld.long 0 20. " CS2POL "  "0 ,1 "
bitfld.long 0 21. " CD1POL "  "0 ,1 "
bitfld.long 0 22. " CD2POL "  "0 ,1 "
bitfld.long 0 23. " WR1POL "  "0 ,1 "
bitfld.long 0 24. " WR2POL "  "0 ,1 "
bitfld.long 0 25. " RD1POL "  "0 ,1 "
bitfld.long 0 26. " RD2POL "  "0 ,1 "
bitfld.long 0 27. " RES1POL "  "0 ,1 "
bitfld.long 0 28. " RES2POL "  "0 ,1 "
bitfld.long 0 29.--30. " SYNCCTRL "  " "
bitfld.long 0 31. " CLAMPC1EN "  "0 ,1 "
tree.end

base sd:0xa0350c04
tree "PBCCRC0"
group 0--3
line.long 0 "PBCCRC0"
bitfld.long 0 0.--2. " BSCM "  " "
bitfld.long 0 4.--6. " BSDM "  " "
bitfld.long 0 8.--9. " PDM "  " "
bitfld.long 0 12. " PDCTRL "  "0 ,1 "
bitfld.long 0 13.--15. " BPP "  " "
tree.end

base sd:0xa0350c08
tree "PBCCRC1"
group 0--3
line.long 0 "PBCCRC1"
bitfld.long 0 0.--2. " BSCM "  " "
bitfld.long 0 4.--6. " BSDM "  " "
bitfld.long 0 8.--9. " PDM "  " "
bitfld.long 0 12. " PDCTRL "  "0 ,1 "
bitfld.long 0 13.--15. " BPP "  " "
tree.end

base sd:0xa0350c0c
tree "PBCBMRC00"
group 0--3
line.long 0 "PBCBMRC00"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base sd:0xa0350c10
tree "PBCBMRC01"
group 0--3
line.long 0 "PBCBMRC01"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base sd:0xa0350c14
tree "PBCBMRC02"
group 0--3
line.long 0 "PBCBMRC02"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base sd:0xa0350c18
tree "PBCBMRC03"
group 0--3
line.long 0 "PBCBMRC03"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base sd:0xa0350c1c
tree "PBCBMRC04"
group 0--3
line.long 0 "PBCBMRC04"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base sd:0xa0350c20
tree "PBCBMRC10"
group 0--3
line.long 0 "PBCBMRC10"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base sd:0xa0350c24
tree "PBCBMRC11"
group 0--3
line.long 0 "PBCBMRC11"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base sd:0xa0350c28
tree "PBCBMRC12"
group 0--3
line.long 0 "PBCBMRC12"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base sd:0xa0350c2c
tree "PBCBMRC13"
group 0--3
line.long 0 "PBCBMRC13"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base sd:0xa0350c30
tree "PBCBMRC14"
group 0--3
line.long 0 "PBCBMRC14"
bitfld.long 0 0. " MUXI0 "  "0 ,1 "
bitfld.long 0 1. " MUXI1 "  "0 ,1 "
bitfld.long 0 2. " MUXI2 "  "0 ,1 "
bitfld.long 0 3. " MUXI3 "  "0 ,1 "
bitfld.long 0 4. " MUXI4 "  "0 ,1 "
bitfld.long 0 5. " MUXI5 "  "0 ,1 "
bitfld.long 0 6. " MUXI6 "  "0 ,1 "
bitfld.long 0 7. " MUXI7 "  "0 ,1 "
bitfld.long 0 8. " MUXI8 "  "0 ,1 "
bitfld.long 0 9. " MUXI9 "  "0 ,1 "
bitfld.long 0 10. " MUXI10 "  "0 ,1 "
bitfld.long 0 11. " MUXI11 "  "0 ,1 "
bitfld.long 0 12. " MUXI12 "  "0 ,1 "
bitfld.long 0 13. " MUXI13 "  "0 ,1 "
bitfld.long 0 14. " MUXI14 "  "0 ,1 "
bitfld.long 0 15. " MUXI15 "  "0 ,1 "
bitfld.long 0 16. " MUXI16 "  "0 ,1 "
bitfld.long 0 17. " MUXI17 "  "0 ,1 "
bitfld.long 0 18. " MUXI18 "  "0 ,1 "
bitfld.long 0 19. " MUXI19 "  "0 ,1 "
bitfld.long 0 20. " MUXI20 "  "0 ,1 "
bitfld.long 0 21. " MUXI21 "  "0 ,1 "
bitfld.long 0 22. " MUXI22 "  "0 ,1 "
bitfld.long 0 23. " MUXI23 "  "0 ,1 "
bitfld.long 0 24. " MUXI24 "  "0 ,1 "
bitfld.long 0 25. " MUXI25 "  "0 ,1 "
bitfld.long 0 26. " MUXI26 "  "0 ,1 "
bitfld.long 0 27. " MUXI27 "  "0 ,1 "
bitfld.long 0 28. " MUXI28 "  "0 ,1 "
bitfld.long 0 29. " MUXI29 "  "0 ,1 "
bitfld.long 0 30. " MUXI30 "  "0 ,1 "
bitfld.long 0 31. " MUXI31 "  "0 ,1 "
tree.end

base sd:0xa0350c34
tree "PBCBCR00"
group 0--3
line.long 0 "PBCBCR00"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
tree.end

base sd:0xa0350c38
tree "PBCBCR01"
group 0--3
line.long 0 "PBCBCR01"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
tree.end

base sd:0xa0350c48
tree "PBCBCR10"
group 0--3
line.long 0 "PBCBCR10"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
tree.end

base sd:0xa0350c4c
tree "PBCBCR11"
group 0--3
line.long 0 "PBCBCR11"
bitfld.long 0 0. " CTLI0 "  "0 ,1 "
bitfld.long 0 1. " CTLI1 "  "0 ,1 "
bitfld.long 0 2. " CTLI2 "  "0 ,1 "
bitfld.long 0 3. " CTLI3 "  "0 ,1 "
bitfld.long 0 4. " CTLI4 "  "0 ,1 "
bitfld.long 0 5. " CTLI5 "  "0 ,1 "
bitfld.long 0 6. " CTLI6 "  "0 ,1 "
bitfld.long 0 7. " CTLI7 "  "0 ,1 "
bitfld.long 0 8. " CTLI8 "  "0 ,1 "
bitfld.long 0 9. " CTLI9 "  "0 ,1 "
bitfld.long 0 10. " CTLI10 "  "0 ,1 "
bitfld.long 0 11. " CTLI11 "  "0 ,1 "
bitfld.long 0 12. " CTLI12 "  "0 ,1 "
bitfld.long 0 13. " CTLI13 "  "0 ,1 "
bitfld.long 0 14. " CTLI14 "  "0 ,1 "
bitfld.long 0 15. " CTLI15 "  "0 ,1 "
bitfld.long 0 16. " CTLI16 "  "0 ,1 "
bitfld.long 0 17. " CTLI17 "  "0 ,1 "
bitfld.long 0 18. " CTLI18 "  "0 ,1 "
bitfld.long 0 19. " CTLI19 "  "0 ,1 "
bitfld.long 0 20. " CTLI20 "  "0 ,1 "
bitfld.long 0 21. " CTLI21 "  "0 ,1 "
bitfld.long 0 22. " CTLI22 "  "0 ,1 "
bitfld.long 0 23. " CTLI23 "  "0 ,1 "
bitfld.long 0 24. " CTLI24 "  "0 ,1 "
bitfld.long 0 25. " CTLI25 "  "0 ,1 "
bitfld.long 0 26. " CTLI26 "  "0 ,1 "
bitfld.long 0 27. " CTLI27 "  "0 ,1 "
bitfld.long 0 28. " CTLI28 "  "0 ,1 "
bitfld.long 0 29. " CTLI29 "  "0 ,1 "
bitfld.long 0 30. " CTLI30 "  "0 ,1 "
bitfld.long 0 31. " CTLI31 "  "0 ,1 "
tree.end

base sd:0xa0350c5c
tree "VSCRC0"
group 0--3
line.long 0 "VSCRC0"
bitfld.long 0 0.--11. " VSPMIN "  " "
bitfld.long 0 12.--23. " VSPMAX "  " "
bitfld.long 0 24.--26. " VSPDIV "  " "
bitfld.long 0 27. " VSPOL "  "0 ,1 "
bitfld.long 0 28. " VSSEL "  "0 ,1 "
bitfld.long 0 29.--31. " VSDBL "  " "
tree.end

base sd:0xa0350c60
tree "VSCRC1"
group 0--3
line.long 0 "VSCRC1"
bitfld.long 0 0.--11. " VSPMIN "  " "
bitfld.long 0 12.--23. " VSPMAX "  " "
bitfld.long 0 24.--26. " VSPDIV "  " "
bitfld.long 0 27. " VSPOL "  "0 ,1 "
bitfld.long 0 28. " VSSEL "  "0 ,1 "
bitfld.long 0 29.--31. " VSDBL "  " "
tree.end

base sd:0xa0350c64
tree "SCTRC"
group 0--3
line.long 0 "SCTRC"
bitfld.long 0 0.--7. " SYNCDELC0 "  " "
bitfld.long 0 8.--15. " SYNCDELC1 "  " "
bitfld.long 0 16.--27. " TRDELC "  " "
tree.end

base sd:0xa0350c6c
tree "BCNR0"
group 0--3
line.long 0 "BCNR0"
bitfld.long 0 0.--7. " BCN "  " "
tree.end

base sd:0xa0350c70
tree "BCNR1"
group 0--3
line.long 0 "BCNR1"
bitfld.long 0 0.--7. " BCN "  " "
tree.end

base sd:0xa0350c74
tree "CSCDTRC0"
group 0--3
line.long 0 "CSCDTRC0"
bitfld.long 0 0.--7. " CSACT "  " "
bitfld.long 0 8.--15. " CSDEACT "  " "
bitfld.long 0 16.--23. " CDACT "  " "
bitfld.long 0 24.--31. " CDDEACT "  " "
tree.end

base sd:0xa0350c78
tree "CSCDTRC1"
group 0--3
line.long 0 "CSCDTRC1"
bitfld.long 0 0.--7. " CSACT "  " "
bitfld.long 0 8.--15. " CSDEACT "  " "
bitfld.long 0 16.--23. " CDACT "  " "
bitfld.long 0 24.--31. " CDDEACT "  " "
tree.end

base sd:0xa0350c7c
tree "RDWRTRC0"
group 0--3
line.long 0 "RDWRTRC0"
bitfld.long 0 0.--7. " RWACT "  " "
bitfld.long 0 8.--15. " RWDEACT "  " "
bitfld.long 0 16. " MOTINT "  "0 ,1 "
tree.end

base sd:0xa0350c80
tree "RDWRTRC1"
group 0--3
line.long 0 "RDWRTRC1"
bitfld.long 0 0.--7. " RWACT "  " "
bitfld.long 0 8.--15. " RWDEACT "  " "
bitfld.long 0 16. " MOTINT "  "0 ,1 "
tree.end

base sd:0xa0350c84
tree "DOTRC0"
group 0--3
line.long 0 "DOTRC0"
bitfld.long 0 0.--7. " DOACT "  " "
bitfld.long 0 8.--15. " DODEACT "  " "
tree.end

base sd:0xa0350c88
tree "DOTRC1"
group 0--3
line.long 0 "DOTRC1"
bitfld.long 0 0.--7. " DOACT "  " "
bitfld.long 0 8.--15. " DODEACT "  " "
tree.end

base sd:0xa0350c94
tree "WDATADC0"
group 0--3
line.long 0 "WDATADC0"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
tree.end

base sd:0xa0350c98
tree "WDATADC1"
group 0--3
line.long 0 "WDATADC1"
bitfld.long 0 0.--23. " DATAVALUE "  " "
bitfld.long 0 24. " DC "  "0 ,1 "
tree.end

base sd:0xa0350c9c
tree "RDATADC0"
group 0--3
line.long 0 "RDATADC0"
bitfld.long 0 0.--15. " DATAREADFROMDISPLAYMODULE "  " "
bitfld.long 0 16. " STARTREAD "  "0 ,1 "
tree.end

base sd:0xa0350ca0
tree "RDATADC1"
group 0--3
line.long 0 "RDATADC1"
bitfld.long 0 0.--15. " DATAREADFROMDISPLAYMODULE "  " "
bitfld.long 0 16. " STARTREAD "  "0 ,1 "
tree.end

base sd:0xa0350ca4
tree "STATC"
rgroup 0--3
line.long 0 "STATC"
bitfld.long 0 0. " STATBUSY0 "  "0 ,1 "
bitfld.long 0 5. " STATBUSY1 "  "0 ,1 "
tree.end

base sd:0xa0350ca8
tree "CTRLC0"
group 0--3
line.long 0 "CTRLC0"
bitfld.long 0 0.--9. " FIFOWTRMRK "  " "
bitfld.long 0 12. " FIFOEMPTY "  "0 ,1 "
bitfld.long 0 13. " FIFOFULL "  "0 ,1 "
bitfld.long 0 16.--18. " FORMID "  " "
bitfld.long 0 20.--22. " FORMTYPE "  " "
tree.end

base sd:0xa0350cac
tree "CTRLC1"
group 0--3
line.long 0 "CTRLC1"
bitfld.long 0 0.--9. " FIFOWTRMRK "  " "
bitfld.long 0 12. " FIFOEMPTY "  "0 ,1 "
bitfld.long 0 13. " FIFOFULL "  "0 ,1 "
bitfld.long 0 16.--18. " FORMID "  " "
bitfld.long 0 20.--22. " FORMTYPE "  " "
tree.end

base sd:0xa0350e00
tree "DSI0CONF0"
group 0--3
line.long 0 "DSI0CONF0"
bitfld.long 0 0.--7. " BLANKING "  " "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  " "
tree.end

base sd:0xa0350e04
tree "DSI0FRAME"
group 0--3
line.long 0 "DSI0FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
tree.end

base sd:0xa0350e08
tree "DSI0PKT"
group 0--3
line.long 0 "DSI0PKT"
bitfld.long 0 0.--15. " PACKET "  " "
tree.end

base sd:0xa0350e0c
tree "DSI0SYNC"
group 0--3
line.long 0 "DSI0SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
tree.end

base sd:0xa0350e10
tree "DSI0CMDW"
group 0--3
line.long 0 "DSI0CMDW"
bitfld.long 0 0.--15. " CMDW_CONTINUE "  " "
bitfld.long 0 16.--31. " CMDW_START "  " "
tree.end

base sd:0xa0350e14
tree "DSI0DELAY0"
group 0--3
line.long 0 "DSI0DELAY0"
bitfld.long 0 0.--15. " INTPKTDEL "  " "
tree.end

base sd:0xa0350e18
tree "DSI0DELAY1"
group 0--3
line.long 0 "DSI0DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
bitfld.long 0 16.--23. " FRAMESTARTDEL "  " "
tree.end

base sd:0xa0350e20
tree "DSI1CONF0"
group 0--3
line.long 0 "DSI1CONF0"
bitfld.long 0 0.--7. " BLANKING "  " "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  " "
tree.end

base sd:0xa0350e24
tree "DSI1FRAME"
group 0--3
line.long 0 "DSI1FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
tree.end

base sd:0xa0350e28
tree "DSI1PKT"
group 0--3
line.long 0 "DSI1PKT"
bitfld.long 0 0.--15. " PACKET "  " "
tree.end

base sd:0xa0350e2c
tree "DSI1SYNC"
group 0--3
line.long 0 "DSI1SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
tree.end

base sd:0xa0350e30
tree "DSI1CMDW"
group 0--3
line.long 0 "DSI1CMDW"
bitfld.long 0 0.--15. " CMDW_CONTINUE "  " "
bitfld.long 0 16.--31. " CMDW_START "  " "
tree.end

base sd:0xa0350e34
tree "DSI1DELAY0"
group 0--3
line.long 0 "DSI1DELAY0"
bitfld.long 0 0.--15. " INTPKTDEL "  " "
tree.end

base sd:0xa0350e38
tree "DSI1DELAY1"
group 0--3
line.long 0 "DSI1DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
bitfld.long 0 16.--23. " FRAMESTARTDEL "  " "
tree.end

base sd:0xa0350e40
tree "DSI2CONF0"
group 0--3
line.long 0 "DSI2CONF0"
bitfld.long 0 0.--7. " BLANKING "  " "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  " "
tree.end

base sd:0xa0350e44
tree "DSI2FRAME"
group 0--3
line.long 0 "DSI2FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
tree.end

base sd:0xa0350e48
tree "DSI2PKT"
group 0--3
line.long 0 "DSI2PKT"
bitfld.long 0 0.--15. " PACKET "  " "
tree.end

base sd:0xa0350e4c
tree "DSI2SYNC"
group 0--3
line.long 0 "DSI2SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
tree.end

base sd:0xa0350e50
tree "DSI2CMDW"
group 0--3
line.long 0 "DSI2CMDW"
bitfld.long 0 0.--15. " CMDW_CONTINUE "  " "
bitfld.long 0 16.--31. " CMDW_START "  " "
tree.end

base sd:0xa0350e54
tree "DSI2DELAY0"
group 0--3
line.long 0 "DSI2DELAY0"
bitfld.long 0 0.--15. " INTPKTDEL "  " "
tree.end

base sd:0xa0350e58
tree "DSI2DELAY1"
group 0--3
line.long 0 "DSI2DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
bitfld.long 0 16.--23. " FRAMESTARTDEL "  " "
tree.end

base sd:0xa0350e60
tree "DSI3CONF0"
group 0--3
line.long 0 "DSI3CONF0"
bitfld.long 0 0.--7. " BLANKING "  " "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  " "
tree.end

base sd:0xa0350e64
tree "DSI3FRAME"
group 0--3
line.long 0 "DSI3FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
tree.end

base sd:0xa0350e68
tree "DSI3PKT"
group 0--3
line.long 0 "DSI3PKT"
bitfld.long 0 0.--15. " PACKET "  " "
tree.end

base sd:0xa0350e6c
tree "DSI3SYNC"
group 0--3
line.long 0 "DSI3SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
tree.end

base sd:0xa0350e70
tree "DSI3CMDW"
group 0--3
line.long 0 "DSI3CMDW"
bitfld.long 0 0.--15. " CMDW_CONTINUE "  " "
bitfld.long 0 16.--31. " CMDW_START "  " "
tree.end

base sd:0xa0350e74
tree "DSI3DELAY0"
group 0--3
line.long 0 "DSI3DELAY0"
bitfld.long 0 0.--15. " INTPKTDEL "  " "
tree.end

base sd:0xa0350e78
tree "DSI3DELAY1"
group 0--3
line.long 0 "DSI3DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
bitfld.long 0 16.--23. " FRAMESTARTDEL "  " "
tree.end

base sd:0xa0350e80
tree "DSI4CONF0"
group 0--3
line.long 0 "DSI4CONF0"
bitfld.long 0 0.--7. " BLANKING "  " "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  " "
tree.end

base sd:0xa0350e84
tree "DSI4FRAME"
group 0--3
line.long 0 "DSI4FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
tree.end

base sd:0xa0350e88
tree "DSI4PKT"
group 0--3
line.long 0 "DSI4PKT"
bitfld.long 0 0.--15. " PACKET "  " "
tree.end

base sd:0xa0350e8c
tree "DSI4SYNC"
group 0--3
line.long 0 "DSI4SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
tree.end

base sd:0xa0350e90
tree "DSI4CMDW"
group 0--3
line.long 0 "DSI4CMDW"
bitfld.long 0 0.--15. " CMDW_CONTINUE "  " "
bitfld.long 0 16.--31. " CMDW_START "  " "
tree.end

base sd:0xa0350e94
tree "DSI4DELAY0"
group 0--3
line.long 0 "DSI4DELAY0"
bitfld.long 0 0.--15. " INTPKTDEL "  " "
tree.end

base sd:0xa0350e98
tree "DSI4DELAY1"
group 0--3
line.long 0 "DSI4DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
bitfld.long 0 16.--23. " FRAMESTARTDEL "  " "
tree.end

base sd:0xa0350ea0
tree "DSI5CONF0"
group 0--3
line.long 0 "DSI5CONF0"
bitfld.long 0 0.--7. " BLANKING "  " "
bitfld.long 0 12. " VID_MODE "  "0 ,1 "
bitfld.long 0 13. " CMD8 "  "0 ,1 "
bitfld.long 0 16. " BIT_SWAP "  "0 ,1 "
bitfld.long 0 17. " BYTE_SWAP "  "0 ,1 "
bitfld.long 0 18. " DCSVID_NOTGEN "  "0 ,1 "
bitfld.long 0 20.--22. " PACKING "  " "
tree.end

base sd:0xa0350ea4
tree "DSI5FRAME"
group 0--3
line.long 0 "DSI5FRAME"
bitfld.long 0 0.--23. " FRAME "  " "
tree.end

base sd:0xa0350ea8
tree "DSI5PKT"
group 0--3
line.long 0 "DSI5PKT"
bitfld.long 0 0.--15. " PACKET "  " "
tree.end

base sd:0xa0350eac
tree "DSI5SYNC"
group 0--3
line.long 0 "DSI5SYNC"
bitfld.long 0 0.--11. " DMA "  " "
bitfld.long 0 16.--27. " SW "  " "
tree.end

base sd:0xa0350eb0
tree "DSI5CMDW"
group 0--3
line.long 0 "DSI5CMDW"
bitfld.long 0 0.--15. " CMDW_CONTINUE "  " "
bitfld.long 0 16.--31. " CMDW_START "  " "
tree.end

base sd:0xa0350eb4
tree "DSI5DELAY0"
group 0--3
line.long 0 "DSI5DELAY0"
bitfld.long 0 0.--15. " INTPKTDEL "  " "
tree.end

base sd:0xa0350eb8
tree "DSI5DELAY1"
group 0--3
line.long 0 "DSI5DELAY1"
bitfld.long 0 0.--11. " TEREQDEL "  " "
bitfld.long 0 16.--23. " FRAMESTARTDEL "  " "
tree.end

tree.end

;==============================================================
tree "MCSBAG"
;==============================================================
base sd:0xa0390000
tree "BA_ENABLE"
group 0--3
line.long 0 "BA_ENABLE"
bitfld.long 0 0. " ENABLE "  "0 ,1 "
tree.end

base sd:0xa0390004
tree "BA_MODE"
group 0--3
line.long 0 "BA_MODE"
bitfld.long 0 0.--2. " MODE "  " "
tree.end

base sd:0xa0390008
tree "BA_MSG_PORT_PACE"
group 0--3
line.long 0 "BA_MSG_PORT_PACE"
bitfld.long 0 0.--15. " DIVIDER "  " "
tree.end

base sd:0xa039000c
tree "BA_STATUS"
rgroup 0--3
line.long 0 "BA_STATUS"
bitfld.long 0 0.--1. " FF_FLAGS "  " "
tree.end

base sd:0xa0390020
tree "WPSAT_ENABLE"
group 0--3
line.long 0 "WPSAT_ENABLE"
bitfld.long 0 0.--3. " WPSen "  " "
tree.end

base sd:0xa0390024
tree "WPSAT_PROG_MODE"
group 0--3
line.long 0 "WPSAT_PROG_MODE"
bitfld.long 0 0.--3. " WPSprog "  " "
tree.end

base sd:0xa0390028
tree "WPSAT_PROG_STATUS"
rgroup 0--3
line.long 0 "WPSAT_PROG_STATUS"
bitfld.long 0 0.--3. " WPSprogstatus "  " "
tree.end

base sd:0xa039002c
tree "WPSAT_PROG_CLEAR"
group 0--3
line.long 0 "WPSAT_PROG_CLEAR"
bitfld.long 0 0. " CLEAR "  "0 ,1 "
tree.end

base sd:0xa0390040
tree "TMSAT_ENABLE"
group 0--3
line.long 0 "TMSAT_ENABLE"
bitfld.long 0 0.--7. " TMSen "  " "
tree.end

base sd:0xa0390044
tree "TMSAT_PROG_MODE"
group 0--3
line.long 0 "TMSAT_PROG_MODE"
bitfld.long 0 0.--7. " TMSprog "  " "
tree.end

base sd:0xa0390048
tree "TMSAT_PROG_STATUS"
rgroup 0--3
line.long 0 "TMSAT_PROG_STATUS"
bitfld.long 0 0.--7. " TMSprogstatus "  " "
tree.end

base sd:0xa039004c
tree "TMSAT_PROG_CLEAR"
group 0--3
line.long 0 "TMSAT_PROG_CLEAR"
bitfld.long 0 0. " CLEAR "  "0 ,1 "
tree.end

base sd:0xa0390050
tree "TMSAT_READ_STATUS"
rgroup 0--3
line.long 0 "TMSAT_READ_STATUS"
bitfld.long 0 0.--7. " TMSreadstatus "  " "
tree.end

base sd:0xa0390060
tree "WPSAT_ITS"
rgroup 0--3
line.long 0 "WPSAT_ITS"
bitfld.long 0 0.--3. " WPSAT_ITS "  " "
tree.end

base sd:0xa0390064
tree "WPSAT_ITS_CLR"
group 0--3
line.long 0 "WPSAT_ITS_CLR"
bitfld.long 0 0.--3. " WPSAT_ITS_CLR "  " "
tree.end

base sd:0xa0390068
tree "WPSAT_ITS_SET"
wgroup 0--3
line.long 0 "WPSAT_ITS_SET"
bitfld.long 0 0.--3. " WPSAT_ITS_SET "  " "
tree.end

base sd:0xa039006c
tree "WPSAT_ITM"
rgroup 0--3
line.long 0 "WPSAT_ITM"
bitfld.long 0 0.--3. " WPSAT_ITM "  " "
tree.end

base sd:0xa0390070
tree "WPSAT_ITM_CLR"
group 0--3
line.long 0 "WPSAT_ITM_CLR"
bitfld.long 0 0.--3. " WPSAT_ITM_CLR "  " "
tree.end

base sd:0xa0390074
tree "WPSAT_ITM_SET"
wgroup 0--3
line.long 0 "WPSAT_ITM_SET"
bitfld.long 0 0.--3. " WPSAT_ITM_SET "  " "
tree.end

base sd:0xa0390078
tree "PI_ITS"
rgroup 0--3
line.long 0 "PI_ITS"
bitfld.long 0 0.--15. " PI_ITS "  " "
tree.end

base sd:0xa039007c
tree "PI_ITS_CLR"
group 0--3
line.long 0 "PI_ITS_CLR"
bitfld.long 0 0.--15. " PI_ITS_CLR "  " "
tree.end

base sd:0xa0390080
tree "PI_ITS_SET"
wgroup 0--3
line.long 0 "PI_ITS_SET"
bitfld.long 0 0.--15. " PI_ITS_SET "  " "
tree.end

base sd:0xa0390084
tree "PI_ITM"
rgroup 0--3
line.long 0 "PI_ITM"
bitfld.long 0 0.--15. " PI_ITM "  " "
tree.end

base sd:0xa0390088
tree "PI_ITM_CLR"
group 0--3
line.long 0 "PI_ITM_CLR"
bitfld.long 0 0.--15. " PI_ITM_CLR "  " "
tree.end

base sd:0xa039008c
tree "PI_ITM_SET"
wgroup 0--3
line.long 0 "PI_ITM_SET"
bitfld.long 0 0.--15. " PI_ITM_SET "  " "
tree.end

base sd:0xa0390090
tree "TMSAT_ITS"
rgroup 0--3
line.long 0 "TMSAT_ITS"
bitfld.long 0 0.--7. " TMSAT_ITS "  " "
tree.end

base sd:0xa0390094
tree "TMSAT_ITS_CLR"
group 0--3
line.long 0 "TMSAT_ITS_CLR"
bitfld.long 0 0.--7. " TMSAT_ITS_CLR "  " "
tree.end

base sd:0xa0390098
tree "TMSAT_ITS_SET"
wgroup 0--3
line.long 0 "TMSAT_ITS_SET"
bitfld.long 0 0.--7. " TMSAT_ITS_SET "  " "
tree.end

base sd:0xa039009c
tree "TMSAT_ITM"
rgroup 0--3
line.long 0 "TMSAT_ITM"
bitfld.long 0 0.--7. " TMSAT_ITM "  " "
tree.end

base sd:0xa03900a0
tree "TMSAT_ITM_CLR"
group 0--3
line.long 0 "TMSAT_ITM_CLR"
bitfld.long 0 0.--7. " TMSAT_ITM_CLR "  " "
tree.end

base sd:0xa03900a4
tree "TMSAT_ITM_SET"
wgroup 0--3
line.long 0 "TMSAT_ITM_SET"
bitfld.long 0 0.--7. " TMSAT_ITM_SET "  " "
tree.end

base sd:0xa03900a8
tree "PI_ERROR"
rgroup 0--3
line.long 0 "PI_ERROR"
bitfld.long 0 0.--15. " PI_ERROR "  " "
tree.end

base sd:0xa03900ac
tree "PI_ERROR_CLR"
group 0--3
line.long 0 "PI_ERROR_CLR"
bitfld.long 0 0.--15. " PI_ERROR_CLR "  " "
tree.end

base sd:0xa03900b0
tree "TMSAT0_T7_ERROR"
rgroup 0--3
line.long 0 "TMSAT0_T7_ERROR"
bitfld.long 0 0.--31. " TMSAT0_T7_ERROR "  " "
tree.end

base sd:0xa03900b4
tree "TMSAT8_T15_ERROR"
rgroup 0--3
line.long 0 "TMSAT8_T15_ERROR"
bitfld.long 0 0.--31. " TMSAT8_T15_ERROR "  " "
tree.end

base sd:0xa03900b8
tree "TM_LOST_ERROR"
rgroup 0--3
line.long 0 "TM_LOST_ERROR"
bitfld.long 0 0. " TM_ERROR "  "0 ,1 "
tree.end

base sd:0xa03900bc
tree "TM_ERROR_CLR"
group 0--3
line.long 0 "TM_ERROR_CLR"
bitfld.long 0 0. " TM_ERROR_CLR "  "0 ,1 "
tree.end

base sd:0xa03900c0
tree "SBAG_DVF0"
group 0--3
line.long 0 "SBAG_DVF0"
bitfld.long 0 0. " SBAG_DVF0 "  "0 ,1 "
tree.end

base sd:0xa03900c4
tree "TIME_ABSOLUTE_LSB"
group 0--3
line.long 0 "TIME_ABSOLUTE_LSB"
bitfld.long 0 0.--31. " TIME_ABSOLUTE_LSB "  " "
tree.end

base sd:0xa03900c8
tree "TIME_ABSOLUTE_MSB"
rgroup 0--3
line.long 0 "TIME_ABSOLUTE_MSB"
bitfld.long 0 0.--31. " TIME_ABSOLUTE_MSB "  " "
tree.end

base sd:0xa0390200
tree "WPSAT0_REG1"
group 0--3
line.long 0 "WPSAT0_REG1"
bitfld.long 0 0.--31. " REG1 "  " "
tree.end

base sd:0xa0390204
tree "WPSAT0_REG2"
group 0--3
line.long 0 "WPSAT0_REG2"
bitfld.long 0 0.--31. " REG2 "  " "
tree.end

base sd:0xa0390208
tree "WPSAT0_REG3"
group 0--3
line.long 0 "WPSAT0_REG3"
bitfld.long 0 0.--31. " REG3 "  " "
tree.end

base sd:0xa039020c
tree "WPSAT0_REG4"
group 0--3
line.long 0 "WPSAT0_REG4"
bitfld.long 0 0.--31. " REG4 "  " "
tree.end

base sd:0xa0390210
tree "WPSAT0_REQ_NOT_RSP"
rgroup 0--3
line.long 0 "WPSAT0_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
tree.end

base sd:0xa0390214
tree "WPSAT1_REG1"
group 0--3
line.long 0 "WPSAT1_REG1"
bitfld.long 0 0.--31. " REG1 "  " "
tree.end

base sd:0xa0390218
tree "WPSAT1_REG2"
group 0--3
line.long 0 "WPSAT1_REG2"
bitfld.long 0 0.--31. " REG2 "  " "
tree.end

base sd:0xa039021c
tree "WPSAT1_REG3"
group 0--3
line.long 0 "WPSAT1_REG3"
bitfld.long 0 0.--31. " REG3 "  " "
tree.end

base sd:0xa0390220
tree "WPSAT1_REG4"
group 0--3
line.long 0 "WPSAT1_REG4"
bitfld.long 0 0.--31. " REG4 "  " "
tree.end

base sd:0xa0390224
tree "WPSAT1_REQ_NOT_RSP"
rgroup 0--3
line.long 0 "WPSAT1_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
tree.end

base sd:0xa0390228
tree "WPSAT2_REG1"
group 0--3
line.long 0 "WPSAT2_REG1"
bitfld.long 0 0.--31. " REG1 "  " "
tree.end

base sd:0xa039022c
tree "WPSAT2_REG2"
group 0--3
line.long 0 "WPSAT2_REG2"
bitfld.long 0 0.--31. " REG2 "  " "
tree.end

base sd:0xa0390230
tree "WPSAT2_REG3"
group 0--3
line.long 0 "WPSAT2_REG3"
bitfld.long 0 0.--31. " REG3 "  " "
tree.end

base sd:0xa0390234
tree "WPSAT2_REG4"
group 0--3
line.long 0 "WPSAT2_REG4"
bitfld.long 0 0.--31. " REG4 "  " "
tree.end

base sd:0xa0390238
tree "WPSAT2_REQ_NOT_RSP"
rgroup 0--3
line.long 0 "WPSAT2_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
tree.end

base sd:0xa039023c
tree "WPSAT3_REG1"
group 0--3
line.long 0 "WPSAT3_REG1"
bitfld.long 0 0.--31. " REG1 "  " "
tree.end

base sd:0xa0390240
tree "WPSAT3_REG2"
group 0--3
line.long 0 "WPSAT3_REG2"
bitfld.long 0 0.--31. " REG2 "  " "
tree.end

base sd:0xa0390244
tree "WPSAT3_REG3"
group 0--3
line.long 0 "WPSAT3_REG3"
bitfld.long 0 0.--31. " REG3 "  " "
tree.end

base sd:0xa0390248
tree "WPSAT3_REG4"
group 0--3
line.long 0 "WPSAT3_REG4"
bitfld.long 0 0.--31. " REG4 "  " "
tree.end

base sd:0xa039024c
tree "WPSAT3_REQ_NOT_RSP"
rgroup 0--3
line.long 0 "WPSAT3_REQ_NOT_RSP"
bitfld.long 0 0. " REQ_NOT_RSP "  "0 ,1 "
tree.end

base sd:0xa0390400
tree "MSG_REF_PACE"
group 0--3
line.long 0 "MSG_REF_PACE"
bitfld.long 0 0.--31. " PACE "  " "
tree.end

base sd:0xa0390404
tree "MSG_FPF_DATA"
group 0--3
line.long 0 "MSG_FPF_DATA"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0xa0390408
tree "MSG_FPF_TRACE_CTRL"
group 0--3
line.long 0 "MSG_FPF_TRACE_CTRL"
bitfld.long 0 0. " DATA "  "0 ,1 "
bitfld.long 0 24. " TIME "  "0 ,1 "
bitfld.long 0 31. " EN "  "0 ,1 "
tree.end

base sd:0xa039040c
tree "MSG_PI_TRACE_CTRL"
group 0--3
line.long 0 "MSG_PI_TRACE_CTRL"
bitfld.long 0 0.--15. " INCDATA "  " "
bitfld.long 0 24. " TIME "  "0 ,1 "
bitfld.long 0 31. " EN "  "0 ,1 "
tree.end

base sd:0xa0390410
tree "MSG_REF_TRACE_CONTROL"
group 0--3
line.long 0 "MSG_REF_TRACE_CONTROL"
bitfld.long 0 31. " EN "  "0 ,1 "
tree.end

base sd:0xa0390414
tree "MSG_ERR_TRACE_CONTROL"
group 0--3
line.long 0 "MSG_ERR_TRACE_CONTROL"
bitfld.long 0 0. " FL0 "  "0 ,1 "
bitfld.long 0 8. " FL1 "  "0 ,1 "
bitfld.long 0 9. " FL2 "  "0 ,1 "
bitfld.long 0 16. " FL3 "  "0 ,1 "
bitfld.long 0 31. " EN "  "0 ,1 "
tree.end

base sd:0xa0390418
tree "MSG_WP_ENABLE"
group 0--3
line.long 0 "MSG_WP_ENABLE"
bitfld.long 0 0.--3. " MSGWPEN "  " "
tree.end

base sd:0xa039041c
tree "MSG_WP_TRACE_CTRL"
group 0--3
line.long 0 "MSG_WP_TRACE_CTRL"
bitfld.long 0 0. " C1 "  "0 ,1 "
bitfld.long 0 1. " C2 "  "0 ,1 "
bitfld.long 0 8. " DATA "  "0 ,1 "
bitfld.long 0 24. " TIME "  "0 ,1 "
tree.end

base sd:0xa0390420
tree "MSG_TM_ENABLE"
group 0--3
line.long 0 "MSG_TM_ENABLE"
bitfld.long 0 0.--7. " MSGTMEN "  " "
tree.end

base sd:0xa0390424
tree "MSG_TM_TRACE_CTRL_L"
group 0--3
line.long 0 "MSG_TM_TRACE_CTRL_L"
bitfld.long 0 0. " ERR_M3_M2_M1 "  "0 ,1 "
tree.end

base sd:0xa0390428
tree "MSG_TM_TRACE_CTRL_M"
group 0--3
line.long 0 "MSG_TM_TRACE_CTRL_M"
bitfld.long 0 0. " ERR_M3_M2_M1 "  "0 ,1 "
tree.end

base sd:0xa0390600
tree "TMSAT0_REG1"
group 0--3
line.long 0 "TMSAT0_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390604
tree "TMSAT0_REG2"
group 0--3
line.long 0 "TMSAT0_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390608
tree "TMSAT0_REG3"
group 0--3
line.long 0 "TMSAT0_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa039060c
tree "TMSAT1_REG1"
group 0--3
line.long 0 "TMSAT1_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390610
tree "TMSAT1_REG2"
group 0--3
line.long 0 "TMSAT1_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390614
tree "TMSAT1_REG3"
group 0--3
line.long 0 "TMSAT1_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390618
tree "TMSAT2_REG1"
group 0--3
line.long 0 "TMSAT2_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa039061c
tree "TMSAT2_REG2"
group 0--3
line.long 0 "TMSAT2_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390620
tree "TMSAT2_REG3"
group 0--3
line.long 0 "TMSAT2_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390624
tree "TMSAT3_REG1"
group 0--3
line.long 0 "TMSAT3_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390628
tree "TMSAT3_REG2"
group 0--3
line.long 0 "TMSAT3_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa039062c
tree "TMSAT3_REG3"
group 0--3
line.long 0 "TMSAT3_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390630
tree "TMSAT4_REG1"
group 0--3
line.long 0 "TMSAT4_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390634
tree "TMSAT4_REG2"
group 0--3
line.long 0 "TMSAT4_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390638
tree "TMSAT4_REG3"
group 0--3
line.long 0 "TMSAT4_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa039063c
tree "TMSAT5_REG1"
group 0--3
line.long 0 "TMSAT5_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390640
tree "TMSAT5_REG2"
group 0--3
line.long 0 "TMSAT5_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390644
tree "TMSAT5_REG3"
group 0--3
line.long 0 "TMSAT5_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390648
tree "TMSAT6_REG1"
group 0--3
line.long 0 "TMSAT6_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa039064c
tree "TMSAT6_REG2"
group 0--3
line.long 0 "TMSAT6_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390650
tree "TMSAT6_REG3"
group 0--3
line.long 0 "TMSAT6_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390654
tree "TMSAT7_REG1"
group 0--3
line.long 0 "TMSAT7_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390658
tree "TMSAT7_REG2"
group 0--3
line.long 0 "TMSAT7_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa039065c
tree "TMSAT7_REG3"
group 0--3
line.long 0 "TMSAT7_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390660
tree "TMSAT8_REG1"
group 0--3
line.long 0 "TMSAT8_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390664
tree "TMSAT8_REG2"
group 0--3
line.long 0 "TMSAT8_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390668
tree "TMSAT8_REG3"
group 0--3
line.long 0 "TMSAT8_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa039066c
tree "TMSAT9_REG1"
group 0--3
line.long 0 "TMSAT9_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390670
tree "TMSAT9_REG2"
group 0--3
line.long 0 "TMSAT9_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390674
tree "TMSAT9_REG3"
group 0--3
line.long 0 "TMSAT9_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390678
tree "TMSAT10_REG1"
group 0--3
line.long 0 "TMSAT10_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa039067c
tree "TMSAT10_REG2"
group 0--3
line.long 0 "TMSAT10_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390680
tree "TMSAT10_REG3"
group 0--3
line.long 0 "TMSAT10_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390684
tree "TMSAT11_REG1"
group 0--3
line.long 0 "TMSAT11_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390688
tree "TMSAT11_REG2"
group 0--3
line.long 0 "TMSAT11_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa039068c
tree "TMSAT11_REG3"
group 0--3
line.long 0 "TMSAT11_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390690
tree "TMSAT12_REG1"
group 0--3
line.long 0 "TMSAT12_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390694
tree "TMSAT12_REG2"
group 0--3
line.long 0 "TMSAT12_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390698
tree "TMSAT12_REG3"
group 0--3
line.long 0 "TMSAT12_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa039069c
tree "TMSAT13_REG1"
group 0--3
line.long 0 "TMSAT13_REG1"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa03906a0
tree "TMSAT13_REG2"
group 0--3
line.long 0 "TMSAT13_REG2"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa03906a4
tree "TMSAT13_REG3"
group 0--3
line.long 0 "TMSAT13_REG3"
bitfld.long 0 0. " VAL "  "0 ,1 "
tree.end

base sd:0xa0390800
tree "PI_TRIGGER_RAISE"
group 0--3
line.long 0 "PI_TRIGGER_RAISE"
bitfld.long 0 0.--15. " RISING "  " "
tree.end

base sd:0xa0390804
tree "PI_TRIGGER_FALLING"
group 0--3
line.long 0 "PI_TRIGGER_FALLING"
bitfld.long 0 0.--15. " FALLING "  " "
tree.end

tree.end

;==============================================================
;tree "MMCI (6 instances)"
;==============================================================
base sd:0x80126000
;********************************************
tree "MMCI-0"
;********************************************
base sd:0x80126000
tree "0Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  " "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
tree.end

base sd:0x80126004
tree "0Clock"
group 0--3
line.long 0 "Clock"
bitfld.long 0 0.--7. " ClkDiv "  " "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  " "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
tree.end

base sd:0x80126008
tree "0Argument"
group 0--3
line.long 0 "Argument"
bitfld.long 0 0.--31. " CmdArg "  " "
tree.end

base sd:0x8012600c
tree "0Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  " "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
tree.end

base sd:0x80126010
tree "0RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  " "
tree.end

base sd:0x80126014
tree "0Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80126018
tree "0Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x8012601c
tree "0Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80126020
tree "0Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80126024
tree "0Datatimer"
group 0--3
line.long 0 "Datatimer"
bitfld.long 0 0.--31. " DataTime "  " "
tree.end

base sd:0x80126028
tree "0DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
tree.end

base sd:0x8012602c
tree "0DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
tree.end

base sd:0x80126030
tree "0DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
tree.end

base sd:0x80126034
tree "0Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
tree.end

base sd:0x80126038
tree "0Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
tree.end

base sd:0x8012603c
tree "0Mask0"
group 0--3
line.long 0 "Mask0"
tree.end

base sd:0x80126040
tree "0Mask1"
group 0--3
line.long 0 "Mask1"
tree.end

base sd:0x80126044
tree "0CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  " "
tree.end

base sd:0x80126048
tree "0FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
tree.end

base sd:0x80126080
tree "0Fifo"
group 0--3
line.long 0 "Fifo"
bitfld.long 0 0.--31. " FIFOData "  " "
tree.end

base sd:0x801260c0
tree "0DBtimer"
group 0--3
line.long 0 "DBtimer"
bitfld.long 0 0.--31. " DBTIME "  " "
tree.end

base sd:0x801260c4
tree "0TRSCA"
group 0--3
line.long 0 "TRSCA"
bitfld.long 0 0.--31. " TRSCA "  " "
tree.end

base sd:0x80126fe0
tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80126fe4
tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80126fe8
tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80126fec
tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80126ff0
tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " SDIPCellID0 "  " "
tree.end

base sd:0x80126ff4
tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " SDIPCellID1 "  " "
tree.end

base sd:0x80126ff8
tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " SDIPCellID2 "  " "
tree.end

base sd:0x80126ffc
tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " SDIPCellID3 "  " "
tree.end

tree.end

base sd:0x80114000
;********************************************
tree "MMCI-4"
;********************************************
base sd:0x80114000
tree "4Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  " "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
tree.end

base sd:0x80114004
tree "4Clock"
group 0--3
line.long 0 "Clock"
bitfld.long 0 0.--7. " ClkDiv "  " "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  " "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
tree.end

base sd:0x80114008
tree "4Argument"
group 0--3
line.long 0 "Argument"
bitfld.long 0 0.--31. " CmdArg "  " "
tree.end

base sd:0x8011400c
tree "4Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  " "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
tree.end

base sd:0x80114010
tree "4RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  " "
tree.end

base sd:0x80114014
tree "4Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80114018
tree "4Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x8011401c
tree "4Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80114020
tree "4Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80114024
tree "4Datatimer"
group 0--3
line.long 0 "Datatimer"
bitfld.long 0 0.--31. " DataTime "  " "
tree.end

base sd:0x80114028
tree "4DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
tree.end

base sd:0x8011402c
tree "4DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
tree.end

base sd:0x80114030
tree "4DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
tree.end

base sd:0x80114034
tree "4Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
tree.end

base sd:0x80114038
tree "4Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
tree.end

base sd:0x8011403c
tree "4Mask0"
group 0--3
line.long 0 "Mask0"
tree.end

base sd:0x80114040
tree "4Mask1"
group 0--3
line.long 0 "Mask1"
tree.end

base sd:0x80114044
tree "4CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  " "
tree.end

base sd:0x80114048
tree "4FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
tree.end

base sd:0x80114080
tree "4Fifo"
group 0--3
line.long 0 "Fifo"
bitfld.long 0 0.--31. " FIFOData "  " "
tree.end

base sd:0x801140c0
tree "4DBtimer"
group 0--3
line.long 0 "DBtimer"
bitfld.long 0 0.--31. " DBTIME "  " "
tree.end

base sd:0x801140c4
tree "4TRSCA"
group 0--3
line.long 0 "TRSCA"
bitfld.long 0 0.--31. " TRSCA "  " "
tree.end

base sd:0x80114fe0
tree "4PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80114fe4
tree "4PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80114fe8
tree "4PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80114fec
tree "4PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80114ff0
tree "4PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " SDIPCellID0 "  " "
tree.end

base sd:0x80114ff4
tree "4PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " SDIPCellID1 "  " "
tree.end

base sd:0x80114ff8
tree "4PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " SDIPCellID2 "  " "
tree.end

base sd:0x80114ffc
tree "4PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " SDIPCellID3 "  " "
tree.end

tree.end

base sd:0x80118000
;********************************************
tree "MMCI-1"
;********************************************
base sd:0x80118000
tree "1Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  " "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
tree.end

base sd:0x80118004
tree "1Clock"
group 0--3
line.long 0 "Clock"
bitfld.long 0 0.--7. " ClkDiv "  " "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  " "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
tree.end

base sd:0x80118008
tree "1Argument"
group 0--3
line.long 0 "Argument"
bitfld.long 0 0.--31. " CmdArg "  " "
tree.end

base sd:0x8011800c
tree "1Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  " "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
tree.end

base sd:0x80118010
tree "1RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  " "
tree.end

base sd:0x80118014
tree "1Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80118018
tree "1Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x8011801c
tree "1Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80118020
tree "1Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80118024
tree "1Datatimer"
group 0--3
line.long 0 "Datatimer"
bitfld.long 0 0.--31. " DataTime "  " "
tree.end

base sd:0x80118028
tree "1DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
tree.end

base sd:0x8011802c
tree "1DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
tree.end

base sd:0x80118030
tree "1DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
tree.end

base sd:0x80118034
tree "1Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
tree.end

base sd:0x80118038
tree "1Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
tree.end

base sd:0x8011803c
tree "1Mask0"
group 0--3
line.long 0 "Mask0"
tree.end

base sd:0x80118040
tree "1Mask1"
group 0--3
line.long 0 "Mask1"
tree.end

base sd:0x80118044
tree "1CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  " "
tree.end

base sd:0x80118048
tree "1FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
tree.end

base sd:0x80118080
tree "1Fifo"
group 0--3
line.long 0 "Fifo"
bitfld.long 0 0.--31. " FIFOData "  " "
tree.end

base sd:0x801180c0
tree "1DBtimer"
group 0--3
line.long 0 "DBtimer"
bitfld.long 0 0.--31. " DBTIME "  " "
tree.end

base sd:0x801180c4
tree "1TRSCA"
group 0--3
line.long 0 "TRSCA"
bitfld.long 0 0.--31. " TRSCA "  " "
tree.end

base sd:0x80118fe0
tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80118fe4
tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80118fe8
tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80118fec
tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80118ff0
tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " SDIPCellID0 "  " "
tree.end

base sd:0x80118ff4
tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " SDIPCellID1 "  " "
tree.end

base sd:0x80118ff8
tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " SDIPCellID2 "  " "
tree.end

base sd:0x80118ffc
tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " SDIPCellID3 "  " "
tree.end

tree.end

base sd:0x80119000
;********************************************
tree "MMCI-3"
;********************************************
base sd:0x80119000
tree "3Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  " "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
tree.end

base sd:0x80119004
tree "3Clock"
group 0--3
line.long 0 "Clock"
bitfld.long 0 0.--7. " ClkDiv "  " "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  " "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
tree.end

base sd:0x80119008
tree "3Argument"
group 0--3
line.long 0 "Argument"
bitfld.long 0 0.--31. " CmdArg "  " "
tree.end

base sd:0x8011900c
tree "3Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  " "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
tree.end

base sd:0x80119010
tree "3RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  " "
tree.end

base sd:0x80119014
tree "3Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80119018
tree "3Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x8011901c
tree "3Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80119020
tree "3Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80119024
tree "3Datatimer"
group 0--3
line.long 0 "Datatimer"
bitfld.long 0 0.--31. " DataTime "  " "
tree.end

base sd:0x80119028
tree "3DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
tree.end

base sd:0x8011902c
tree "3DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
tree.end

base sd:0x80119030
tree "3DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
tree.end

base sd:0x80119034
tree "3Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
tree.end

base sd:0x80119038
tree "3Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
tree.end

base sd:0x8011903c
tree "3Mask0"
group 0--3
line.long 0 "Mask0"
tree.end

base sd:0x80119040
tree "3Mask1"
group 0--3
line.long 0 "Mask1"
tree.end

base sd:0x80119044
tree "3CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  " "
tree.end

base sd:0x80119048
tree "3FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
tree.end

base sd:0x80119080
tree "3Fifo"
group 0--3
line.long 0 "Fifo"
bitfld.long 0 0.--31. " FIFOData "  " "
tree.end

base sd:0x801190c0
tree "3DBtimer"
group 0--3
line.long 0 "DBtimer"
bitfld.long 0 0.--31. " DBTIME "  " "
tree.end

base sd:0x801190c4
tree "3TRSCA"
group 0--3
line.long 0 "TRSCA"
bitfld.long 0 0.--31. " TRSCA "  " "
tree.end

base sd:0x80119fe0
tree "3PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80119fe4
tree "3PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80119fe8
tree "3PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80119fec
tree "3PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80119ff0
tree "3PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " SDIPCellID0 "  " "
tree.end

base sd:0x80119ff4
tree "3PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " SDIPCellID1 "  " "
tree.end

base sd:0x80119ff8
tree "3PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " SDIPCellID2 "  " "
tree.end

base sd:0x80119ffc
tree "3PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " SDIPCellID3 "  " "
tree.end

tree.end

base sd:0x80005000
;********************************************
tree "MMCI-2"
;********************************************
base sd:0x80005000
tree "2Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  " "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
tree.end

base sd:0x80005004
tree "2Clock"
group 0--3
line.long 0 "Clock"
bitfld.long 0 0.--7. " ClkDiv "  " "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  " "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
tree.end

base sd:0x80005008
tree "2Argument"
group 0--3
line.long 0 "Argument"
bitfld.long 0 0.--31. " CmdArg "  " "
tree.end

base sd:0x8000500c
tree "2Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  " "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
tree.end

base sd:0x80005010
tree "2RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  " "
tree.end

base sd:0x80005014
tree "2Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80005018
tree "2Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x8000501c
tree "2Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80005020
tree "2Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80005024
tree "2Datatimer"
group 0--3
line.long 0 "Datatimer"
bitfld.long 0 0.--31. " DataTime "  " "
tree.end

base sd:0x80005028
tree "2DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
tree.end

base sd:0x8000502c
tree "2DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
tree.end

base sd:0x80005030
tree "2DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
tree.end

base sd:0x80005034
tree "2Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
tree.end

base sd:0x80005038
tree "2Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
tree.end

base sd:0x8000503c
tree "2Mask0"
group 0--3
line.long 0 "Mask0"
tree.end

base sd:0x80005040
tree "2Mask1"
group 0--3
line.long 0 "Mask1"
tree.end

base sd:0x80005044
tree "2CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  " "
tree.end

base sd:0x80005048
tree "2FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
tree.end

base sd:0x80005080
tree "2Fifo"
group 0--3
line.long 0 "Fifo"
bitfld.long 0 0.--31. " FIFOData "  " "
tree.end

base sd:0x800050c0
tree "2DBtimer"
group 0--3
line.long 0 "DBtimer"
bitfld.long 0 0.--31. " DBTIME "  " "
tree.end

base sd:0x800050c4
tree "2TRSCA"
group 0--3
line.long 0 "TRSCA"
bitfld.long 0 0.--31. " TRSCA "  " "
tree.end

base sd:0x80005fe0
tree "2PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80005fe4
tree "2PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80005fe8
tree "2PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80005fec
tree "2PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80005ff0
tree "2PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " SDIPCellID0 "  " "
tree.end

base sd:0x80005ff4
tree "2PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " SDIPCellID1 "  " "
tree.end

base sd:0x80005ff8
tree "2PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " SDIPCellID2 "  " "
tree.end

base sd:0x80005ffc
tree "2PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " SDIPCellID3 "  " "
tree.end

tree.end

base sd:0x80008000
;********************************************
tree "MMCI-5"
;********************************************
base sd:0x80008000
tree "5Power"
group 0--3
line.long 0 "Power"
bitfld.long 0 0.--1. " Ctrl "  " "
bitfld.long 0 2. " DAT2DIREN "  "0 ,1 "
bitfld.long 0 3. " CMDDIREN "  "0 ,1 "
bitfld.long 0 4. " DAT0DIREN "  "0 ,1 "
bitfld.long 0 5. " DAT31DIREN "  "0 ,1 "
bitfld.long 0 6. " OpenDrain "  "0 ,1 "
bitfld.long 0 7. " FBCLKEn "  "0 ,1 "
bitfld.long 0 8. " DAT74DIREN "  "0 ,1 "
bitfld.long 0 9. " RSTNEN "  "0 ,1 "
tree.end

base sd:0x80008004
tree "5Clock"
group 0--3
line.long 0 "Clock"
bitfld.long 0 0.--7. " ClkDiv "  " "
bitfld.long 0 8. " Enable "  "0 ,1 "
bitfld.long 0 9. " PwrSave "  "0 ,1 "
bitfld.long 0 10. " Bypass "  "0 ,1 "
bitfld.long 0 11.--12. " Widebus "  " "
bitfld.long 0 13. " NEGEDG "  "0 ,1 "
bitfld.long 0 14. " FLOWCTRLEN "  "0 ,1 "
bitfld.long 0 15. " CLKOUT_INV "  "0 ,1 "
bitfld.long 0 16. " CLKGATE_EN "  "0 ,1 "
tree.end

base sd:0x80008008
tree "5Argument"
group 0--3
line.long 0 "Argument"
bitfld.long 0 0.--31. " CmdArg "  " "
tree.end

base sd:0x8000800c
tree "5Command"
group 0--3
line.long 0 "Command"
bitfld.long 0 0.--5. " CmdIndex "  " "
bitfld.long 0 6. " Response "  "0 ,1 "
bitfld.long 0 7. " LongRsp "  "0 ,1 "
bitfld.long 0 8. " Interrupt "  "0 ,1 "
bitfld.long 0 9. " Pending "  "0 ,1 "
bitfld.long 0 10. " Enable "  "0 ,1 "
bitfld.long 0 11. " SDIOSuspend "  "0 ,1 "
bitfld.long 0 12. " ENCMDcompl "  "0 ,1 "
bitfld.long 0 13. " nIEN "  "0 ,1 "
bitfld.long 0 14. " CEATACMD "  "0 ,1 "
bitfld.long 0 15. " CBOOTMODEEN "  "0 ,1 "
tree.end

base sd:0x80008010
tree "5RespCmd"
rgroup 0--3
line.long 0 "RespCmd"
bitfld.long 0 0.--5. " RspCmd "  " "
tree.end

base sd:0x80008014
tree "5Rsp0"
rgroup 0--3
line.long 0 "Rsp0"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80008018
tree "5Rsp1"
rgroup 0--3
line.long 0 "Rsp1"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x8000801c
tree "5Rsp2"
rgroup 0--3
line.long 0 "Rsp2"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80008020
tree "5Rsp3"
rgroup 0--3
line.long 0 "Rsp3"
bitfld.long 0 0.--31. " Status "  " "
tree.end

base sd:0x80008024
tree "5Datatimer"
group 0--3
line.long 0 "Datatimer"
bitfld.long 0 0.--31. " DataTime "  " "
tree.end

base sd:0x80008028
tree "5DataLength"
group 0--3
line.long 0 "DataLength"
bitfld.long 0 0.--24. " DataLength "  " "
tree.end

base sd:0x8000802c
tree "5DataCtrl"
group 0--3
line.long 0 "DataCtrl"
bitfld.long 0 0. " Enable "  "0 ,1 "
bitfld.long 0 1. " Direction "  "0 ,1 "
bitfld.long 0 2. " Mode "  "0 ,1 "
bitfld.long 0 3. " DMAEnable "  "0 ,1 "
bitfld.long 0 8. " RWStart "  "0 ,1 "
bitfld.long 0 9. " RWStop "  "0 ,1 "
bitfld.long 0 10. " RWMode "  "0 ,1 "
bitfld.long 0 11. " SDIOEn "  "0 ,1 "
bitfld.long 0 12. " DMAReqCtl "  "0 ,1 "
bitfld.long 0 13. " DBOOTMODEEN "  "0 ,1 "
bitfld.long 0 14. " BUSYMODE "  "0 ,1 "
bitfld.long 0 15. " DDR_mode "  "0 ,1 "
bitfld.long 0 16.--30. " BlockSize "  " "
tree.end

base sd:0x80008030
tree "5DataCnt"
group 0--3
line.long 0 "DataCnt"
bitfld.long 0 0.--24. " dataCount "  " "
tree.end

base sd:0x80008034
tree "5Status"
rgroup 0--3
line.long 0 "Status"
bitfld.long 0 0. " CmdCrcFail "  "0 ,1 "
bitfld.long 0 1. " DataCrcFail "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOut "  "0 ,1 "
bitfld.long 0 3. " DataTimeOut "  "0 ,1 "
bitfld.long 0 4. " TxUnderrun "  "0 ,1 "
bitfld.long 0 5. " RxOverrun "  "0 ,1 "
bitfld.long 0 6. " CmdRespEnd "  "0 ,1 "
bitfld.long 0 7. " CmdSent "  "0 ,1 "
bitfld.long 0 8. " DataEnd "  "0 ,1 "
bitfld.long 0 9. " StBitE "  "0 ,1 "
bitfld.long 0 10. " DataBlockEnd "  "0 ,1 "
bitfld.long 0 11. " CmdActive "  "0 ,1 "
bitfld.long 0 12. " TxActive "  "0 ,1 "
bitfld.long 0 13. " RxActive "  "0 ,1 "
bitfld.long 0 14. " TxFifoHalfFull "  "0 ,1 "
bitfld.long 0 15. " RxFifoHalfFull "  "0 ,1 "
bitfld.long 0 16. " TxFifoFull "  "0 ,1 "
bitfld.long 0 17. " RxFifoFull "  "0 ,1 "
bitfld.long 0 18. " TxFifoEmpty "  "0 ,1 "
bitfld.long 0 19. " RxFifoEmpty "  "0 ,1 "
bitfld.long 0 20. " TxDataAvlbl "  "0 ,1 "
bitfld.long 0 21. " RxDataAvlbl "  "0 ,1 "
bitfld.long 0 22. " Sdioit "  "0 ,1 "
bitfld.long 0 23. " CEATAEND "  "0 ,1 "
bitfld.long 0 24. " CARDBUSY "  "0 ,1 "
bitfld.long 0 25. " BOOTMODE "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERR "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUT "  "0 ,1 "
bitfld.long 0 28. " RSTNEND "  "0 ,1 "
tree.end

base sd:0x80008038
tree "5Clear"
group 0--3
line.long 0 "Clear"
bitfld.long 0 0. " CmdCrcFailClr "  "0 ,1 "
bitfld.long 0 1. " DataCrcFailClr "  "0 ,1 "
bitfld.long 0 2. " CmdTimeOutClr "  "0 ,1 "
bitfld.long 0 3. " DataTimeOutClr "  "0 ,1 "
bitfld.long 0 4. " TxUnderrunClr "  "0 ,1 "
bitfld.long 0 5. " RxOverrunClr "  "0 ,1 "
bitfld.long 0 6. " CmdRespEndClr "  "0 ,1 "
bitfld.long 0 7. " CmdSentClr "  "0 ,1 "
bitfld.long 0 8. " DataEndClr "  "0 ,1 "
bitfld.long 0 9. " StBitEClr "  "0 ,1 "
bitfld.long 0 10. " DataBlockEndClr "  "0 ,1 "
bitfld.long 0 22. " SDioitClr "  "0 ,1 "
bitfld.long 0 23. " CEATAENDC "  "0 ,1 "
bitfld.long 0 24. " BUSYENDC "  "0 ,1 "
bitfld.long 0 26. " BOOTACKERRC "  "0 ,1 "
bitfld.long 0 27. " BOOTACKTIMEOUTC "  "0 ,1 "
bitfld.long 0 28. " RSTNENC "  "0 ,1 "
tree.end

base sd:0x8000803c
tree "5Mask0"
group 0--3
line.long 0 "Mask0"
tree.end

base sd:0x80008040
tree "5Mask1"
group 0--3
line.long 0 "Mask1"
tree.end

base sd:0x80008044
tree "5CardSel"
group 0--3
line.long 0 "CardSel"
bitfld.long 0 0.--3. " CardSel "  " "
tree.end

base sd:0x80008048
tree "5FifoCnt"
group 0--3
line.long 0 "FifoCnt"
bitfld.long 0 0.--23. " DataCount "  " "
tree.end

base sd:0x80008080
tree "5Fifo"
group 0--3
line.long 0 "Fifo"
bitfld.long 0 0.--31. " FIFOData "  " "
tree.end

base sd:0x800080c0
tree "5DBtimer"
group 0--3
line.long 0 "DBtimer"
bitfld.long 0 0.--31. " DBTIME "  " "
tree.end

base sd:0x800080c4
tree "5TRSCA"
group 0--3
line.long 0 "TRSCA"
bitfld.long 0 0.--31. " TRSCA "  " "
tree.end

base sd:0x80008fe0
tree "5PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80008fe4
tree "5PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80008fe8
tree "5PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80008fec
tree "5PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80008ff0
tree "5PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " SDIPCellID0 "  " "
tree.end

base sd:0x80008ff4
tree "5PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " SDIPCellID1 "  " "
tree.end

base sd:0x80008ff8
tree "5PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " SDIPCellID2 "  " "
tree.end

base sd:0x80008ffc
tree "5PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " SDIPCellID3 "  " "
tree.end

;tree.end

tree.end

;==============================================================
;tree "MSP (4 instances)"
;==============================================================
base sd:0x80123000
;********************************************
tree "MSP-0"
;********************************************
base sd:0x80123000
tree "0DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80123004
tree "0GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  " "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  " "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  " "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
tree.end

base sd:0x80123008
tree "0TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  " "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  " "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  " "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  " "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  " "
tree.end

base sd:0x8012300c
tree "0RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  " "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  " "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  " "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  " "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  " "
tree.end

base sd:0x80123010
tree "0SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  " "
bitfld.long 0 16.--28. " FRPER "  " "
tree.end

base sd:0x80123014
tree "0FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
tree.end

base sd:0x80123018
tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
tree.end

base sd:0x8012301c
tree "0WMRK"
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
tree.end

base sd:0x80123020
tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
tree.end

base sd:0x80123024
tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
tree.end

base sd:0x80123028
tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
tree.end

base sd:0x8012302c
tree "0ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
tree.end

base sd:0x80123030
tree "0MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  " "
bitfld.long 0 3.--4. " RCMPM "  " "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  " "
tree.end

base sd:0x80123034
tree "0RCV"
group 0--3
line.long 0 "RCV"
bitfld.long 0 0.--31. " RCV "  " "
tree.end

base sd:0x80123038
tree "0RCM"
group 0--3
line.long 0 "RCM"
bitfld.long 0 0.--31. " RCM "  " "
tree.end

base sd:0x80123040
tree "0TCE0"
group 0--3
line.long 0 "TCE0"
bitfld.long 0 0.--31. " TCE0 "  " "
tree.end

base sd:0x80123044
tree "0TCE1"
group 0--3
line.long 0 "TCE1"
bitfld.long 0 0.--31. " TCE1 "  " "
tree.end

base sd:0x80123048
tree "0TCE2"
group 0--3
line.long 0 "TCE2"
bitfld.long 0 0.--31. " TCE2 "  " "
tree.end

base sd:0x8012304c
tree "0TCE3"
group 0--3
line.long 0 "TCE3"
bitfld.long 0 0.--31. " TCE3 "  " "
tree.end

base sd:0x80123060
tree "0RCE0"
group 0--3
line.long 0 "RCE0"
bitfld.long 0 0.--31. " RCE0 "  " "
tree.end

base sd:0x80123064
tree "0RCE1"
group 0--3
line.long 0 "RCE1"
bitfld.long 0 0.--31. " RCE1 "  " "
tree.end

base sd:0x80123068
tree "0RCE2"
group 0--3
line.long 0 "RCE2"
bitfld.long 0 0.--31. " RCE2 "  " "
tree.end

base sd:0x8012306c
tree "0RCE3"
group 0--3
line.long 0 "RCE3"
bitfld.long 0 0.--31. " RCE3 "  " "
tree.end

base sd:0x80123070
tree "0IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  " "
bitfld.long 0 4.--6. " TFSDLY "  " "
bitfld.long 0 8.--10. " TDXDLY "  " "
bitfld.long 0 12.--14. " RCKDLY "  " "
bitfld.long 0 16.--18. " RFSDLY "  " "
bitfld.long 0 20.--22. " RDXDLY "  " "
bitfld.long 0 24.--26. " SCKDLY "  " "
tree.end

base sd:0x80123080
tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
tree.end

base sd:0x80123084
tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80123088
tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x8012308c
tree "0TSTDR"
group 0--3
line.long 0 "TSTDR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80123fe0
tree "0PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80123fe4
tree "0PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80123fe8
tree "0PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80123fec
tree "0PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80123ff0
tree "0PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80123ff4
tree "0PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80123ff8
tree "0PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80123ffc
tree "0PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

tree.end

base sd:0x80124000
;********************************************
tree "MSP-1"
;********************************************
base sd:0x80124000
tree "1DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80124004
tree "1GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  " "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  " "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  " "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
tree.end

base sd:0x80124008
tree "1TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  " "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  " "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  " "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  " "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  " "
tree.end

base sd:0x8012400c
tree "1RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  " "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  " "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  " "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  " "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  " "
tree.end

base sd:0x80124010
tree "1SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  " "
bitfld.long 0 16.--28. " FRPER "  " "
tree.end

base sd:0x80124014
tree "1FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
tree.end

base sd:0x80124018
tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
tree.end

base sd:0x8012401c
tree "1WMRK"
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
tree.end

base sd:0x80124020
tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
tree.end

base sd:0x80124024
tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
tree.end

base sd:0x80124028
tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
tree.end

base sd:0x8012402c
tree "1ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
tree.end

base sd:0x80124030
tree "1MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  " "
bitfld.long 0 3.--4. " RCMPM "  " "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  " "
tree.end

base sd:0x80124034
tree "1RCV"
group 0--3
line.long 0 "RCV"
bitfld.long 0 0.--31. " RCV "  " "
tree.end

base sd:0x80124038
tree "1RCM"
group 0--3
line.long 0 "RCM"
bitfld.long 0 0.--31. " RCM "  " "
tree.end

base sd:0x80124040
tree "1TCE0"
group 0--3
line.long 0 "TCE0"
bitfld.long 0 0.--31. " TCE0 "  " "
tree.end

base sd:0x80124044
tree "1TCE1"
group 0--3
line.long 0 "TCE1"
bitfld.long 0 0.--31. " TCE1 "  " "
tree.end

base sd:0x80124048
tree "1TCE2"
group 0--3
line.long 0 "TCE2"
bitfld.long 0 0.--31. " TCE2 "  " "
tree.end

base sd:0x8012404c
tree "1TCE3"
group 0--3
line.long 0 "TCE3"
bitfld.long 0 0.--31. " TCE3 "  " "
tree.end

base sd:0x80124060
tree "1RCE0"
group 0--3
line.long 0 "RCE0"
bitfld.long 0 0.--31. " RCE0 "  " "
tree.end

base sd:0x80124064
tree "1RCE1"
group 0--3
line.long 0 "RCE1"
bitfld.long 0 0.--31. " RCE1 "  " "
tree.end

base sd:0x80124068
tree "1RCE2"
group 0--3
line.long 0 "RCE2"
bitfld.long 0 0.--31. " RCE2 "  " "
tree.end

base sd:0x8012406c
tree "1RCE3"
group 0--3
line.long 0 "RCE3"
bitfld.long 0 0.--31. " RCE3 "  " "
tree.end

base sd:0x80124070
tree "1IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  " "
bitfld.long 0 4.--6. " TFSDLY "  " "
bitfld.long 0 8.--10. " TDXDLY "  " "
bitfld.long 0 12.--14. " RCKDLY "  " "
bitfld.long 0 16.--18. " RFSDLY "  " "
bitfld.long 0 20.--22. " RDXDLY "  " "
bitfld.long 0 24.--26. " SCKDLY "  " "
tree.end

base sd:0x80124080
tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
tree.end

base sd:0x80124084
tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80124088
tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x8012408c
tree "1TSTDR"
group 0--3
line.long 0 "TSTDR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80124fe0
tree "1PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80124fe4
tree "1PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80124fe8
tree "1PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80124fec
tree "1PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80124ff0
tree "1PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80124ff4
tree "1PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80124ff8
tree "1PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80124ffc
tree "1PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

tree.end

base sd:0x80125000
;********************************************
tree "MSP-3"
;********************************************
base sd:0x80125000
tree "3DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80125004
tree "3GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  " "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  " "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  " "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
tree.end

base sd:0x80125008
tree "3TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  " "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  " "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  " "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  " "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  " "
tree.end

base sd:0x8012500c
tree "3RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  " "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  " "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  " "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  " "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  " "
tree.end

base sd:0x80125010
tree "3SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  " "
bitfld.long 0 16.--28. " FRPER "  " "
tree.end

base sd:0x80125014
tree "3FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
tree.end

base sd:0x80125018
tree "3DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
tree.end

base sd:0x8012501c
tree "3WMRK"
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
tree.end

base sd:0x80125020
tree "3IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
tree.end

base sd:0x80125024
tree "3RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
tree.end

base sd:0x80125028
tree "3MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
tree.end

base sd:0x8012502c
tree "3ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
tree.end

base sd:0x80125030
tree "3MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  " "
bitfld.long 0 3.--4. " RCMPM "  " "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  " "
tree.end

base sd:0x80125034
tree "3RCV"
group 0--3
line.long 0 "RCV"
bitfld.long 0 0.--31. " RCV "  " "
tree.end

base sd:0x80125038
tree "3RCM"
group 0--3
line.long 0 "RCM"
bitfld.long 0 0.--31. " RCM "  " "
tree.end

base sd:0x80125040
tree "3TCE0"
group 0--3
line.long 0 "TCE0"
bitfld.long 0 0.--31. " TCE0 "  " "
tree.end

base sd:0x80125044
tree "3TCE1"
group 0--3
line.long 0 "TCE1"
bitfld.long 0 0.--31. " TCE1 "  " "
tree.end

base sd:0x80125048
tree "3TCE2"
group 0--3
line.long 0 "TCE2"
bitfld.long 0 0.--31. " TCE2 "  " "
tree.end

base sd:0x8012504c
tree "3TCE3"
group 0--3
line.long 0 "TCE3"
bitfld.long 0 0.--31. " TCE3 "  " "
tree.end

base sd:0x80125060
tree "3RCE0"
group 0--3
line.long 0 "RCE0"
bitfld.long 0 0.--31. " RCE0 "  " "
tree.end

base sd:0x80125064
tree "3RCE1"
group 0--3
line.long 0 "RCE1"
bitfld.long 0 0.--31. " RCE1 "  " "
tree.end

base sd:0x80125068
tree "3RCE2"
group 0--3
line.long 0 "RCE2"
bitfld.long 0 0.--31. " RCE2 "  " "
tree.end

base sd:0x8012506c
tree "3RCE3"
group 0--3
line.long 0 "RCE3"
bitfld.long 0 0.--31. " RCE3 "  " "
tree.end

base sd:0x80125070
tree "3IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  " "
bitfld.long 0 4.--6. " TFSDLY "  " "
bitfld.long 0 8.--10. " TDXDLY "  " "
bitfld.long 0 12.--14. " RCKDLY "  " "
bitfld.long 0 16.--18. " RFSDLY "  " "
bitfld.long 0 20.--22. " RDXDLY "  " "
bitfld.long 0 24.--26. " SCKDLY "  " "
tree.end

base sd:0x80125080
tree "3ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
tree.end

base sd:0x80125084
tree "3ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80125088
tree "3ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x8012508c
tree "3TSTDR"
group 0--3
line.long 0 "TSTDR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80125fe0
tree "3PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80125fe4
tree "3PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80125fe8
tree "3PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80125fec
tree "3PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80125ff0
tree "3PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80125ff4
tree "3PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80125ff8
tree "3PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80125ffc
tree "3PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

tree.end

base sd:0x80117000
;********************************************
tree "MSP-2"
;********************************************
base sd:0x80117000
tree "2DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80117004
tree "2GCR"
group 0--3
line.long 0 "GCR"
bitfld.long 0 0. " RXEN "  "0 ,1 "
bitfld.long 0 1. " RFFEN "  "0 ,1 "
bitfld.long 0 2. " RFSPOL "  "0 ,1 "
bitfld.long 0 3. " DCM "  "0 ,1 "
bitfld.long 0 4. " RFSSEL "  "0 ,1 "
bitfld.long 0 5. " RCKPOL "  "0 ,1 "
bitfld.long 0 6. " RCKSEL "  "0 ,1 "
bitfld.long 0 7. " LBM "  "0 ,1 "
bitfld.long 0 8. " TXEN "  "0 ,1 "
bitfld.long 0 9. " TFFEN "  "0 ,1 "
bitfld.long 0 10. " TFSPOL "  "0 ,1 "
bitfld.long 0 11.--12. " TFSSEL "  " "
bitfld.long 0 13. " TCKPOL "  "0 ,1 "
bitfld.long 0 14. " TCKSEL "  "0 ,1 "
bitfld.long 0 15. " TDXDL "  "0 ,1 "
bitfld.long 0 16. " SGEN "  "0 ,1 "
bitfld.long 0 17. " SCKPOL "  "0 ,1 "
bitfld.long 0 18.--19. " SCKSEL "  " "
bitfld.long 0 20. " FGEN "  "0 ,1 "
bitfld.long 0 21.--22. " SPICKM "  " "
bitfld.long 0 23. " SPIBME "  "0 ,1 "
tree.end

base sd:0x80117008
tree "2TCF"
group 0--3
line.long 0 "TCF"
bitfld.long 0 0.--2. " TP1ELEN "  " "
bitfld.long 0 3.--9. " TP1FLEN "  " "
bitfld.long 0 10.--11. " TDTYP "  " "
bitfld.long 0 12. " TENDN "  "0 ,1 "
bitfld.long 0 13.--14. " TDDLY "  " "
bitfld.long 0 15. " TFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " TP2ELEN "  " "
bitfld.long 0 19.--25. " TP2FLEN "  " "
bitfld.long 0 26. " TP2SM "  "0 ,1 "
bitfld.long 0 27. " TP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " TBSWAP "  " "
tree.end

base sd:0x8011700c
tree "2RCF"
group 0--3
line.long 0 "RCF"
bitfld.long 0 0.--2. " RP1ELEN "  " "
bitfld.long 0 3.--9. " RP1FLEN "  " "
bitfld.long 0 10.--11. " RDTYP "  " "
bitfld.long 0 12. " RENDN "  "0 ,1 "
bitfld.long 0 13.--14. " RDDLY "  " "
bitfld.long 0 15. " RFSIG "  "0 ,1 "
bitfld.long 0 16.--18. " RP2ELEN "  " "
bitfld.long 0 19.--25. " RP2FLEN "  " "
bitfld.long 0 26. " RP2SM "  "0 ,1 "
bitfld.long 0 27. " RP2EN "  "0 ,1 "
bitfld.long 0 28.--29. " RBSWAP "  " "
tree.end

base sd:0x80117010
tree "2SRG"
group 0--3
line.long 0 "SRG"
bitfld.long 0 0.--9. " SCKDIV "  " "
bitfld.long 0 10.--15. " FRWID "  " "
bitfld.long 0 16.--28. " FRPER "  " "
tree.end

base sd:0x80117014
tree "2FLR"
rgroup 0--3
line.long 0 "FLR"
bitfld.long 0 0. " RBUSY "  "0 ,1 "
bitfld.long 0 1. " RFE "  "0 ,1 "
bitfld.long 0 2. " RFU "  "0 ,1 "
bitfld.long 0 3. " TBUSY "  "0 ,1 "
bitfld.long 0 4. " TFE "  "0 ,1 "
bitfld.long 0 5. " TFU "  "0 ,1 "
tree.end

base sd:0x80117018
tree "2DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RDMAE "  "0 ,1 "
bitfld.long 0 1. " TDMAE "  "0 ,1 "
tree.end

base sd:0x8011701c
tree "2WMRK"
group 0--3
line.long 0 "WMRK"
bitfld.long 0 0. " RWMRK "  "0 ,1 "
bitfld.long 0 1. " TWMRK "  "0 ,1 "
tree.end

base sd:0x80117020
tree "2IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RXIM "  "0 ,1 "
bitfld.long 0 1. " ROEIM "  "0 ,1 "
bitfld.long 0 2. " RSEIM "  "0 ,1 "
bitfld.long 0 3. " RFSIM "  "0 ,1 "
bitfld.long 0 4. " TXIM "  "0 ,1 "
bitfld.long 0 5. " TUEIM "  "0 ,1 "
bitfld.long 0 6. " TSEIM "  "0 ,1 "
bitfld.long 0 7. " TFSIM "  "0 ,1 "
bitfld.long 0 8. " RFOIM "  "0 ,1 "
bitfld.long 0 9. " TFOIM "  "0 ,1 "
tree.end

base sd:0x80117024
tree "2RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RXRIS "  "0 ,1 "
bitfld.long 0 1. " ROERIS "  "0 ,1 "
bitfld.long 0 2. " RSERIS "  "0 ,1 "
bitfld.long 0 3. " RFSRIS "  "0 ,1 "
bitfld.long 0 4. " TXRIS "  "0 ,1 "
bitfld.long 0 5. " TUERIS "  "0 ,1 "
bitfld.long 0 6. " TSERIS "  "0 ,1 "
bitfld.long 0 7. " TFSRIS "  "0 ,1 "
bitfld.long 0 8. " RFORIS "  "0 ,1 "
bitfld.long 0 9. " TFORIS "  "0 ,1 "
tree.end

base sd:0x80117028
tree "2MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RXMIS "  "0 ,1 "
bitfld.long 0 1. " ROEMIS "  "0 ,1 "
bitfld.long 0 2. " RSEMIS "  "0 ,1 "
bitfld.long 0 3. " RFSMIS "  "0 ,1 "
bitfld.long 0 4. " TXMIS "  "0 ,1 "
bitfld.long 0 5. " TUEMIS "  "0 ,1 "
bitfld.long 0 6. " TSEMIS "  "0 ,1 "
bitfld.long 0 7. " TFSMIS "  "0 ,1 "
bitfld.long 0 8. " RFOMIS "  "0 ,1 "
bitfld.long 0 9. " TFOMIS "  "0 ,1 "
tree.end

base sd:0x8011702c
tree "2ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 1. " ROEIC "  "0 ,1 "
bitfld.long 0 2. " RSEIC "  "0 ,1 "
bitfld.long 0 3. " RFSIC "  "0 ,1 "
bitfld.long 0 5. " TUEIC "  "0 ,1 "
bitfld.long 0 6. " TSEIC "  "0 ,1 "
bitfld.long 0 7. " TFSIC "  "0 ,1 "
tree.end

base sd:0x80117030
tree "2MCR"
group 0--3
line.long 0 "MCR"
bitfld.long 0 0. " RMCEN "  "0 ,1 "
bitfld.long 0 1.--2. " RMCSF "  " "
bitfld.long 0 3.--4. " RCMPM "  " "
bitfld.long 0 5. " TMCEN "  "0 ,1 "
bitfld.long 0 6.--7. " TMCSF "  " "
tree.end

base sd:0x80117034
tree "2RCV"
group 0--3
line.long 0 "RCV"
bitfld.long 0 0.--31. " RCV "  " "
tree.end

base sd:0x80117038
tree "2RCM"
group 0--3
line.long 0 "RCM"
bitfld.long 0 0.--31. " RCM "  " "
tree.end

base sd:0x80117040
tree "2TCE0"
group 0--3
line.long 0 "TCE0"
bitfld.long 0 0.--31. " TCE0 "  " "
tree.end

base sd:0x80117044
tree "2TCE1"
group 0--3
line.long 0 "TCE1"
bitfld.long 0 0.--31. " TCE1 "  " "
tree.end

base sd:0x80117048
tree "2TCE2"
group 0--3
line.long 0 "TCE2"
bitfld.long 0 0.--31. " TCE2 "  " "
tree.end

base sd:0x8011704c
tree "2TCE3"
group 0--3
line.long 0 "TCE3"
bitfld.long 0 0.--31. " TCE3 "  " "
tree.end

base sd:0x80117060
tree "2RCE0"
group 0--3
line.long 0 "RCE0"
bitfld.long 0 0.--31. " RCE0 "  " "
tree.end

base sd:0x80117064
tree "2RCE1"
group 0--3
line.long 0 "RCE1"
bitfld.long 0 0.--31. " RCE1 "  " "
tree.end

base sd:0x80117068
tree "2RCE2"
group 0--3
line.long 0 "RCE2"
bitfld.long 0 0.--31. " RCE2 "  " "
tree.end

base sd:0x8011706c
tree "2RCE3"
group 0--3
line.long 0 "RCE3"
bitfld.long 0 0.--31. " RCE3 "  " "
tree.end

base sd:0x80117070
tree "2IODLY"
group 0--3
line.long 0 "IODLY"
bitfld.long 0 0.--2. " TCKDLY "  " "
bitfld.long 0 4.--6. " TFSDLY "  " "
bitfld.long 0 8.--10. " TDXDLY "  " "
bitfld.long 0 12.--14. " RCKDLY "  " "
bitfld.long 0 16.--18. " RFSDLY "  " "
bitfld.long 0 20.--22. " RDXDLY "  " "
bitfld.long 0 24.--26. " SCKDLY "  " "
tree.end

base sd:0x80117080
tree "2ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
tree.end

base sd:0x80117084
tree "2ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80117088
tree "2ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x8011708c
tree "2TSTDR"
group 0--3
line.long 0 "TSTDR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80117fe0
tree "2PERIPHID0"
rgroup 0--3
line.long 0 "PERIPHID0"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80117fe4
tree "2PERIPHID1"
rgroup 0--3
line.long 0 "PERIPHID1"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80117fe8
tree "2PERIPHID2"
rgroup 0--3
line.long 0 "PERIPHID2"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80117fec
tree "2PERIPHID3"
rgroup 0--3
line.long 0 "PERIPHID3"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80117ff0
tree "2PCELLID0"
rgroup 0--3
line.long 0 "PCELLID0"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80117ff4
tree "2PCELLID1"
rgroup 0--3
line.long 0 "PCELLID1"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80117ff8
tree "2PCELLID2"
rgroup 0--3
line.long 0 "PCELLID2"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x80117ffc
tree "2PCELLID3"
rgroup 0--3
line.long 0 "PCELLID3"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

;tree.end

tree.end

;==============================================================
tree "MSSCSTF"
;==============================================================
base sd:0xb7a04000
tree "CSTFCONTROLREG"
group 0--3
line.long 0 "CSTFCONTROLREG"
bitfld.long 0 0. " EnS0 "  "0 ,1 "
bitfld.long 0 1. " EnS1 "  "0 ,1 "
bitfld.long 0 2. " EnS2 "  "0 ,1 "
bitfld.long 0 3. " EnS3 "  "0 ,1 "
bitfld.long 0 4. " EnS4 "  "0 ,1 "
bitfld.long 0 5. " EnS5 "  "0 ,1 "
bitfld.long 0 6. " EnS6 "  "0 ,1 "
bitfld.long 0 7. " EnS7 "  "0 ,1 "
bitfld.long 0 8.--11. " HT "  " "
tree.end

base sd:0xb7a04004
tree "CSTFPRIORCNTRLREG"
group 0--3
line.long 0 "CSTFPRIORCNTRLREG"
bitfld.long 0 0.--2. " PriPort0 "  " "
bitfld.long 0 3.--5. " PriPort1 "  " "
bitfld.long 0 6.--8. " PriPort2 "  " "
bitfld.long 0 9.--11. " PriPort3 "  " "
bitfld.long 0 12.--14. " PriPort4 "  " "
bitfld.long 0 15.--17. " PriPort5 "  " "
bitfld.long 0 18.--20. " PriPort6 "  " "
bitfld.long 0 21.--23. " PriPort7 "  " "
tree.end

base sd:0xb7a04eec
tree "ITATBDATA0"
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ATDATA0 "  "0 ,1 "
bitfld.long 0 1. " ATDATA7 "  "0 ,1 "
bitfld.long 0 2. " ATDATA15 "  "0 ,1 "
bitfld.long 0 3. " ATDATA23 "  "0 ,1 "
bitfld.long 0 4. " ATDATA31 "  "0 ,1 "
tree.end

base sd:0xb7a04ef0
tree "ITATBCTR2"
group 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ATREADY "  "0 ,1 "
bitfld.long 0 1. " AFVALID "  "0 ,1 "
tree.end

base sd:0xb7a04ef4
tree "ITATBCTR1"
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0.--6. " ATID "  " "
tree.end

base sd:0xb7a04ef8
tree "ITATBCTR0"
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ATVALID "  "0 ,1 "
bitfld.long 0 1. " AFREADYS "  "0 ,1 "
bitfld.long 0 8.--9. " ATBYTES "  " "
tree.end

base sd:0xb7a04f00
tree "IMCR"
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " IMCR "  "0 ,1 "
tree.end

base sd:0xb7a04fa0
tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  " "
tree.end

base sd:0xb7a04fa4
tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  " "
tree.end

base sd:0xb7a04fb0
tree "LAR"
wgroup 0--3
line.long 0 "LAR"
bitfld.long 0 0.--31. " LAR "  " "
tree.end

base sd:0xb7a04fb4
tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  " "
tree.end

base sd:0xb7a04fb8
tree "ASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--7. " ASR "  " "
tree.end

base sd:0xb7a04fc8
tree "DID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--7. " DID "  " "
tree.end

base sd:0xb7a04fcc
tree "DTIR"
rgroup 0--3
line.long 0 "DTIR"
bitfld.long 0 0.--7. " DTIR "  " "
tree.end

base sd:0xb7a04fd0
tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0.--7. " PERIPHERAL_ID4 "  " "
tree.end

base sd:0xb7a04fd4
tree "PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
tree.end

base sd:0xb7a04fd8
tree "PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
tree.end

base sd:0xb7a04fdc
tree "PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
tree.end

base sd:0xb7a04fe0
tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0.--7. " PERIPHERAL_ID0 "  " "
tree.end

base sd:0xb7a04fe4
tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0.--7. " PERIPHERAL_ID1 "  " "
tree.end

base sd:0xb7a04fe8
tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0.--7. " PERIPHERAL_ID2 "  " "
tree.end

base sd:0xb7a04fec
tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0.--7. " PERIPHERAL_ID3 "  " "
tree.end

base sd:0xb7a04ff0
tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
tree.end

base sd:0xb7a04ff4
tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0.--7. " COMPONENT_ID1 "  " "
tree.end

base sd:0xb7a04ff8
tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0.--7. " COMPONENT_ID2 "  " "
tree.end

base sd:0xb7a04ffc
tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0.--7. " COMPONENT_ID3 "  " "
tree.end

tree.end

;==============================================================
;tree "MSSCTI (4 instances)"
;==============================================================
base sd:0xb7a02000
;********************************************
tree "MSSCTI-CS"
;********************************************
base sd:0xb7a02000
tree "CSCTICONTROL"
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
tree.end

base sd:0xb7a02010
tree "CSCTIINTACK"
wgroup 0--3
line.long 0 "CTIINTACK"
bitfld.long 0 0.--7. " INTACK "  " "
tree.end

base sd:0xb7a02014
tree "CSCTIAPPSET"
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  " "
tree.end

base sd:0xb7a02018
tree "CSCTIAPPCLEAR"
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  " "
tree.end

base sd:0xb7a0201c
tree "CSCTIAPPPULSE"
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  " "
tree.end

base sd:0xb7a02020
tree "CSCTIINEN0"
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a02024
tree "CSCTIINEN1"
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a02028
tree "CSCTIINEN2"
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0202c
tree "CSCTIINEN3"
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a02030
tree "CSCTIINEN4"
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a02034
tree "CSCTIINEN5"
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a02038
tree "CSCTIINEN6"
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0203c
tree "CSCTIINEN7"
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a020a0
tree "CSCTIOUTEN0"
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a020a4
tree "CSCTIOUTEN1"
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a020a8
tree "CSCTIOUTEN2"
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a020ac
tree "CSCTIOUTEN3"
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a020b0
tree "CSCTIOUTEN4"
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a020b4
tree "CSCTIOUTEN5"
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a020b8
tree "CSCTIOUTEN6"
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a020bc
tree "CSCTIOUTEN7"
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a02130
tree "CSCTITRIGINSTATUS"
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
bitfld.long 0 0.--7. " TRIGINSTATUS "  " "
tree.end

base sd:0xb7a02134
tree "CSCTITRIGOUTSTATUS"
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
bitfld.long 0 0.--7. " TRIGOUTSTATUS "  " "
tree.end

base sd:0xb7a02138
tree "CSCTICHINSTATUS"
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  " "
tree.end

base sd:0xb7a0213c
tree "CSCTICHOUTSTATUS"
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  " "
tree.end

base sd:0xb7a02140
tree "CSCTIGATE"
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
tree.end

base sd:0xb7a02144
tree "CSASICCTL"
group 0--3
line.long 0 "ASICCTL"
bitfld.long 0 0.--7. " ASICCTL "  " "
tree.end

base sd:0xb7a02edc
tree "CSITCHINACK"
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  " "
tree.end

base sd:0xb7a02ee0
tree "CSITTRIGINACK"
wgroup 0--3
line.long 0 "ITTRIGINACK"
bitfld.long 0 0.--7. " CTTRIGINACK "  " "
tree.end

base sd:0xb7a02ee4
tree "CSITCHOUT"
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  " "
tree.end

base sd:0xb7a02ee8
tree "CSITTRFLIN"
wgroup 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0.--7. " CTTRIGOUT "  " "
tree.end

base sd:0xb7a02eec
tree "CSITCHOUTACK"
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  " "
tree.end

base sd:0xb7a02ef0
tree "CSITTRIGOUTACK"
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
bitfld.long 0 0.--7. " CTTRIGOUTACK "  " "
tree.end

base sd:0xb7a02ef4
tree "CSITCHIN"
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  " "
tree.end

base sd:0xb7a02ef8
tree "CSITRIGIN"
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
tree.end

base sd:0xb7a02fa0
tree "CSCTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  " "
tree.end

base sd:0xb7a02fa4
tree "CSCTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  " "
tree.end

base sd:0xb7a02fb0
tree "CSLAR"
wgroup 0--3
line.long 0 "LAR"
bitfld.long 0 0.--31. " LAR "  " "
tree.end

base sd:0xb7a02fb4
tree "CSLSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  " "
tree.end

base sd:0xb7a02fb8
tree "CSASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  " "
tree.end

base sd:0xb7a02fc8
tree "CSDID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
tree.end

base sd:0xb7a02fcc
tree "CSDTIR"
rgroup 0--3
line.long 0 "DTIR"
bitfld.long 0 0.--7. " DTIR "  " "
tree.end

base sd:0xb7a02fd0
tree "CSPERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0.--7. " PERIPHERAL_ID4 "  " "
tree.end

base sd:0xb7a02fd4
tree "CSPERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
tree.end

base sd:0xb7a02fd8
tree "CSPERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
tree.end

base sd:0xb7a02fdc
tree "CSPERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
tree.end

base sd:0xb7a02fe0
tree "CSPERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0.--7. " PERIPHERAL_ID0 "  " "
tree.end

base sd:0xb7a02fe4
tree "CSPERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0.--7. " PERIPHERAL_ID1 "  " "
tree.end

base sd:0xb7a02fe8
tree "CSPERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0.--7. " PERIPHERAL_ID2 "  " "
tree.end

base sd:0xb7a02fec
tree "CSPERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0.--7. " PERIPHERAL_ID3 "  " "
tree.end

base sd:0xb7a02ff0
tree "CSCOMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
tree.end

base sd:0xb7a02ff4
tree "CSCOMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0.--7. " COMPONENT_ID1 "  " "
tree.end

base sd:0xb7a02ff8
tree "CSCOMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0.--7. " COMPONENT_ID2 "  " "
tree.end

base sd:0xb7a02ffc
tree "CSCOMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0.--7. " COMPONENT_ID3 "  " "
tree.end

tree.end

base sd:0xb7a09000
;********************************************
tree "MSSCTI-L1CTI"
;********************************************
base sd:0xb7a09000
tree "L1CTICTICONTROL"
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
tree.end

base sd:0xb7a09010
tree "L1CTICTIINTACK"
wgroup 0--3
line.long 0 "CTIINTACK"
bitfld.long 0 0.--7. " INTACK "  " "
tree.end

base sd:0xb7a09014
tree "L1CTICTIAPPSET"
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  " "
tree.end

base sd:0xb7a09018
tree "L1CTICTIAPPCLEAR"
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  " "
tree.end

base sd:0xb7a0901c
tree "L1CTICTIAPPPULSE"
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  " "
tree.end

base sd:0xb7a09020
tree "L1CTICTIINEN0"
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a09024
tree "L1CTICTIINEN1"
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a09028
tree "L1CTICTIINEN2"
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0902c
tree "L1CTICTIINEN3"
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a09030
tree "L1CTICTIINEN4"
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a09034
tree "L1CTICTIINEN5"
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a09038
tree "L1CTICTIINEN6"
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0903c
tree "L1CTICTIINEN7"
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a090a0
tree "L1CTICTIOUTEN0"
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a090a4
tree "L1CTICTIOUTEN1"
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a090a8
tree "L1CTICTIOUTEN2"
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a090ac
tree "L1CTICTIOUTEN3"
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a090b0
tree "L1CTICTIOUTEN4"
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a090b4
tree "L1CTICTIOUTEN5"
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a090b8
tree "L1CTICTIOUTEN6"
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a090bc
tree "L1CTICTIOUTEN7"
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a09130
tree "L1CTICTITRIGINSTATUS"
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
bitfld.long 0 0.--7. " TRIGINSTATUS "  " "
tree.end

base sd:0xb7a09134
tree "L1CTICTITRIGOUTSTATUS"
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
bitfld.long 0 0.--7. " TRIGOUTSTATUS "  " "
tree.end

base sd:0xb7a09138
tree "L1CTICTICHINSTATUS"
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  " "
tree.end

base sd:0xb7a0913c
tree "L1CTICTICHOUTSTATUS"
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  " "
tree.end

base sd:0xb7a09140
tree "L1CTICTIGATE"
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
tree.end

base sd:0xb7a09144
tree "L1CTIASICCTL"
group 0--3
line.long 0 "ASICCTL"
bitfld.long 0 0.--7. " ASICCTL "  " "
tree.end

base sd:0xb7a09edc
tree "L1CTIITCHINACK"
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  " "
tree.end

base sd:0xb7a09ee0
tree "L1CTIITTRIGINACK"
wgroup 0--3
line.long 0 "ITTRIGINACK"
bitfld.long 0 0.--7. " CTTRIGINACK "  " "
tree.end

base sd:0xb7a09ee4
tree "L1CTIITCHOUT"
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  " "
tree.end

base sd:0xb7a09ee8
tree "L1CTIITTRFLIN"
wgroup 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0.--7. " CTTRIGOUT "  " "
tree.end

base sd:0xb7a09eec
tree "L1CTIITCHOUTACK"
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  " "
tree.end

base sd:0xb7a09ef0
tree "L1CTIITTRIGOUTACK"
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
bitfld.long 0 0.--7. " CTTRIGOUTACK "  " "
tree.end

base sd:0xb7a09ef4
tree "L1CTIITCHIN"
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  " "
tree.end

base sd:0xb7a09ef8
tree "L1CTIITRIGIN"
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
tree.end

base sd:0xb7a09fa0
tree "L1CTICTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  " "
tree.end

base sd:0xb7a09fa4
tree "L1CTICTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  " "
tree.end

base sd:0xb7a09fb0
tree "L1CTILAR"
wgroup 0--3
line.long 0 "LAR"
bitfld.long 0 0.--31. " LAR "  " "
tree.end

base sd:0xb7a09fb4
tree "L1CTILSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  " "
tree.end

base sd:0xb7a09fb8
tree "L1CTIASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  " "
tree.end

base sd:0xb7a09fc8
tree "L1CTIDID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
tree.end

base sd:0xb7a09fcc
tree "L1CTIDTIR"
rgroup 0--3
line.long 0 "DTIR"
bitfld.long 0 0.--7. " DTIR "  " "
tree.end

base sd:0xb7a09fd0
tree "L1CTIPERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0.--7. " PERIPHERAL_ID4 "  " "
tree.end

base sd:0xb7a09fd4
tree "L1CTIPERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
tree.end

base sd:0xb7a09fd8
tree "L1CTIPERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
tree.end

base sd:0xb7a09fdc
tree "L1CTIPERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
tree.end

base sd:0xb7a09fe0
tree "L1CTIPERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0.--7. " PERIPHERAL_ID0 "  " "
tree.end

base sd:0xb7a09fe4
tree "L1CTIPERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0.--7. " PERIPHERAL_ID1 "  " "
tree.end

base sd:0xb7a09fe8
tree "L1CTIPERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0.--7. " PERIPHERAL_ID2 "  " "
tree.end

base sd:0xb7a09fec
tree "L1CTIPERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0.--7. " PERIPHERAL_ID3 "  " "
tree.end

base sd:0xb7a09ff0
tree "L1CTICOMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
tree.end

base sd:0xb7a09ff4
tree "L1CTICOMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0.--7. " COMPONENT_ID1 "  " "
tree.end

base sd:0xb7a09ff8
tree "L1CTICOMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0.--7. " COMPONENT_ID2 "  " "
tree.end

base sd:0xb7a09ffc
tree "L1CTICOMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0.--7. " COMPONENT_ID3 "  " "
tree.end

tree.end

base sd:0xb7a0c000
;********************************************
tree "MSSCTI-L2CTI"
;********************************************
base sd:0xb7a0c000
tree "L2CTICTICONTROL"
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
tree.end

base sd:0xb7a0c010
tree "L2CTICTIINTACK"
wgroup 0--3
line.long 0 "CTIINTACK"
bitfld.long 0 0.--7. " INTACK "  " "
tree.end

base sd:0xb7a0c014
tree "L2CTICTIAPPSET"
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  " "
tree.end

base sd:0xb7a0c018
tree "L2CTICTIAPPCLEAR"
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  " "
tree.end

base sd:0xb7a0c01c
tree "L2CTICTIAPPPULSE"
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  " "
tree.end

base sd:0xb7a0c020
tree "L2CTICTIINEN0"
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0c024
tree "L2CTICTIINEN1"
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0c028
tree "L2CTICTIINEN2"
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0c02c
tree "L2CTICTIINEN3"
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0c030
tree "L2CTICTIINEN4"
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0c034
tree "L2CTICTIINEN5"
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0c038
tree "L2CTICTIINEN6"
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0c03c
tree "L2CTICTIINEN7"
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0c0a0
tree "L2CTICTIOUTEN0"
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0c0a4
tree "L2CTICTIOUTEN1"
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0c0a8
tree "L2CTICTIOUTEN2"
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0c0ac
tree "L2CTICTIOUTEN3"
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0c0b0
tree "L2CTICTIOUTEN4"
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0c0b4
tree "L2CTICTIOUTEN5"
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0c0b8
tree "L2CTICTIOUTEN6"
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0c0bc
tree "L2CTICTIOUTEN7"
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0c130
tree "L2CTICTITRIGINSTATUS"
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
bitfld.long 0 0.--7. " TRIGINSTATUS "  " "
tree.end

base sd:0xb7a0c134
tree "L2CTICTITRIGOUTSTATUS"
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
bitfld.long 0 0.--7. " TRIGOUTSTATUS "  " "
tree.end

base sd:0xb7a0c138
tree "L2CTICTICHINSTATUS"
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  " "
tree.end

base sd:0xb7a0c13c
tree "L2CTICTICHOUTSTATUS"
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  " "
tree.end

base sd:0xb7a0c140
tree "L2CTICTIGATE"
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
tree.end

base sd:0xb7a0c144
tree "L2CTIASICCTL"
group 0--3
line.long 0 "ASICCTL"
bitfld.long 0 0.--7. " ASICCTL "  " "
tree.end

base sd:0xb7a0cedc
tree "L2CTIITCHINACK"
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  " "
tree.end

base sd:0xb7a0cee0
tree "L2CTIITTRIGINACK"
wgroup 0--3
line.long 0 "ITTRIGINACK"
bitfld.long 0 0.--7. " CTTRIGINACK "  " "
tree.end

base sd:0xb7a0cee4
tree "L2CTIITCHOUT"
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  " "
tree.end

base sd:0xb7a0cee8
tree "L2CTIITTRFLIN"
wgroup 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0.--7. " CTTRIGOUT "  " "
tree.end

base sd:0xb7a0ceec
tree "L2CTIITCHOUTACK"
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  " "
tree.end

base sd:0xb7a0cef0
tree "L2CTIITTRIGOUTACK"
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
bitfld.long 0 0.--7. " CTTRIGOUTACK "  " "
tree.end

base sd:0xb7a0cef4
tree "L2CTIITCHIN"
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  " "
tree.end

base sd:0xb7a0cef8
tree "L2CTIITRIGIN"
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
tree.end

base sd:0xb7a0cfa0
tree "L2CTICTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  " "
tree.end

base sd:0xb7a0cfa4
tree "L2CTICTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  " "
tree.end

base sd:0xb7a0cfb0
tree "L2CTILAR"
wgroup 0--3
line.long 0 "LAR"
bitfld.long 0 0.--31. " LAR "  " "
tree.end

base sd:0xb7a0cfb4
tree "L2CTILSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  " "
tree.end

base sd:0xb7a0cfb8
tree "L2CTIASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  " "
tree.end

base sd:0xb7a0cfc8
tree "L2CTIDID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
tree.end

base sd:0xb7a0cfcc
tree "L2CTIDTIR"
rgroup 0--3
line.long 0 "DTIR"
bitfld.long 0 0.--7. " DTIR "  " "
tree.end

base sd:0xb7a0cfd0
tree "L2CTIPERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0.--7. " PERIPHERAL_ID4 "  " "
tree.end

base sd:0xb7a0cfd4
tree "L2CTIPERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
tree.end

base sd:0xb7a0cfd8
tree "L2CTIPERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
tree.end

base sd:0xb7a0cfdc
tree "L2CTIPERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
tree.end

base sd:0xb7a0cfe0
tree "L2CTIPERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0.--7. " PERIPHERAL_ID0 "  " "
tree.end

base sd:0xb7a0cfe4
tree "L2CTIPERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0.--7. " PERIPHERAL_ID1 "  " "
tree.end

base sd:0xb7a0cfe8
tree "L2CTIPERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0.--7. " PERIPHERAL_ID2 "  " "
tree.end

base sd:0xb7a0cfec
tree "L2CTIPERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0.--7. " PERIPHERAL_ID3 "  " "
tree.end

base sd:0xb7a0cff0
tree "L2CTICOMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
tree.end

base sd:0xb7a0cff4
tree "L2CTICOMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0.--7. " COMPONENT_ID1 "  " "
tree.end

base sd:0xb7a0cff8
tree "L2CTICOMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0.--7. " COMPONENT_ID2 "  " "
tree.end

base sd:0xb7a0cffc
tree "L2CTICOMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0.--7. " COMPONENT_ID3 "  " "
tree.end

tree.end

base sd:0xb7a0d000
;********************************************
tree "MSSCTI-MSS"
;********************************************
base sd:0xb7a0d000
tree "MSSCTICONTROL"
group 0--3
line.long 0 "CTICONTROL"
bitfld.long 0 0. " GLBEN "  "0 ,1 "
tree.end

base sd:0xb7a0d010
tree "MSSCTIINTACK"
wgroup 0--3
line.long 0 "CTIINTACK"
bitfld.long 0 0.--7. " INTACK "  " "
tree.end

base sd:0xb7a0d014
tree "MSSCTIAPPSET"
group 0--3
line.long 0 "CTIAPPSET"
bitfld.long 0 0.--3. " APPSET "  " "
tree.end

base sd:0xb7a0d018
tree "MSSCTIAPPCLEAR"
wgroup 0--3
line.long 0 "CTIAPPCLEAR"
bitfld.long 0 0.--3. " APPCLEAR "  " "
tree.end

base sd:0xb7a0d01c
tree "MSSCTIAPPPULSE"
wgroup 0--3
line.long 0 "CTIAPPPULSE"
bitfld.long 0 0.--3. " APPPULSE "  " "
tree.end

base sd:0xb7a0d020
tree "MSSCTIINEN0"
group 0--3
line.long 0 "CTIINEN0"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0d024
tree "MSSCTIINEN1"
group 0--3
line.long 0 "CTIINEN1"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0d028
tree "MSSCTIINEN2"
group 0--3
line.long 0 "CTIINEN2"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0d02c
tree "MSSCTIINEN3"
group 0--3
line.long 0 "CTIINEN3"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0d030
tree "MSSCTIINEN4"
group 0--3
line.long 0 "CTIINEN4"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0d034
tree "MSSCTIINEN5"
group 0--3
line.long 0 "CTIINEN5"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0d038
tree "MSSCTIINEN6"
group 0--3
line.long 0 "CTIINEN6"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0d03c
tree "MSSCTIINEN7"
group 0--3
line.long 0 "CTIINEN7"
bitfld.long 0 0.--3. " TRIGINEN "  " "
tree.end

base sd:0xb7a0d0a0
tree "MSSCTIOUTEN0"
group 0--3
line.long 0 "CTIOUTEN0"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0d0a4
tree "MSSCTIOUTEN1"
group 0--3
line.long 0 "CTIOUTEN1"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0d0a8
tree "MSSCTIOUTEN2"
group 0--3
line.long 0 "CTIOUTEN2"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0d0ac
tree "MSSCTIOUTEN3"
group 0--3
line.long 0 "CTIOUTEN3"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0d0b0
tree "MSSCTIOUTEN4"
group 0--3
line.long 0 "CTIOUTEN4"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0d0b4
tree "MSSCTIOUTEN5"
group 0--3
line.long 0 "CTIOUTEN5"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0d0b8
tree "MSSCTIOUTEN6"
group 0--3
line.long 0 "CTIOUTEN6"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0d0bc
tree "MSSCTIOUTEN7"
group 0--3
line.long 0 "CTIOUTEN7"
bitfld.long 0 0.--3. " TRIGOUTEN "  " "
tree.end

base sd:0xb7a0d130
tree "MSSCTITRIGINSTATUS"
rgroup 0--3
line.long 0 "CTITRIGINSTATUS"
bitfld.long 0 0.--7. " TRIGINSTATUS "  " "
tree.end

base sd:0xb7a0d134
tree "MSSCTITRIGOUTSTATUS"
rgroup 0--3
line.long 0 "CTITRIGOUTSTATUS"
bitfld.long 0 0.--7. " TRIGOUTSTATUS "  " "
tree.end

base sd:0xb7a0d138
tree "MSSCTICHINSTATUS"
rgroup 0--3
line.long 0 "CTICHINSTATUS"
bitfld.long 0 0.--3. " CTCHINSTATUS "  " "
tree.end

base sd:0xb7a0d13c
tree "MSSCTICHOUTSTATUS"
rgroup 0--3
line.long 0 "CTICHOUTSTATUS"
bitfld.long 0 0.--3. " CTCHOUTSTATUS "  " "
tree.end

base sd:0xb7a0d140
tree "MSSCTIGATE"
group 0--3
line.long 0 "CTIGATE"
bitfld.long 0 0. " CTIGATEEN0 "  "0 ,1 "
bitfld.long 0 1. " CTIGATEEN1 "  "0 ,1 "
bitfld.long 0 2. " CTIGATEEN2 "  "0 ,1 "
bitfld.long 0 3. " CTIGATEEN3 "  "0 ,1 "
tree.end

base sd:0xb7a0d144
tree "MSSASICCTL"
group 0--3
line.long 0 "ASICCTL"
bitfld.long 0 0.--7. " ASICCTL "  " "
tree.end

base sd:0xb7a0dedc
tree "MSSITCHINACK"
wgroup 0--3
line.long 0 "ITCHINACK"
bitfld.long 0 0.--3. " CTCHINACK "  " "
tree.end

base sd:0xb7a0dee0
tree "MSSITTRIGINACK"
wgroup 0--3
line.long 0 "ITTRIGINACK"
bitfld.long 0 0.--7. " CTTRIGINACK "  " "
tree.end

base sd:0xb7a0dee4
tree "MSSITCHOUT"
wgroup 0--3
line.long 0 "ITCHOUT"
bitfld.long 0 0.--3. " CTCHOUT "  " "
tree.end

base sd:0xb7a0dee8
tree "MSSITTRFLIN"
wgroup 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0.--7. " CTTRIGOUT "  " "
tree.end

base sd:0xb7a0deec
tree "MSSITCHOUTACK"
rgroup 0--3
line.long 0 "ITCHOUTACK"
bitfld.long 0 0.--3. " CTCHOUTACK "  " "
tree.end

base sd:0xb7a0def0
tree "MSSITTRIGOUTACK"
rgroup 0--3
line.long 0 "ITTRIGOUTACK"
bitfld.long 0 0.--7. " CTTRIGOUTACK "  " "
tree.end

base sd:0xb7a0def4
tree "MSSITCHIN"
rgroup 0--3
line.long 0 "ITCHIN"
bitfld.long 0 0.--3. " CTCHIN "  " "
tree.end

base sd:0xb7a0def8
tree "MSSITRIGIN"
rgroup 0--3
line.long 0 "ITRIGIN"
bitfld.long 0 0. " CTTRIGIN "  "0 ,1 "
tree.end

base sd:0xb7a0dfa0
tree "MSSCTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  " "
tree.end

base sd:0xb7a0dfa4
tree "MSSCTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  " "
tree.end

base sd:0xb7a0dfb0
tree "MSSLAR"
wgroup 0--3
line.long 0 "LAR"
bitfld.long 0 0.--31. " LAR "  " "
tree.end

base sd:0xb7a0dfb4
tree "MSSLSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  " "
tree.end

base sd:0xb7a0dfb8
tree "MSSASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--3. " ASR "  " "
tree.end

base sd:0xb7a0dfc8
tree "MSSDID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--19. " DID "  " "
tree.end

base sd:0xb7a0dfcc
tree "MSSDTIR"
rgroup 0--3
line.long 0 "DTIR"
bitfld.long 0 0.--7. " DTIR "  " "
tree.end

base sd:0xb7a0dfd0
tree "MSSPERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0.--7. " PERIPHERAL_ID4 "  " "
tree.end

base sd:0xb7a0dfd4
tree "MSSPERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0. " PERIPHERAL_ID5 "  "0 ,1 "
tree.end

base sd:0xb7a0dfd8
tree "MSSPERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0. " PERIPHERAL_ID6 "  "0 ,1 "
tree.end

base sd:0xb7a0dfdc
tree "MSSPERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0. " PERIPHERAL_ID7 "  "0 ,1 "
tree.end

base sd:0xb7a0dfe0
tree "MSSPERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0.--7. " PERIPHERAL_ID0 "  " "
tree.end

base sd:0xb7a0dfe4
tree "MSSPERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0.--7. " PERIPHERAL_ID1 "  " "
tree.end

base sd:0xb7a0dfe8
tree "MSSPERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0.--7. " PERIPHERAL_ID2 "  " "
tree.end

base sd:0xb7a0dfec
tree "MSSPERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0.--7. " PERIPHERAL_ID3 "  " "
tree.end

base sd:0xb7a0dff0
tree "MSSCOMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0. " COMPONENT_ID0 "  "0 ,1 "
tree.end

base sd:0xb7a0dff4
tree "MSSCOMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0.--7. " COMPONENT_ID1 "  " "
tree.end

base sd:0xb7a0dff8
tree "MSSCOMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0.--7. " COMPONENT_ID2 "  " "
tree.end

base sd:0xb7a0dffc
tree "MSSCOMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0.--7. " COMPONENT_ID3 "  " "
tree.end

;tree.end

tree.end

;==============================================================
tree "MSSETB11"
;==============================================================
base sd:0xb7a01004
tree "RAM_DEPTH"
rgroup 0--3
line.long 0 "RAM_DEPTH"
bitfld.long 0 0.--31. " RDP "  " "
tree.end

base sd:0xb7a0100c
tree "STATUS"
rgroup 0--3
line.long 0 "STATUS"
bitfld.long 0 0. " FULL "  "0 ,1 "
bitfld.long 0 1. " TRIGGERED "  "0 ,1 "
bitfld.long 0 2. " ACQCOMP "  "0 ,1 "
bitfld.long 0 3. " FTEMPTY "  "0 ,1 "
tree.end

base sd:0xb7a01010
tree "RAM_DATA"
group 0--3
line.long 0 "RAM_DATA"
bitfld.long 0 0.--31. " RAM_READ_DATA "  " "
tree.end

base sd:0xb7a01014
tree "RAM_READ_POINTER"
group 0--3
line.long 0 "RAM_READ_POINTER"
bitfld.long 0 0.--1. " RAM_READ_POINTER "  " "
tree.end

base sd:0xb7a01018
tree "RAM_WRITE_POINTER"
group 0--3
line.long 0 "RAM_WRITE_POINTER"
bitfld.long 0 0.--1. " RAM_WRITE_POINTER "  " "
tree.end

base sd:0xb7a0101c
tree "TRIGGER_COUNTER"
group 0--3
line.long 0 "TRIGGER_COUNTER"
bitfld.long 0 0.--1. " TRIGGER_COUNTER "  " "
tree.end

base sd:0xb7a01020
tree "CONTROL"
group 0--3
line.long 0 "CONTROL"
bitfld.long 0 0. " TRACECAPTEN "  "0 ,1 "
tree.end

base sd:0xb7a01024
tree "RAM_WRITE"
wgroup 0--3
line.long 0 "RAM_WRITE"
bitfld.long 0 0.--31. " RAM_WRITE_DATA "  " "
tree.end

base sd:0xb7a01300
tree "FFSR"
rgroup 0--3
line.long 0 "FFSR"
bitfld.long 0 0. " FLINPROG "  "0 ,1 "
bitfld.long 0 1. " FTSTOPPED "  "0 ,1 "
tree.end

base sd:0xb7a01304
tree "DESCRIPTION"
group 0--3
line.long 0 "DESCRIPTION"
bitfld.long 0 0. " ENFTC "  "0 ,1 "
bitfld.long 0 1. " ENFCONT "  "0 ,1 "
bitfld.long 0 4. " FONFLIN "  "0 ,1 "
bitfld.long 0 5. " FONTRIG "  "0 ,1 "
bitfld.long 0 6. " FONMAN "  "0 ,1 "
bitfld.long 0 8. " TRIGIN "  "0 ,1 "
bitfld.long 0 9. " TRIGEVT "  "0 ,1 "
bitfld.long 0 10. " TRGFL "  "0 ,1 "
bitfld.long 0 12. " STOPFL "  "0 ,1 "
bitfld.long 0 13. " STOPTRIG "  "0 ,1 "
tree.end

base sd:0xb7a01ee0
tree "ITMISCOP0"
group 0--3
line.long 0 "ITMISCOP0"
bitfld.long 0 0. " ACQCOMP "  "0 ,1 "
bitfld.long 0 1. " FULL "  "0 ,1 "
tree.end

base sd:0xb7a01ee4
tree "ITTRFLINACK"
group 0--3
line.long 0 "ITTRFLINACK"
bitfld.long 0 0. " TRIGNACK "  "0 ,1 "
bitfld.long 0 1. " FLUSHINACK "  "0 ,1 "
tree.end

base sd:0xb7a01ee8
tree "ITTRFLIN"
group 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0. " TRIGIN "  "0 ,1 "
bitfld.long 0 1. " FLUSHIN "  "0 ,1 "
tree.end

base sd:0xb7a01eec
tree "ITATBDATA0"
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ATDATA0 "  "0 ,1 "
bitfld.long 0 1. " ATDATA7 "  "0 ,1 "
bitfld.long 0 2. " ATDATA15 "  "0 ,1 "
bitfld.long 0 3. " ATDATA23 "  "0 ,1 "
bitfld.long 0 4. " ATDATA31 "  "0 ,1 "
tree.end

base sd:0xb7a01ef0
tree "ITATBCTR2"
group 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ATREADYS "  "0 ,1 "
bitfld.long 0 1. " AFVALIDS "  "0 ,1 "
tree.end

base sd:0xb7a01ef4
tree "ITATBCTR1"
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0.--6. " ATID "  " "
tree.end

base sd:0xb7a01ef8
tree "ITATBCTR0"
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ATVALID "  "0 ,1 "
bitfld.long 0 1. " AFREADY "  "0 ,1 "
bitfld.long 0 8.--9. " ATBYTES "  " "
tree.end

base sd:0xb7a01f00
tree "IMCR"
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " IMCR "  "0 ,1 "
tree.end

base sd:0xb7a01fa0
tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0. " CTSR "  "0 ,1 "
tree.end

base sd:0xb7a01fa4
tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0. " CTCR "  "0 ,1 "
tree.end

base sd:0xb7a01fb0
tree "LAR"
wgroup 0--3
line.long 0 "LAR"
bitfld.long 0 0.--31. " LAR "  " "
tree.end

base sd:0xb7a01fb4
tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  " "
tree.end

base sd:0xb7a01fb8
tree "ASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--7. " ASR "  " "
tree.end

base sd:0xb7a01fc8
tree "DID"
rgroup 0--3
line.long 0 "DID"
bitfld.long 0 0.--31. " DID "  " "
tree.end

base sd:0xb7a01fcc
tree "DTIR"
rgroup 0--3
line.long 0 "DTIR"
bitfld.long 0 0.--7. " DTIR "  " "
tree.end

base sd:0xb7a01fd0
tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0.--7. " PERIPHERAL_ID4 "  " "
tree.end

base sd:0xb7a01fd4
tree "PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0.--7. " PERIPHERAL_ID5 "  " "
tree.end

base sd:0xb7a01fd8
tree "PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0.--7. " PERIPHERAL_ID6 "  " "
tree.end

base sd:0xb7a01fdc
tree "PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0.--7. " PERIPHERAL_ID7 "  " "
tree.end

base sd:0xb7a01fe0
tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0.--7. " PERIPHERAL_ID0 "  " "
tree.end

base sd:0xb7a01fe4
tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0.--7. " PERIPHERAL_ID1 "  " "
tree.end

base sd:0xb7a01fe8
tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0.--7. " PERIPHERAL_ID2 "  " "
tree.end

base sd:0xb7a01fec
tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0.--7. " PERIPHERAL_ID3 "  " "
tree.end

base sd:0xb7a01ff0
tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0.--7. " COMPONENT_ID0 "  " "
tree.end

base sd:0xb7a01ff4
tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0.--7. " COMPONENT_ID1 "  " "
tree.end

base sd:0xb7a01ff8
tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0.--7. " COMPONENT_ID2 "  " "
tree.end

base sd:0xb7a01ffc
tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0.--7. " COMPONENT_ID3 "  " "
tree.end

tree.end

;==============================================================
;tree "MSSETM11CS (2 instances)"
;==============================================================
base sd:0xb7a08000
;********************************************
tree "MSSETM11CS-1"
;********************************************
base sd:0xb7a08000
tree "1ETMCR"
group 0--3
line.long 0 "ETMCR"
bitfld.long 0 0. " ETMCR "  "0 ,1 "
tree.end

base sd:0xb7a08004
tree "1ETMCCR"
rgroup 0--3
line.long 0 "ETMCCR"
bitfld.long 0 0. " ETMCCR "  "0 ,1 "
tree.end

base sd:0xb7a08008
tree "1ETMTRIGGER"
wgroup 0--3
line.long 0 "ETMTRIGGER"
bitfld.long 0 0. " ETMTRIGGER "  "0 ,1 "
tree.end

base sd:0xb7a0800c
tree "1ETMASICCTLR"
wgroup 0--3
line.long 0 "ETMASICCTLR"
bitfld.long 0 0. " ETMASICCTLR "  "0 ,1 "
tree.end

base sd:0xb7a08010
tree "1ETMSR"
group 0--3
line.long 0 "ETMSR"
bitfld.long 0 0. " STATUS "  "0 ,1 "
tree.end

base sd:0xb7a08014
tree "1SYSCONFIG"
group 0--3
line.long 0 "SYSCONFIG"
bitfld.long 0 0. " SYSCONFIG "  "0 ,1 "
tree.end

base sd:0xb7a08018
tree "1TRACEENSTARTSTOP"
wgroup 0--3
line.long 0 "TRACEENSTARTSTOP"
bitfld.long 0 0. " TRACEENSTARTSTOP "  "0 ,1 "
tree.end

base sd:0xb7a0801c
tree "1TRACEENCTRL2"
wgroup 0--3
line.long 0 "TRACEENCTRL2"
bitfld.long 0 0. " TRACEENCTRL2 "  "0 ,1 "
tree.end

base sd:0xb7a08020
tree "1TRACEENEVENT"
wgroup 0--3
line.long 0 "TRACEENEVENT"
bitfld.long 0 0. " TRACEENEVENT "  "0 ,1 "
tree.end

base sd:0xb7a08024
tree "1TRACEENCTRL1"
wgroup 0--3
line.long 0 "TRACEENCTRL1"
bitfld.long 0 0. " TRACEENCTRL1 "  "0 ,1 "
tree.end

base sd:0xb7a08028
tree "1FIFOFULLREGION"
wgroup 0--3
line.long 0 "FIFOFULLREGION"
bitfld.long 0 0. " FIFOFULLREGION "  "0 ,1 "
tree.end

base sd:0xb7a0802c
tree "1FIFOFULLLEVEL"
group 0--3
line.long 0 "FIFOFULLLEVEL"
bitfld.long 0 0. " FIFOFULLLEVEL "  "0 ,1 "
tree.end

base sd:0xb7a08030
tree "1VIEWDATAEVENT"
wgroup 0--3
line.long 0 "VIEWDATAEVENT"
bitfld.long 0 0. " VIEWDATAEVENT "  "0 ,1 "
tree.end

base sd:0xb7a08034
tree "1VIEWDATACTRL1"
wgroup 0--3
line.long 0 "VIEWDATACTRL1"
bitfld.long 0 0. " VIEWDATACTRL1 "  "0 ,1 "
tree.end

base sd:0xb7a08038
tree "1VIEWDATACTRL2"
wgroup 0--3
line.long 0 "VIEWDATACTRL2"
bitfld.long 0 0. " VIEWDATACTRL2 "  "0 ,1 "
tree.end

base sd:0xb7a0803c
tree "1VIEWDATACTRL3"
wgroup 0--3
line.long 0 "VIEWDATACTRL3"
bitfld.long 0 0. " VIEWDATACTRL3 "  "0 ,1 "
tree.end

base sd:0xb7a08040
tree "1ADDRCOMP0"
wgroup 0--3
line.long 0 "ADDRCOMP0"
bitfld.long 0 0. " ADDRCOMP0 "  "0 ,1 "
tree.end

base sd:0xb7a08044
tree "1ADDRCOMP1"
wgroup 0--3
line.long 0 "ADDRCOMP1"
bitfld.long 0 0. " ADDRCOMP1 "  "0 ,1 "
tree.end

base sd:0xb7a08048
tree "1ADDRCOMP2"
wgroup 0--3
line.long 0 "ADDRCOMP2"
bitfld.long 0 0. " ADDRCOMP2 "  "0 ,1 "
tree.end

base sd:0xb7a0804c
tree "1ADDRCOMP3"
wgroup 0--3
line.long 0 "ADDRCOMP3"
bitfld.long 0 0. " ADDRCOMP3 "  "0 ,1 "
tree.end

base sd:0xb7a08050
tree "1ADDRCOMP4"
wgroup 0--3
line.long 0 "ADDRCOMP4"
bitfld.long 0 0. " ADDRCOMP4 "  "0 ,1 "
tree.end

base sd:0xb7a08054
tree "1ADDRCOMP5"
wgroup 0--3
line.long 0 "ADDRCOMP5"
bitfld.long 0 0. " ADDRCOMP5 "  "0 ,1 "
tree.end

base sd:0xb7a08058
tree "1ADDRCOMP6"
wgroup 0--3
line.long 0 "ADDRCOMP6"
bitfld.long 0 0. " ADDRCOMP6 "  "0 ,1 "
tree.end

base sd:0xb7a0805c
tree "1ADDRCOMP7"
wgroup 0--3
line.long 0 "ADDRCOMP7"
bitfld.long 0 0. " ADDRCOMP7 "  "0 ,1 "
tree.end

base sd:0xb7a08080
tree "1ADDRACCTYPE0"
wgroup 0--3
line.long 0 "ADDRACCTYPE0"
bitfld.long 0 0. " ADDRACCTYPE0 "  "0 ,1 "
tree.end

base sd:0xb7a08084
tree "1ADDRACCTYPE1"
wgroup 0--3
line.long 0 "ADDRACCTYPE1"
bitfld.long 0 0. " ADDRACCTYPE1 "  "0 ,1 "
tree.end

base sd:0xb7a08088
tree "1ADDRACCTYPE2"
wgroup 0--3
line.long 0 "ADDRACCTYPE2"
bitfld.long 0 0. " ADDRACCTYPE2 "  "0 ,1 "
tree.end

base sd:0xb7a0808c
tree "1ADDRACCTYPE3"
wgroup 0--3
line.long 0 "ADDRACCTYPE3"
bitfld.long 0 0. " ADDRACCTYPE3 "  "0 ,1 "
tree.end

base sd:0xb7a08090
tree "1ADDRACCTYPE4"
wgroup 0--3
line.long 0 "ADDRACCTYPE4"
bitfld.long 0 0. " ADDRACCTYPE4 "  "0 ,1 "
tree.end

base sd:0xb7a08094
tree "1ADDRACCTYPE5"
wgroup 0--3
line.long 0 "ADDRACCTYPE5"
bitfld.long 0 0. " ADDRACCTYPE5 "  "0 ,1 "
tree.end

base sd:0xb7a08098
tree "1ADDRACCTYPE6"
wgroup 0--3
line.long 0 "ADDRACCTYPE6"
bitfld.long 0 0. " ADDRACCTYPE6 "  "0 ,1 "
tree.end

base sd:0xb7a0809c
tree "1ADDRACCTYPE7"
wgroup 0--3
line.long 0 "ADDRACCTYPE7"
bitfld.long 0 0. " ADDRACCTYPE7 "  "0 ,1 "
tree.end

base sd:0xb7a080c0
tree "1DATACOMP0"
wgroup 0--3
line.long 0 "DATACOMP0"
bitfld.long 0 0. " DATACOMP0 "  "0 ,1 "
tree.end

base sd:0xb7a080c8
tree "1DATACOMP1"
wgroup 0--3
line.long 0 "DATACOMP1"
bitfld.long 0 0. " DATACOMP1 "  "0 ,1 "
tree.end

base sd:0xb7a08100
tree "1DATAMASK0"
wgroup 0--3
line.long 0 "DATAMASK0"
bitfld.long 0 0. " DATAMASK0 "  "0 ,1 "
tree.end

base sd:0xb7a08108
tree "1DATAMASK1"
wgroup 0--3
line.long 0 "DATAMASK1"
bitfld.long 0 0. " DATAMASK1 "  "0 ,1 "
tree.end

base sd:0xb7a08140
tree "1COUNTRELOADVAL0"
wgroup 0--3
line.long 0 "COUNTRELOADVAL0"
bitfld.long 0 0. " COUNTRELOADVAL0 "  "0 ,1 "
tree.end

base sd:0xb7a08144
tree "1COUNTRELOADVAL1"
wgroup 0--3
line.long 0 "COUNTRELOADVAL1"
bitfld.long 0 0. " COUNTRELOADVAL1 "  "0 ,1 "
tree.end

base sd:0xb7a08150
tree "1COUNTEN0"
wgroup 0--3
line.long 0 "COUNTEN0"
bitfld.long 0 0. " COUNTEN0 "  "0 ,1 "
tree.end

base sd:0xb7a08154
tree "1COUNTEN1"
wgroup 0--3
line.long 0 "COUNTEN1"
bitfld.long 0 0. " COUNTEN1 "  "0 ,1 "
tree.end

base sd:0xb7a08160
tree "1COUNTRELOADEV0"
wgroup 0--3
line.long 0 "COUNTRELOADEV0"
bitfld.long 0 0. " COUNTRELOADEV0 "  "0 ,1 "
tree.end

base sd:0xb7a08164
tree "1COUNTRELOADEV1"
wgroup 0--3
line.long 0 "COUNTRELOADEV1"
bitfld.long 0 0. " COUNTRELOADEV1 "  "0 ,1 "
tree.end

base sd:0xb7a08170
tree "1COUNTVALUE0"
group 0--3
line.long 0 "COUNTVALUE0"
bitfld.long 0 0. " COUNTVALUE0 "  "0 ,1 "
tree.end

base sd:0xb7a08174
tree "1COUNTVALUE1"
group 0--3
line.long 0 "COUNTVALUE1"
bitfld.long 0 0. " COUNTVALUE1 "  "0 ,1 "
tree.end

base sd:0xb7a08180
tree "1SEQCTRL0"
wgroup 0--3
line.long 0 "SEQCTRL0"
bitfld.long 0 0. " SEQCTRL0 "  "0 ,1 "
tree.end

base sd:0xb7a08184
tree "1SEQCTRL1"
wgroup 0--3
line.long 0 "SEQCTRL1"
bitfld.long 0 0. " SEQCTRL1 "  "0 ,1 "
tree.end

base sd:0xb7a08188
tree "1SEQCTRL2"
wgroup 0--3
line.long 0 "SEQCTRL2"
bitfld.long 0 0. " SEQCTRL2 "  "0 ,1 "
tree.end

base sd:0xb7a0818c
tree "1SEQCTRL3"
wgroup 0--3
line.long 0 "SEQCTRL3"
bitfld.long 0 0. " SEQCTRL3 "  "0 ,1 "
tree.end

base sd:0xb7a08190
tree "1SEQCTRL4"
wgroup 0--3
line.long 0 "SEQCTRL4"
bitfld.long 0 0. " SEQCTRL4 "  "0 ,1 "
tree.end

base sd:0xb7a08194
tree "1SEQCTRL5"
wgroup 0--3
line.long 0 "SEQCTRL5"
bitfld.long 0 0. " SEQCTRL5 "  "0 ,1 "
tree.end

base sd:0xb7a0819c
tree "1SEQSTATE"
group 0--3
line.long 0 "SEQSTATE"
bitfld.long 0 0. " SEQSTATE "  "0 ,1 "
tree.end

base sd:0xb7a081a0
tree "1EXTOUTPUT0"
wgroup 0--3
line.long 0 "EXTOUTPUT0"
bitfld.long 0 0. " EXTOUTPUT0 "  "0 ,1 "
tree.end

base sd:0xb7a081a4
tree "1EXTOUTPUT1"
wgroup 0--3
line.long 0 "EXTOUTPUT1"
bitfld.long 0 0. " EXTOUTPUT1 "  "0 ,1 "
tree.end

base sd:0xb7a081b0
tree "1CONTEXTIDCOMP"
wgroup 0--3
line.long 0 "CONTEXTIDCOMP"
bitfld.long 0 0. " CONTEXTIDCOMP "  "0 ,1 "
tree.end

base sd:0xb7a081bc
tree "1CONTEXTIDMASK"
wgroup 0--3
line.long 0 "CONTEXTIDMASK"
bitfld.long 0 0. " CONTEXTIDMASK "  "0 ,1 "
tree.end

base sd:0xb7a081c0
tree "1IMPSPECIFIC0"
wgroup 0--3
line.long 0 "IMPSPECIFIC0"
bitfld.long 0 0. " IMPSPECIFIC0 "  "0 ,1 "
tree.end

base sd:0xb7a081c4
tree "1IMPSPECIFIC1"
wgroup 0--3
line.long 0 "IMPSPECIFIC1"
bitfld.long 0 0. " IMPSPECIFIC1 "  "0 ,1 "
tree.end

base sd:0xb7a081c8
tree "1IMPSPECIFIC2"
wgroup 0--3
line.long 0 "IMPSPECIFIC2"
bitfld.long 0 0. " IMPSPECIFIC2 "  "0 ,1 "
tree.end

base sd:0xb7a081cc
tree "1IMPSPECIFIC3"
wgroup 0--3
line.long 0 "IMPSPECIFIC3"
bitfld.long 0 0. " IMPSPECIFIC3 "  "0 ,1 "
tree.end

base sd:0xb7a081d0
tree "1IMPSPECIFIC4"
wgroup 0--3
line.long 0 "IMPSPECIFIC4"
bitfld.long 0 0. " IMPSPECIFIC4 "  "0 ,1 "
tree.end

base sd:0xb7a081d4
tree "1IMPSPECIFIC5"
wgroup 0--3
line.long 0 "IMPSPECIFIC5"
bitfld.long 0 0. " IMPSPECIFIC5 "  "0 ,1 "
tree.end

base sd:0xb7a081d8
tree "1IMPSPECIFIC6"
wgroup 0--3
line.long 0 "IMPSPECIFIC6"
bitfld.long 0 0. " IMPSPECIFIC6 "  "0 ,1 "
tree.end

base sd:0xb7a081dc
tree "1IMPSPECIFIC7"
wgroup 0--3
line.long 0 "IMPSPECIFIC7"
bitfld.long 0 0. " IMPSPECIFIC7 "  "0 ,1 "
tree.end

base sd:0xb7a081e0
tree "1SYNCHFREQ"
wgroup 0--3
line.long 0 "SYNCHFREQ"
bitfld.long 0 0. " SYNCHFREQ "  "0 ,1 "
tree.end

base sd:0xb7a081e4
tree "1ETMID"
group 0--3
line.long 0 "ETMID"
bitfld.long 0 0. " ETMID "  "0 ,1 "
tree.end

base sd:0xb7a081e8
tree "1CONFIGCODEEXT"
group 0--3
line.long 0 "CONFIGCODEEXT"
bitfld.long 0 0. " CONFIGCODEEXT "  "0 ,1 "
tree.end

base sd:0xb7a081ec
tree "1EXTERNALINEXT"
wgroup 0--3
line.long 0 "EXTERNALINEXT"
bitfld.long 0 0. " EXTERNALINEXT "  "0 ,1 "
tree.end

base sd:0xb7a08200
tree "1CSTRACEID"
wgroup 0--3
line.long 0 "CSTRACEID"
bitfld.long 0 0. " CSTRACEID "  "0 ,1 "
tree.end

base sd:0xb7a08fa0
tree "1CLAIMTAGSET"
group 0--3
line.long 0 "CLAIMTAGSET"
bitfld.long 0 0. " CLAIMTAGSET "  "0 ,1 "
tree.end

base sd:0xb7a08fa4
tree "1CLAIMTAGCLR"
group 0--3
line.long 0 "CLAIMTAGCLR"
bitfld.long 0 0. " CLAIMTAGCLR "  "0 ,1 "
tree.end

base sd:0xb7a08fb0
tree "1LAR"
wgroup 0--3
line.long 0 "LAR"
bitfld.long 0 0.--31. " LAR "  " "
tree.end

base sd:0xb7a08fb4
tree "1LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  " "
tree.end

base sd:0xb7a08fb8
tree "1ASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--7. " ASR "  " "
tree.end

base sd:0xb7a08fcc
tree "1CSDEVICETYPE"
rgroup 0--3
line.long 0 "CSDEVICETYPE"
bitfld.long 0 0. " CSDEVICETYPE "  "0 ,1 "
tree.end

base sd:0xb7a08fd0
tree "1PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0.--7. " PERIPHERAL_ID4 "  " "
tree.end

base sd:0xb7a08fd4
tree "1PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0.--7. " PERIPHERAL_ID5 "  " "
tree.end

base sd:0xb7a08fd8
tree "1PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0.--7. " PERIPHERAL_ID6 "  " "
tree.end

base sd:0xb7a08fdc
tree "1PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0.--7. " PERIPHERAL_ID7 "  " "
tree.end

base sd:0xb7a08fe0
tree "1PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0.--7. " PERIPHERAL_ID0 "  " "
tree.end

base sd:0xb7a08fe4
tree "1PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0.--7. " PERIPHERAL_ID1 "  " "
tree.end

base sd:0xb7a08fe8
tree "1PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0.--7. " PERIPHERAL_ID2 "  " "
tree.end

base sd:0xb7a08fec
tree "1PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0.--7. " PERIPHERAL_ID3 "  " "
tree.end

base sd:0xb7a08ff0
tree "1COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0.--7. " COMPONENT_ID0 "  " "
tree.end

base sd:0xb7a08ff4
tree "1COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0.--7. " COMPONENT_ID1 "  " "
tree.end

base sd:0xb7a08ff8
tree "1COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0.--7. " COMPONENT_ID2 "  " "
tree.end

base sd:0xb7a08ffc
tree "1COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0.--7. " COMPONENT_ID3 "  " "
tree.end

tree.end

base sd:0xb7a0b000
;********************************************
tree "MSSETM11CS-2"
;********************************************
base sd:0xb7a0b000
tree "2ETMCR"
group 0--3
line.long 0 "ETMCR"
bitfld.long 0 0. " ETMCR "  "0 ,1 "
tree.end

base sd:0xb7a0b004
tree "2ETMCCR"
rgroup 0--3
line.long 0 "ETMCCR"
bitfld.long 0 0. " ETMCCR "  "0 ,1 "
tree.end

base sd:0xb7a0b008
tree "2ETMTRIGGER"
wgroup 0--3
line.long 0 "ETMTRIGGER"
bitfld.long 0 0. " ETMTRIGGER "  "0 ,1 "
tree.end

base sd:0xb7a0b00c
tree "2ETMASICCTLR"
wgroup 0--3
line.long 0 "ETMASICCTLR"
bitfld.long 0 0. " ETMASICCTLR "  "0 ,1 "
tree.end

base sd:0xb7a0b010
tree "2ETMSR"
group 0--3
line.long 0 "ETMSR"
bitfld.long 0 0. " STATUS "  "0 ,1 "
tree.end

base sd:0xb7a0b014
tree "2SYSCONFIG"
group 0--3
line.long 0 "SYSCONFIG"
bitfld.long 0 0. " SYSCONFIG "  "0 ,1 "
tree.end

base sd:0xb7a0b018
tree "2TRACEENSTARTSTOP"
wgroup 0--3
line.long 0 "TRACEENSTARTSTOP"
bitfld.long 0 0. " TRACEENSTARTSTOP "  "0 ,1 "
tree.end

base sd:0xb7a0b01c
tree "2TRACEENCTRL2"
wgroup 0--3
line.long 0 "TRACEENCTRL2"
bitfld.long 0 0. " TRACEENCTRL2 "  "0 ,1 "
tree.end

base sd:0xb7a0b020
tree "2TRACEENEVENT"
wgroup 0--3
line.long 0 "TRACEENEVENT"
bitfld.long 0 0. " TRACEENEVENT "  "0 ,1 "
tree.end

base sd:0xb7a0b024
tree "2TRACEENCTRL1"
wgroup 0--3
line.long 0 "TRACEENCTRL1"
bitfld.long 0 0. " TRACEENCTRL1 "  "0 ,1 "
tree.end

base sd:0xb7a0b028
tree "2FIFOFULLREGION"
wgroup 0--3
line.long 0 "FIFOFULLREGION"
bitfld.long 0 0. " FIFOFULLREGION "  "0 ,1 "
tree.end

base sd:0xb7a0b02c
tree "2FIFOFULLLEVEL"
group 0--3
line.long 0 "FIFOFULLLEVEL"
bitfld.long 0 0. " FIFOFULLLEVEL "  "0 ,1 "
tree.end

base sd:0xb7a0b030
tree "2VIEWDATAEVENT"
wgroup 0--3
line.long 0 "VIEWDATAEVENT"
bitfld.long 0 0. " VIEWDATAEVENT "  "0 ,1 "
tree.end

base sd:0xb7a0b034
tree "2VIEWDATACTRL1"
wgroup 0--3
line.long 0 "VIEWDATACTRL1"
bitfld.long 0 0. " VIEWDATACTRL1 "  "0 ,1 "
tree.end

base sd:0xb7a0b038
tree "2VIEWDATACTRL2"
wgroup 0--3
line.long 0 "VIEWDATACTRL2"
bitfld.long 0 0. " VIEWDATACTRL2 "  "0 ,1 "
tree.end

base sd:0xb7a0b03c
tree "2VIEWDATACTRL3"
wgroup 0--3
line.long 0 "VIEWDATACTRL3"
bitfld.long 0 0. " VIEWDATACTRL3 "  "0 ,1 "
tree.end

base sd:0xb7a0b040
tree "2ADDRCOMP0"
wgroup 0--3
line.long 0 "ADDRCOMP0"
bitfld.long 0 0. " ADDRCOMP0 "  "0 ,1 "
tree.end

base sd:0xb7a0b044
tree "2ADDRCOMP1"
wgroup 0--3
line.long 0 "ADDRCOMP1"
bitfld.long 0 0. " ADDRCOMP1 "  "0 ,1 "
tree.end

base sd:0xb7a0b048
tree "2ADDRCOMP2"
wgroup 0--3
line.long 0 "ADDRCOMP2"
bitfld.long 0 0. " ADDRCOMP2 "  "0 ,1 "
tree.end

base sd:0xb7a0b04c
tree "2ADDRCOMP3"
wgroup 0--3
line.long 0 "ADDRCOMP3"
bitfld.long 0 0. " ADDRCOMP3 "  "0 ,1 "
tree.end

base sd:0xb7a0b050
tree "2ADDRCOMP4"
wgroup 0--3
line.long 0 "ADDRCOMP4"
bitfld.long 0 0. " ADDRCOMP4 "  "0 ,1 "
tree.end

base sd:0xb7a0b054
tree "2ADDRCOMP5"
wgroup 0--3
line.long 0 "ADDRCOMP5"
bitfld.long 0 0. " ADDRCOMP5 "  "0 ,1 "
tree.end

base sd:0xb7a0b058
tree "2ADDRCOMP6"
wgroup 0--3
line.long 0 "ADDRCOMP6"
bitfld.long 0 0. " ADDRCOMP6 "  "0 ,1 "
tree.end

base sd:0xb7a0b05c
tree "2ADDRCOMP7"
wgroup 0--3
line.long 0 "ADDRCOMP7"
bitfld.long 0 0. " ADDRCOMP7 "  "0 ,1 "
tree.end

base sd:0xb7a0b080
tree "2ADDRACCTYPE0"
wgroup 0--3
line.long 0 "ADDRACCTYPE0"
bitfld.long 0 0. " ADDRACCTYPE0 "  "0 ,1 "
tree.end

base sd:0xb7a0b084
tree "2ADDRACCTYPE1"
wgroup 0--3
line.long 0 "ADDRACCTYPE1"
bitfld.long 0 0. " ADDRACCTYPE1 "  "0 ,1 "
tree.end

base sd:0xb7a0b088
tree "2ADDRACCTYPE2"
wgroup 0--3
line.long 0 "ADDRACCTYPE2"
bitfld.long 0 0. " ADDRACCTYPE2 "  "0 ,1 "
tree.end

base sd:0xb7a0b08c
tree "2ADDRACCTYPE3"
wgroup 0--3
line.long 0 "ADDRACCTYPE3"
bitfld.long 0 0. " ADDRACCTYPE3 "  "0 ,1 "
tree.end

base sd:0xb7a0b090
tree "2ADDRACCTYPE4"
wgroup 0--3
line.long 0 "ADDRACCTYPE4"
bitfld.long 0 0. " ADDRACCTYPE4 "  "0 ,1 "
tree.end

base sd:0xb7a0b094
tree "2ADDRACCTYPE5"
wgroup 0--3
line.long 0 "ADDRACCTYPE5"
bitfld.long 0 0. " ADDRACCTYPE5 "  "0 ,1 "
tree.end

base sd:0xb7a0b098
tree "2ADDRACCTYPE6"
wgroup 0--3
line.long 0 "ADDRACCTYPE6"
bitfld.long 0 0. " ADDRACCTYPE6 "  "0 ,1 "
tree.end

base sd:0xb7a0b09c
tree "2ADDRACCTYPE7"
wgroup 0--3
line.long 0 "ADDRACCTYPE7"
bitfld.long 0 0. " ADDRACCTYPE7 "  "0 ,1 "
tree.end

base sd:0xb7a0b0c0
tree "2DATACOMP0"
wgroup 0--3
line.long 0 "DATACOMP0"
bitfld.long 0 0. " DATACOMP0 "  "0 ,1 "
tree.end

base sd:0xb7a0b0c8
tree "2DATACOMP1"
wgroup 0--3
line.long 0 "DATACOMP1"
bitfld.long 0 0. " DATACOMP1 "  "0 ,1 "
tree.end

base sd:0xb7a0b100
tree "2DATAMASK0"
wgroup 0--3
line.long 0 "DATAMASK0"
bitfld.long 0 0. " DATAMASK0 "  "0 ,1 "
tree.end

base sd:0xb7a0b108
tree "2DATAMASK1"
wgroup 0--3
line.long 0 "DATAMASK1"
bitfld.long 0 0. " DATAMASK1 "  "0 ,1 "
tree.end

base sd:0xb7a0b140
tree "2COUNTRELOADVAL0"
wgroup 0--3
line.long 0 "COUNTRELOADVAL0"
bitfld.long 0 0. " COUNTRELOADVAL0 "  "0 ,1 "
tree.end

base sd:0xb7a0b144
tree "2COUNTRELOADVAL1"
wgroup 0--3
line.long 0 "COUNTRELOADVAL1"
bitfld.long 0 0. " COUNTRELOADVAL1 "  "0 ,1 "
tree.end

base sd:0xb7a0b150
tree "2COUNTEN0"
wgroup 0--3
line.long 0 "COUNTEN0"
bitfld.long 0 0. " COUNTEN0 "  "0 ,1 "
tree.end

base sd:0xb7a0b154
tree "2COUNTEN1"
wgroup 0--3
line.long 0 "COUNTEN1"
bitfld.long 0 0. " COUNTEN1 "  "0 ,1 "
tree.end

base sd:0xb7a0b160
tree "2COUNTRELOADEV0"
wgroup 0--3
line.long 0 "COUNTRELOADEV0"
bitfld.long 0 0. " COUNTRELOADEV0 "  "0 ,1 "
tree.end

base sd:0xb7a0b164
tree "2COUNTRELOADEV1"
wgroup 0--3
line.long 0 "COUNTRELOADEV1"
bitfld.long 0 0. " COUNTRELOADEV1 "  "0 ,1 "
tree.end

base sd:0xb7a0b170
tree "2COUNTVALUE0"
group 0--3
line.long 0 "COUNTVALUE0"
bitfld.long 0 0. " COUNTVALUE0 "  "0 ,1 "
tree.end

base sd:0xb7a0b174
tree "2COUNTVALUE1"
group 0--3
line.long 0 "COUNTVALUE1"
bitfld.long 0 0. " COUNTVALUE1 "  "0 ,1 "
tree.end

base sd:0xb7a0b180
tree "2SEQCTRL0"
wgroup 0--3
line.long 0 "SEQCTRL0"
bitfld.long 0 0. " SEQCTRL0 "  "0 ,1 "
tree.end

base sd:0xb7a0b184
tree "2SEQCTRL1"
wgroup 0--3
line.long 0 "SEQCTRL1"
bitfld.long 0 0. " SEQCTRL1 "  "0 ,1 "
tree.end

base sd:0xb7a0b188
tree "2SEQCTRL2"
wgroup 0--3
line.long 0 "SEQCTRL2"
bitfld.long 0 0. " SEQCTRL2 "  "0 ,1 "
tree.end

base sd:0xb7a0b18c
tree "2SEQCTRL3"
wgroup 0--3
line.long 0 "SEQCTRL3"
bitfld.long 0 0. " SEQCTRL3 "  "0 ,1 "
tree.end

base sd:0xb7a0b190
tree "2SEQCTRL4"
wgroup 0--3
line.long 0 "SEQCTRL4"
bitfld.long 0 0. " SEQCTRL4 "  "0 ,1 "
tree.end

base sd:0xb7a0b194
tree "2SEQCTRL5"
wgroup 0--3
line.long 0 "SEQCTRL5"
bitfld.long 0 0. " SEQCTRL5 "  "0 ,1 "
tree.end

base sd:0xb7a0b19c
tree "2SEQSTATE"
group 0--3
line.long 0 "SEQSTATE"
bitfld.long 0 0. " SEQSTATE "  "0 ,1 "
tree.end

base sd:0xb7a0b1a0
tree "2EXTOUTPUT0"
wgroup 0--3
line.long 0 "EXTOUTPUT0"
bitfld.long 0 0. " EXTOUTPUT0 "  "0 ,1 "
tree.end

base sd:0xb7a0b1a4
tree "2EXTOUTPUT1"
wgroup 0--3
line.long 0 "EXTOUTPUT1"
bitfld.long 0 0. " EXTOUTPUT1 "  "0 ,1 "
tree.end

base sd:0xb7a0b1b0
tree "2CONTEXTIDCOMP"
wgroup 0--3
line.long 0 "CONTEXTIDCOMP"
bitfld.long 0 0. " CONTEXTIDCOMP "  "0 ,1 "
tree.end

base sd:0xb7a0b1bc
tree "2CONTEXTIDMASK"
wgroup 0--3
line.long 0 "CONTEXTIDMASK"
bitfld.long 0 0. " CONTEXTIDMASK "  "0 ,1 "
tree.end

base sd:0xb7a0b1c0
tree "2IMPSPECIFIC0"
wgroup 0--3
line.long 0 "IMPSPECIFIC0"
bitfld.long 0 0. " IMPSPECIFIC0 "  "0 ,1 "
tree.end

base sd:0xb7a0b1c4
tree "2IMPSPECIFIC1"
wgroup 0--3
line.long 0 "IMPSPECIFIC1"
bitfld.long 0 0. " IMPSPECIFIC1 "  "0 ,1 "
tree.end

base sd:0xb7a0b1c8
tree "2IMPSPECIFIC2"
wgroup 0--3
line.long 0 "IMPSPECIFIC2"
bitfld.long 0 0. " IMPSPECIFIC2 "  "0 ,1 "
tree.end

base sd:0xb7a0b1cc
tree "2IMPSPECIFIC3"
wgroup 0--3
line.long 0 "IMPSPECIFIC3"
bitfld.long 0 0. " IMPSPECIFIC3 "  "0 ,1 "
tree.end

base sd:0xb7a0b1d0
tree "2IMPSPECIFIC4"
wgroup 0--3
line.long 0 "IMPSPECIFIC4"
bitfld.long 0 0. " IMPSPECIFIC4 "  "0 ,1 "
tree.end

base sd:0xb7a0b1d4
tree "2IMPSPECIFIC5"
wgroup 0--3
line.long 0 "IMPSPECIFIC5"
bitfld.long 0 0. " IMPSPECIFIC5 "  "0 ,1 "
tree.end

base sd:0xb7a0b1d8
tree "2IMPSPECIFIC6"
wgroup 0--3
line.long 0 "IMPSPECIFIC6"
bitfld.long 0 0. " IMPSPECIFIC6 "  "0 ,1 "
tree.end

base sd:0xb7a0b1dc
tree "2IMPSPECIFIC7"
wgroup 0--3
line.long 0 "IMPSPECIFIC7"
bitfld.long 0 0. " IMPSPECIFIC7 "  "0 ,1 "
tree.end

base sd:0xb7a0b1e0
tree "2SYNCHFREQ"
wgroup 0--3
line.long 0 "SYNCHFREQ"
bitfld.long 0 0. " SYNCHFREQ "  "0 ,1 "
tree.end

base sd:0xb7a0b1e4
tree "2ETMID"
group 0--3
line.long 0 "ETMID"
bitfld.long 0 0. " ETMID "  "0 ,1 "
tree.end

base sd:0xb7a0b1e8
tree "2CONFIGCODEEXT"
group 0--3
line.long 0 "CONFIGCODEEXT"
bitfld.long 0 0. " CONFIGCODEEXT "  "0 ,1 "
tree.end

base sd:0xb7a0b1ec
tree "2EXTERNALINEXT"
wgroup 0--3
line.long 0 "EXTERNALINEXT"
bitfld.long 0 0. " EXTERNALINEXT "  "0 ,1 "
tree.end

base sd:0xb7a0b200
tree "2CSTRACEID"
wgroup 0--3
line.long 0 "CSTRACEID"
bitfld.long 0 0. " CSTRACEID "  "0 ,1 "
tree.end

base sd:0xb7a0bfa0
tree "2CLAIMTAGSET"
group 0--3
line.long 0 "CLAIMTAGSET"
bitfld.long 0 0. " CLAIMTAGSET "  "0 ,1 "
tree.end

base sd:0xb7a0bfa4
tree "2CLAIMTAGCLR"
group 0--3
line.long 0 "CLAIMTAGCLR"
bitfld.long 0 0. " CLAIMTAGCLR "  "0 ,1 "
tree.end

base sd:0xb7a0bfb0
tree "2LAR"
wgroup 0--3
line.long 0 "LAR"
bitfld.long 0 0.--31. " LAR "  " "
tree.end

base sd:0xb7a0bfb4
tree "2LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  " "
tree.end

base sd:0xb7a0bfb8
tree "2ASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--7. " ASR "  " "
tree.end

base sd:0xb7a0bfcc
tree "2CSDEVICETYPE"
rgroup 0--3
line.long 0 "CSDEVICETYPE"
bitfld.long 0 0. " CSDEVICETYPE "  "0 ,1 "
tree.end

base sd:0xb7a0bfd0
tree "2PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0.--7. " PERIPHERAL_ID4 "  " "
tree.end

base sd:0xb7a0bfd4
tree "2PERIPHERAL_ID5"
rgroup 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0.--7. " PERIPHERAL_ID5 "  " "
tree.end

base sd:0xb7a0bfd8
tree "2PERIPHERAL_ID6"
rgroup 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0.--7. " PERIPHERAL_ID6 "  " "
tree.end

base sd:0xb7a0bfdc
tree "2PERIPHERAL_ID7"
rgroup 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0.--7. " PERIPHERAL_ID7 "  " "
tree.end

base sd:0xb7a0bfe0
tree "2PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0.--7. " PERIPHERAL_ID0 "  " "
tree.end

base sd:0xb7a0bfe4
tree "2PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0.--7. " PERIPHERAL_ID1 "  " "
tree.end

base sd:0xb7a0bfe8
tree "2PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0.--7. " PERIPHERAL_ID2 "  " "
tree.end

base sd:0xb7a0bfec
tree "2PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0.--7. " PERIPHERAL_ID3 "  " "
tree.end

base sd:0xb7a0bff0
tree "2COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0.--7. " COMPONENT_ID0 "  " "
tree.end

base sd:0xb7a0bff4
tree "2COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0.--7. " COMPONENT_ID1 "  " "
tree.end

base sd:0xb7a0bff8
tree "2COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0.--7. " COMPONENT_ID2 "  " "
tree.end

base sd:0xb7a0bffc
tree "2COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0.--7. " COMPONENT_ID3 "  " "
tree.end

;tree.end

tree.end

;==============================================================
tree "MSSTPIU"
;==============================================================
base sd:0xb7a03000
tree "PORTSIZE"
rgroup 0--3
line.long 0 "PORTSIZE"
bitfld.long 0 0. " PORTSIZE "  "0 ,1 "
tree.end

base sd:0xb7a03004
tree "CURRPORTSIZE"
group 0--3
line.long 0 "CURRPORTSIZE"
bitfld.long 0 0.--31. " CURRPORTSIZE "  " "
tree.end

base sd:0xb7a03100
tree "SUPPTRIGMODES"
rgroup 0--3
line.long 0 "SUPPTRIGMODES"
bitfld.long 0 0. " MULT2 "  "0 ,1 "
bitfld.long 0 1. " MULT4 "  "0 ,1 "
bitfld.long 0 2. " MULT16 "  "0 ,1 "
bitfld.long 0 3. " MULT256 "  "0 ,1 "
bitfld.long 0 4. " MULT64K "  "0 ,1 "
bitfld.long 0 8. " TCOUNT8 "  "0 ,1 "
bitfld.long 0 16. " TRIGGERED "  "0 ,1 "
bitfld.long 0 17. " TRGRUN "  "0 ,1 "
tree.end

base sd:0xb7a03104
tree "TRIGCOUNT"
group 0--3
line.long 0 "TRIGCOUNT"
bitfld.long 0 0.--7. " TRIGCOUNT "  " "
tree.end

base sd:0xb7a03108
tree "TRIGMULT"
group 0--3
line.long 0 "TRIGMULT"
bitfld.long 0 0. " MULT2 "  "0 ,1 "
bitfld.long 0 1. " MULT4 "  "0 ,1 "
bitfld.long 0 2. " MULT16 "  "0 ,1 "
bitfld.long 0 3. " MULT256 "  "0 ,1 "
bitfld.long 0 4. " MULT64K "  "0 ,1 "
tree.end

base sd:0xb7a03200
tree "SUPPTESTPAT"
rgroup 0--3
line.long 0 "SUPPTESTPAT"
bitfld.long 0 0. " PATW1 "  "0 ,1 "
bitfld.long 0 1. " PATW0 "  "0 ,1 "
bitfld.long 0 2. " PATA5 "  "0 ,1 "
bitfld.long 0 3. " PATF0 "  "0 ,1 "
bitfld.long 0 16. " PTIMEEN "  "0 ,1 "
bitfld.long 0 17. " PCONTEN "  "0 ,1 "
tree.end

base sd:0xb7a03204
tree "CURRTESTPAT"
group 0--3
line.long 0 "CURRTESTPAT"
bitfld.long 0 0. " PATW1 "  "0 ,1 "
bitfld.long 0 1. " PATW0 "  "0 ,1 "
bitfld.long 0 2. " PATA5 "  "0 ,1 "
bitfld.long 0 3. " PATF0 "  "0 ,1 "
bitfld.long 0 16. " PTIMEEN "  "0 ,1 "
bitfld.long 0 17. " PCONTEN "  "0 ,1 "
tree.end

base sd:0xb7a03208
tree "TESTPATTREPCNT"
group 0--3
line.long 0 "TESTPATTREPCNT"
bitfld.long 0 0.--7. " PATTCOUNT "  " "
tree.end

base sd:0xb7a03300
tree "FORMATSTAT"
rgroup 0--3
line.long 0 "FORMATSTAT"
bitfld.long 0 0. " FIP "  "0 ,1 "
bitfld.long 0 1. " FTS "  "0 ,1 "
bitfld.long 0 2. " TCP "  "0 ,1 "
tree.end

base sd:0xb7a03304
tree "FORMATCTRL"
group 0--3
line.long 0 "FORMATCTRL"
bitfld.long 0 0. " ENFTC "  "0 ,1 "
bitfld.long 0 1. " ENFCONT "  "0 ,1 "
bitfld.long 0 4. " FONFLIN "  "0 ,1 "
bitfld.long 0 5. " FONTRIG "  "0 ,1 "
bitfld.long 0 6. " FONMAN "  "0 ,1 "
bitfld.long 0 8. " TRIGIN "  "0 ,1 "
bitfld.long 0 9. " TRIGEVT "  "0 ,1 "
bitfld.long 0 10. " TRIGFL "  "0 ,1 "
bitfld.long 0 12. " STOPFI "  "0 ,1 "
bitfld.long 0 13. " STOPTRIG "  "0 ,1 "
tree.end

base sd:0xb7a03308
tree "FORMATSYNC"
group 0--3
line.long 0 "FORMATSYNC"
bitfld.long 0 0.--11. " CYCCOUNT "  " "
tree.end

base sd:0xb7a03400
tree "EXTCTLIN"
group 0--3
line.long 0 "EXTCTLIN"
bitfld.long 0 0. " EXTCTLIN "  "0 ,1 "
tree.end

base sd:0xb7a03404
tree "EXTCTLOUT"
group 0--3
line.long 0 "EXTCTLOUT"
bitfld.long 0 0. " EXTCTLOUT "  "0 ,1 "
tree.end

base sd:0xb7a03ee4
tree "ITTRFLINACK"
wgroup 0--3
line.long 0 "ITTRFLINACK"
bitfld.long 0 0. " ITTRFLINACK "  "0 ,1 "
tree.end

base sd:0xb7a03ee8
tree "ITTRFLIN"
group 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0. " ITTRFLIN "  "0 ,1 "
tree.end

base sd:0xb7a03eec
tree "ITATBDATA0"
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ITATBDATA0 "  "0 ,1 "
tree.end

base sd:0xb7a03ef0
tree "ITATBCTR2"
wgroup 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ITATBCTR2 "  "0 ,1 "
tree.end

base sd:0xb7a03ef4
tree "ITATBCTR1"
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0. " ITATBCTR1 "  "0 ,1 "
tree.end

base sd:0xb7a03ef8
tree "ITATBCTR0"
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ITATBCTR0 "  "0 ,1 "
tree.end

base sd:0xb7a03f00
tree "IMCR"
group 0--3
line.long 0 "IMCR"
bitfld.long 0 0. " IMCR "  "0 ,1 "
tree.end

base sd:0xb7a03fa0
tree "CTSR"
group 0--3
line.long 0 "CTSR"
bitfld.long 0 0.--3. " CTSR "  " "
tree.end

base sd:0xb7a03fa4
tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--3. " CTCR "  " "
tree.end

base sd:0xb7a03fb0
tree "LAR"
wgroup 0--3
line.long 0 "LAR"
bitfld.long 0 0.--31. " LAR "  " "
tree.end

base sd:0xb7a03fb4
tree "LSR"
rgroup 0--3
line.long 0 "LSR"
bitfld.long 0 0.--1. " LSR "  " "
tree.end

base sd:0xb7a03fb8
tree "ASR"
rgroup 0--3
line.long 0 "ASR"
bitfld.long 0 0.--7. " ASR "  " "
tree.end

base sd:0xb7a03fc8
tree "DevID"
rgroup 0--3
line.long 0 "DevID"
bitfld.long 0 0. " DevID "  "0 ,1 "
tree.end

base sd:0xb7a03fcc
tree "Dev"
rgroup 0--3
line.long 0 "Dev"
bitfld.long 0 0.--7. " Dev "  " "
tree.end

base sd:0xb7a03fd0
tree "PERIPHERAL_ID4"
rgroup 0--3
line.long 0 "PERIPHERAL_ID4"
bitfld.long 0 0.--7. " PERIPHERAL_ID4 "  " "
tree.end

base sd:0xb7a03fd4
tree "PERIPHERAL_ID5"
group 0--3
line.long 0 "PERIPHERAL_ID5"
bitfld.long 0 0.--7. " PERIPHERAL_ID5 "  " "
tree.end

base sd:0xb7a03fd8
tree "PERIPHERAL_ID6"
group 0--3
line.long 0 "PERIPHERAL_ID6"
bitfld.long 0 0.--7. " PERIPHERAL_ID6 "  " "
tree.end

base sd:0xb7a03fdc
tree "PERIPHERAL_ID7"
group 0--3
line.long 0 "PERIPHERAL_ID7"
bitfld.long 0 0.--7. " PERIPHERAL_ID7 "  " "
tree.end

base sd:0xb7a03fe0
tree "PERIPHERAL_ID0"
rgroup 0--3
line.long 0 "PERIPHERAL_ID0"
bitfld.long 0 0.--7. " PERIPHERAL_ID0 "  " "
tree.end

base sd:0xb7a03fe4
tree "PERIPHERAL_ID1"
rgroup 0--3
line.long 0 "PERIPHERAL_ID1"
bitfld.long 0 0.--7. " PERIPHERAL_ID1 "  " "
tree.end

base sd:0xb7a03fe8
tree "PERIPHERAL_ID2"
rgroup 0--3
line.long 0 "PERIPHERAL_ID2"
bitfld.long 0 0.--7. " PERIPHERAL_ID2 "  " "
tree.end

base sd:0xb7a03fec
tree "PERIPHERAL_ID3"
rgroup 0--3
line.long 0 "PERIPHERAL_ID3"
bitfld.long 0 0.--7. " PERIPHERAL_ID3 "  " "
tree.end

base sd:0xb7a03ff0
tree "COMPONENT_ID0"
rgroup 0--3
line.long 0 "COMPONENT_ID0"
bitfld.long 0 0.--7. " COMPONENT_ID0 "  " "
tree.end

base sd:0xb7a03ff4
tree "COMPONENT_ID1"
rgroup 0--3
line.long 0 "COMPONENT_ID1"
bitfld.long 0 0.--7. " COMPONENT_ID1 "  " "
tree.end

base sd:0xb7a03ff8
tree "COMPONENT_ID2"
rgroup 0--3
line.long 0 "COMPONENT_ID2"
bitfld.long 0 0.--7. " COMPONENT_ID2 "  " "
tree.end

base sd:0xb7a03ffc
tree "COMPONENT_ID3"
rgroup 0--3
line.long 0 "COMPONENT_ID3"
bitfld.long 0 0.--7. " COMPONENT_ID3 "  " "
tree.end

tree.end

;==============================================================
tree "PKA"
;==============================================================
base sd:0xa03c4000
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PKAGO "  "0 ,1 "
bitfld.long 0 1. " PKASTOP "  "0 ,1 "
bitfld.long 0 2. " PKARESTORE "  "0 ,1 "
tree.end

base sd:0xa03c4004
tree "CFG"
group 0--3
line.long 0 "CFG"
bitfld.long 0 0. " SEC "  "0 ,1 "
bitfld.long 0 1. " PRIVn "  "0 ,1 "
bitfld.long 0 2. " ALGOMODE "  "0 ,1 "
bitfld.long 0 3.--4. " ALGOCALC "  " "
bitfld.long 0 5.--6. " SECLVL "  " "
bitfld.long 0 7.--8. " DATASWAP "  " "
tree.end

base sd:0xa03c4008
tree "SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " BUSY "  "0 ,1 "
bitfld.long 0 1. " STATUSSTOP "  "0 ,1 "
bitfld.long 0 2. " STATUSRESTORE "  "0 ,1 "
tree.end

base sd:0xa03c400c
tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " PKAIM "  "0 ,1 "
tree.end

base sd:0xa03c4010
tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " PKARIS "  "0 ,1 "
tree.end

base sd:0xa03c4014
tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " PKAMIS "  "0 ,1 "
tree.end

base sd:0xa03c4018
tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " PKAIC "  "0 ,1 "
tree.end

base sd:0xa03c4800
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0xa03c4804
tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
tree.end

base sd:0xa03c4808
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " PKAINTR "  "0 ,1 "
tree.end

base sd:0xa03c4fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0xa03c4fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0xa03c4fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0xa03c4fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0xa03c4ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " PKAPCellID0 "  " "
tree.end

base sd:0xa03c4ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " PKAPCellID1 "  " "
tree.end

base sd:0xa03c4ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " PKAPCellID2 "  " "
tree.end

base sd:0xa03c4ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " PKA0PCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "PL310"
;==============================================================
base sd:0xa0412000
tree "ID"
rgroup 0--3
line.long 0 "ID"
bitfld.long 0 0.--5. " REL "  " "
bitfld.long 0 6.--9. " PART "  " "
bitfld.long 0 10.--15. " ID "  " "
bitfld.long 0 24.--31. " IMPL "  " "
tree.end

base sd:0xa0412004
tree "Type"
rgroup 0--3
line.long 0 "Type"
bitfld.long 0 0.--1. " ILINELEN "  " "
bitfld.long 0 6. " IASSOC "  "0 ,1 "
bitfld.long 0 7.--11. " ISIZE "  " "
bitfld.long 0 12.--13. " DLINELEN "  " "
bitfld.long 0 18. " DASSOC "  "0 ,1 "
bitfld.long 0 19.--23. " DSIZE "  " "
bitfld.long 0 24. " H "  "0 ,1 "
bitfld.long 0 25.--28. " CTYPE "  " "
tree.end

base sd:0xa0412100
tree "Control"
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " EN "  "0 ,1 "
tree.end

base sd:0xa0412104
tree "AuxControl"
group 0--3
line.long 0 "AuxControl"
bitfld.long 0 12. " EXCONF "  "0 ,1 "
bitfld.long 0 16. " ASSOC "  "0 ,1 "
bitfld.long 0 17.--19. " WAYSZ "  " "
bitfld.long 0 20. " EMBEN "  "0 ,1 "
bitfld.long 0 21. " PAREN "  "0 ,1 "
bitfld.long 0 22. " SAOEN "  "0 ,1 "
bitfld.long 0 23.--24. " FWALLOC "  " "
bitfld.long 0 26. " NSLCKEN "  "0 ,1 "
bitfld.long 0 27. " NSIAC "  "0 ,1 "
bitfld.long 0 28. " DPFEN "  "0 ,1 "
bitfld.long 0 29. " IPFEN "  "0 ,1 "
tree.end

base sd:0xa0412108
tree "TagLatControl"
group 0--3
line.long 0 "TagLatControl"
bitfld.long 0 0.--2. " SLAT "  " "
bitfld.long 0 4.--6. " RLAT "  " "
bitfld.long 0 8.--10. " WLAT "  " "
tree.end

base sd:0xa041210c
tree "DataLatControl"
group 0--3
line.long 0 "DataLatControl"
bitfld.long 0 0.--2. " SLAT "  " "
bitfld.long 0 4.--6. " RLAT "  " "
bitfld.long 0 8.--10. " WLAT "  " "
tree.end

base sd:0xa0412200
tree "EventCountControl"
group 0--3
line.long 0 "EventCountControl"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 1.--2. " RES "  " "
tree.end

base sd:0xa0412204
tree "EventCount1Conf"
group 0--3
line.long 0 "EventCount1Conf"
bitfld.long 0 0.--1. " EVINTGEN "  " "
bitfld.long 0 2.--5. " EVSRC "  " "
tree.end

base sd:0xa0412208
tree "EventCount0Conf"
group 0--3
line.long 0 "EventCount0Conf"
bitfld.long 0 0.--1. " EVINTGEN "  " "
bitfld.long 0 2.--5. " EVSRC "  " "
tree.end

base sd:0xa041220c
tree "EventCount1Value"
group 0--3
line.long 0 "EventCount1Value"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0xa0412210
tree "EventCount0Value"
group 0--3
line.long 0 "EventCount0Value"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0xa0412214
tree "IntMask"
group 0--3
line.long 0 "IntMask"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
tree.end

base sd:0xa0412218
tree "MaskedIntStatus"
rgroup 0--3
line.long 0 "MaskedIntStatus"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
tree.end

base sd:0xa041221c
tree "RawIntStatus"
rgroup 0--3
line.long 0 "RawIntStatus"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
tree.end

base sd:0xa0412220
tree "IntClear"
wgroup 0--3
line.long 0 "IntClear"
bitfld.long 0 0. " ECNTR "  "0 ,1 "
bitfld.long 0 1. " PARRT "  "0 ,1 "
bitfld.long 0 2. " PARRD "  "0 ,1 "
bitfld.long 0 3. " ERRWT "  "0 ,1 "
bitfld.long 0 4. " ERRWD "  "0 ,1 "
bitfld.long 0 5. " ERRRT "  "0 ,1 "
bitfld.long 0 6. " ERRRD "  "0 ,1 "
bitfld.long 0 7. " SLVERR "  "0 ,1 "
bitfld.long 0 8. " DECERR "  "0 ,1 "
tree.end

base sd:0xa0412730
tree "CacheSync"
group 0--3
line.long 0 "CacheSync"
bitfld.long 0 0.--31. " SYNC "  " "
tree.end

base sd:0xa0412770
tree "InvalidateLine"
group 0--3
line.long 0 "InvalidateLine"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
tree.end

base sd:0xa041277c
tree "InvalidateByWay"
group 0--3
line.long 0 "InvalidateByWay"
bitfld.long 0 0.--15. " WAYBITS "  " "
tree.end

base sd:0xa04127b0
tree "CleanLine"
group 0--3
line.long 0 "CleanLine"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
tree.end

base sd:0xa04127b8
tree "CleanLineByWay"
group 0--3
line.long 0 "CleanLineByWay"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 28.--31. " WAY "  " "
tree.end

base sd:0xa04127bc
tree "CleanByWay"
group 0--3
line.long 0 "CleanByWay"
bitfld.long 0 0.--15. " WAYBITS "  " "
tree.end

base sd:0xa04127f0
tree "CleanInvLine"
group 0--3
line.long 0 "CleanInvLine"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 12.--31. " TAG "  " "
tree.end

base sd:0xa04127f8
tree "CleanInvLineByWay"
group 0--3
line.long 0 "CleanInvLineByWay"
bitfld.long 0 5.--11. " INDEX "  " "
bitfld.long 0 28.--31. " WAY "  " "
tree.end

base sd:0xa04127fc
tree "CleanInvByWay"
group 0--3
line.long 0 "CleanInvByWay"
bitfld.long 0 0.--15. " WAYBITS "  " "
tree.end

base sd:0xa0412900
tree "DataLockdownByWay_0"
group 0--3
line.long 0 "DataLockdownByWay_0"
bitfld.long 0 0.--15. " DATALOCK000 "  " "
tree.end

base sd:0xa0412904
tree "InstLockdownByWay_0"
group 0--3
line.long 0 "InstLockdownByWay_0"
bitfld.long 0 0.--15. " INSTRLOCK000 "  " "
tree.end

base sd:0xa0412908
tree "DataLockdownByWay_1"
group 0--3
line.long 0 "DataLockdownByWay_1"
bitfld.long 0 0.--15. " DATALOCK001 "  " "
tree.end

base sd:0xa041290c
tree "InstLockdownByWay_1"
group 0--3
line.long 0 "InstLockdownByWay_1"
bitfld.long 0 0.--15. " INSTRLOCK001 "  " "
tree.end

base sd:0xa0412910
tree "DataLockdownByWay_2"
group 0--3
line.long 0 "DataLockdownByWay_2"
bitfld.long 0 0.--15. " DATALOCK010 "  " "
tree.end

base sd:0xa0412914
tree "InstLockdownByWay_2"
group 0--3
line.long 0 "InstLockdownByWay_2"
bitfld.long 0 0.--15. " INSTRLOCK010 "  " "
tree.end

base sd:0xa0412918
tree "DataLockdownByWay_3"
group 0--3
line.long 0 "DataLockdownByWay_3"
bitfld.long 0 0.--15. " DATALOCK011 "  " "
tree.end

base sd:0xa041291c
tree "InstLockdownByWay_3"
group 0--3
line.long 0 "InstLockdownByWay_3"
bitfld.long 0 0.--15. " INSTRLOCK011 "  " "
tree.end

base sd:0xa0412920
tree "DataLockdownByWay_4"
group 0--3
line.long 0 "DataLockdownByWay_4"
bitfld.long 0 0.--15. " DATALOCK100 "  " "
tree.end

base sd:0xa0412924
tree "InstLockdownByWay_4"
group 0--3
line.long 0 "InstLockdownByWay_4"
bitfld.long 0 0.--15. " INSTRLOCK100 "  " "
tree.end

base sd:0xa0412928
tree "DataLockdownByWay_5"
group 0--3
line.long 0 "DataLockdownByWay_5"
bitfld.long 0 0.--15. " DATALOCK101 "  " "
tree.end

base sd:0xa041292c
tree "InstLockdownByWay_5"
group 0--3
line.long 0 "InstLockdownByWay_5"
bitfld.long 0 0.--15. " INSTRLOCK101 "  " "
tree.end

base sd:0xa0412930
tree "DataLockdownByWay_6"
group 0--3
line.long 0 "DataLockdownByWay_6"
bitfld.long 0 0.--15. " DATALOCK110 "  " "
tree.end

base sd:0xa0412934
tree "InstLockdownByWay_6"
group 0--3
line.long 0 "InstLockdownByWay_6"
bitfld.long 0 0.--15. " INSTRLOCK110 "  " "
tree.end

base sd:0xa0412938
tree "DataLockdownByWay_7"
group 0--3
line.long 0 "DataLockdownByWay_7"
bitfld.long 0 0.--15. " DATALOCK111 "  " "
tree.end

base sd:0xa041293c
tree "InstLockdownByWay_7"
group 0--3
line.long 0 "InstLockdownByWay_7"
bitfld.long 0 0.--15. " INSTRLOCK111 "  " "
tree.end

base sd:0xa0412950
tree "LockdownByLineEnable"
group 0--3
line.long 0 "LockdownByLineEnable"
bitfld.long 0 0. " EN "  "0 ,1 "
tree.end

base sd:0xa0412954
tree "UnlockAllLinesByWay"
group 0--3
line.long 0 "UnlockAllLinesByWay"
bitfld.long 0 0.--15. " UNLOCK "  " "
tree.end

base sd:0xa0412c00
tree "AddrFilterStart"
group 0--3
line.long 0 "AddrFilterStart"
bitfld.long 0 0. " EN "  "0 ,1 "
bitfld.long 0 20.--31. " AFS "  " "
tree.end

base sd:0xa0412c04
tree "AddrFilterEnd"
group 0--3
line.long 0 "AddrFilterEnd"
bitfld.long 0 20.--31. " AFE "  " "
tree.end

base sd:0xa0412f40
tree "DebugControl"
group 0--3
line.long 0 "DebugControl"
bitfld.long 0 0. " DCL "  "0 ,1 "
bitfld.long 0 1. " DWB "  "0 ,1 "
bitfld.long 0 2. " SPNIDEN "  "0 ,1 "
tree.end

base sd:0xa0412f80
tree "PowerControl"
group 0--3
line.long 0 "PowerControl"
bitfld.long 0 0. " STDBY_MODE_EN "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "PRCMU"
;==============================================================
base sd:0x80157000
tree "PRCM_ARMCLKFIX_MGT"
group 0--3
line.long 0 "PRCM_ARMCLKFIX_MGT"
bitfld.long 0 0.--4. " ARMCLKPLLDIV "  " "
bitfld.long 0 5.--7. " ARMCLKPLLSW "  " "
bitfld.long 0 8. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 9. " ARMCLK38 "  "0 ,1 "
bitfld.long 0 10. " ARMCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " ARMCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157004
tree "PRCM_ACLK_MGT"
group 0--3
line.long 0 "PRCM_ACLK_MGT"
bitfld.long 0 0.--4. " ACLKPLLDIV "  " "
bitfld.long 0 5.--7. " ACLKPLLSW "  " "
bitfld.long 0 8. " ACLKEN "  "0 ,1 "
bitfld.long 0 9. " ACLK38 "  "0 ,1 "
bitfld.long 0 10. " ACLK38SRC "  "0 ,1 "
bitfld.long 0 11. " ACLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157008
tree "PRCM_SVAMMDSPCLK_MGT"
group 0--3
line.long 0 "PRCM_SVAMMDSPCLK_MGT"
bitfld.long 0 0.--4. " SVAMMDSPCLKPLLDIV "  " "
bitfld.long 0 5.--7. " SVAMMDSPCLKPLLSW "  " "
bitfld.long 0 8. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 9. " SVAMMDSPCLK38 "  "0 ,1 "
bitfld.long 0 10. " SVAMMDSPCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SVA_LOW_FREQ "  "0 ,1 "
bitfld.long 0 12. " SVA_PHY_EN "  "0 ,1 "
bitfld.long 0 13. " SVAMMDSPCLK38DIV "  "0 ,1 "
tree.end

base sd:0x8015700c
tree "PRCM_SIAMMDSPCLK_MGT"
group 0--3
line.long 0 "PRCM_SIAMMDSPCLK_MGT"
bitfld.long 0 0.--4. " SIAMMDSPCLKPLLDIV "  " "
bitfld.long 0 5.--7. " SIAMMDSPCLKPLLSW "  " "
bitfld.long 0 8. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 9. " SIAMMDSPCLK38 "  "0 ,1 "
bitfld.long 0 10. " SIAMMDSPCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SIA_LOW_FREQ "  "0 ,1 "
bitfld.long 0 12. " SIA_PHY_EN "  "0 ,1 "
bitfld.long 0 13. " SIAMMDSPCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157014
tree "PRCM_SGACLK_MGT"
group 0--3
line.long 0 "PRCM_SGACLK_MGT"
bitfld.long 0 0.--4. " SGACLKPLLDIV "  " "
bitfld.long 0 5.--7. " SGACLKPLLSW "  " "
bitfld.long 0 8. " SGACLKEN "  "0 ,1 "
bitfld.long 0 9. " SGACLK38 "  "0 ,1 "
bitfld.long 0 10. " SGACLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SGACLK38DIV "  "0 ,1 "
bitfld.long 0 12. " SGACLKDIV_by_2_5_en "  "0 ,1 "
tree.end

base sd:0x80157018
tree "PRCM_UARTCLK_MGT"
group 0--3
line.long 0 "PRCM_UARTCLK_MGT"
bitfld.long 0 0.--4. " UARTCLKPLLDIV "  " "
bitfld.long 0 5.--7. " UARTCLKPLLSW "  " "
bitfld.long 0 8. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 9. " UARTCLK38 "  "0 ,1 "
bitfld.long 0 10. " UARTCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " UARTCLK38DIV "  "0 ,1 "
tree.end

base sd:0x8015701c
tree "PRCM_MSP02CLK_MGT"
group 0--3
line.long 0 "PRCM_MSP02CLK_MGT"
bitfld.long 0 0.--4. " MSP02CLKPLLDIV "  " "
bitfld.long 0 5.--7. " MSP02CLKPLLSW "  " "
bitfld.long 0 8. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 9. " MSP02CLK38 "  "0 ,1 "
bitfld.long 0 10. " MSP02CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " MSP02CLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157020
tree "PRCM_I2CCLK_MGT"
group 0--3
line.long 0 "PRCM_I2CCLK_MGT"
bitfld.long 0 0.--4. " I2CCLKPLLDIV "  " "
bitfld.long 0 5.--7. " I2CCLKPLLSW "  " "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " I2CCLK38 "  "0 ,1 "
bitfld.long 0 10. " I2CCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " I2CCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157024
tree "PRCM_SDMMCCLK_MGT"
group 0--3
line.long 0 "PRCM_SDMMCCLK_MGT"
bitfld.long 0 0.--4. " SDMMCCLKPLLDIV "  " "
bitfld.long 0 5.--7. " SDMMCCLKPLLSW "  " "
bitfld.long 0 8. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLK38 "  "0 ,1 "
bitfld.long 0 10. " SDMMCCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SDMMCCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157028
tree "PRCM_SLIMCLK_MGT"
group 0--3
line.long 0 "PRCM_SLIMCLK_MGT"
bitfld.long 0 0.--4. " SLIMCLKPLLDIV "  " "
bitfld.long 0 5.--7. " SLIMCLKPLLSW "  " "
bitfld.long 0 8. " SLIMCLKEN "  "0 ,1 "
bitfld.long 0 9. " SLIMCLK38 "  "0 ,1 "
bitfld.long 0 10. " SLIMCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SLIMCLK38DIV "  "0 ,1 "
bitfld.long 0 12.--14. " SLIMCLKMSP "  " "
tree.end

base sd:0x8015702c
tree "PRCM_PER1CLK_MGT"
group 0--3
line.long 0 "PRCM_PER1CLK_MGT"
bitfld.long 0 0.--4. " PER1CLKPLLDIV "  " "
bitfld.long 0 5.--7. " PER1CLKPLLSW "  " "
bitfld.long 0 8. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER1CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER1CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER1CLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157030
tree "PRCM_PER2CLK_MGT"
group 0--3
line.long 0 "PRCM_PER2CLK_MGT"
bitfld.long 0 0.--4. " PER2CLKPLLDIV "  " "
bitfld.long 0 5.--7. " PER2CLKPLLSW "  " "
bitfld.long 0 8. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER2CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER2CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER2CLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157034
tree "PRCM_PER3CLK_MGT"
group 0--3
line.long 0 "PRCM_PER3CLK_MGT"
bitfld.long 0 0.--4. " PER3CLKPLLDIV "  " "
bitfld.long 0 5.--7. " PER3CLKPLLSW "  " "
bitfld.long 0 8. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER3CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER3CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER3CLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157038
tree "PRCM_PER5CLK_MGT"
group 0--3
line.long 0 "PRCM_PER5CLK_MGT"
bitfld.long 0 0.--4. " PER5CLKPLLDIV "  " "
bitfld.long 0 5.--7. " PER5CLKPLLSW "  " "
bitfld.long 0 8. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER5CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER5CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER5CLK38DIV "  "0 ,1 "
tree.end

base sd:0x8015703c
tree "PRCM_PER6CLK_MGT"
group 0--3
line.long 0 "PRCM_PER6CLK_MGT"
bitfld.long 0 0.--4. " PER6CLKPLLDIV "  " "
bitfld.long 0 5.--7. " PER6CLKPLLSW "  " "
bitfld.long 0 8. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER6CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER6CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER6CLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157040
tree "PRCM_PER7CLK_MGT"
group 0--3
line.long 0 "PRCM_PER7CLK_MGT"
bitfld.long 0 0.--4. " PER7CLKPLLDIV "  " "
bitfld.long 0 5.--7. " PER7CLKPLLSW "  " "
bitfld.long 0 8. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 9. " PER7CLK38 "  "0 ,1 "
bitfld.long 0 10. " PER7CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " PER7CLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157044
tree "PRCM_LCDCLK_MGT"
group 0--3
line.long 0 "PRCM_LCDCLK_MGT"
bitfld.long 0 0.--4. " LCDCLKPLLDIV "  " "
bitfld.long 0 5.--7. " LCDCLKPLLSW "  " "
bitfld.long 0 8. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 9. " LCDCLK38 "  "0 ,1 "
bitfld.long 0 10. " LCDCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " LCDCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157048
tree "PRCM_SPARE1CLK_MGT"
group 0--3
line.long 0 "PRCM_SPARE1CLK_MGT"
tree.end

base sd:0x8015704c
tree "PRCM_BMLCLK_MGT"
group 0--3
line.long 0 "PRCM_BMLCLK_MGT"
bitfld.long 0 0.--4. " BMLCLKPLLDIV "  " "
bitfld.long 0 5.--7. " BMLCLKPLLSW "  " "
bitfld.long 0 8. " BMLCLKEN "  "0 ,1 "
bitfld.long 0 9. " BMLCLK38 "  "0 ,1 "
bitfld.long 0 10. " BMLCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " BMLCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157050
tree "PRCM_HSITXCLK_MGT"
group 0--3
line.long 0 "PRCM_HSITXCLK_MGT"
bitfld.long 0 0.--4. " HSITXCLKPLLDIV "  " "
bitfld.long 0 5.--7. " HSITXCLKPLLSW "  " "
bitfld.long 0 8. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 9. " HSITXCLK38 "  "0 ,1 "
bitfld.long 0 10. " HSITXCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " HSITXCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157054
tree "PRCM_HSIRXCLK_MGT"
group 0--3
line.long 0 "PRCM_HSIRXCLK_MGT"
bitfld.long 0 0.--4. " HSIRXCLKPLLDIV "  " "
bitfld.long 0 5.--7. " HSIRXCLKPLLSW "  " "
bitfld.long 0 8. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 9. " HSIRXCLK38 "  "0 ,1 "
bitfld.long 0 10. " HSIRXCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " HSIRXCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157058
tree "PRCM_HDMICLK_MGT"
group 0--3
line.long 0 "PRCM_HDMICLK_MGT"
bitfld.long 0 0.--4. " HDMICLKPLLDIV "  " "
bitfld.long 0 5.--7. " HDMICLKPLLSW "  " "
bitfld.long 0 8. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 9. " HDMICLK38 "  "0 ,1 "
bitfld.long 0 10. " HDMICLK38SRC "  "0 ,1 "
bitfld.long 0 11. " HDMICLK38DIV "  "0 ,1 "
tree.end

base sd:0x8015705c
tree "PRCM_APEATCLK_MGT"
group 0--3
line.long 0 "PRCM_APEATCLK_MGT"
bitfld.long 0 0.--4. " APEATCLKPLLDIV "  " "
bitfld.long 0 5.--7. " APEATCLKPLLSW "  " "
bitfld.long 0 8. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 9. " APEATCLK38 "  "0 ,1 "
bitfld.long 0 10. " APEATCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " APEATCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157060
tree "PRCM_APETRACECLK_MGT"
group 0--3
line.long 0 "PRCM_APETRACECLK_MGT"
bitfld.long 0 0.--4. " APETRACECLKPLLDIV "  " "
bitfld.long 0 5.--7. " APETRACECLKPLLSW "  " "
bitfld.long 0 8. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 9. " APETRACECLK38 "  "0 ,1 "
bitfld.long 0 10. " APETRACECLK38SRC "  "0 ,1 "
bitfld.long 0 11. " APETRACECLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157064
tree "PRCM_MCDECLK_MGT"
group 0--3
line.long 0 "PRCM_MCDECLK_MGT"
bitfld.long 0 0.--4. " MCDECLKPLLDIV "  " "
bitfld.long 0 5.--7. " MCDECLKPLLSW "  " "
bitfld.long 0 8. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 9. " MCDECLK38 "  "0 ,1 "
bitfld.long 0 10. " MCDECLK38SRC "  "0 ,1 "
bitfld.long 0 11. " MCDECLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157068
tree "PRCM_IPI2CCLK_MGT"
group 0--3
line.long 0 "PRCM_IPI2CCLK_MGT"
bitfld.long 0 0.--4. " IPI2CCLKPLLDIV "  " "
bitfld.long 0 5.--7. " IPI2CCLKPLLSW "  " "
bitfld.long 0 8. " IPI2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " IPI2CCLK38 "  "0 ,1 "
bitfld.long 0 10. " IPI2CCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " IPI2CCLK38DIV "  "0 ,1 "
tree.end

base sd:0x8015706c
tree "PRCM_DSIALTCLK_MGT"
group 0--3
line.long 0 "PRCM_DSIALTCLK_MGT"
bitfld.long 0 0.--4. " DSIALTCLKPLLDIV "  " "
bitfld.long 0 5.--7. " DSIALTCLKPLLSW "  " "
bitfld.long 0 8. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 9. " DSIALTCLK38 "  "0 ,1 "
bitfld.long 0 10. " DSIALTCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " DSIALTCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157070
tree "PRCM_SPARE2CLK_MGT"
group 0--3
line.long 0 "PRCM_SPARE2CLK_MGT"
tree.end

base sd:0x80157074
tree "PRCM_DMACLK_MGT"
group 0--3
line.long 0 "PRCM_DMACLK_MGT"
bitfld.long 0 0.--4. " DMACLKPLLDIV "  " "
bitfld.long 0 5.--7. " DMACLKPLLSW "  " "
bitfld.long 0 8. " DMACLKEN "  "0 ,1 "
bitfld.long 0 9. " DMACLK38 "  "0 ,1 "
bitfld.long 0 10. " DMACLK38SRC "  "0 ,1 "
bitfld.long 0 11. " DMACLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157078
tree "PRCM_B2R2CLK_MGT"
group 0--3
line.long 0 "PRCM_B2R2CLK_MGT"
bitfld.long 0 0.--4. " B2R2CLKPLLDIV "  " "
bitfld.long 0 5.--7. " B2R2CLKPLLSW "  " "
bitfld.long 0 8. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 9. " B2R2CLK38 "  "0 ,1 "
bitfld.long 0 10. " B2R2CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " B2R2CLK38DIV "  "0 ,1 "
tree.end

base sd:0x8015707c
tree "PRCM_TVCLK_MGT"
group 0--3
line.long 0 "PRCM_TVCLK_MGT"
bitfld.long 0 0.--4. " TVCLKPLLDIV "  " "
bitfld.long 0 5.--7. " TVCLKPLLSW "  " "
bitfld.long 0 8. " TVCLKEN "  "0 ,1 "
bitfld.long 0 9. " TVCLK38 "  "0 ,1 "
bitfld.long 0 10. " TVCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " TVCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157080
tree "PRCM_PLLSOC0_FREQ"
group 0--3
line.long 0 "PRCM_PLLSOC0_FREQ"
bitfld.long 0 0.--7. " D "  " "
bitfld.long 0 8.--13. " N "  " "
bitfld.long 0 16.--18. " R "  " "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
bitfld.long 0 25. " DIV2EN "  "0 ,1 "
tree.end

base sd:0x80157084
tree "PRCM_PLLSOC1_FREQ"
group 0--3
line.long 0 "PRCM_PLLSOC1_FREQ"
bitfld.long 0 0.--7. " D "  " "
bitfld.long 0 8.--13. " N "  " "
bitfld.long 0 16.--18. " R "  " "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
tree.end

base sd:0x80157088
tree "PRCM_PLLARM_FREQ"
group 0--3
line.long 0 "PRCM_PLLARM_FREQ"
bitfld.long 0 0.--7. " D "  " "
bitfld.long 0 8.--13. " N "  " "
bitfld.long 0 16.--18. " R "  " "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
tree.end

base sd:0x8015708c
tree "PRCM_PLLDDR_FREQ"
group 0--3
line.long 0 "PRCM_PLLDDR_FREQ"
bitfld.long 0 0.--7. " D "  " "
bitfld.long 0 8.--13. " N "  " "
bitfld.long 0 16.--18. " R "  " "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
bitfld.long 0 25. " DIV2EN "  "0 ,1 "
tree.end

base sd:0x80157090
tree "PRCM_PLLSOC0_ENABLE"
group 0--3
line.long 0 "PRCM_PLLSOC0_ENABLE"
bitfld.long 0 0. " PRCM_PLLSOC0_ENABLE "  "0 ,1 "
tree.end

base sd:0x80157094
tree "PRCM_PLLSOC1_ENABLE"
group 0--3
line.long 0 "PRCM_PLLSOC1_ENABLE"
bitfld.long 0 0. " PRCM_PLLSOC1_ENABLE "  "0 ,1 "
tree.end

base sd:0x80157098
tree "PRCM_PLLARM_ENABLE"
group 0--3
line.long 0 "PRCM_PLLARM_ENABLE"
bitfld.long 0 0. " PRCM_PLLARM_ENABLE "  "0 ,1 "
bitfld.long 0 8. " PRCM_PLLARM_COUNTON "  "0 ,1 "
tree.end

base sd:0x8015709c
tree "PRCM_PLLDDR_ENABLE"
group 0--3
line.long 0 "PRCM_PLLDDR_ENABLE"
bitfld.long 0 0. " PRCM_PLLDDR_ENABLE "  "0 ,1 "
tree.end

base sd:0x801570a0
tree "PRCM_PLLSOC0_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLSOC0_LOCKP"
bitfld.long 0 0. " PRCM_PLLSOC0_LOCK10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLSOC0_LOCK3 "  "0 ,1 "
tree.end

base sd:0x801570a4
tree "PRCM_PLLSOC1_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLSOC1_LOCKP"
bitfld.long 0 0. " PRCM_PLLSOC1_LOCK10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLSOC1_LOCK3 "  "0 ,1 "
tree.end

base sd:0x801570a8
tree "PRCM_PLLARM_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLARM_LOCKP"
bitfld.long 0 0. " PRCM_PLLARM_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLARM_LOCKP3 "  "0 ,1 "
tree.end

base sd:0x801570ac
tree "PRCM_PLLDDR_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLDDR_LOCKP"
bitfld.long 0 0. " PRCM_PLLDDR_LOCKP "  "0 ,1 "
tree.end

base sd:0x801570b0
tree "PRCM_XP70CLK_MGT"
group 0--3
line.long 0 "PRCM_XP70CLK_MGT"
bitfld.long 0 1. " PMBCLK_DIV4_SEL "  "0 ,1 "
bitfld.long 0 3. " P4PRCM_CLK_L2_SW "  "0 ,1 "
bitfld.long 0 4. " CLK38M2CLKGEN_SW "  "0 ,1 "
bitfld.long 0 5.--7. " CLK38M_DDRPLL_SW "  " "
bitfld.long 0 8.--14. " FREERUNNINGOSC_DIV "  " "
bitfld.long 0 15.--16. " SPARE_P4SUBCLK_EN "  " "
bitfld.long 0 17.--19. " P4SUBCLK_EN "  " "
bitfld.long 0 22. " EVT_FORCESFREERUNNING_CLK "  "0 ,1 "
bitfld.long 0 23.--25. " CLK38M_SOC1PLL_SW "  " "
bitfld.long 0 26. " CLK38MDSI_SW "  "0 ,1 "
bitfld.long 0 27. " PCLK_DBG_EN "  "0 ,1 "
bitfld.long 0 28. " CLK38M2CLKGEN_EN "  "0 ,1 "
bitfld.long 0 29. " CLK38M2DSI_EN "  "0 ,1 "
bitfld.long 0 30. " PMBCLK_EN "  "0 ,1 "
bitfld.long 0 31. " TEMP_SENS_EN "  "0 ,1 "
tree.end

base sd:0x801570b4
tree "PRCM_TIMER_0_REF"
group 0--3
line.long 0 "PRCM_TIMER_0_REF"
bitfld.long 0 0.--31. " PRCM_TIMER_0_REF "  " "
tree.end

base sd:0x801570b8
tree "PRCM_TIMER_0_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_0_DOWNCOUNT"
bitfld.long 0 0.--31. " PRCM_TIMER_0_DOWNCOUNT "  " "
tree.end

base sd:0x801570bc
tree "PRCM_TIMER_0_MODE"
group 0--3
line.long 0 "PRCM_TIMER_0_MODE"
bitfld.long 0 0. " PRCM_TIMER_0_MODE "  "0 ,1 "
tree.end

base sd:0x801570c0
tree "PRCM_TIMER_1_REF"
group 0--3
line.long 0 "PRCM_TIMER_1_REF"
bitfld.long 0 0.--31. " PRCM_TIMER_1_REF "  " "
tree.end

base sd:0x801570c4
tree "PRCM_TIMER_1_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_1_DOWNCOUNT"
bitfld.long 0 0.--31. " PRCM_TIMER_1_DOWNCOUNT "  " "
tree.end

base sd:0x801570c8
tree "PRCM_TIMER_1_MODE"
group 0--3
line.long 0 "PRCM_TIMER_1_MODE"
bitfld.long 0 0. " PRCM_TIMER_1_MODE "  "0 ,1 "
tree.end

base sd:0x801570cc
tree "PRCM_TIMER_2_REF"
group 0--3
line.long 0 "PRCM_TIMER_2_REF"
bitfld.long 0 0.--31. " PRCM_TIMER_2_REF "  " "
tree.end

base sd:0x801570d0
tree "PRCM_TIMER_2_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_2_DOWNCOUNT"
bitfld.long 0 0.--31. " PRCM_TIMER_2_DOWNCOUNT "  " "
tree.end

base sd:0x801570d4
tree "PRCM_TIMER_2_MODE"
group 0--3
line.long 0 "PRCM_TIMER_2_MODE"
bitfld.long 0 0. " PRCM_TIMER_2_MODE "  "0 ,1 "
tree.end

base sd:0x801570e4
tree "PRCM_CLK009_MGT"
group 0--3
line.long 0 "PRCM_CLK009_MGT"
bitfld.long 0 0.--2. " CLK009DIV "  " "
bitfld.long 0 3. " CLK009CLK38SRC "  "0 ,1 "
tree.end

base sd:0x801570e8
tree "PRCM_MODECLK"
group 0--3
line.long 0 "PRCM_MODECLK"
bitfld.long 0 0.--2. " PRCM_MODECLK "  " "
tree.end

base sd:0x801570f0
tree "PRCM_ARM_IT_SET"
group 0--3
line.long 0 "PRCM_ARM_IT_SET"
bitfld.long 0 0. " PRCM_ARM_IT_SET "  "0 ,1 "
tree.end

base sd:0x801570f4
tree "PRCM_ARM_IT_CLR"
group 0--3
line.long 0 "PRCM_ARM_IT_CLR"
bitfld.long 0 0. " PRCM_ARM_IT_CLR "  "0 ,1 "
tree.end

base sd:0x801570f8
tree "PRCM_4500_CLK_REQ"
group 0--3
line.long 0 "PRCM_4500_CLK_REQ"
bitfld.long 0 0. " PRCM_4500_CLK_REQ "  "0 ,1 "
bitfld.long 0 16. " PRCM_MODSYSCLKREQ_EN "  "0 ,1 "
tree.end

base sd:0x801570fc
tree "PRCM_MBOX_CPU_VAL"
rgroup 0--3
line.long 0 "PRCM_MBOX_CPU_VAL"
bitfld.long 0 0. " XP70_IT_EVENT_10 "  "0 ,1 "
bitfld.long 0 1. " XP70_IT_EVENT_11 "  "0 ,1 "
bitfld.long 0 2. " XP70_IT_EVENT_12 "  "0 ,1 "
bitfld.long 0 3. " XP70_IT_EVENT_13 "  "0 ,1 "
bitfld.long 0 4. " XP70_IT_EVENT_16 "  "0 ,1 "
bitfld.long 0 5. " XP70_IT_EVENT_17 "  "0 ,1 "
bitfld.long 0 6. " XP70_IT_EVENT_18 "  "0 ,1 "
bitfld.long 0 7. " XP70_IT_EVENT_19 "  "0 ,1 "
tree.end

base sd:0x80157100
tree "PRCM_MBOX_CPU_SET"
wgroup 0--3
line.long 0 "PRCM_MBOX_CPU_SET"
bitfld.long 0 0. " XP70_IT_EVENT_10 "  "0 ,1 "
bitfld.long 0 1. " XP70_IT_EVENT_11 "  "0 ,1 "
bitfld.long 0 2. " XP70_IT_EVENT_12 "  "0 ,1 "
bitfld.long 0 3. " XP70_IT_EVENT_13 "  "0 ,1 "
bitfld.long 0 4. " XP70_IT_EVENT_16 "  "0 ,1 "
bitfld.long 0 5. " XP70_IT_EVENT_17 "  "0 ,1 "
bitfld.long 0 6. " XP70_IT_EVENT_18 "  "0 ,1 "
bitfld.long 0 7. " XP70_IT_EVENT_19 "  "0 ,1 "
tree.end

base sd:0x80157104
tree "PRCM_MBOX_CPU_CLR"
wgroup 0--3
line.long 0 "PRCM_MBOX_CPU_CLR"
bitfld.long 0 0. " XP70_IT_EVENT_10 "  "0 ,1 "
bitfld.long 0 1. " XP70_IT_EVENT_11 "  "0 ,1 "
bitfld.long 0 2. " XP70_IT_EVENT_12 "  "0 ,1 "
bitfld.long 0 3. " XP70_IT_EVENT_13 "  "0 ,1 "
bitfld.long 0 4. " XP70_IT_EVENT_16 "  "0 ,1 "
bitfld.long 0 5. " XP70_IT_EVENT_17 "  "0 ,1 "
bitfld.long 0 6. " XP70_IT_EVENT_18 "  "0 ,1 "
bitfld.long 0 7. " XP70_IT_EVENT_19 "  "0 ,1 "
tree.end

base sd:0x8015710c
tree "PRCM_PLL32K_ENABLE"
group 0--3
line.long 0 "PRCM_PLL32K_ENABLE"
bitfld.long 0 0. " PRCM_PLL32K_ENABLE "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLL32K_BIDIR_OEN "  "0 ,1 "
bitfld.long 0 2. " PRCM_PLL32K_GATE_EN "  "0 ,1 "
tree.end

base sd:0x80157110
tree "PRCM_PLL32K_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLL32K_LOCKP"
bitfld.long 0 0. " PRCM_PLL32K_LOCKP "  "0 ,1 "
tree.end

base sd:0x80157114
tree "PRCM_ARM_CHGCLKREQ"
group 0--3
line.long 0 "PRCM_ARM_CHGCLKREQ"
bitfld.long 0 0. " PRCM_ARM_CHGCLKREQ "  "0 ,1 "
bitfld.long 0 16. " PRCM_ARM_DIVSEL "  "0 ,1 "
tree.end

base sd:0x80157118
tree "PRCM_ARM_PLLDIVPS"
group 0--3
line.long 0 "PRCM_ARM_PLLDIVPS"
bitfld.long 0 0.--5. " ARM_BRM_RATE "  " "
bitfld.long 0 8.--9. " ARM_BRM_IDLEDIV "  " "
bitfld.long 0 12. " ARM_BRM_IDLEEN "  "0 ,1 "
bitfld.long 0 16.--17. " ARM_PLL_OBSDIV "  " "
bitfld.long 0 20. " ARM_PLL_OBSEN "  "0 ,1 "
tree.end

base sd:0x8015711c
tree "PRCM_ARMITMSK31TO0"
group 0--3
line.long 0 "PRCM_ARMITMSK31TO0"
bitfld.long 0 0.--31. " PRCM_ARMITMSK31TO0 "  " "
tree.end

base sd:0x80157120
tree "PRCM_ARMITMSK63TO32"
group 0--3
line.long 0 "PRCM_ARMITMSK63TO32"
bitfld.long 0 0.--31. " PRCM_ARMITMSK63TO32 "  " "
tree.end

base sd:0x80157124
tree "PRCM_ARMITMSK95TO64"
group 0--3
line.long 0 "PRCM_ARMITMSK95TO64"
bitfld.long 0 0.--31. " PRCM_ARMITMSK95TO64 "  " "
tree.end

base sd:0x80157128
tree "PRCM_ARMITMSK127TO96"
group 0--3
line.long 0 "PRCM_ARMITMSK127TO96"
bitfld.long 0 0.--31. " PRCM_ARMITMSK127TO96 "  " "
tree.end

base sd:0x80157130
tree "PRCM_ARMSTANDBY_STATUS"
rgroup 0--3
line.long 0 "PRCM_ARMSTANDBY_STATUS"
bitfld.long 0 0. " PL320_IDLE "  "0 ,1 "
bitfld.long 0 1. " STANDBYWFE_0 "  "0 ,1 "
bitfld.long 0 2. " STANDBYWFE_1 "  "0 ,1 "
bitfld.long 0 3. " STANDBYWFI_0 "  "0 ,1 "
bitfld.long 0 4. " STANDBYWFI_1 "  "0 ,1 "
bitfld.long 0 5. " STANDBYWFI_WFE "  "0 ,1 "
bitfld.long 0 6. " EVENT_O "  "0 ,1 "
tree.end

base sd:0x80157134
tree "PRCM_CGATING_BYPASS"
group 0--3
line.long 0 "PRCM_CGATING_BYPASS"
bitfld.long 0 0. " PRCMCKGEN_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 1. " APECKGEN_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 2. " DSS_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 3. " DMA_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 4. " ICN0_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 5. " ICN1_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 6. " ICN2_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 7. " ICN3_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 8. " SPARE0_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 9. " SPARE1_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 10. " SPARE2_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 11. " SPARE3_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 12. " SPARE4_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 13. " SPARE5_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 14. " SPARE6_CGATING_BYPASS "  "0 ,1 "
bitfld.long 0 15. " SPARE7_CGATING_BYPASS "  "0 ,1 "
tree.end

base sd:0x80157138
tree "PRCM_GPIOCR"
group 0--3
line.long 0 "PRCM_GPIOCR"
bitfld.long 0 0. " DBG_UARTMOD_CMD0 "  "0 ,1 "
bitfld.long 0 1. " DBG_UARTMOD_CMD1 "  "0 ,1 "
bitfld.long 0 2. " DBG_ETM_R4_CMD0 "  "0 ,1 "
bitfld.long 0 4. " DBG_NEXUS_CMD "  "0 ,1 "
bitfld.long 0 5. " DBG_PTM_A9_CMD0 "  "0 ,1 "
bitfld.long 0 6. " DBG_PTM_A9_CMD1 "  "0 ,1 "
bitfld.long 0 7. " DBG_SBAG_CMD0 "  "0 ,1 "
bitfld.long 0 8. " DBG_SBAG_CMD1 "  "0 ,1 "
bitfld.long 0 9. " DBG_STM_APE_CMD "  "0 ,1 "
bitfld.long 0 10. " DBG_STM_MOD_CMD0 "  "0 ,1 "
bitfld.long 0 11. " DBG_STM_MOD_CMD1 "  "0 ,1 "
bitfld.long 0 12. " DBG_KBD_CMD "  "0 ,1 "
bitfld.long 0 13. " DBG_STM_MOD_CMD2 "  "0 ,1 "
bitfld.long 0 14. " DBG_PTM_A9_CMD2 "  "0 ,1 "
bitfld.long 0 15. " DBG_ETM_R4_CMD1 "  "0 ,1 "
bitfld.long 0 16. " DBG_UARTMOD_CMD2 "  "0 ,1 "
bitfld.long 0 17. " TRIGGER_SELECT "  "0 ,1 "
bitfld.long 0 18. " REMAP_SELECT_ON "  "0 ,1 "
bitfld.long 0 19. " DBG_ETM_R4_CMD2 "  "0 ,1 "
bitfld.long 0 20. " DBG_PTM_A9_CMD3 "  "0 ,1 "
bitfld.long 0 21. " DBG_PTM_A9_CMD4 "  "0 ,1 "
bitfld.long 0 22. " DBG_PTM_A9_CMD5 "  "0 ,1 "
bitfld.long 0 23. " SPI2_SELECT "  "0 ,1 "
bitfld.long 0 24. " DBG_HW_OBS_CMD1 "  "0 ,1 "
bitfld.long 0 25. " DBG_HW_OBS_CMD2 "  "0 ,1 "
bitfld.long 0 27. " MSPBYP01AEN "  "0 ,1 "
bitfld.long 0 28. " MSPBYP01CK10 "  "0 ,1 "
bitfld.long 0 29. " MSPBYP01CK01 "  "0 ,1 "
bitfld.long 0 30. " MSPBYP01FS10 "  "0 ,1 "
bitfld.long 0 31. " MSPBYP01FS01 "  "0 ,1 "
tree.end

base sd:0x8015713c
tree "PRCM_LEMI"
group 0--3
line.long 0 "PRCM_LEMI"
bitfld.long 0 0. " APECLK "  "0 ,1 "
bitfld.long 0 1. " APEINT "  "0 ,1 "
bitfld.long 0 2. " I2CAPE "  "0 ,1 "
bitfld.long 0 3. " I2CMOD "  "0 ,1 "
bitfld.long 0 4. " GPS "  "0 ,1 "
bitfld.long 0 5. " UICC "  "0 ,1 "
bitfld.long 0 6. " LINKO "  "0 ,1 "
bitfld.long 0 7. " MOD4500 "  "0 ,1 "
bitfld.long 0 8. " RST4500 "  "0 ,1 "
bitfld.long 0 9. " RTCK "  "0 ,1 "
bitfld.long 0 10. " CLKREQ "  "0 ,1 "
bitfld.long 0 11. " JTAG "  "0 ,1 "
bitfld.long 0 16.--31. " RESERVED_FOR_PUPD "  " "
tree.end

base sd:0x80157140
tree "PRCM_COMPCR"
group 0--3
line.long 0 "PRCM_COMPCR"
bitfld.long 0 0. " C1V2COMPTYP "  "0 ,1 "
bitfld.long 0 1. " C1V2COMPFRZ "  "0 ,1 "
bitfld.long 0 2. " C1V2COMPN "  "0 ,1 "
bitfld.long 0 3. " C1V8COMPTQ "  "0 ,1 "
bitfld.long 0 4. " C1V8COMPFRZ "  "0 ,1 "
bitfld.long 0 5. " C1V8COMPN "  "0 ,1 "
bitfld.long 0 6. " C1V8COMPACCURATE "  "0 ,1 "
bitfld.long 0 7. " C1V8COMPFASTFRZ "  "0 ,1 "
bitfld.long 0 16.--22. " C1V8NASRCR "  " "
bitfld.long 0 23.--29. " C1V8PASRCR "  " "
tree.end

base sd:0x80157144
tree "PRCM_COMPSTA"
rgroup 0--3
line.long 0 "PRCM_COMPSTA"
bitfld.long 0 0. " C1V2COMPOK "  "0 ,1 "
bitfld.long 0 2.--8. " C1V2NASRC "  " "
bitfld.long 0 9.--15. " C1V2PASRC "  " "
bitfld.long 0 16. " C1V8COMPOK "  "0 ,1 "
bitfld.long 0 18.--24. " C1V8NASRC "  " "
bitfld.long 0 25.--31. " C1V8PASRC "  " "
tree.end

base sd:0x80157148
tree "PRCM_ITSTATUS0"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS0"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " HSI_CAWAKE0 "  "0 ,1 "
bitfld.long 0 4. " HSI_CAWAKE1 "  "0 ,1 "
bitfld.long 0 5. " MOD_WAKE_HOST_IRQ "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " APEINT_4500 "  "0 ,1 "
tree.end

base sd:0x8015714c
tree "PRCM_ITCLR0"
wgroup 0--3
line.long 0 "PRCM_ITCLR0"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " HSI_CAWAKE0 "  "0 ,1 "
bitfld.long 0 4. " HSI_CAWAKE1 "  "0 ,1 "
bitfld.long 0 5. " MOD_WAKE_HOST_IRQ "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " APEINT_4500 "  "0 ,1 "
tree.end

base sd:0x80157150
tree "PRCM_ITSTATUS1"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS1"
bitfld.long 0 0. " FIFO4500IT "  "0 ,1 "
tree.end

base sd:0x80157154
tree "PRCM_ITCLR1"
wgroup 0--3
line.long 0 "PRCM_ITCLR1"
bitfld.long 0 0. " FIFO4500IT "  "0 ,1 "
tree.end

base sd:0x80157158
tree "PRCM_ITSTATUS2"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS2"
bitfld.long 0 0. " MOD_MEM_IF_REQ "  "0 ,1 "
bitfld.long 0 1. " MOD_REQ_LATENCY "  "0 ,1 "
bitfld.long 0 2. " MOD_HOST_PORT_AVAILABLE "  "0 ,1 "
bitfld.long 0 3. " MOD_MEM_IF_ACK "  "0 ,1 "
tree.end

base sd:0x8015715c
tree "PRCM_ITCLR2"
wgroup 0--3
line.long 0 "PRCM_ITCLR2"
bitfld.long 0 0. " MOD_MEM_IF_REQ "  "0 ,1 "
bitfld.long 0 1. " MOD_REQ_LATENCY "  "0 ,1 "
bitfld.long 0 2. " MOD_HOST_PORT_AVAILABLE "  "0 ,1 "
bitfld.long 0 3. " MOD_MEM_IF_ACK "  "0 ,1 "
tree.end

base sd:0x80157160
tree "PRCM_ITSTATUS3"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS3"
bitfld.long 0 0. " MOD_STATE "  "0 ,1 "
bitfld.long 0 1. " MOD_PWRENA "  "0 ,1 "
bitfld.long 0 2. " MOD_SYSCLKREQ "  "0 ,1 "
bitfld.long 0 3. " MOD_AUX_CLK_REQ "  "0 ,1 "
tree.end

base sd:0x80157164
tree "PRCM_ITCLR3"
wgroup 0--3
line.long 0 "PRCM_ITCLR3"
bitfld.long 0 0. " MOD_STATE "  "0 ,1 "
bitfld.long 0 1. " MOD_PWRENA "  "0 ,1 "
bitfld.long 0 2. " MOD_SYSCLKREQ "  "0 ,1 "
bitfld.long 0 3. " MOD_AUX_CLK_REQ "  "0 ,1 "
tree.end

base sd:0x80157168
tree "PRCM_ITSTATUS4"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS4"
bitfld.long 0 0. " SWRESET "  "0 ,1 "
bitfld.long 0 1. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 2. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 3. " MOD_SW_RESET_REQ "  "0 ,1 "
bitfld.long 0 4. " HSEM_INT_SVA_MMDSP "  "0 ,1 "
bitfld.long 0 5. " HSEM_INT_SIA_MMDSP "  "0 ,1 "
tree.end

base sd:0x8015716c
tree "PRCM_ITCLR4"
wgroup 0--3
line.long 0 "PRCM_ITCLR4"
bitfld.long 0 0. " SWRESET "  "0 ,1 "
bitfld.long 0 1. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 2. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 3. " MOD_SW_RESET_REQ "  "0 ,1 "
bitfld.long 0 4. " HSEM_INT_SVA_MMDSP "  "0 ,1 "
bitfld.long 0 5. " HSEM_INT_SIA_MMDSP "  "0 ,1 "
tree.end

base sd:0x80157170
tree "PRCM_LINE_VALUE"
rgroup 0--3
line.long 0 "PRCM_LINE_VALUE"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " HSI_CAWAKE0 "  "0 ,1 "
bitfld.long 0 4. " HSI_CAWAKE1 "  "0 ,1 "
bitfld.long 0 5. " MOD_WAKE_HOST_IRQ "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " APEINT_4500 "  "0 ,1 "
bitfld.long 0 8. " FIFO4500IT "  "0 ,1 "
bitfld.long 0 9. " MOD_MEM_IF_REQ "  "0 ,1 "
bitfld.long 0 10. " MOD_REQ_LATENCY "  "0 ,1 "
bitfld.long 0 11. " MOD_HOST_PORT_AVAILABLE "  "0 ,1 "
bitfld.long 0 12. " MOD_MEM_IF_ACK "  "0 ,1 "
bitfld.long 0 13. " MOD_STATE "  "0 ,1 "
bitfld.long 0 14. " MOD_PWRENA "  "0 ,1 "
bitfld.long 0 15. " MOD_SYSCLKREQ "  "0 ,1 "
bitfld.long 0 16. " MOD_AUX_CLK_REQ "  "0 ,1 "
bitfld.long 0 17. " SWRESET "  "0 ,1 "
bitfld.long 0 18. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 19. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 20. " MOD_SW_RESET_REQ "  "0 ,1 "
bitfld.long 0 21. " HSEM_INT_SVA_MMDSP "  "0 ,1 "
bitfld.long 0 22. " HSEM_INT_SIA_MMDSP "  "0 ,1 "
bitfld.long 0 23.--31. " GPIO_EVENTS "  " "
tree.end

base sd:0x80157174
tree "PRCM_HOLD_EVT"
group 0--3
line.long 0 "PRCM_HOLD_EVT"
bitfld.long 0 0. " RTCWKUP "  "0 ,1 "
bitfld.long 0 1. " RTT0WKUP "  "0 ,1 "
bitfld.long 0 2. " RTT1WKUP "  "0 ,1 "
bitfld.long 0 3. " HSI_CAWAKE0 "  "0 ,1 "
bitfld.long 0 4. " HSI_CAWAKE1 "  "0 ,1 "
bitfld.long 0 5. " MOD_WAKE_HOST_IRQ "  "0 ,1 "
bitfld.long 0 6. " USB_WKUP "  "0 ,1 "
bitfld.long 0 7. " APEINT_4500 "  "0 ,1 "
bitfld.long 0 8. " FIFO4500IT "  "0 ,1 "
bitfld.long 0 9. " MOD_MEM_IF_REQ "  "0 ,1 "
bitfld.long 0 10. " MOD_REQ_LATENCY "  "0 ,1 "
bitfld.long 0 11. " MOD_HOST_PORT_AVAILABLE "  "0 ,1 "
bitfld.long 0 12. " MOD_MEM_IF_ACK "  "0 ,1 "
bitfld.long 0 13. " MOD_STATE "  "0 ,1 "
bitfld.long 0 14. " MOD_PWRENA "  "0 ,1 "
bitfld.long 0 15. " MOD_SYSCLKREQ "  "0 ,1 "
bitfld.long 0 16. " MOD_AUX_CLK_REQ "  "0 ,1 "
bitfld.long 0 17. " SWRESET "  "0 ,1 "
bitfld.long 0 18. " A9_WDRSTREQ_INT_1 "  "0 ,1 "
bitfld.long 0 19. " A9_WDRSTREQ_INT_0 "  "0 ,1 "
bitfld.long 0 20. " MOD_SW_RESET_REQ "  "0 ,1 "
bitfld.long 0 21. " HSEM_INT_SVA_MMDSP "  "0 ,1 "
bitfld.long 0 22. " HSEM_INT_SIA_MMDSP "  "0 ,1 "
bitfld.long 0 23.--31. " GPIO_EVENTS "  " "
tree.end

base sd:0x80157178
tree "PRCM_EDGE_SENS_L"
group 0--3
line.long 0 "PRCM_EDGE_SENS_L"
bitfld.long 0 0.--1. " RTCWKUP "  " "
bitfld.long 0 2.--3. " RTT0WKUP "  " "
bitfld.long 0 4.--5. " RTT1WKUP "  " "
bitfld.long 0 6.--7. " HSI_CAWAKE0 "  " "
bitfld.long 0 8.--9. " HSI_CAWAKE1 "  " "
bitfld.long 0 10.--11. " MOD_WAKE_HOST_IRQ "  " "
bitfld.long 0 12.--13. " USB_WKUP "  " "
bitfld.long 0 14.--15. " APEINT_4500 "  " "
bitfld.long 0 16.--17. " FIFO4500IT "  " "
bitfld.long 0 18.--19. " MOD_MEM_IF_REQ "  " "
bitfld.long 0 20.--21. " MOD_REQ_LATENCY "  " "
bitfld.long 0 22.--23. " MOD_HOST_PORT_AVAILABLE "  " "
bitfld.long 0 24.--25. " MOD_MEM_IF_ACK "  " "
bitfld.long 0 26.--27. " MOD_STATE "  " "
bitfld.long 0 28.--29. " MOD_PWRENA "  " "
bitfld.long 0 30.--31. " MOD_SYSCLKREQ "  " "
tree.end

base sd:0x8015717c
tree "PRCM_EDGE_SENS_H"
group 0--3
line.long 0 "PRCM_EDGE_SENS_H"
bitfld.long 0 0.--1. " MOD_AUX_CLK_REQ "  " "
bitfld.long 0 2.--3. " SWRESET "  " "
bitfld.long 0 4.--5. " A9_WDRSTREQ_INT_1 "  " "
bitfld.long 0 6.--7. " A9_WDRSTREQ_INT_0 "  " "
bitfld.long 0 8.--9. " MOD_SW_RESET_REQ "  " "
bitfld.long 0 10.--11. " HSEM_INT_SVA_MMDSP "  " "
bitfld.long 0 12.--13. " HSEM_INT_SIA_MMDSP "  " "
bitfld.long 0 14.--15. " GPIO_EVENTS_0 "  " "
bitfld.long 0 16.--17. " GPIO_EVENTS_1 "  " "
bitfld.long 0 18.--19. " GPIO_EVENTS_2 "  " "
bitfld.long 0 20.--21. " GPIO_EVENTS_3 "  " "
bitfld.long 0 22.--23. " GPIO_EVENTS_4 "  " "
bitfld.long 0 24.--25. " GPIO_EVENTS_5 "  " "
bitfld.long 0 26.--27. " GPIO_EVENTS_6 "  " "
bitfld.long 0 28.--29. " GPIO_EVENTS_7 "  " "
bitfld.long 0 30.--31. " GPIO_EVENTS_8 "  " "
tree.end

base sd:0x80157190
tree "PRCM_DEBUG_CTRL_VAL"
rgroup 0--3
line.long 0 "PRCM_DEBUG_CTRL_VAL"
bitfld.long 0 0. " MOD_PWRUPACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
tree.end

base sd:0x80157194
tree "PRCM_DEBUG_NOPWRDOWN_VAL"
rgroup 0--3
line.long 0 "PRCM_DEBUG_NOPWRDOWN_VAL"
bitfld.long 0 0. " ARM_DEBUG_NOPOWER_DOWN_REQ "  "0 ,1 "
bitfld.long 0 1. " SVA_DEBUG_NOPOWER_DOWN_REQ "  "0 ,1 "
bitfld.long 0 2. " SIA_DEBUG_NOPOWER_DOWN_REQ "  "0 ,1 "
tree.end

base sd:0x80157198
tree "PRCM_DEBUG_CTRL_ACK"
group 0--3
line.long 0 "PRCM_DEBUG_CTRL_ACK"
bitfld.long 0 0. " SIA_PWRUP_ACK "  "0 ,1 "
bitfld.long 0 1. " SVA_PWRUP_ACK "  "0 ,1 "
bitfld.long 0 2. " MOD_PWRUPREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_CSYSPWRUPACK "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_CDBGRSTACK "  "0 ,1 "
bitfld.long 0 8. " CSYSPWRUP_SWT "  "0 ,1 "
tree.end

base sd:0x8015719c
tree "PRCM_A9PL_FORCE_CLKEN"
group 0--3
line.long 0 "PRCM_A9PL_FORCE_CLKEN"
bitfld.long 0 0. " PRCM_A9PL_FORCE_CLKEN "  "0 ,1 "
bitfld.long 0 1. " PRCM_A9AXI_FORCE_CLKEN "  "0 ,1 "
tree.end

base sd:0x801571a0
tree "PRCM_TPIU_FLUSHIN_REQ"
group 0--3
line.long 0 "PRCM_TPIU_FLUSHIN_REQ"
bitfld.long 0 0. " PRCM_TPIU_FLUSHIN_REQ "  "0 ,1 "
tree.end

base sd:0x801571a4
tree "PRCM_TPIU_FLUSHIN_ACK"
rgroup 0--3
line.long 0 "PRCM_TPIU_FLUSHIN_ACK"
bitfld.long 0 0. " PRCM_TPIU_FLUSHIN_ACK "  "0 ,1 "
tree.end

base sd:0x801571a8
tree "PRCM_STP_FLUSHIN_REQ"
group 0--3
line.long 0 "PRCM_STP_FLUSHIN_REQ"
bitfld.long 0 0. " PRCM_STP_FLUSHIN_REQ "  "0 ,1 "
tree.end

base sd:0x801571ac
tree "PRCM_STP_FLUSHIN_ACK"
rgroup 0--3
line.long 0 "PRCM_STP_FLUSHIN_ACK"
bitfld.long 0 0. " PRCM_STP_FLUSHIN_ACK "  "0 ,1 "
tree.end

base sd:0x801571b0
tree "PRCM_HWI2C_DIV"
group 0--3
line.long 0 "PRCM_HWI2C_DIV"
bitfld.long 0 0.--1. " PRCM_HWI2C_DIV "  " "
tree.end

base sd:0x801571b4
tree "PRCM_HWI2C_GO"
group 0--3
line.long 0 "PRCM_HWI2C_GO"
bitfld.long 0 0. " PRCM_HWI2C_GO "  "0 ,1 "
tree.end

base sd:0x801571b8
tree "PRCM_HWI2C_CMD"
group 0--3
line.long 0 "PRCM_HWI2C_CMD"
bitfld.long 0 0. " RWB "  "0 ,1 "
bitfld.long 0 1.--7. " A7 "  " "
bitfld.long 0 8.--9. " TSIZE "  " "
bitfld.long 0 10. " HWGCEN "  "0 ,1 "
bitfld.long 0 11. " STOPEN "  "0 ,1 "
bitfld.long 0 16.--23. " REG_ADD "  " "
bitfld.long 0 24.--31. " REG_DATA "  " "
tree.end

base sd:0x801571bc
tree "PRCM_HWI2C_DATA123"
group 0--3
line.long 0 "PRCM_HWI2C_DATA123"
bitfld.long 0 0.--7. " DATA1 "  " "
bitfld.long 0 8.--15. " DATA2 "  " "
bitfld.long 0 16.--23. " DATA3 "  " "
tree.end

base sd:0x801571c0
tree "PRCM_HWI2C_SR"
rgroup 0--3
line.long 0 "PRCM_HWI2C_SR"
bitfld.long 0 0.--1. " STATUS "  " "
bitfld.long 0 2.--4. " CAUSE "  " "
tree.end

base sd:0x801571c4
tree "PRCM_REMAPCR"
group 0--3
line.long 0 "PRCM_REMAPCR"
bitfld.long 0 0. " REMAPCLR "  "0 ,1 "
bitfld.long 0 1. " REMAPSTAT "  "0 ,1 "
tree.end

base sd:0x801571c8
tree "PRCM_TCR"
group 0--3
line.long 0 "PRCM_TCR"
bitfld.long 0 0. " TENSEL0 "  "0 ,1 "
bitfld.long 0 1. " TENSEL1 "  "0 ,1 "
bitfld.long 0 2. " TENSEL2 "  "0 ,1 "
bitfld.long 0 3. " TENSEL3 "  "0 ,1 "
bitfld.long 0 4. " TENSEL4 "  "0 ,1 "
bitfld.long 0 5. " TENSEL5 "  "0 ,1 "
bitfld.long 0 6. " TENSEL6 "  "0 ,1 "
bitfld.long 0 7. " TENSEL7 "  "0 ,1 "
bitfld.long 0 16. " STOP_TIMERS "  "0 ,1 "
bitfld.long 0 17. " DOZE_MODE "  "0 ,1 "
tree.end

base sd:0x801571cc
tree "PRCM_CLKOCR"
group 0--3
line.long 0 "PRCM_CLKOCR"
bitfld.long 0 0.--5. " CLKODIV0 "  " "
bitfld.long 0 6.--8. " CLKOSEL0 "  " "
bitfld.long 0 16.--21. " CLKODIV1 "  " "
bitfld.long 0 22.--24. " CLKOSEL1 "  " "
bitfld.long 0 28. " CLK1TYPE "  "0 ,1 "
tree.end

base sd:0x801571d0
tree "PRCM_ITSTATUS_DBG"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS_DBG"
bitfld.long 0 0. " MOD_PWRUPACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
tree.end

base sd:0x801571d4
tree "PRCM_ITCLR_DBG"
wgroup 0--3
line.long 0 "PRCM_ITCLR_DBG"
bitfld.long 0 0. " MOD_PWRUPACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
tree.end

base sd:0x801571d8
tree "PRCM_LINE_VALUE_DBG"
rgroup 0--3
line.long 0 "PRCM_LINE_VALUE_DBG"
bitfld.long 0 0. " MOD_PWRUPACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
tree.end

base sd:0x801571dc
tree "PRCM_DBG_HOLD"
group 0--3
line.long 0 "PRCM_DBG_HOLD"
bitfld.long 0 0. " MOD_PWRUPACK "  "0 ,1 "
bitfld.long 0 1. " DAP_APE_CSYSPWRUPREQ "  "0 ,1 "
bitfld.long 0 2. " DAP_APE_CDBGRSTREQ "  "0 ,1 "
bitfld.long 0 3. " DAP_APE_SVA_PWRUPREQ "  "0 ,1 "
bitfld.long 0 4. " DAP_APE_SIA_PWRUPREQ "  "0 ,1 "
tree.end

base sd:0x801571e0
tree "PRCM_EDGE_SENS_DBG"
group 0--3
line.long 0 "PRCM_EDGE_SENS_DBG"
bitfld.long 0 0.--1. " MOD_PWRUPACK "  " "
bitfld.long 0 2.--3. " DAP_APE_CSYSPWRUPREQ "  " "
bitfld.long 0 4.--5. " DAP_APE_CDBGRSTREQ "  " "
bitfld.long 0 6.--7. " DAP_APE_SVA_PWRUPREQ "  " "
bitfld.long 0 8.--9. " DAP_APE_SIA_PWRUPREQ "  " "
tree.end

base sd:0x801571e4
tree "PRCM_APE_RESETN_SET"
group 0--3
line.long 0 "PRCM_APE_RESETN_SET"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "
bitfld.long 0 1. " SGA_M_INITN "  "0 ,1 "
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " DSS_M_INITN "  "0 ,1 "
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 11. " SIA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 14. " DSIPLL_RESETN "  "0 ,1 "
bitfld.long 0 17. " DDR_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 18. " DDR_MOD_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 19. " DDR_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 20. " DDR_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 21. " SPARE_1 "  "0 ,1 "
bitfld.long 0 22. " SIA_PIPE_M_RAD_RESETN "  "0 ,1 "
bitfld.long 0 24. " ESRAM1_INITN "  "0 ,1 "
bitfld.long 0 25. " ESRAM2_INITN "  "0 ,1 "
bitfld.long 0 26. " ESRAM3_INITN "  "0 ,1 "
bitfld.long 0 27. " ESRAM4_INITN "  "0 ,1 "
bitfld.long 0 29. " APE_MEM_INITN "  "0 ,1 "
bitfld.long 0 30. " APE_PWRON_RESETN "  "0 ,1 "
bitfld.long 0 31. " APE_RESETN "  "0 ,1 "
tree.end

base sd:0x801571e8
tree "PRCM_APE_RESETN_CLR"
group 0--3
line.long 0 "PRCM_APE_RESETN_CLR"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "
bitfld.long 0 1. " SGA_M_INITN "  "0 ,1 "
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " DSS_M_INITN "  "0 ,1 "
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 11. " SIA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 14. " DSIPLL_RESETN "  "0 ,1 "
bitfld.long 0 17. " DDR_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 18. " DDR_MOD_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 19. " DDR_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 20. " DDR_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 21. " SPARE_1 "  "0 ,1 "
bitfld.long 0 22. " SIA_PIPE_M_RAD_RESETN "  "0 ,1 "
bitfld.long 0 24. " ESRAM1_INITN "  "0 ,1 "
bitfld.long 0 25. " ESRAM2_INITN "  "0 ,1 "
bitfld.long 0 26. " ESRAM3_INITN "  "0 ,1 "
bitfld.long 0 27. " ESRAM4_INITN "  "0 ,1 "
bitfld.long 0 29. " APE_MEM_INITN "  "0 ,1 "
bitfld.long 0 30. " APE_PWRON_RESETN "  "0 ,1 "
bitfld.long 0 31. " APE_RESETN "  "0 ,1 "
tree.end

base sd:0x801571ec
tree "PRCM_APE_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_APE_RESETN_VAL"
bitfld.long 0 0. " SGA_L_RESETN "  "0 ,1 "
bitfld.long 0 1. " SGA_M_INITN "  "0 ,1 "
bitfld.long 0 2. " DSS_L_RESETN "  "0 ,1 "
bitfld.long 0 3. " DSS_M_INITN "  "0 ,1 "
bitfld.long 0 4. " SVA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 8. " SVA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 9. " SIA_PIPE_L_RESETN "  "0 ,1 "
bitfld.long 0 10. " SIA_MMDSP_L_RESETN "  "0 ,1 "
bitfld.long 0 11. " SIA_PIPE_M_INITN "  "0 ,1 "
bitfld.long 0 12. " SIA_MMDSP_M_INITN "  "0 ,1 "
bitfld.long 0 13. " SIA_MMDSP_MRET_INITN "  "0 ,1 "
bitfld.long 0 14. " DSIPLL_RESETN "  "0 ,1 "
bitfld.long 0 17. " DDR_APE_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 18. " DDR_MOD_FIFO_RESETN "  "0 ,1 "
bitfld.long 0 19. " DDR_SS_L_RESETN "  "0 ,1 "
bitfld.long 0 20. " DDR_SS_L_RESETN_QUALIFIER "  "0 ,1 "
bitfld.long 0 21. " SPARE_1 "  "0 ,1 "
bitfld.long 0 22. " SIA_PIPE_M_RAD_RESETN "  "0 ,1 "
bitfld.long 0 24. " ESRAM1_INITN "  "0 ,1 "
bitfld.long 0 25. " ESRAM2_INITN "  "0 ,1 "
bitfld.long 0 26. " ESRAM3_INITN "  "0 ,1 "
bitfld.long 0 27. " ESRAM4_INITN "  "0 ,1 "
bitfld.long 0 29. " APE_MEM_INITN "  "0 ,1 "
bitfld.long 0 30. " APE_PWRON_RESETN "  "0 ,1 "
bitfld.long 0 31. " APE_RESETN "  "0 ,1 "
tree.end

base sd:0x801571f0
tree "PRCM_A9_RESETN_SET"
group 0--3
line.long 0 "PRCM_A9_RESETN_SET"
bitfld.long 0 0. " A9_NPORESET "  "0 ,1 "
bitfld.long 0 1. " A9_NRESET_SLICE "  "0 ,1 "
bitfld.long 0 2. " APE_NRESET "  "0 ,1 "
bitfld.long 0 3. " A9_NRESET_DBG "  "0 ,1 "
bitfld.long 0 4. " A9_NRESET_0 "  "0 ,1 "
bitfld.long 0 5. " A9_NRESET_1 "  "0 ,1 "
bitfld.long 0 6. " A9_WD_REQ_RESETN "  "0 ,1 "
bitfld.long 0 7. " A9_NRESET_SWPLL_FF "  "0 ,1 "
tree.end

base sd:0x801571f4
tree "PRCM_A9_RESETN_CLR"
group 0--3
line.long 0 "PRCM_A9_RESETN_CLR"
bitfld.long 0 0. " A9_NPORESET "  "0 ,1 "
bitfld.long 0 1. " A9_NRESET_SLICE "  "0 ,1 "
bitfld.long 0 2. " APE_NRESET "  "0 ,1 "
bitfld.long 0 3. " A9_NRESET_DBG "  "0 ,1 "
bitfld.long 0 4. " A9_NRESET_0 "  "0 ,1 "
bitfld.long 0 5. " A9_NRESET_1 "  "0 ,1 "
bitfld.long 0 6. " A9_WD_REQ_RESETN "  "0 ,1 "
bitfld.long 0 7. " A9_NRESET_SWPLL_FF "  "0 ,1 "
tree.end

base sd:0x801571f8
tree "PRCM_A9_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_A9_RESETN_VAL"
bitfld.long 0 0. " A9_NPORESET "  "0 ,1 "
bitfld.long 0 1. " A9_NRESET_SLICE "  "0 ,1 "
bitfld.long 0 2. " APE_NRESET "  "0 ,1 "
bitfld.long 0 3. " A9_NRESET_DBG "  "0 ,1 "
bitfld.long 0 4. " A9_NRESET_0 "  "0 ,1 "
bitfld.long 0 5. " A9_NRESET_1 "  "0 ,1 "
bitfld.long 0 6. " A9_WD_REQ_RESETN "  "0 ,1 "
bitfld.long 0 7. " A9_NRESET_SWPLL_FF "  "0 ,1 "
tree.end

base sd:0x801571fc
tree "PRCM_MOD_RESETN_SET"
group 0--3
line.long 0 "PRCM_MOD_RESETN_SET"
bitfld.long 0 0. " NPURESET "  "0 ,1 "
bitfld.long 0 1. " NSWRESET "  "0 ,1 "
tree.end

base sd:0x80157200
tree "PRCM_MOD_RESETN_CLR"
group 0--3
line.long 0 "PRCM_MOD_RESETN_CLR"
bitfld.long 0 0. " NPURESET "  "0 ,1 "
bitfld.long 0 1. " NSWRESET "  "0 ,1 "
tree.end

base sd:0x80157204
tree "PRCM_MOD_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_MOD_RESETN_VAL"
bitfld.long 0 0. " NPURESET "  "0 ,1 "
bitfld.long 0 1. " NSWRESET "  "0 ,1 "
tree.end

base sd:0x80157208
tree "PRCM_GPIO_RESETN_SET"
group 0--3
line.long 0 "PRCM_GPIO_RESETN_SET"
bitfld.long 0 0. " GPIO_RESETN_GRP0 "  "0 ,1 "
bitfld.long 0 1. " GPIO_RESETN_GRP0_MX "  "0 ,1 "
bitfld.long 0 2. " GPIO_RESETN_GRP1 "  "0 ,1 "
bitfld.long 0 3. " GPIO_RESETN_GRP1_MX "  "0 ,1 "
bitfld.long 0 4. " GPIO_RESETN_GRP2 "  "0 ,1 "
bitfld.long 0 5. " GPIO_RESETN_GRP2_MX "  "0 ,1 "
bitfld.long 0 6. " GPIO_RESETN_GRP3 "  "0 ,1 "
bitfld.long 0 7. " GPIO_RESETN_GRP3_MX "  "0 ,1 "
bitfld.long 0 8. " GPIO_RESETN_GRP4 "  "0 ,1 "
bitfld.long 0 9. " GPIO_RESETN_GRP4_MX "  "0 ,1 "
bitfld.long 0 10. " GPIO_RESETN_GRP5 "  "0 ,1 "
bitfld.long 0 11. " GPIO_RESETN_GRP5_MX "  "0 ,1 "
bitfld.long 0 12. " GPIO_RESETN_GRP6 "  "0 ,1 "
bitfld.long 0 13. " GPIO_RESETN_GRP6_MX "  "0 ,1 "
bitfld.long 0 14. " GPIO_RESETN_GRP7 "  "0 ,1 "
bitfld.long 0 15. " GPIO_RESETN_GRP7_MX "  "0 ,1 "
bitfld.long 0 16. " GPIO_RESETN_GRP8 "  "0 ,1 "
bitfld.long 0 17. " GPIO_RESETN_GRP8_MX "  "0 ,1 "
tree.end

base sd:0x8015720c
tree "PRCM_GPIO_RESETN_CLR"
group 0--3
line.long 0 "PRCM_GPIO_RESETN_CLR"
bitfld.long 0 0. " GPIO_RESETN_GRP0 "  "0 ,1 "
bitfld.long 0 1. " GPIO_RESETN_GRP0_MX "  "0 ,1 "
bitfld.long 0 2. " GPIO_RESETN_GRP1 "  "0 ,1 "
bitfld.long 0 3. " GPIO_RESETN_GRP1_MX "  "0 ,1 "
bitfld.long 0 4. " GPIO_RESETN_GRP2 "  "0 ,1 "
bitfld.long 0 5. " GPIO_RESETN_GRP2_MX "  "0 ,1 "
bitfld.long 0 6. " GPIO_RESETN_GRP3 "  "0 ,1 "
bitfld.long 0 7. " GPIO_RESETN_GRP3_MX "  "0 ,1 "
bitfld.long 0 8. " GPIO_RESETN_GRP4 "  "0 ,1 "
bitfld.long 0 9. " GPIO_RESETN_GRP4_MX "  "0 ,1 "
bitfld.long 0 10. " GPIO_RESETN_GRP5 "  "0 ,1 "
bitfld.long 0 11. " GPIO_RESETN_GRP5_MX "  "0 ,1 "
bitfld.long 0 12. " GPIO_RESETN_GRP6 "  "0 ,1 "
bitfld.long 0 13. " GPIO_RESETN_GRP6_MX "  "0 ,1 "
bitfld.long 0 14. " GPIO_RESETN_GRP7 "  "0 ,1 "
bitfld.long 0 15. " GPIO_RESETN_GRP7_MX "  "0 ,1 "
bitfld.long 0 16. " GPIO_RESETN_GRP8 "  "0 ,1 "
bitfld.long 0 17. " GPIO_RESETN_GRP8_MX "  "0 ,1 "
tree.end

base sd:0x80157210
tree "PRCM_GPIO_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_GPIO_RESETN_VAL"
bitfld.long 0 0. " GPIO_RESETN_GRP0 "  "0 ,1 "
bitfld.long 0 1. " GPIO_RESETN_GRP0_MX "  "0 ,1 "
bitfld.long 0 2. " GPIO_RESETN_GRP1 "  "0 ,1 "
bitfld.long 0 3. " GPIO_RESETN_GRP1_MX "  "0 ,1 "
bitfld.long 0 4. " GPIO_RESETN_GRP2 "  "0 ,1 "
bitfld.long 0 5. " GPIO_RESETN_GRP2_MX "  "0 ,1 "
bitfld.long 0 6. " GPIO_RESETN_GRP3 "  "0 ,1 "
bitfld.long 0 7. " GPIO_RESETN_GRP3_MX "  "0 ,1 "
bitfld.long 0 8. " GPIO_RESETN_GRP4 "  "0 ,1 "
bitfld.long 0 9. " GPIO_RESETN_GRP4_MX "  "0 ,1 "
bitfld.long 0 10. " GPIO_RESETN_GRP5 "  "0 ,1 "
bitfld.long 0 11. " GPIO_RESETN_GRP5_MX "  "0 ,1 "
bitfld.long 0 12. " GPIO_RESETN_GRP6 "  "0 ,1 "
bitfld.long 0 13. " GPIO_RESETN_GRP6_MX "  "0 ,1 "
bitfld.long 0 14. " GPIO_RESETN_GRP7 "  "0 ,1 "
bitfld.long 0 15. " GPIO_RESETN_GRP7_MX "  "0 ,1 "
bitfld.long 0 16. " GPIO_RESETN_GRP8 "  "0 ,1 "
bitfld.long 0 17. " GPIO_RESETN_GRP8_MX "  "0 ,1 "
tree.end

base sd:0x80157214
tree "PRCM_4500_RESETN_SET"
group 0--3
line.long 0 "PRCM_4500_RESETN_SET"
bitfld.long 0 0. " STN4500_RESETN "  "0 ,1 "
tree.end

base sd:0x80157218
tree "PRCM_4500_RESETN_CLR"
group 0--3
line.long 0 "PRCM_4500_RESETN_CLR"
bitfld.long 0 0. " STN4500_RESETN "  "0 ,1 "
tree.end

base sd:0x8015721c
tree "PRCM_4500_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_4500_RESETN_VAL"
bitfld.long 0 0. " STN4500_RESETN "  "0 ,1 "
tree.end

base sd:0x80157224
tree "PRCM_HSI_SOFTRST"
wgroup 0--3
line.long 0 "PRCM_HSI_SOFTRST"
bitfld.long 0 0. " HSITX_SOFTRST "  "0 ,1 "
bitfld.long 0 1. " HSIRX_SOFTRST "  "0 ,1 "
tree.end

base sd:0x80157228
tree "PRCM_APE_SOFTRST"
wgroup 0--3
line.long 0 "PRCM_APE_SOFTRST"
bitfld.long 0 0. " PRCM_APE_SOFTRST "  "0 ,1 "
tree.end

base sd:0x80157238
tree "PRCM_SWD_RST_TEMPO"
group 0--3
line.long 0 "PRCM_SWD_RST_TEMPO"
bitfld.long 0 0.--9. " PRCM_SWD_RST_TEMPO "  " "
tree.end

base sd:0x8015723c
tree "PRCM_RST_4500_TEMPO"
group 0--3
line.long 0 "PRCM_RST_4500_TEMPO"
bitfld.long 0 0.--9. " PRCM_RST_4500_TEMPO "  " "
tree.end

base sd:0x80157240
tree "PRCM_SVAMMDSP_IT"
group 0--3
line.long 0 "PRCM_SVAMMDSP_IT"
bitfld.long 0 0.--7. " PRCM_SVAMMDSP_IT "  " "
tree.end

base sd:0x80157244
tree "PRCM_SVAMMDSP_IT_CLR"
group 0--3
line.long 0 "PRCM_SVAMMDSP_IT_CLR"
bitfld.long 0 0. " PRCM_SVAMMDSP_IT_CLR "  "0 ,1 "
tree.end

base sd:0x80157248
tree "PRCM_SIAMMDSP_IT"
group 0--3
line.long 0 "PRCM_SIAMMDSP_IT"
bitfld.long 0 0.--7. " PRCM_SIAMMDSP_IT "  " "
tree.end

base sd:0x8015724c
tree "PRCM_SIAMMDSP_IT_CLR"
group 0--3
line.long 0 "PRCM_SIAMMDSP_IT_CLR"
bitfld.long 0 0. " PRCM_SIAMMDSP_IT_CLR "  "0 ,1 "
tree.end

base sd:0x80157250
tree "PRCM_STM_DATA"
wgroup 0--3
line.long 0 "PRCM_STM_DATA"
bitfld.long 0 0.--7. " PRCM_STM_DATA "  " "
tree.end

base sd:0x80157254
tree "PRCM_POWER_STATE_SET"
group 0--3
line.long 0 "PRCM_POWER_STATE_SET"
bitfld.long 0 0.--1. " VAPE_STATE "  " "
bitfld.long 0 2.--3. " VARM_STATE "  " "
bitfld.long 0 4. " DDR_CONTROLLER "  "0 ,1 "
bitfld.long 0 5.--6. " SIA_MMDSP_STATE "  " "
bitfld.long 0 7. " SIA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 8.--9. " SVA_MMDSP_STATE "  " "
bitfld.long 0 10. " SVA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 11. " DSS_STATE "  "0 ,1 "
bitfld.long 0 12. " SGA_STATE "  "0 ,1 "
bitfld.long 0 13.--14. " VMODEM_STATE "  " "
bitfld.long 0 15. " CSI_DSI "  "0 ,1 "
bitfld.long 0 16.--17. " ESRAM0_STATE "  " "
bitfld.long 0 18.--19. " ESRAM1_STATE "  " "
bitfld.long 0 20.--21. " ESRAM2_STATE "  " "
bitfld.long 0 22.--23. " ESRAM3_STATE "  " "
bitfld.long 0 24.--25. " ESRAM4_STATE "  " "
tree.end

base sd:0x80157258
tree "PRCM_POWER_STATE_CLR"
group 0--3
line.long 0 "PRCM_POWER_STATE_CLR"
bitfld.long 0 0.--1. " VAPE_STATE "  " "
bitfld.long 0 2.--3. " VARM_STATE "  " "
bitfld.long 0 4. " DDR_CONTROLLER "  "0 ,1 "
bitfld.long 0 5.--6. " SIA_MMDSP_STATE "  " "
bitfld.long 0 7. " SIA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 8.--9. " SVA_MMDSP_STATE "  " "
bitfld.long 0 10. " SVA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 11. " DSS_STATE "  "0 ,1 "
bitfld.long 0 12. " SGA_STATE "  "0 ,1 "
bitfld.long 0 13.--14. " VMODEM_STATE "  " "
bitfld.long 0 15. " CSI_DSI "  "0 ,1 "
bitfld.long 0 16.--17. " ESRAM0_STATE "  " "
bitfld.long 0 18.--19. " ESRAM1_STATE "  " "
bitfld.long 0 20.--21. " ESRAM2_STATE "  " "
bitfld.long 0 22.--23. " ESRAM3_STATE "  " "
bitfld.long 0 24.--25. " ESRAM4_STATE "  " "
tree.end

base sd:0x8015725c
tree "PRCM_POWER_STATE_VAL"
group 0--3
line.long 0 "PRCM_POWER_STATE_VAL"
bitfld.long 0 0.--1. " VAPE_STATE "  " "
bitfld.long 0 2.--3. " VARM_STATE "  " "
bitfld.long 0 4. " DDR_CONTROLLER "  "0 ,1 "
bitfld.long 0 5.--6. " SIA_MMDSP_STATE "  " "
bitfld.long 0 7. " SIA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 8.--9. " SVA_MMDSP_STATE "  " "
bitfld.long 0 10. " SVA_PIPE_STATE "  "0 ,1 "
bitfld.long 0 11. " DSS_STATE "  "0 ,1 "
bitfld.long 0 12. " SGA_STATE "  "0 ,1 "
bitfld.long 0 13.--14. " VMODEM_STATE "  " "
bitfld.long 0 15. " CSI_DSI "  "0 ,1 "
bitfld.long 0 16.--17. " ESRAM0_STATE "  " "
bitfld.long 0 18.--19. " ESRAM1_STATE "  " "
bitfld.long 0 20.--21. " ESRAM2_STATE "  " "
bitfld.long 0 22.--23. " ESRAM3_STATE "  " "
bitfld.long 0 24.--25. " ESRAM4_STATE "  " "
tree.end

base sd:0x80157260
tree "PRCM_ARMITVALUE31TO0"
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE31TO0"
bitfld.long 0 0.--31. " PRCM_ARMITVALUE31TO0 "  " "
tree.end

base sd:0x80157264
tree "PRCM_ARMITVALUE63TO32"
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE63TO32"
bitfld.long 0 0.--31. " PRCM_ARMITVALUE63TO32 "  " "
tree.end

base sd:0x80157268
tree "PRCM_ARMITVALUE95TO64"
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE95TO64"
bitfld.long 0 0.--31. " PRCM_ARMITVALUE95TO64 "  " "
tree.end

base sd:0x8015726c
tree "PRCM_ARMITVALUE127TO96"
rgroup 0--3
line.long 0 "PRCM_ARMITVALUE127TO96"
bitfld.long 0 0.--31. " PRCM_ARMITVALUE127TO96 "  " "
tree.end

base sd:0x80157270
tree "PRCM_REDUN_LOAD"
group 0--3
line.long 0 "PRCM_REDUN_LOAD"
bitfld.long 0 0. " PRCM_REDUN_GO_ARM "  "0 ,1 "
bitfld.long 0 1. " PRCM_REDUN_GO_SIA "  "0 ,1 "
tree.end

base sd:0x80157274
tree "PRCM_REDUN_STATUS"
rgroup 0--3
line.long 0 "PRCM_REDUN_STATUS"
bitfld.long 0 0. " PRCM_REDUN_OK_ARM "  "0 ,1 "
bitfld.long 0 1. " PRCM_REDUN_OK_SIA "  "0 ,1 "
bitfld.long 0 2. " PRCM_REDUN_OK_ESRAM "  "0 ,1 "
tree.end

base sd:0x80157278
tree "PRCM_UNIPROCLK_MGT"
rgroup 0--3
line.long 0 "PRCM_UNIPROCLK_MGT"
tree.end

base sd:0x8015727c
tree "PRCM_UICCCLK_MGT"
group 0--3
line.long 0 "PRCM_UICCCLK_MGT"
bitfld.long 0 0.--4. " UICCCLKPLLDIV "  " "
bitfld.long 0 8. " UICCCLKEN "  "0 ,1 "
bitfld.long 0 9. " UICCCLK38 "  "0 ,1 "
bitfld.long 0 10. " UICCCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " UICCCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157280
tree "PRCM_SSPCLK_MGT"
group 0--3
line.long 0 "PRCM_SSPCLK_MGT"
bitfld.long 0 0.--4. " SSPCLKPLLDIV "  " "
bitfld.long 0 5.--7. " SSPCLKPLLSW "  " "
bitfld.long 0 8. " SSPCLKEN "  "0 ,1 "
bitfld.long 0 9. " SSPCLK38 "  "0 ,1 "
bitfld.long 0 10. " SSPCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " SSPCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157284
tree "PRCM_RNGCLK_MGT"
group 0--3
line.long 0 "PRCM_RNGCLK_MGT"
bitfld.long 0 0.--4. " RNGCLKPLLDIV "  " "
bitfld.long 0 5.--7. " RNGCLKPLLSW "  " "
bitfld.long 0 8. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 9. " RNGCLK38 "  "0 ,1 "
bitfld.long 0 10. " RNGCLK38SRC "  "0 ,1 "
bitfld.long 0 11. " RNGCLK38DIV "  "0 ,1 "
tree.end

base sd:0x80157288
tree "PRCM_MSP1CLK_MGT"
group 0--3
line.long 0 "PRCM_MSP1CLK_MGT"
bitfld.long 0 0.--4. " MSP1CLKPLLDIV "  " "
bitfld.long 0 5.--7. " MSP1CLKPLLSW "  " "
bitfld.long 0 8. " MSP1CLKEN "  "0 ,1 "
bitfld.long 0 9. " MSP1CLK38 "  "0 ,1 "
bitfld.long 0 10. " MSP1CLK38SRC "  "0 ,1 "
bitfld.long 0 11. " MSP1CLK38DIV "  "0 ,1 "
tree.end

base sd:0x801572a0
tree "PRCM_DAP_RESETN_SET"
group 0--3
line.long 0 "PRCM_DAP_RESETN_SET"
bitfld.long 0 0. " DAP_RESETN "  "0 ,1 "
tree.end

base sd:0x801572a4
tree "PRCM_DAP_RESETN_CLR"
group 0--3
line.long 0 "PRCM_DAP_RESETN_CLR"
bitfld.long 0 0. " DAP_RESETN "  "0 ,1 "
tree.end

base sd:0x801572a8
tree "PRCM_DAP_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_DAP_RESETN_VAL"
bitfld.long 0 0. " DAP_RESETN "  "0 ,1 "
tree.end

base sd:0x80157300
tree "PRCM_SRAM_DEDCSTOV"
group 0--3
line.long 0 "PRCM_SRAM_DEDCSTOV"
bitfld.long 0 0.--5. " DC "  " "
bitfld.long 0 6. " DE "  "0 ,1 "
bitfld.long 0 7. " STOV "  "0 ,1 "
tree.end

base sd:0x80157304
tree "PRCM_SRAM_LS_SLEEP"
group 0--3
line.long 0 "PRCM_SRAM_LS_SLEEP"
bitfld.long 0 0. " SGA_SLEEP "  "0 ,1 "
bitfld.long 0 1. " SGA_LS "  "0 ,1 "
bitfld.long 0 2. " SVA_PIPE_SLEEP "  "0 ,1 "
bitfld.long 0 3. " SVA_PIPE_LS "  "0 ,1 "
bitfld.long 0 4. " SVA_MMDSP_SLEEP "  "0 ,1 "
bitfld.long 0 5. " SVA_MMDSP_LS "  "0 ,1 "
bitfld.long 0 6. " SIA_PIPE_SLEEP "  "0 ,1 "
bitfld.long 0 7. " SIA_PIPE_LS "  "0 ,1 "
bitfld.long 0 8. " SIA_MMDSP_SLEEP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_LS "  "0 ,1 "
bitfld.long 0 10. " DSS_SLEEP "  "0 ,1 "
bitfld.long 0 11. " DSS_LS "  "0 ,1 "
bitfld.long 0 14. " APE_SLEEP "  "0 ,1 "
bitfld.long 0 15. " APE_LS "  "0 ,1 "
bitfld.long 0 18. " ESRAM1_SLEEP "  "0 ,1 "
bitfld.long 0 19. " ESRAM1_LS "  "0 ,1 "
bitfld.long 0 20. " ESRAM2_SLEEP "  "0 ,1 "
bitfld.long 0 21. " ESRAM2_LS "  "0 ,1 "
bitfld.long 0 22. " ESRAM3_SLEEP "  "0 ,1 "
bitfld.long 0 23. " ESRAM3_LS "  "0 ,1 "
bitfld.long 0 24. " ESRAM4_SLEEP "  "0 ,1 "
bitfld.long 0 25. " ESRAM4_LS "  "0 ,1 "
bitfld.long 0 28. " SPARE "  "0 ,1 "
bitfld.long 0 29. " SVAROM_PDN "  "0 ,1 "
tree.end

base sd:0x80157308
tree "PRCM_SRAM_A9"
group 0--3
line.long 0 "PRCM_SRAM_A9"
bitfld.long 0 0.--5. " A9_DC "  " "
bitfld.long 0 6. " A9_DE "  "0 ,1 "
bitfld.long 0 7. " A9_STOV "  "0 ,1 "
bitfld.long 0 8. " A9_SLEEP "  "0 ,1 "
bitfld.long 0 9. " A9_LS "  "0 ,1 "
tree.end

base sd:0x8015730c
tree "PRCM_ARM_LS_CLAMP"
group 0--3
line.long 0 "PRCM_ARM_LS_CLAMP"
bitfld.long 0 0. " INCLAMP_I "  "0 ,1 "
bitfld.long 0 1. " OUTCLAMP_I "  "0 ,1 "
bitfld.long 0 2. " PLL_INLATCH_I "  "0 ,1 "
bitfld.long 0 3. " TST_CLK_INLATCH_I "  "0 ,1 "
bitfld.long 0 4. " TST_FCT_INLATCH_I "  "0 ,1 "
bitfld.long 0 5. " TST_OUTCLAMP_I "  "0 ,1 "
tree.end

base sd:0x80157310
tree "PRCM_IOCR"
group 0--3
line.long 0 "PRCM_IOCR"
bitfld.long 0 0. " IOFORCE "  "0 ,1 "
tree.end

base sd:0x80157314
tree "PRCM_MODEM_SYSCLKOK"
group 0--3
line.long 0 "PRCM_MODEM_SYSCLKOK"
bitfld.long 0 0.--1. " PRCM_MODEM_SYSCLKOK "  " "
tree.end

base sd:0x80157318
tree "PRCM_SYSCLKOK_DELAY"
group 0--3
line.long 0 "PRCM_SYSCLKOK_DELAY"
bitfld.long 0 0.--7. " PRCM_SYSCLKOK_DELAY "  " "
tree.end

base sd:0x8015731c
tree "PRCM_SYSCLKSTATUS"
rgroup 0--3
line.long 0 "PRCM_SYSCLKSTATUS"
bitfld.long 0 0. " SYSCLKIND_SYNC "  "0 ,1 "
bitfld.long 0 1. " SYSCLKLOCKED "  "0 ,1 "
tree.end

base sd:0x80157324
tree "PRCM_DSI_SW_RESET"
group 0--3
line.long 0 "PRCM_DSI_SW_RESET"
bitfld.long 0 0. " DSI0_SW_RESETN "  "0 ,1 "
bitfld.long 0 1. " DSI1_SW_RESETN "  "0 ,1 "
bitfld.long 0 2. " DSI2_SW_RESETN "  "0 ,1 "
tree.end

base sd:0x80157328
tree "PRCM_A9_MASK_REQ"
group 0--3
line.long 0 "PRCM_A9_MASK_REQ"
bitfld.long 0 0. " PRCM_A9_MASK_REQ "  "0 ,1 "
tree.end

base sd:0x8015732c
tree "PRCM_A9_MASK_ACK"
rgroup 0--3
line.long 0 "PRCM_A9_MASK_ACK"
bitfld.long 0 0. " PRCM_A9_MASK_ACK "  "0 ,1 "
tree.end

base sd:0x80157334
tree "PRCM_HOSTACCESS_REQ"
group 0--3
line.long 0 "PRCM_HOSTACCESS_REQ"
bitfld.long 0 0. " HOSTACCESS_REQ "  "0 ,1 "
bitfld.long 0 1.--2. " HOSTACCESS_ID "  " "
bitfld.long 0 16. " WAKE_REQ "  "0 ,1 "
tree.end

base sd:0x80157338
tree "PRCM_TIMER_3_REF"
group 0--3
line.long 0 "PRCM_TIMER_3_REF"
bitfld.long 0 0.--31. " PRCM_TIMER_3_REF "  " "
tree.end

base sd:0x8015733c
tree "PRCM_TIMER_3_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_3_DOWNCOUNT"
bitfld.long 0 0.--31. " PRCM_TIMER_3_DOWNCOUNT "  " "
tree.end

base sd:0x80157340
tree "PRCM_TIMER_3_MODE"
group 0--3
line.long 0 "PRCM_TIMER_3_MODE"
bitfld.long 0 0. " PRCM_TIMER_3_MODE "  "0 ,1 "
tree.end

base sd:0x80157344
tree "PRCM_PMB_SENS_CTRL"
group 0--3
line.long 0 "PRCM_PMB_SENS_CTRL"
bitfld.long 0 0.--3. " SEL "  " "
bitfld.long 0 6.--7. " DIV_SPEED "  " "
bitfld.long 0 8.--9. " DIV_LEAK "  " "
bitfld.long 0 10. " SENS_RUN "  "0 ,1 "
bitfld.long 0 11.--12. " SMODE "  " "
bitfld.long 0 13. " AUX_SEL "  "0 ,1 "
bitfld.long 0 14. " ALL_SENS "  "0 ,1 "
bitfld.long 0 15. " PD_SENS "  "0 ,1 "
tree.end

base sd:0x80157348
tree "PRCM_PMB_REF_COUNTER"
group 0--3
line.long 0 "PRCM_PMB_REF_COUNTER"
bitfld.long 0 0.--15. " REF_COUNTER "  " "
tree.end

base sd:0x8015734c
tree "PRCM_PMB_SENSOR_STATUS"
group 0--3
line.long 0 "PRCM_PMB_SENSOR_STATUS"
bitfld.long 0 0.--15. " SENSOR_STATUS "  " "
tree.end

base sd:0x80157400
tree "PRCM_SEM"
group 0--3
line.long 0 "PRCM_SEM"
bitfld.long 0 0. " PRCM_SEM "  "0 ,1 "
tree.end

base sd:0x80157404
tree "PRCM_APE_EPOD_CFG"
group 0--3
line.long 0 "PRCM_APE_EPOD_CFG"
bitfld.long 0 0.--1. " VDDI_WAKEUP_CUR_0 "  " "
bitfld.long 0 2.--3. " VDDI_WAKEUP_CUR_1 "  " "
bitfld.long 0 4.--6. " VDDI_BIAS_VOLT_0 "  " "
bitfld.long 0 7.--9. " VDDI_BIAS_VOLT_1 "  " "
bitfld.long 0 10.--11. " VDDI_BIAS_CUR_0 "  " "
bitfld.long 0 12.--13. " BIAS_BOOST_VDDI_ESRAM "  " "
bitfld.long 0 14.--15. " VDDI_BIAS_CUR_1 "  " "
bitfld.long 0 16. " BIAS_BOOST_VDDI_MMDSP "  "0 ,1 "
tree.end

base sd:0x80157408
tree "PRCM_DDR_EPOD_CFG"
group 0--3
line.long 0 "PRCM_DDR_EPOD_CFG"
bitfld.long 0 0.--1. " GNDI_WAKEUP_CUR "  " "
bitfld.long 0 2.--3. " VDDI_WAKEUP_CUR "  " "
bitfld.long 0 4.--5. " GNDI_BIAS_VOLT "  " "
bitfld.long 0 6.--8. " VDDI_BIAS_VOLT_CTRL "  " "
bitfld.long 0 9.--11. " VDDI_BIAS_VOLT_PHY "  " "
bitfld.long 0 12.--13. " BIAS_CUR_CTRL "  " "
bitfld.long 0 14. " BIAS_BOOST_GNDI_CTRL "  "0 ,1 "
bitfld.long 0 15.--17. " BIAS_BOOST_VDDI_CTRL "  " "
tree.end

base sd:0x80157410
tree "PRCM_EPOD_C_SET"
group 0--3
line.long 0 "PRCM_EPOD_C_SET"
bitfld.long 0 0. " ESRAM1_2_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM1_2_RET "  "0 ,1 "
bitfld.long 0 2. " ESRAM3_4_ON "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_4_RET "  "0 ,1 "
bitfld.long 0 8. " SGA_L_ON "  "0 ,1 "
bitfld.long 0 9. " SGA_M_ON "  "0 ,1 "
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 11. " SVA_M_ON "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_ON "  "0 ,1 "
bitfld.long 0 13. " SVA_MM_M_ON "  "0 ,1 "
bitfld.long 0 14. " SVA_MM_M_RET "  "0 ,1 "
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 16. " SIA_M_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "
bitfld.long 0 18. " SIA_MM_M_ON "  "0 ,1 "
bitfld.long 0 19. " SIA_MM_M_RET "  "0 ,1 "
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "
bitfld.long 0 21. " DSS_M_ON "  "0 ,1 "
bitfld.long 0 22. " APERAMS_ON "  "0 ,1 "
tree.end

base sd:0x80157414
tree "PRCM_EPOD_C_CLR"
group 0--3
line.long 0 "PRCM_EPOD_C_CLR"
bitfld.long 0 0. " ESRAM1_2_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM1_2_RET "  "0 ,1 "
bitfld.long 0 2. " ESRAM3_4_ON "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_4_RET "  "0 ,1 "
bitfld.long 0 8. " SGA_L_ON "  "0 ,1 "
bitfld.long 0 9. " SGA_M_ON "  "0 ,1 "
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 11. " SVA_M_ON "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_ON "  "0 ,1 "
bitfld.long 0 13. " SVA_MM_M_ON "  "0 ,1 "
bitfld.long 0 14. " SVA_MM_M_RET "  "0 ,1 "
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 16. " SIA_M_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "
bitfld.long 0 18. " SIA_MM_M_ON "  "0 ,1 "
bitfld.long 0 19. " SIA_MM_M_RET "  "0 ,1 "
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "
bitfld.long 0 21. " DSS_M_ON "  "0 ,1 "
bitfld.long 0 22. " APERAMS_ON "  "0 ,1 "
tree.end

base sd:0x80157418
tree "PRCM_EPOD_C_VAL"
group 0--3
line.long 0 "PRCM_EPOD_C_VAL"
bitfld.long 0 0. " ESRAM1_2_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM1_2_RET "  "0 ,1 "
bitfld.long 0 2. " ESRAM3_4_ON "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_4_RET "  "0 ,1 "
bitfld.long 0 8. " SGA_L_ON "  "0 ,1 "
bitfld.long 0 9. " SGA_M_ON "  "0 ,1 "
bitfld.long 0 10. " SVA_L_ON "  "0 ,1 "
bitfld.long 0 11. " SVA_M_ON "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_ON "  "0 ,1 "
bitfld.long 0 13. " SVA_MM_M_ON "  "0 ,1 "
bitfld.long 0 14. " SVA_MM_M_RET "  "0 ,1 "
bitfld.long 0 15. " SIA_L_ON "  "0 ,1 "
bitfld.long 0 16. " SIA_M_ON "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_ON "  "0 ,1 "
bitfld.long 0 18. " SIA_MM_M_ON "  "0 ,1 "
bitfld.long 0 19. " SIA_MM_M_RET "  "0 ,1 "
bitfld.long 0 20. " DSS_L_ON "  "0 ,1 "
bitfld.long 0 21. " DSS_M_ON "  "0 ,1 "
bitfld.long 0 22. " APERAMS_ON "  "0 ,1 "
tree.end

base sd:0x8015741c
tree "PRCM_EPOD_VOK"
rgroup 0--3
line.long 0 "PRCM_EPOD_VOK"
bitfld.long 0 0. " ESRAM1_2_VOK "  "0 ,1 "
bitfld.long 0 1. " ESRAM3_4_VOK "  "0 ,1 "
bitfld.long 0 8. " SGA_L_VOK "  "0 ,1 "
bitfld.long 0 9. " SGA_M_VOK "  "0 ,1 "
bitfld.long 0 10. " SVA_L_VOK "  "0 ,1 "
bitfld.long 0 11. " SVA_M_VOK "  "0 ,1 "
bitfld.long 0 12. " SVA_MM_L_VOK "  "0 ,1 "
bitfld.long 0 13. " SVA_MM_M_VOK "  "0 ,1 "
bitfld.long 0 14. " SVA_MM_MRET_VOK "  "0 ,1 "
bitfld.long 0 15. " SIA_L_VOK "  "0 ,1 "
bitfld.long 0 16. " SIA_M_VOK "  "0 ,1 "
bitfld.long 0 17. " SIA_MM_L_VOK "  "0 ,1 "
bitfld.long 0 18. " SIA_MM_M_VOK "  "0 ,1 "
bitfld.long 0 19. " SIA_MM_MRET_VOK "  "0 ,1 "
bitfld.long 0 20. " DSS_L_VOK "  "0 ,1 "
bitfld.long 0 21. " DSS_M_VOK "  "0 ,1 "
bitfld.long 0 22. " APERAMS_M_VOK "  "0 ,1 "
tree.end

base sd:0x80157420
tree "PRCM_MMIP_LS_CLAMP_SET"
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_SET"
bitfld.long 0 0. " SIA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 1. " SVA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 2. " ESRAM2_CLAMP "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_CLAMP "  "0 ,1 "
bitfld.long 0 4. " ESRAM4_CLAMP "  "0 ,1 "
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "
bitfld.long 0 11. " DSIPLL_CLAMP "  "0 ,1 "
bitfld.long 0 16. " SGA_CLAMPI "  "0 ,1 "
bitfld.long 0 17. " SVA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 18. " SVA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 19. " SIA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 20. " SIA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 21. " DSS_CLAMPI "  "0 ,1 "
bitfld.long 0 22. " DSIPLL_CLAMPI "  "0 ,1 "
tree.end

base sd:0x80157424
tree "PRCM_MMIP_LS_CLAMP_CLR"
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_CLR"
bitfld.long 0 0. " SIA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 1. " SVA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 2. " ESRAM2_CLAMP "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_CLAMP "  "0 ,1 "
bitfld.long 0 4. " ESRAM4_CLAMP "  "0 ,1 "
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "
bitfld.long 0 11. " DSIPLL_CLAMP "  "0 ,1 "
bitfld.long 0 16. " SGA_CLAMPI "  "0 ,1 "
bitfld.long 0 17. " SVA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 18. " SVA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 19. " SIA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 20. " SIA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 21. " DSS_CLAMPI "  "0 ,1 "
bitfld.long 0 22. " DSIPLL_CLAMPI "  "0 ,1 "
tree.end

base sd:0x80157428
tree "PRCM_MMIP_LS_CLAMP_VAL"
group 0--3
line.long 0 "PRCM_MMIP_LS_CLAMP_VAL"
bitfld.long 0 0. " SIA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 1. " SVA_MM_IT_MSK "  "0 ,1 "
bitfld.long 0 2. " ESRAM2_CLAMP "  "0 ,1 "
bitfld.long 0 3. " ESRAM3_CLAMP "  "0 ,1 "
bitfld.long 0 4. " ESRAM4_CLAMP "  "0 ,1 "
bitfld.long 0 5. " SGA_CLAMP "  "0 ,1 "
bitfld.long 0 6. " SVA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 7. " SVA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 8. " SIA_PIPE_CLAMP "  "0 ,1 "
bitfld.long 0 9. " SIA_MMDSP_CLAMP "  "0 ,1 "
bitfld.long 0 10. " DSS_CLAMP "  "0 ,1 "
bitfld.long 0 11. " DSIPLL_CLAMP "  "0 ,1 "
bitfld.long 0 16. " SGA_CLAMPI "  "0 ,1 "
bitfld.long 0 17. " SVA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 18. " SVA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 19. " SIA_PIPE_CLAMPI "  "0 ,1 "
bitfld.long 0 20. " SIA_MMDSP_CLAMPI "  "0 ,1 "
bitfld.long 0 21. " DSS_CLAMPI "  "0 ,1 "
bitfld.long 0 22. " DSIPLL_CLAMPI "  "0 ,1 "
tree.end

base sd:0x8015742c
tree "PRCM_VSAFE_LS_CLAMP_SET"
group 0--3
line.long 0 "PRCM_VSAFE_LS_CLAMP_SET"
bitfld.long 0 0. " VAPE_VSAFE_FIFOCLAMP "  "0 ,1 "
bitfld.long 0 1. " VAPE_VSAFE_HOLD_0 "  "0 ,1 "
bitfld.long 0 2. " VAPE_VSAFE_CLAMP_0 "  "0 ,1 "
bitfld.long 0 3. " VAPE_VSAFE_HOLD_1 "  "0 ,1 "
bitfld.long 0 4. " VAPE_VSAFE_CLAMP_1 "  "0 ,1 "
bitfld.long 0 5. " VAPE_VSAFE_HOLD_2 "  "0 ,1 "
bitfld.long 0 6. " VAPE_VSAFE_CSI_CLAMP "  "0 ,1 "
bitfld.long 0 7. " VAPE_VSAFE_HOLD_3 "  "0 ,1 "
bitfld.long 0 8. " VAPE_VSAFE_CLAMP_3 "  "0 ,1 "
bitfld.long 0 16. " PMB_CLAMP_VARM "  "0 ,1 "
bitfld.long 0 17. " PMB_CLAMP_VAPE "  "0 ,1 "
bitfld.long 0 18. " PMB_CLAMP_VMODEM "  "0 ,1 "
tree.end

base sd:0x80157430
tree "PRCM_VSAFE_LS_CLAMP_CLR"
group 0--3
line.long 0 "PRCM_VSAFE_LS_CLAMP_CLR"
bitfld.long 0 0. " VAPE_VSAFE_FIFOCLAMP "  "0 ,1 "
bitfld.long 0 1. " VAPE_VSAFE_HOLD_0 "  "0 ,1 "
bitfld.long 0 2. " VAPE_VSAFE_CLAMP_0 "  "0 ,1 "
bitfld.long 0 3. " VAPE_VSAFE_HOLD_1 "  "0 ,1 "
bitfld.long 0 4. " VAPE_VSAFE_CLAMP_1 "  "0 ,1 "
bitfld.long 0 5. " VAPE_VSAFE_HOLD_2 "  "0 ,1 "
bitfld.long 0 6. " VAPE_VSAFE_CSI_CLAMP "  "0 ,1 "
bitfld.long 0 7. " VAPE_VSAFE_HOLD_3 "  "0 ,1 "
bitfld.long 0 8. " VAPE_VSAFE_CLAMP_3 "  "0 ,1 "
bitfld.long 0 16. " PMB_CLAMP_VARM "  "0 ,1 "
bitfld.long 0 17. " PMB_CLAMP_VAPE "  "0 ,1 "
bitfld.long 0 18. " PMB_CLAMP_VMODEM "  "0 ,1 "
tree.end

base sd:0x80157434
tree "PRCM_VSAFE_LS_CLAMP_VAL"
group 0--3
line.long 0 "PRCM_VSAFE_LS_CLAMP_VAL"
bitfld.long 0 0. " VAPE_VSAFE_FIFOCLAMP "  "0 ,1 "
bitfld.long 0 1. " VAPE_VSAFE_HOLD_0 "  "0 ,1 "
bitfld.long 0 2. " VAPE_VSAFE_CLAMP_0 "  "0 ,1 "
bitfld.long 0 3. " VAPE_VSAFE_HOLD_1 "  "0 ,1 "
bitfld.long 0 4. " VAPE_VSAFE_CLAMP_1 "  "0 ,1 "
bitfld.long 0 5. " VAPE_VSAFE_HOLD_2 "  "0 ,1 "
bitfld.long 0 6. " VAPE_VSAFE_CSI_CLAMP "  "0 ,1 "
bitfld.long 0 7. " VAPE_VSAFE_HOLD_3 "  "0 ,1 "
bitfld.long 0 8. " VAPE_VSAFE_CLAMP_3 "  "0 ,1 "
bitfld.long 0 16. " PMB_CLAMP_VARM "  "0 ,1 "
bitfld.long 0 17. " PMB_CLAMP_VAPE "  "0 ,1 "
bitfld.long 0 18. " PMB_CLAMP_VMODEM "  "0 ,1 "
tree.end

base sd:0x80157438
tree "PRCM_DDRSUBSYS_APE_MINBW"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_APE_MINBW"
bitfld.long 0 0.--1. " APE_MIN_BW "  " "
tree.end

base sd:0x8015743c
tree "PRCM_DDRSUBSYS_STATUS"
rgroup 0--3
line.long 0 "PRCM_DDRSUBSYS_STATUS"
bitfld.long 0 0.--4. " MAIN_FSM_STATE "  " "
bitfld.long 0 5.--6. " EFFECTIVE_MIN_BW "  " "
bitfld.long 0 7. " CORE_VDDIOK "  "0 ,1 "
bitfld.long 0 8. " CORE_GNDIOK "  "0 ,1 "
bitfld.long 0 9. " PHY_VDDIOK "  "0 ,1 "
bitfld.long 0 10.--13. " CORE_DOMAIN_FSM_STATE "  " "
bitfld.long 0 14.--16. " PHY_DOMAIN_FSM_STATE "  " "
bitfld.long 0 17.--19. " PLL_FSM_STATE "  " "
bitfld.long 0 20.--31. " SPARE "  " "
tree.end

base sd:0x80157440
tree "PRCM_DDRSUBSYS_CONTROL"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_CONTROL"
bitfld.long 0 0. " CORE_BIAS_DISABLE "  "0 ,1 "
bitfld.long 0 1. " CORE_OFF_DISABLE "  "0 ,1 "
bitfld.long 0 2. " PHY_OFF_DISABLE "  "0 ,1 "
bitfld.long 0 3.--4. " SPARE_1 "  " "
bitfld.long 0 5. " FREQDIV_BY4_DISABLE "  "0 ,1 "
bitfld.long 0 6. " CORE_ISOLATION_RESYNCH_DISABLE "  "0 ,1 "
bitfld.long 0 7. " FORCE_CORE_ISOLATION "  "0 ,1 "
bitfld.long 0 8. " FORCE_PHY_IO_ISOLATION "  "0 ,1 "
bitfld.long 0 9. " VREF_IO_SET_WITH_EXTERNAL_VREF "  "0 ,1 "
bitfld.long 0 10.--23. " SPARE_2 "  " "
tree.end

base sd:0x80157444
tree "PRCM_DDRSUBSYS_HIGH_LEAK_COND"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_HIGH_LEAK_COND"
bitfld.long 0 0. " HIGH_LEAK "  "0 ,1 "
tree.end

base sd:0x80157448
tree "PRCM_DDRSUBSYS_CONFIG"
rgroup 0--3
line.long 0 "PRCM_DDRSUBSYS_CONFIG"
bitfld.long 0 0.--1. " DDRCONFIG_REQ "  " "
tree.end

base sd:0x8015744c
tree "PRCM_DDRSUBSYS_CONFIG_ACK"
group 0--3
line.long 0 "PRCM_DDRSUBSYS_CONFIG_ACK"
bitfld.long 0 0.--1. " DDRCONFIG_ACK "  " "
tree.end

base sd:0x80157450
tree "PRCM_TIMER_4_REF"
group 0--3
line.long 0 "PRCM_TIMER_4_REF"
bitfld.long 0 0.--31. " PRCM_TIMER_4_REF "  " "
tree.end

base sd:0x80157454
tree "PRCM_TIMER_4_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_4_DOWNCOUNT"
bitfld.long 0 0.--31. " PRCM_TIMER_4_DOWNCOUNT "  " "
tree.end

base sd:0x80157458
tree "PRCM_TIMER_4_MODE"
group 0--3
line.long 0 "PRCM_TIMER_4_MODE"
bitfld.long 0 0. " PRCM_TIMER_4_MODE "  "0 ,1 "
tree.end

base sd:0x8015745c
tree "PRCM_TIMER_5_REF"
group 0--3
line.long 0 "PRCM_TIMER_5_REF"
bitfld.long 0 0.--31. " PRCM_TIMER_5_REF "  " "
tree.end

base sd:0x80157460
tree "PRCM_TIMER_5_DOWNCOUNT"
group 0--3
line.long 0 "PRCM_TIMER_5_DOWNCOUNT"
bitfld.long 0 0.--31. " PRCM_TIMER_5_DOWNCOUNT "  " "
tree.end

base sd:0x80157464
tree "PRCM_TIMER_5_MODE"
group 0--3
line.long 0 "PRCM_TIMER_5_MODE"
bitfld.long 0 0. " PRCM_TIMER_5_MODE "  "0 ,1 "
tree.end

base sd:0x8015746c
tree "PRCM_SEM_A9_IT_CLR"
group 0--3
line.long 0 "PRCM_SEM_A9_IT_CLR"
bitfld.long 0 0. " PRCM_SEM_A9_IT_CLR "  "0 ,1 "
tree.end

base sd:0x80157470
tree "PRCM_APE_MEM_REQ"
group 0--3
line.long 0 "PRCM_APE_MEM_REQ"
bitfld.long 0 0. " APE_MEM_REQ "  "0 ,1 "
tree.end

base sd:0x80157474
tree "PRCM_DBG_FORCES_APE_MEM_REQ"
group 0--3
line.long 0 "PRCM_DBG_FORCES_APE_MEM_REQ"
bitfld.long 0 0. " DBG_FORCES_APE_MEM_REQ "  "0 ,1 "
tree.end

base sd:0x80157478
tree "PRCM_APE_MEM_WFX_EN"
group 0--3
line.long 0 "PRCM_APE_MEM_WFX_EN"
bitfld.long 0 0. " PL310_IDLE_ENABLE "  "0 ,1 "
bitfld.long 0 1. " WFI_0_ENABLE "  "0 ,1 "
bitfld.long 0 2. " WFI_1_ENABLE "  "0 ,1 "
bitfld.long 0 3. " WFE_0_ENABLE "  "0 ,1 "
bitfld.long 0 4. " WFE_1_ENABLE "  "0 ,1 "
tree.end

base sd:0x8015747c
tree "PRCM_APE_MEM_LATENCY"
group 0--3
line.long 0 "PRCM_APE_MEM_LATENCY"
bitfld.long 0 0. " APE_MEM_LATENCY "  "0 ,1 "
tree.end

base sd:0x80157480
tree "PRCM_APE_MEM_ACK"
rgroup 0--3
line.long 0 "PRCM_APE_MEM_ACK"
bitfld.long 0 0. " APE_MEM_ACK "  "0 ,1 "
tree.end

base sd:0x80157484
tree "PRCM_ITSTATUS5"
rgroup 0--3
line.long 0 "PRCM_ITSTATUS5"
bitfld.long 0 0.--8. " GPIO_EVENTS "  " "
tree.end

base sd:0x80157488
tree "PRCM_ITCLR5"
wgroup 0--3
line.long 0 "PRCM_ITCLR5"
bitfld.long 0 0.--8. " GPIO_EVENTS "  " "
tree.end

base sd:0x8015748c
tree "PRCM_ARM_IT1_CLR"
group 0--3
line.long 0 "PRCM_ARM_IT1_CLR"
bitfld.long 0 0.--7. " PRCM_ARM_IT1_CLR "  " "
tree.end

base sd:0x80157490
tree "PRCM_ARM_IT1_SET"
group 0--3
line.long 0 "PRCM_ARM_IT1_SET"
bitfld.long 0 0.--7. " PRCM_ARM_IT1_SET "  " "
tree.end

base sd:0x80157494
tree "PRCM_ARM_IT1_VAL"
group 0--3
line.long 0 "PRCM_ARM_IT1_VAL"
bitfld.long 0 0.--7. " PRCM_ARM_IT1_VAL "  " "
tree.end

base sd:0x80157498
tree "PRCM_MOD_PWR_OK"
group 0--3
line.long 0 "PRCM_MOD_PWR_OK"
bitfld.long 0 0. " PRCM_MOD_PWR_OK "  "0 ,1 "
tree.end

base sd:0x8015749c
tree "PRCM_MOD_AUXCLKOK"
group 0--3
line.long 0 "PRCM_MOD_AUXCLKOK"
bitfld.long 0 0. " PRCM_MOD_AUXCLKOK "  "0 ,1 "
tree.end

base sd:0x801574a0
tree "PRCM_MOD_AWAKE_STATUS"
rgroup 0--3
line.long 0 "PRCM_MOD_AWAKE_STATUS"
bitfld.long 0 0. " PRCM_MOD_COREPD_AWAKE "  "0 ,1 "
bitfld.long 0 1. " PRCM_MOD_AAPD_AWAKE "  "0 ,1 "
bitfld.long 0 2. " PRCM_MOD_VMODEM_OFF_ISO "  "0 ,1 "
tree.end

base sd:0x801574a4
tree "PRCM_MOD_SWRESET_IRQ_ACK"
group 0--3
line.long 0 "PRCM_MOD_SWRESET_IRQ_ACK"
bitfld.long 0 0. " PRCM_MOD_SWRESET_IRQ_ACK "  "0 ,1 "
tree.end

base sd:0x801574a8
tree "PRCM_MOD_SWRESET_ACK"
rgroup 0--3
line.long 0 "PRCM_MOD_SWRESET_ACK"
bitfld.long 0 0. " PRCM_MOD_SWRESET_ACK "  "0 ,1 "
tree.end

base sd:0x801574ac
tree "PRCM_DBG_PWRCTL"
group 0--3
line.long 0 "PRCM_DBG_PWRCTL"
bitfld.long 0 0. " A9PWRUPEN "  "0 ,1 "
bitfld.long 0 1. " MODPWRUPEN "  "0 ,1 "
bitfld.long 0 2. " MODNOPWRDN "  "0 ,1 "
tree.end

base sd:0x801574b0
tree "PRCM_HWOBS_H"
group 0--3
line.long 0 "PRCM_HWOBS_H"
bitfld.long 0 0.--1. " HW_OBS_SEL_16 "  " "
bitfld.long 0 2.--3. " HW_OBS_SEL_17 "  " "
bitfld.long 0 4. " HW_OBS_EN "  "0 ,1 "
tree.end

base sd:0x801574b4
tree "PRCM_HWOBS_L"
group 0--3
line.long 0 "PRCM_HWOBS_L"
bitfld.long 0 0.--1. " HW_OBS_SEL_0 "  " "
bitfld.long 0 2.--3. " HW_OBS_SEL_1 "  " "
bitfld.long 0 4.--5. " HW_OBS_SEL_2 "  " "
bitfld.long 0 6.--7. " HW_OBS_SEL_3 "  " "
bitfld.long 0 8.--9. " HW_OBS_SEL_4 "  " "
bitfld.long 0 10.--11. " HW_OBS_SEL_5 "  " "
bitfld.long 0 12.--13. " HW_OBS_SEL_6 "  " "
bitfld.long 0 14.--15. " HW_OBS_SEL_7 "  " "
bitfld.long 0 16.--17. " HW_OBS_SEL_8 "  " "
bitfld.long 0 18.--19. " HW_OBS_SEL_9 "  " "
bitfld.long 0 20.--21. " HW_OBS_SEL_10 "  " "
bitfld.long 0 22.--23. " HW_OBS_SEL_11 "  " "
bitfld.long 0 24.--25. " HW_OBS_SEL_12 "  " "
bitfld.long 0 26.--27. " HW_OBS_SEL_13 "  " "
bitfld.long 0 28.--29. " HW_OBS_SEL_14 "  " "
bitfld.long 0 30.--31. " HW_OBS_SEL_15 "  " "
tree.end

base sd:0x80157500
tree "PRCM_PLLDSI_FREQ"
group 0--3
line.long 0 "PRCM_PLLDSI_FREQ"
bitfld.long 0 0.--7. " D "  " "
bitfld.long 0 8.--13. " N "  " "
bitfld.long 0 16.--18. " R "  " "
bitfld.long 0 24. " SELDIV2 "  "0 ,1 "
tree.end

base sd:0x80157504
tree "PRCM_PLLDSI_ENABLE"
group 0--3
line.long 0 "PRCM_PLLDSI_ENABLE"
bitfld.long 0 0. " PRCM_PLLDSI_ENABLE "  "0 ,1 "
tree.end

base sd:0x80157508
tree "PRCM_PLLDSI_LOCKP"
rgroup 0--3
line.long 0 "PRCM_PLLDSI_LOCKP"
bitfld.long 0 0. " PRCM_PLLDSI_LOCKP10 "  "0 ,1 "
bitfld.long 0 1. " PRCM_PLLDSI_LOCKP3 "  "0 ,1 "
tree.end

base sd:0x8015750c
tree "PRCM_RNG_ENABLE"
group 0--3
line.long 0 "PRCM_RNG_ENABLE"
bitfld.long 0 0. " PRCM_RNG_ENABLE "  "0 ,1 "
tree.end

base sd:0x80157510
tree "PRCM_YYCLKEN0_MGT_SET"
group 0--3
line.long 0 "PRCM_YYCLKEN0_MGT_SET"
bitfld.long 0 0. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 1. " ACLKEN "  "0 ,1 "
bitfld.long 0 2. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 3. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 4. " SGACLKEN "  "0 ,1 "
bitfld.long 0 5. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 6. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 7. " MSP1CLKEN "  "0 ,1 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 10. " SLIMCLKEN "  "0 ,1 "
bitfld.long 0 11. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 12. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 13. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 14. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 15. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 16. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 17. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 18. " BMLCLKEN "  "0 ,1 "
bitfld.long 0 19. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 20. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 21. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 22. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 23. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 24. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 25. " IPI2CCLKEN "  "0 ,1 "
bitfld.long 0 26. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 27. " DMACLKEN "  "0 ,1 "
bitfld.long 0 28. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 29. " TVCLKEN "  "0 ,1 "
bitfld.long 0 30. " SPARE_UNIPROCLKEN "  "0 ,1 "
bitfld.long 0 31. " SSPCLKEN "  "0 ,1 "
tree.end

base sd:0x80157514
tree "PRCM_YYCLKEN1_MGT_SET"
group 0--3
line.long 0 "PRCM_YYCLKEN1_MGT_SET"
bitfld.long 0 0. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 1. " UICCCLKEN "  "0 ,1 "
bitfld.long 0 8. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE2CLKEN "  "0 ,1 "
tree.end

base sd:0x80157518
tree "PRCM_YYCLKEN0_MGT_CLR"
group 0--3
line.long 0 "PRCM_YYCLKEN0_MGT_CLR"
bitfld.long 0 0. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 1. " ACLKEN "  "0 ,1 "
bitfld.long 0 2. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 3. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 4. " SGACLKEN "  "0 ,1 "
bitfld.long 0 5. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 6. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 7. " MSP1CLKEN "  "0 ,1 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 10. " SLIMCLKEN "  "0 ,1 "
bitfld.long 0 11. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 12. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 13. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 14. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 15. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 16. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 17. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 18. " BMLCLKEN "  "0 ,1 "
bitfld.long 0 19. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 20. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 21. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 22. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 23. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 24. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 25. " IPI2CCLKEN "  "0 ,1 "
bitfld.long 0 26. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 27. " DMACLKEN "  "0 ,1 "
bitfld.long 0 28. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 29. " TVCLKEN "  "0 ,1 "
bitfld.long 0 30. " SPARE_UNIPROCLKEN "  "0 ,1 "
bitfld.long 0 31. " SSPCLKEN "  "0 ,1 "
tree.end

base sd:0x8015751c
tree "PRCM_YYCLKEN1_MGT_CLR"
group 0--3
line.long 0 "PRCM_YYCLKEN1_MGT_CLR"
bitfld.long 0 0. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 1. " UICCCLKEN "  "0 ,1 "
bitfld.long 0 8. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE2CLKEN "  "0 ,1 "
tree.end

base sd:0x80157520
tree "PRCM_YYCLKEN0_MGT_VAL"
group 0--3
line.long 0 "PRCM_YYCLKEN0_MGT_VAL"
bitfld.long 0 0. " ARMCLKEN "  "0 ,1 "
bitfld.long 0 1. " ACLKEN "  "0 ,1 "
bitfld.long 0 2. " SVAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 3. " SIAMMDSPCLKEN "  "0 ,1 "
bitfld.long 0 4. " SGACLKEN "  "0 ,1 "
bitfld.long 0 5. " UARTCLKEN "  "0 ,1 "
bitfld.long 0 6. " MSP02CLKEN "  "0 ,1 "
bitfld.long 0 7. " MSP1CLKEN "  "0 ,1 "
bitfld.long 0 8. " I2CCLKEN "  "0 ,1 "
bitfld.long 0 9. " SDMMCCLKEN "  "0 ,1 "
bitfld.long 0 10. " SLIMCLKEN "  "0 ,1 "
bitfld.long 0 11. " PER1CLKEN "  "0 ,1 "
bitfld.long 0 12. " PER2CLKEN "  "0 ,1 "
bitfld.long 0 13. " PER3CLKEN "  "0 ,1 "
bitfld.long 0 14. " PER5CLKEN "  "0 ,1 "
bitfld.long 0 15. " PER6CLKEN "  "0 ,1 "
bitfld.long 0 16. " PER7CLKEN "  "0 ,1 "
bitfld.long 0 17. " LCDCLKEN "  "0 ,1 "
bitfld.long 0 18. " BMLCLKEN "  "0 ,1 "
bitfld.long 0 19. " HSITXCLKEN "  "0 ,1 "
bitfld.long 0 20. " HSIRXCLKEN "  "0 ,1 "
bitfld.long 0 21. " HDMICLKEN "  "0 ,1 "
bitfld.long 0 22. " APEATCLKEN "  "0 ,1 "
bitfld.long 0 23. " APETRACECLKEN "  "0 ,1 "
bitfld.long 0 24. " MCDECLKEN "  "0 ,1 "
bitfld.long 0 25. " IPI2CCLKEN "  "0 ,1 "
bitfld.long 0 26. " DSIALTCLKEN "  "0 ,1 "
bitfld.long 0 27. " DMACLKEN "  "0 ,1 "
bitfld.long 0 28. " B2R2CLKEN "  "0 ,1 "
bitfld.long 0 29. " TVCLKEN "  "0 ,1 "
bitfld.long 0 30. " SPARE_UNIPROCLKEN "  "0 ,1 "
bitfld.long 0 31. " SSPCLKEN "  "0 ,1 "
tree.end

base sd:0x80157524
tree "PRCM_YYCLKEN1_MGT_VAL"
group 0--3
line.long 0 "PRCM_YYCLKEN1_MGT_VAL"
bitfld.long 0 0. " RNGCLKEN "  "0 ,1 "
bitfld.long 0 1. " UICCCLKEN "  "0 ,1 "
bitfld.long 0 8. " SPARE1CLKEN "  "0 ,1 "
bitfld.long 0 9. " SPARE2CLKEN "  "0 ,1 "
tree.end

base sd:0x80157528
tree "PRCM_XP70CLK_MGT2"
group 0--3
line.long 0 "PRCM_XP70CLK_MGT2"
bitfld.long 0 0.--2. " PLL_SOC0_MX "  " "
bitfld.long 0 3.--5. " XP70_CLK_L2 "  " "
bitfld.long 0 6.--8. " XP70_CLK_L1 "  " "
bitfld.long 0 16.--18. " SPARE "  " "
tree.end

base sd:0x8015752c
tree "PRCM_DSITVCLK_DIV"
group 0--3
line.long 0 "PRCM_DSITVCLK_DIV"
bitfld.long 0 0.--7. " DSI0_ESC_CLK_DIV "  " "
bitfld.long 0 8.--15. " DSI1_ESC_CLK_DIV "  " "
bitfld.long 0 16.--23. " DSI2_ESC_CLK_DIV "  " "
bitfld.long 0 24. " DSI0_ESC_CLK_EN "  "0 ,1 "
bitfld.long 0 25. " DSI1_ESC_CLK_EN "  "0 ,1 "
bitfld.long 0 26. " DSI2_ESC_CLK_EN "  "0 ,1 "
tree.end

base sd:0x80157530
tree "PRCM_DSI_PLLOUT_SEL"
group 0--3
line.long 0 "PRCM_DSI_PLLOUT_SEL"
bitfld.long 0 0.--2. " DSI0_PLLOUT_DIVSEL "  " "
bitfld.long 0 8.--10. " DSI1_PLLOUT_DIVSEL "  " "
tree.end

base sd:0x80157534
tree "PRCM_DSI_GLITCHFREE_EN"
group 0--3
line.long 0 "PRCM_DSI_GLITCHFREE_EN"
bitfld.long 0 0. " DSI0_BYPASS_BYTE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 1. " DSI0_BYPASS_MCDE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 8. " DSI1_BYPASS_BYTE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 9. " DSI1_BYPASS_MCDE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 16. " DSI2_BYPASS_BYTE_CLK_SYNC "  "0 ,1 "
bitfld.long 0 17. " DSI2_BYPASS_MCDE_CLK_SYNC "  "0 ,1 "
tree.end

base sd:0x80157538
tree "PRCM_CLKACTIV"
group 0--3
line.long 0 "PRCM_CLKACTIV"
bitfld.long 0 0. " CLK32_RUNNING "  "0 ,1 "
bitfld.long 0 1. " SYSCLK_RUNNING "  "0 ,1 "
bitfld.long 0 2. " PLLSOC0_RUNNING "  "0 ,1 "
bitfld.long 0 3. " PLLSOC1_RUNNING "  "0 ,1 "
bitfld.long 0 4. " PLLDDR_RUNNING "  "0 ,1 "
bitfld.long 0 5. " STW4500_ULPCLK_RUNNING "  "0 ,1 "
bitfld.long 0 6. " STW8500_ULPCLK_RUNNING "  "0 ,1 "
bitfld.long 0 7. " MSP0SCK_RUNNING "  "0 ,1 "
bitfld.long 0 8. " MSP2SCK_RUNNING "  "0 ,1 "
bitfld.long 0 16. " PLLSOC0_EN "  "0 ,1 "
bitfld.long 0 17. " PLLSOC1_EN "  "0 ,1 "
bitfld.long 0 18. " PLLDDR_DIV12_EN "  "0 ,1 "
bitfld.long 0 19. " PLLDDR_DIV2_EN "  "0 ,1 "
bitfld.long 0 20. " PLLSOC0_DIV12_EN "  "0 ,1 "
bitfld.long 0 21. " PLLSOC0_DIV2_EN "  "0 ,1 "
tree.end

base sd:0x8015753c
tree "PRCM_SIA_MMDSP_MEM_MGT"
group 0--3
line.long 0 "PRCM_SIA_MMDSP_MEM_MGT"
bitfld.long 0 0. " MEM_REQ "  "0 ,1 "
bitfld.long 0 1. " MEM_LATENCY "  "0 ,1 "
tree.end

base sd:0x80157540
tree "PRCM_SVA_MMDSP_MEM_MGT"
group 0--3
line.long 0 "PRCM_SVA_MMDSP_MEM_MGT"
bitfld.long 0 0. " MEM_REQ "  "0 ,1 "
bitfld.long 0 1. " MEM_LATENCY "  "0 ,1 "
tree.end

base sd:0x80157544
tree "PRCM_SXAMMDSP_FORCE_CLKEN"
group 0--3
line.long 0 "PRCM_SXAMMDSP_FORCE_CLKEN"
bitfld.long 0 0. " SIA "  "0 ,1 "
bitfld.long 0 1. " SVA "  "0 ,1 "
tree.end

base sd:0x80157570
tree "PRCM_UICC_NANDTREE"
group 0--3
line.long 0 "PRCM_UICC_NANDTREE"
bitfld.long 0 0. " UICC_NAND_I "  "0 ,1 "
bitfld.long 0 1. " UICC_NAND_O "  "0 ,1 "
tree.end

base sd:0x80157574
tree "PRCM_GPIOCR2"
group 0--3
line.long 0 "PRCM_GPIOCR2"
bitfld.long 0 0. " DBG_MODEMRF_CTRL_CMD1 "  "0 ,1 "
bitfld.long 0 1. " DBG_MODEMRF_CTRL_CMD0 "  "0 ,1 "
bitfld.long 0 2. " DBG_MODEMRF_INT_CMD1 "  "0 ,1 "
bitfld.long 0 3. " DBG_MODEMRF_INT_CMD0 "  "0 ,1 "
bitfld.long 0 4.--5. " MOD_DDR_SPACE "  " "
bitfld.long 0 6. " PORn_PULL_DOWN "  "0 ,1 "
bitfld.long 0 7.--15. " MOD_GPIOCR_SPARE "  " "
tree.end

base sd:0x80157578
tree "PRCM_MDM_ACWAKE"
group 0--3
line.long 0 "PRCM_MDM_ACWAKE"
bitfld.long 0 0. " MDM_ACWAKE "  "0 ,1 "
tree.end

base sd:0x801575a4
tree "PRCM_MOD_MEM_REQ"
group 0--3
line.long 0 "PRCM_MOD_MEM_REQ"
bitfld.long 0 0. " MOD_MEM_REQ_EN "  "0 ,1 "
bitfld.long 0 1. " MOD_MEM_REQ_FORCE "  "0 ,1 "
tree.end

base sd:0x801575a8
tree "PRCM_MOD_MEM_ACK"
group 0--3
line.long 0 "PRCM_MOD_MEM_ACK"
bitfld.long 0 0. " MOD_MEM_ACK_EN "  "0 ,1 "
bitfld.long 0 1. " MOD_MEM_ACK_FORCE "  "0 ,1 "
tree.end

base sd:0x801575b0
tree "PRCM_ARM_PLLDIVPS_REQ"
group 0--3
line.long 0 "PRCM_ARM_PLLDIVPS_REQ"
bitfld.long 0 0. " ARM_BRM_RATEVAL "  "0 ,1 "
bitfld.long 0 4. " ARM_PLL_OBSVAL "  "0 ,1 "
tree.end

base sd:0x801575b4
tree "PRCM_ARM_PLLDIVPS_ACK"
rgroup 0--3
line.long 0 "PRCM_ARM_PLLDIVPS_ACK"
bitfld.long 0 0. " ARM_BRM_RATEACK "  "0 ,1 "
bitfld.long 0 4. " ARM_PLL_OBSACK "  "0 ,1 "
tree.end

base sd:0x801575d0
tree "PRCM_SRPTIMER_VAL"
group 0--3
line.long 0 "PRCM_SRPTIMER_VAL"
bitfld.long 0 0.--7. " SRPTIMER_VAL "  " "
tree.end

base sd:0x801575d4
tree "PRCM_SRPTIMER_A9_IT_CLR"
wgroup 0--3
line.long 0 "PRCM_SRPTIMER_A9_IT_CLR"
bitfld.long 0 0. " PRCM_SRPTIMER_A9_IT_CLR "  "0 ,1 "
tree.end

base sd:0x801575d8
tree "PRCM_HWI2C_A9_IT_CLR"
wgroup 0--3
line.long 0 "PRCM_HWI2C_A9_IT_CLR"
bitfld.long 0 0. " PRCM_HWI2C_A9_IT_CLR "  "0 ,1 "
tree.end

base sd:0x80158000
tree "PRCM_SECNONSEWM"
group 0--3
line.long 0 "PRCM_SECNONSEWM"
bitfld.long 0 0.--15. " SECNONSECWM "  " "
tree.end

base sd:0x80158004
tree "PRCM_ESRAM0_INITN"
group 0--3
line.long 0 "PRCM_ESRAM0_INITN"
bitfld.long 0 0. " PRCM_ESRAM0_INITN "  "0 ,1 "
tree.end

base sd:0x80158008
tree "PRCM_ARMITMSKSEC_31TO0"
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_31TO0"
bitfld.long 0 0.--31. " PRCM_ARMITMSKSEC_31TO0 "  " "
tree.end

base sd:0x8015800c
tree "PRCM_ARMITMSKSEC_63TO32"
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_63TO32"
bitfld.long 0 0.--31. " PRCM_ARMITMSKSEC_63TO32 "  " "
tree.end

base sd:0x80158010
tree "PRCM_ARMITMSKSEC_95TO64"
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_95TO64"
bitfld.long 0 0.--31. " PRCM_ARMITMSKSEC_95TO64 "  " "
tree.end

base sd:0x80158014
tree "PRCM_ARMITMSKSEC_127TO96"
group 0--3
line.long 0 "PRCM_ARMITMSKSEC_127TO96"
bitfld.long 0 0.--31. " PRCM_ARMITMSKSEC_127TO96 "  " "
tree.end

base sd:0x80158018
tree "PRCM_ARMIT_MASKXP70_IT"
group 0--3
line.long 0 "PRCM_ARMIT_MASKXP70_IT"
bitfld.long 0 0. " PRCM_ARMIT_MASKXP70_IT "  "0 ,1 "
tree.end

base sd:0x8015801c
tree "PRCM_ESRAM0_EPOD_CFG"
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_CFG"
bitfld.long 0 0.--1. " VDDI_WAKEUP_CUR "  " "
bitfld.long 0 2.--4. " VDDI_BIAS_VOLT_CTRL "  " "
bitfld.long 0 5.--6. " BIAS_CUR_CTRL "  " "
bitfld.long 0 7. " BOOST "  "0 ,1 "
tree.end

base sd:0x80158020
tree "PRCM_ESRAM0_EPOD_C_VAL"
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_C_VAL"
bitfld.long 0 0. " ESRAM0_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_RET "  "0 ,1 "
tree.end

base sd:0x80158024
tree "PRCM_ESRAM0_EPOD_C_SET"
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_C_SET"
bitfld.long 0 0. " ESRAM0_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_RET "  "0 ,1 "
tree.end

base sd:0x80158028
tree "PRCM_ESRAM0_EPOD_C_CLR"
group 0--3
line.long 0 "PRCM_ESRAM0_EPOD_C_CLR"
bitfld.long 0 0. " ESRAM0_ON "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_RET "  "0 ,1 "
tree.end

base sd:0x8015802c
tree "PRCM_ESRAM0_EPOD_VOK"
rgroup 0--3
line.long 0 "PRCM_ESRAM0_EPOD_VOK"
bitfld.long 0 0. " ESRAM0_VOK "  "0 ,1 "
tree.end

base sd:0x80158030
tree "PRCM_ESRAM0_LS_SLEEP"
group 0--3
line.long 0 "PRCM_ESRAM0_LS_SLEEP"
bitfld.long 0 0. " ESRAM0_SLEEP "  "0 ,1 "
bitfld.long 0 1. " ESRAM0_LS "  "0 ,1 "
tree.end

base sd:0x80158034
tree "PRCM_SECURE_ONGOING"
group 0--3
line.long 0 "PRCM_SECURE_ONGOING"
bitfld.long 0 0. " SECURE_ONGOING "  "0 ,1 "
tree.end

base sd:0x80158038
tree "PRCM_I2C_SECURE"
group 0--3
line.long 0 "PRCM_I2C_SECURE"
bitfld.long 0 0. " I2C_SECURE "  "0 ,1 "
tree.end

base sd:0x8015803c
tree "PRCM_RESET_STATUS"
group 0--3
line.long 0 "PRCM_RESET_STATUS"
bitfld.long 0 0. " A9_CPU0_WATCHDOG_RESET "  "0 ,1 "
bitfld.long 0 1. " A9_CPU1_WATCHDOG_RESET "  "0 ,1 "
bitfld.long 0 2. " APE_SOFTWARE_RESET "  "0 ,1 "
bitfld.long 0 3. " APE_RESET "  "0 ,1 "
bitfld.long 0 4. " SECURE_WATCHDOG "  "0 ,1 "
bitfld.long 0 5. " POWER_ON_RESET "  "0 ,1 "
bitfld.long 0 6. " A9_RESTART "  "0 ,1 "
bitfld.long 0 7. " APE_RESTART "  "0 ,1 "
bitfld.long 0 8. " MODEM_SOFTWARE_RESET "  "0 ,1 "
bitfld.long 0 16. " BOOT_ENGI "  "0 ,1 "
tree.end

base sd:0x80158040
tree "PRCM_PERIPH4_RESETN_SET"
group 0--3
line.long 0 "PRCM_PERIPH4_RESETN_SET"
bitfld.long 0 0. " RTC_RESETN "  "0 ,1 "
bitfld.long 0 1. " RTT0_RESETN "  "0 ,1 "
bitfld.long 0 2. " RTT1_RESETN "  "0 ,1 "
bitfld.long 0 3. " BACKUP_RAM_RESETN "  "0 ,1 "
bitfld.long 0 4. " SEC_REG_RESETN "  "0 ,1 "
bitfld.long 0 5. " CLK_PLL_CONF_RESETN "  "0 ,1 "
bitfld.long 0 6. " HWI2C_RESETN "  "0 ,1 "
tree.end

base sd:0x80158044
tree "PRCM_PERIPH4_RESETN_CLR"
group 0--3
line.long 0 "PRCM_PERIPH4_RESETN_CLR"
bitfld.long 0 0. " RTC_RESETN "  "0 ,1 "
bitfld.long 0 1. " RTT0_RESETN "  "0 ,1 "
bitfld.long 0 2. " RTT1_RESETN "  "0 ,1 "
bitfld.long 0 3. " BACKUP_RAM_RESETN "  "0 ,1 "
bitfld.long 0 4. " SEC_REG_RESETN "  "0 ,1 "
bitfld.long 0 5. " CLK_PLL_CONF_RESETN "  "0 ,1 "
bitfld.long 0 6. " HWI2C_RESETN "  "0 ,1 "
tree.end

base sd:0x80158048
tree "PRCM_PERIPH4_RESETN_VAL"
rgroup 0--3
line.long 0 "PRCM_PERIPH4_RESETN_VAL"
bitfld.long 0 0. " RTC_RESETN "  "0 ,1 "
bitfld.long 0 1. " RTT0_RESETN "  "0 ,1 "
bitfld.long 0 2. " RTT1_RESETN "  "0 ,1 "
bitfld.long 0 3. " BACKUP_RAM_RESETN "  "0 ,1 "
bitfld.long 0 4. " SEC_REG_RESETN "  "0 ,1 "
bitfld.long 0 5. " CLK_PLL_CONF_RESETN "  "0 ,1 "
bitfld.long 0 6. " HWI2C_RESETN "  "0 ,1 "
tree.end

base sd:0x8015804c
tree "PRCM_SPAREOUT_SEC"
group 0--3
line.long 0 "PRCM_SPAREOUT_SEC"
bitfld.long 0 0. " BOOT_ROM_PDN "  "0 ,1 "
bitfld.long 0 1.--3. " SPAREOUT_SEC_3_1 "  " "
bitfld.long 0 4. " PCLK_RTT0_EN "  "0 ,1 "
bitfld.long 0 5. " PCLK_RTT1_EN "  "0 ,1 "
bitfld.long 0 6.--7. " SPAREOUT_SEC_7_6 "  " "
bitfld.long 0 8.--10. " FREERUNNINGOSC_COMP "  " "
bitfld.long 0 11.--15. " SPAREOUT_SEC_15_11 "  " "
tree.end

base sd:0x801580d8
tree "PRCM_PIPELINEDCR"
group 0--3
line.long 0 "PRCM_PIPELINEDCR"
bitfld.long 0 0.--31. " PRCM_PIPELINEDCR "  " "
tree.end

base sd:0x801580dc
tree "PRCM_VOLATILEIOCR"
group 0--3
line.long 0 "PRCM_VOLATILEIOCR"
bitfld.long 0 0.--31. " PRCM_VOLATILEIOCR "  " "
tree.end

base sd:0x801580e0
tree "PRCM_XP70CFGCR"
group 0--3
line.long 0 "PRCM_XP70CFGCR"
bitfld.long 0 0. " XP70_P_FETCH_EN "  "0 ,1 "
bitfld.long 0 1. " XP70_WAKE_UP "  "0 ,1 "
bitfld.long 0 2. " XP70_EXCEPT_VB "  "0 ,1 "
bitfld.long 0 3. " XP70_IDLE_ACK "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "PTM0"
;==============================================================
base sd:0x801AE000
tree "Control"
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " Control "  "0 ,1 "
tree.end

base sd:0x801AE004
tree "ConfigCode"
rgroup 0--3
line.long 0 "ConfigCode"
bitfld.long 0 0. " ConfigCode "  "0 ,1 "
tree.end

base sd:0x801AE008
tree "TriggerEvent"
wgroup 0--3
line.long 0 "TriggerEvent"
bitfld.long 0 0. " TriggerEvent "  "0 ,1 "
tree.end

base sd:0x801AE00c
tree "AsicControl"
wgroup 0--3
line.long 0 "AsicControl"
bitfld.long 0 0. " AsicControl "  "0 ,1 "
tree.end

base sd:0x801AE010
tree "Status"
group 0--3
line.long 0 "Status"
bitfld.long 0 0. " Status "  "0 ,1 "
tree.end

base sd:0x801AE014
tree "SysConfig"
group 0--3
line.long 0 "SysConfig"
bitfld.long 0 0. " SysConfig "  "0 ,1 "
tree.end

base sd:0x801AE018
tree "TraceEnStartStop"
wgroup 0--3
line.long 0 "TraceEnStartStop"
bitfld.long 0 0. " TraceEnStartStop "  "0 ,1 "
tree.end

base sd:0x801AE01c
tree "TraceEnCtrl2"
wgroup 0--3
line.long 0 "TraceEnCtrl2"
bitfld.long 0 0. " TraceEnCtrl2 "  "0 ,1 "
tree.end

base sd:0x801AE020
tree "TraceEnEvent"
wgroup 0--3
line.long 0 "TraceEnEvent"
bitfld.long 0 0. " TraceEnEvent "  "0 ,1 "
tree.end

base sd:0x801AE024
tree "TraceEnCtrl1"
wgroup 0--3
line.long 0 "TraceEnCtrl1"
bitfld.long 0 0. " TraceEnCtrl1 "  "0 ,1 "
tree.end

base sd:0x801AE028
tree "FifoFullRegion"
wgroup 0--3
line.long 0 "FifoFullRegion"
bitfld.long 0 0. " FifoFullRegion "  "0 ,1 "
tree.end

base sd:0x801AE02c
tree "FifoFullLevel"
group 0--3
line.long 0 "FifoFullLevel"
bitfld.long 0 0. " FifoFullLevel "  "0 ,1 "
tree.end

base sd:0x801AE030
tree "ViewDataEvent"
wgroup 0--3
line.long 0 "ViewDataEvent"
bitfld.long 0 0. " ViewDataEvent "  "0 ,1 "
tree.end

base sd:0x801AE034
tree "ViewDataCtrl1"
wgroup 0--3
line.long 0 "ViewDataCtrl1"
bitfld.long 0 0. " ViewDataCtrl1 "  "0 ,1 "
tree.end

base sd:0x801AE038
tree "ViewDataCtrl2"
wgroup 0--3
line.long 0 "ViewDataCtrl2"
bitfld.long 0 0. " ViewDataCtrl2 "  "0 ,1 "
tree.end

base sd:0x801AE03c
tree "ViewDataCtrl3"
wgroup 0--3
line.long 0 "ViewDataCtrl3"
bitfld.long 0 0. " ViewDataCtrl3 "  "0 ,1 "
tree.end

base sd:0x801AE040
tree "AddrComp0"
wgroup 0--3
line.long 0 "AddrComp0"
bitfld.long 0 0. " AddrComp0 "  "0 ,1 "
tree.end

base sd:0x801AE044
tree "AddrComp1"
wgroup 0--3
line.long 0 "AddrComp1"
bitfld.long 0 0. " AddrComp1 "  "0 ,1 "
tree.end

base sd:0x801AE048
tree "AddrComp2"
wgroup 0--3
line.long 0 "AddrComp2"
bitfld.long 0 0. " AddrComp2 "  "0 ,1 "
tree.end

base sd:0x801AE04c
tree "AddrComp3"
wgroup 0--3
line.long 0 "AddrComp3"
bitfld.long 0 0. " AddrComp3 "  "0 ,1 "
tree.end

base sd:0x801AE050
tree "AddrComp4"
wgroup 0--3
line.long 0 "AddrComp4"
bitfld.long 0 0. " AddrComp4 "  "0 ,1 "
tree.end

base sd:0x801AE054
tree "AddrComp5"
wgroup 0--3
line.long 0 "AddrComp5"
bitfld.long 0 0. " AddrComp5 "  "0 ,1 "
tree.end

base sd:0x801AE058
tree "AddrComp6"
wgroup 0--3
line.long 0 "AddrComp6"
bitfld.long 0 0. " AddrComp6 "  "0 ,1 "
tree.end

base sd:0x801AE05c
tree "AddrComp7"
wgroup 0--3
line.long 0 "AddrComp7"
bitfld.long 0 0. " AddrComp7 "  "0 ,1 "
tree.end

base sd:0x801AE080
tree "AddrAccType0"
wgroup 0--3
line.long 0 "AddrAccType0"
bitfld.long 0 0. " AddrAccType0 "  "0 ,1 "
tree.end

base sd:0x801AE084
tree "AddrAccType1"
wgroup 0--3
line.long 0 "AddrAccType1"
bitfld.long 0 0. " AddrAccType1 "  "0 ,1 "
tree.end

base sd:0x801AE088
tree "AddrAccType2"
wgroup 0--3
line.long 0 "AddrAccType2"
bitfld.long 0 0. " AddrAccType2 "  "0 ,1 "
tree.end

base sd:0x801AE08c
tree "AddrAccType3"
wgroup 0--3
line.long 0 "AddrAccType3"
bitfld.long 0 0. " AddrAccType3 "  "0 ,1 "
tree.end

base sd:0x801AE090
tree "AddrAccType4"
wgroup 0--3
line.long 0 "AddrAccType4"
bitfld.long 0 0. " AddrAccType4 "  "0 ,1 "
tree.end

base sd:0x801AE094
tree "AddrAccType5"
wgroup 0--3
line.long 0 "AddrAccType5"
bitfld.long 0 0. " AddrAccType5 "  "0 ,1 "
tree.end

base sd:0x801AE098
tree "AddrAccType6"
wgroup 0--3
line.long 0 "AddrAccType6"
bitfld.long 0 0. " AddrAccType6 "  "0 ,1 "
tree.end

base sd:0x801AE09c
tree "AddrAccType7"
wgroup 0--3
line.long 0 "AddrAccType7"
bitfld.long 0 0. " AddrAccType7 "  "0 ,1 "
tree.end

base sd:0x801AE0c0
tree "DataComp0"
wgroup 0--3
line.long 0 "DataComp0"
bitfld.long 0 0. " DataComp0 "  "0 ,1 "
tree.end

base sd:0x801AE0c4
tree "DataComp1"
wgroup 0--3
line.long 0 "DataComp1"
bitfld.long 0 0. " DataComp1 "  "0 ,1 "
tree.end

base sd:0x801AE100
tree "DataMask0"
wgroup 0--3
line.long 0 "DataMask0"
tree.end

base sd:0x801AE104
tree "DataMask1"
wgroup 0--3
line.long 0 "DataMask1"
tree.end

base sd:0x801AE140
tree "CountReloadVal0"
wgroup 0--3
line.long 0 "CountReloadVal0"
bitfld.long 0 0. " CountReloadVal0 "  "0 ,1 "
tree.end

base sd:0x801AE144
tree "CountReloadVal1"
wgroup 0--3
line.long 0 "CountReloadVal1"
bitfld.long 0 0. " CountReloadVal1 "  "0 ,1 "
tree.end

base sd:0x801AE150
tree "CountEn0"
wgroup 0--3
line.long 0 "CountEn0"
bitfld.long 0 0. " CountEn0 "  "0 ,1 "
tree.end

base sd:0x801AE154
tree "CountEn1"
wgroup 0--3
line.long 0 "CountEn1"
bitfld.long 0 0. " CountEn1 "  "0 ,1 "
tree.end

base sd:0x801AE160
tree "CountReloadEv0"
wgroup 0--3
line.long 0 "CountReloadEv0"
bitfld.long 0 0. " CountReloadEv0 "  "0 ,1 "
tree.end

base sd:0x801AE164
tree "CountReloadEv1"
wgroup 0--3
line.long 0 "CountReloadEv1"
bitfld.long 0 0. " CountReloadEv1 "  "0 ,1 "
tree.end

base sd:0x801AE170
tree "CountValue0"
group 0--3
line.long 0 "CountValue0"
tree.end

base sd:0x801AE174
tree "CountValue1"
group 0--3
line.long 0 "CountValue1"
tree.end

base sd:0x801AE180
tree "SeqCtrl0"
wgroup 0--3
line.long 0 "SeqCtrl0"
bitfld.long 0 0. " SeqCtrl0 "  "0 ,1 "
tree.end

base sd:0x801AE184
tree "SeqCtrl1"
wgroup 0--3
line.long 0 "SeqCtrl1"
bitfld.long 0 0. " SeqCtrl1 "  "0 ,1 "
tree.end

base sd:0x801AE188
tree "SeqCtrl2"
wgroup 0--3
line.long 0 "SeqCtrl2"
bitfld.long 0 0. " SeqCtrl2 "  "0 ,1 "
tree.end

base sd:0x801AE18c
tree "SeqCtrl3"
wgroup 0--3
line.long 0 "SeqCtrl3"
bitfld.long 0 0. " SeqCtrl3 "  "0 ,1 "
tree.end

base sd:0x801AE190
tree "SeqCtrl4"
wgroup 0--3
line.long 0 "SeqCtrl4"
bitfld.long 0 0. " SeqCtrl4 "  "0 ,1 "
tree.end

base sd:0x801AE194
tree "SeqCtrl5"
wgroup 0--3
line.long 0 "SeqCtrl5"
bitfld.long 0 0. " SeqCtrl5 "  "0 ,1 "
tree.end

base sd:0x801AE19c
tree "SeqState"
group 0--3
line.long 0 "SeqState"
bitfld.long 0 0. " SeqState "  "0 ,1 "
tree.end

base sd:0x801AE1a0
tree "ExtOutput0"
wgroup 0--3
line.long 0 "ExtOutput0"
bitfld.long 0 0. " ExtOutput0 "  "0 ,1 "
tree.end

base sd:0x801AE1a4
tree "ExtOutput1"
wgroup 0--3
line.long 0 "ExtOutput1"
bitfld.long 0 0. " ExtOutput1 "  "0 ,1 "
tree.end

base sd:0x801AE1b0
tree "ContextIdComp"
wgroup 0--3
line.long 0 "ContextIdComp"
bitfld.long 0 0. " ContextIdComp "  "0 ,1 "
tree.end

base sd:0x801AE1bc
tree "ContextIdMask"
wgroup 0--3
line.long 0 "ContextIdMask"
tree.end

base sd:0x801AE1c0
tree "ImpSpecific0"
wgroup 0--3
line.long 0 "ImpSpecific0"
bitfld.long 0 0. " ImpSpecific0 "  "0 ,1 "
tree.end

base sd:0x801AE1c4
tree "ImpSpecific1"
wgroup 0--3
line.long 0 "ImpSpecific1"
bitfld.long 0 0. " ImpSpecific1 "  "0 ,1 "
tree.end

base sd:0x801AE1c8
tree "ImpSpecific2"
wgroup 0--3
line.long 0 "ImpSpecific2"
bitfld.long 0 0. " ImpSpecific2 "  "0 ,1 "
tree.end

base sd:0x801AE1cc
tree "ImpSpecific3"
wgroup 0--3
line.long 0 "ImpSpecific3"
bitfld.long 0 0. " ImpSpecific3 "  "0 ,1 "
tree.end

base sd:0x801AE1d0
tree "ImpSpecific4"
wgroup 0--3
line.long 0 "ImpSpecific4"
bitfld.long 0 0. " ImpSpecific4 "  "0 ,1 "
tree.end

base sd:0x801AE1d4
tree "ImpSpecific5"
wgroup 0--3
line.long 0 "ImpSpecific5"
bitfld.long 0 0. " ImpSpecific5 "  "0 ,1 "
tree.end

base sd:0x801AE1d8
tree "ImpSpecific6"
wgroup 0--3
line.long 0 "ImpSpecific6"
bitfld.long 0 0. " ImpSpecific6 "  "0 ,1 "
tree.end

base sd:0x801AE1dc
tree "ImpSpecific7"
wgroup 0--3
line.long 0 "ImpSpecific7"
bitfld.long 0 0. " ImpSpecific7 "  "0 ,1 "
tree.end

base sd:0x801AE1e0
tree "SynchFreq"
wgroup 0--3
line.long 0 "SynchFreq"
bitfld.long 0 0. " SynchFreq "  "0 ,1 "
tree.end

base sd:0x801AE1e4
tree "EtmId"
group 0--3
line.long 0 "EtmId"
bitfld.long 0 0. " EtmId "  "0 ,1 "
tree.end

base sd:0x801AE1e8
tree "ConfigCodeExt"
group 0--3
line.long 0 "ConfigCodeExt"
bitfld.long 0 0. " ConfigCodeExt "  "0 ,1 "
tree.end

base sd:0x801AE1ec
tree "ExternalInExt"
wgroup 0--3
line.long 0 "ExternalInExt"
bitfld.long 0 0. " ExternalInExt "  "0 ,1 "
tree.end

base sd:0x801AE200
tree "CSTraceID"
wgroup 0--3
line.long 0 "CSTraceID"
bitfld.long 0 0. " CSTraceID "  "0 ,1 "
tree.end

base sd:0x801AEfa0
tree "ClaimTagSet"
group 0--3
line.long 0 "ClaimTagSet"
bitfld.long 0 0. " ClaimTagSet "  "0 ,1 "
tree.end

base sd:0x801AEfa4
tree "ClaimTagClr"
group 0--3
line.long 0 "ClaimTagClr"
bitfld.long 0 0. " ClaimTagClr "  "0 ,1 "
tree.end

base sd:0x801AEfb0
tree "LockAccess"
wgroup 0--3
line.long 0 "LockAccess"
bitfld.long 0 0. " LockAccess "  "0 ,1 "
tree.end

base sd:0x801AEfb4
tree "LockStatus"
wgroup 0--3
line.long 0 "LockStatus"
bitfld.long 0 0. " LockStatus "  "0 ,1 "
tree.end

base sd:0x801AEfb8
tree "AuthenticationStatus"
group 0--3
line.long 0 "AuthenticationStatus"
bitfld.long 0 0. " AuthenticationStatus "  "0 ,1 "
tree.end

base sd:0x801AEfcc
tree "CSDeviceType"
rgroup 0--3
line.long 0 "CSDeviceType"
bitfld.long 0 0. " CSDeviceType "  "0 ,1 "
tree.end

base sd:0x801AEfd0
tree "PeriphID4"
rgroup 0--3
line.long 0 "PeriphID4"
bitfld.long 0 0. " PeriphID4 "  "0 ,1 "
tree.end

base sd:0x801AEfd4
tree "PeriphID5"
rgroup 0--3
line.long 0 "PeriphID5"
bitfld.long 0 0. " PeriphID5 "  "0 ,1 "
tree.end

base sd:0x801AEfd8
tree "PeriphID6"
rgroup 0--3
line.long 0 "PeriphID6"
bitfld.long 0 0. " PeriphID6 "  "0 ,1 "
tree.end

base sd:0x801AEfdc
tree "PeriphID7"
rgroup 0--3
line.long 0 "PeriphID7"
bitfld.long 0 0. " PeriphID7 "  "0 ,1 "
tree.end

base sd:0x801AEfe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0. " PeriphID0 "  "0 ,1 "
tree.end

base sd:0x801AEfe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0. " PeriphID1 "  "0 ,1 "
tree.end

base sd:0x801AEfe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0. " PeriphID2 "  "0 ,1 "
tree.end

base sd:0x801AEfec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0. " PeriphID3 "  "0 ,1 "
tree.end

base sd:0x801AEff0
tree "CompID0"
rgroup 0--3
line.long 0 "CompID0"
bitfld.long 0 0. " CompID0 "  "0 ,1 "
tree.end

base sd:0x801AEff4
tree "CompID1"
rgroup 0--3
line.long 0 "CompID1"
bitfld.long 0 0. " CompID1 "  "0 ,1 "
tree.end

base sd:0x801AEff8
tree "CompID2"
rgroup 0--3
line.long 0 "CompID2"
bitfld.long 0 0. " CompID2 "  "0 ,1 "
tree.end

base sd:0x801AEffc
tree "CompID3"
rgroup 0--3
line.long 0 "CompID3"
bitfld.long 0 0. " CompID3 "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "PTM1"
;==============================================================
base sd:0x801AF000
tree "Control"
group 0--3
line.long 0 "Control"
bitfld.long 0 0. " Control "  "0 ,1 "
tree.end

base sd:0x801AF004
tree "ConfigCode"
rgroup 0--3
line.long 0 "ConfigCode"
bitfld.long 0 0. " ConfigCode "  "0 ,1 "
tree.end

base sd:0x801AF008
tree "TriggerEvent"
wgroup 0--3
line.long 0 "TriggerEvent"
bitfld.long 0 0. " TriggerEvent "  "0 ,1 "
tree.end

base sd:0x801AF00c
tree "AsicControl"
wgroup 0--3
line.long 0 "AsicControl"
bitfld.long 0 0. " AsicControl "  "0 ,1 "
tree.end

base sd:0x801AF010
tree "Status"
group 0--3
line.long 0 "Status"
bitfld.long 0 0. " Status "  "0 ,1 "
tree.end

base sd:0x801AF014
tree "SysConfig"
group 0--3
line.long 0 "SysConfig"
bitfld.long 0 0. " SysConfig "  "0 ,1 "
tree.end

base sd:0x801AF018
tree "TraceEnStartStop"
wgroup 0--3
line.long 0 "TraceEnStartStop"
bitfld.long 0 0. " TraceEnStartStop "  "0 ,1 "
tree.end

base sd:0x801AF01c
tree "TraceEnCtrl2"
wgroup 0--3
line.long 0 "TraceEnCtrl2"
bitfld.long 0 0. " TraceEnCtrl2 "  "0 ,1 "
tree.end

base sd:0x801AF020
tree "TraceEnEvent"
wgroup 0--3
line.long 0 "TraceEnEvent"
bitfld.long 0 0. " TraceEnEvent "  "0 ,1 "
tree.end

base sd:0x801AF024
tree "TraceEnCtrl1"
wgroup 0--3
line.long 0 "TraceEnCtrl1"
bitfld.long 0 0. " TraceEnCtrl1 "  "0 ,1 "
tree.end

base sd:0x801AF028
tree "FifoFullRegion"
wgroup 0--3
line.long 0 "FifoFullRegion"
bitfld.long 0 0. " FifoFullRegion "  "0 ,1 "
tree.end

base sd:0x801AF02c
tree "FifoFullLevel"
group 0--3
line.long 0 "FifoFullLevel"
bitfld.long 0 0. " FifoFullLevel "  "0 ,1 "
tree.end

base sd:0x801AF030
tree "ViewDataEvent"
wgroup 0--3
line.long 0 "ViewDataEvent"
bitfld.long 0 0. " ViewDataEvent "  "0 ,1 "
tree.end

base sd:0x801AF034
tree "ViewDataCtrl1"
wgroup 0--3
line.long 0 "ViewDataCtrl1"
bitfld.long 0 0. " ViewDataCtrl1 "  "0 ,1 "
tree.end

base sd:0x801AF038
tree "ViewDataCtrl2"
wgroup 0--3
line.long 0 "ViewDataCtrl2"
bitfld.long 0 0. " ViewDataCtrl2 "  "0 ,1 "
tree.end

base sd:0x801AF03c
tree "ViewDataCtrl3"
wgroup 0--3
line.long 0 "ViewDataCtrl3"
bitfld.long 0 0. " ViewDataCtrl3 "  "0 ,1 "
tree.end

base sd:0x801AF040
tree "AddrComp0"
wgroup 0--3
line.long 0 "AddrComp0"
bitfld.long 0 0. " AddrComp0 "  "0 ,1 "
tree.end

base sd:0x801AF044
tree "AddrComp1"
wgroup 0--3
line.long 0 "AddrComp1"
bitfld.long 0 0. " AddrComp1 "  "0 ,1 "
tree.end

base sd:0x801AF048
tree "AddrComp2"
wgroup 0--3
line.long 0 "AddrComp2"
bitfld.long 0 0. " AddrComp2 "  "0 ,1 "
tree.end

base sd:0x801AF04c
tree "AddrComp3"
wgroup 0--3
line.long 0 "AddrComp3"
bitfld.long 0 0. " AddrComp3 "  "0 ,1 "
tree.end

base sd:0x801AF050
tree "AddrComp4"
wgroup 0--3
line.long 0 "AddrComp4"
bitfld.long 0 0. " AddrComp4 "  "0 ,1 "
tree.end

base sd:0x801AF054
tree "AddrComp5"
wgroup 0--3
line.long 0 "AddrComp5"
bitfld.long 0 0. " AddrComp5 "  "0 ,1 "
tree.end

base sd:0x801AF058
tree "AddrComp6"
wgroup 0--3
line.long 0 "AddrComp6"
bitfld.long 0 0. " AddrComp6 "  "0 ,1 "
tree.end

base sd:0x801AF05c
tree "AddrComp7"
wgroup 0--3
line.long 0 "AddrComp7"
bitfld.long 0 0. " AddrComp7 "  "0 ,1 "
tree.end

base sd:0x801AF080
tree "AddrAccType0"
wgroup 0--3
line.long 0 "AddrAccType0"
bitfld.long 0 0. " AddrAccType0 "  "0 ,1 "
tree.end

base sd:0x801AF084
tree "AddrAccType1"
wgroup 0--3
line.long 0 "AddrAccType1"
bitfld.long 0 0. " AddrAccType1 "  "0 ,1 "
tree.end

base sd:0x801AF088
tree "AddrAccType2"
wgroup 0--3
line.long 0 "AddrAccType2"
bitfld.long 0 0. " AddrAccType2 "  "0 ,1 "
tree.end

base sd:0x801AF08c
tree "AddrAccType3"
wgroup 0--3
line.long 0 "AddrAccType3"
bitfld.long 0 0. " AddrAccType3 "  "0 ,1 "
tree.end

base sd:0x801AF090
tree "AddrAccType4"
wgroup 0--3
line.long 0 "AddrAccType4"
bitfld.long 0 0. " AddrAccType4 "  "0 ,1 "
tree.end

base sd:0x801AF094
tree "AddrAccType5"
wgroup 0--3
line.long 0 "AddrAccType5"
bitfld.long 0 0. " AddrAccType5 "  "0 ,1 "
tree.end

base sd:0x801AF098
tree "AddrAccType6"
wgroup 0--3
line.long 0 "AddrAccType6"
bitfld.long 0 0. " AddrAccType6 "  "0 ,1 "
tree.end

base sd:0x801AF09c
tree "AddrAccType7"
wgroup 0--3
line.long 0 "AddrAccType7"
bitfld.long 0 0. " AddrAccType7 "  "0 ,1 "
tree.end

base sd:0x801AF0c0
tree "DataComp0"
wgroup 0--3
line.long 0 "DataComp0"
bitfld.long 0 0. " DataComp0 "  "0 ,1 "
tree.end

base sd:0x801AF0c4
tree "DataComp1"
wgroup 0--3
line.long 0 "DataComp1"
bitfld.long 0 0. " DataComp1 "  "0 ,1 "
tree.end

base sd:0x801AF100
tree "DataMask0"
wgroup 0--3
line.long 0 "DataMask0"
tree.end

base sd:0x801AF104
tree "DataMask1"
wgroup 0--3
line.long 0 "DataMask1"
tree.end

base sd:0x801AF140
tree "CountReloadVal0"
wgroup 0--3
line.long 0 "CountReloadVal0"
bitfld.long 0 0. " CountReloadVal0 "  "0 ,1 "
tree.end

base sd:0x801AF144
tree "CountReloadVal1"
wgroup 0--3
line.long 0 "CountReloadVal1"
bitfld.long 0 0. " CountReloadVal1 "  "0 ,1 "
tree.end

base sd:0x801AF150
tree "CountEn0"
wgroup 0--3
line.long 0 "CountEn0"
bitfld.long 0 0. " CountEn0 "  "0 ,1 "
tree.end

base sd:0x801AF154
tree "CountEn1"
wgroup 0--3
line.long 0 "CountEn1"
bitfld.long 0 0. " CountEn1 "  "0 ,1 "
tree.end

base sd:0x801AF160
tree "CountReloadEv0"
wgroup 0--3
line.long 0 "CountReloadEv0"
bitfld.long 0 0. " CountReloadEv0 "  "0 ,1 "
tree.end

base sd:0x801AF164
tree "CountReloadEv1"
wgroup 0--3
line.long 0 "CountReloadEv1"
bitfld.long 0 0. " CountReloadEv1 "  "0 ,1 "
tree.end

base sd:0x801AF170
tree "CountValue0"
group 0--3
line.long 0 "CountValue0"
tree.end

base sd:0x801AF174
tree "CountValue1"
group 0--3
line.long 0 "CountValue1"
tree.end

base sd:0x801AF180
tree "SeqCtrl0"
wgroup 0--3
line.long 0 "SeqCtrl0"
bitfld.long 0 0. " SeqCtrl0 "  "0 ,1 "
tree.end

base sd:0x801AF184
tree "SeqCtrl1"
wgroup 0--3
line.long 0 "SeqCtrl1"
bitfld.long 0 0. " SeqCtrl1 "  "0 ,1 "
tree.end

base sd:0x801AF188
tree "SeqCtrl2"
wgroup 0--3
line.long 0 "SeqCtrl2"
bitfld.long 0 0. " SeqCtrl2 "  "0 ,1 "
tree.end

base sd:0x801AF18c
tree "SeqCtrl3"
wgroup 0--3
line.long 0 "SeqCtrl3"
bitfld.long 0 0. " SeqCtrl3 "  "0 ,1 "
tree.end

base sd:0x801AF190
tree "SeqCtrl4"
wgroup 0--3
line.long 0 "SeqCtrl4"
bitfld.long 0 0. " SeqCtrl4 "  "0 ,1 "
tree.end

base sd:0x801AF194
tree "SeqCtrl5"
wgroup 0--3
line.long 0 "SeqCtrl5"
bitfld.long 0 0. " SeqCtrl5 "  "0 ,1 "
tree.end

base sd:0x801AF19c
tree "SeqState"
group 0--3
line.long 0 "SeqState"
bitfld.long 0 0. " SeqState "  "0 ,1 "
tree.end

base sd:0x801AF1a0
tree "ExtOutput0"
wgroup 0--3
line.long 0 "ExtOutput0"
bitfld.long 0 0. " ExtOutput0 "  "0 ,1 "
tree.end

base sd:0x801AF1a4
tree "ExtOutput1"
wgroup 0--3
line.long 0 "ExtOutput1"
bitfld.long 0 0. " ExtOutput1 "  "0 ,1 "
tree.end

base sd:0x801AF1b0
tree "ContextIdComp"
wgroup 0--3
line.long 0 "ContextIdComp"
bitfld.long 0 0. " ContextIdComp "  "0 ,1 "
tree.end

base sd:0x801AF1bc
tree "ContextIdMask"
wgroup 0--3
line.long 0 "ContextIdMask"
tree.end

base sd:0x801AF1c0
tree "ImpSpecific0"
wgroup 0--3
line.long 0 "ImpSpecific0"
bitfld.long 0 0. " ImpSpecific0 "  "0 ,1 "
tree.end

base sd:0x801AF1c4
tree "ImpSpecific1"
wgroup 0--3
line.long 0 "ImpSpecific1"
bitfld.long 0 0. " ImpSpecific1 "  "0 ,1 "
tree.end

base sd:0x801AF1c8
tree "ImpSpecific2"
wgroup 0--3
line.long 0 "ImpSpecific2"
bitfld.long 0 0. " ImpSpecific2 "  "0 ,1 "
tree.end

base sd:0x801AF1cc
tree "ImpSpecific3"
wgroup 0--3
line.long 0 "ImpSpecific3"
bitfld.long 0 0. " ImpSpecific3 "  "0 ,1 "
tree.end

base sd:0x801AF1d0
tree "ImpSpecific4"
wgroup 0--3
line.long 0 "ImpSpecific4"
bitfld.long 0 0. " ImpSpecific4 "  "0 ,1 "
tree.end

base sd:0x801AF1d4
tree "ImpSpecific5"
wgroup 0--3
line.long 0 "ImpSpecific5"
bitfld.long 0 0. " ImpSpecific5 "  "0 ,1 "
tree.end

base sd:0x801AF1d8
tree "ImpSpecific6"
wgroup 0--3
line.long 0 "ImpSpecific6"
bitfld.long 0 0. " ImpSpecific6 "  "0 ,1 "
tree.end

base sd:0x801AF1dc
tree "ImpSpecific7"
wgroup 0--3
line.long 0 "ImpSpecific7"
bitfld.long 0 0. " ImpSpecific7 "  "0 ,1 "
tree.end

base sd:0x801AF1e0
tree "SynchFreq"
wgroup 0--3
line.long 0 "SynchFreq"
bitfld.long 0 0. " SynchFreq "  "0 ,1 "
tree.end

base sd:0x801AF1e4
tree "EtmId"
group 0--3
line.long 0 "EtmId"
bitfld.long 0 0. " EtmId "  "0 ,1 "
tree.end

base sd:0x801AF1e8
tree "ConfigCodeExt"
group 0--3
line.long 0 "ConfigCodeExt"
bitfld.long 0 0. " ConfigCodeExt "  "0 ,1 "
tree.end

base sd:0x801AF1ec
tree "ExternalInExt"
wgroup 0--3
line.long 0 "ExternalInExt"
bitfld.long 0 0. " ExternalInExt "  "0 ,1 "
tree.end

base sd:0x801AF200
tree "CSTraceID"
wgroup 0--3
line.long 0 "CSTraceID"
bitfld.long 0 0. " CSTraceID "  "0 ,1 "
tree.end

base sd:0x801AFfa0
tree "ClaimTagSet"
group 0--3
line.long 0 "ClaimTagSet"
bitfld.long 0 0. " ClaimTagSet "  "0 ,1 "
tree.end

base sd:0x801AFfa4
tree "ClaimTagClr"
group 0--3
line.long 0 "ClaimTagClr"
bitfld.long 0 0. " ClaimTagClr "  "0 ,1 "
tree.end

base sd:0x801AFfb0
tree "LockAccess"
wgroup 0--3
line.long 0 "LockAccess"
bitfld.long 0 0. " LockAccess "  "0 ,1 "
tree.end

base sd:0x801AFfb4
tree "LockStatus"
wgroup 0--3
line.long 0 "LockStatus"
bitfld.long 0 0. " LockStatus "  "0 ,1 "
tree.end

base sd:0x801AFfb8
tree "AuthenticationStatus"
group 0--3
line.long 0 "AuthenticationStatus"
bitfld.long 0 0. " AuthenticationStatus "  "0 ,1 "
tree.end

base sd:0x801AFfcc
tree "CSDeviceType"
rgroup 0--3
line.long 0 "CSDeviceType"
bitfld.long 0 0. " CSDeviceType "  "0 ,1 "
tree.end

base sd:0x801AFfd0
tree "PeriphID4"
rgroup 0--3
line.long 0 "PeriphID4"
bitfld.long 0 0. " PeriphID4 "  "0 ,1 "
tree.end

base sd:0x801AFfd4
tree "PeriphID5"
rgroup 0--3
line.long 0 "PeriphID5"
bitfld.long 0 0. " PeriphID5 "  "0 ,1 "
tree.end

base sd:0x801AFfd8
tree "PeriphID6"
rgroup 0--3
line.long 0 "PeriphID6"
bitfld.long 0 0. " PeriphID6 "  "0 ,1 "
tree.end

base sd:0x801AFfdc
tree "PeriphID7"
rgroup 0--3
line.long 0 "PeriphID7"
bitfld.long 0 0. " PeriphID7 "  "0 ,1 "
tree.end

base sd:0x801AFfe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0. " PeriphID0 "  "0 ,1 "
tree.end

base sd:0x801AFfe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0. " PeriphID1 "  "0 ,1 "
tree.end

base sd:0x801AFfe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0. " PeriphID2 "  "0 ,1 "
tree.end

base sd:0x801AFfec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0. " PeriphID3 "  "0 ,1 "
tree.end

base sd:0x801AFff0
tree "CompID0"
rgroup 0--3
line.long 0 "CompID0"
bitfld.long 0 0. " CompID0 "  "0 ,1 "
tree.end

base sd:0x801AFff4
tree "CompID1"
rgroup 0--3
line.long 0 "CompID1"
bitfld.long 0 0. " CompID1 "  "0 ,1 "
tree.end

base sd:0x801AFff8
tree "CompID2"
rgroup 0--3
line.long 0 "CompID2"
bitfld.long 0 0. " CompID2 "  "0 ,1 "
tree.end

base sd:0x801AFffc
tree "CompID3"
rgroup 0--3
line.long 0 "CompID3"
bitfld.long 0 0. " CompID3 "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "PWL"
;==============================================================
base sd:0x80113000
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " PWLEN "  "0 ,1 "
tree.end

base sd:0x80113004
tree "LR"
group 0--3
line.long 0 "LR"
bitfld.long 0 0.--7. " PWLVL "  " "
tree.end

base sd:0x80113080
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0x80113088
tree "ITOP"
rgroup 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " PWLOUT "  "0 ,1 "
tree.end

base sd:0x80113fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x80113fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80113fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80113fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80113ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " PCellID0 "  " "
tree.end

base sd:0x80113ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " PCellID1 "  " "
tree.end

base sd:0x80113ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " PCellID2 "  " "
tree.end

base sd:0x80113ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " PCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "RNG"
;==============================================================
base sd:0xa03c0000
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SEC "  "0 ,1 "
bitfld.long 0 1. " PRIV "  "0 ,1 "
bitfld.long 0 2. " RNGDIS "  "0 ,1 "
bitfld.long 0 3. " TSTCLK "  "0 ,1 "
tree.end

base sd:0xa03c0004
tree "SR"
group 0--3
line.long 0 "SR"
bitfld.long 0 0. " RNGRDY "  "0 ,1 "
bitfld.long 0 1. " REVCLK "  "0 ,1 "
bitfld.long 0 2. " FAULT "  "0 ,1 "
tree.end

base sd:0xa03c0008
tree "VAL"
group 0--3
line.long 0 "VAL"
bitfld.long 0 0. " 16 "  "0 ,1 "
tree.end

base sd:0xa03c0080
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0xa03c0084
tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
tree.end

base sd:0xa03c0fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0xa03c0fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0xa03c0fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0xa03c0fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0xa03c0ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " PCellID0 "  " "
tree.end

base sd:0xa03c0ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " PCellID1 "  " "
tree.end

base sd:0xa03c0ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " PCellID2 "  " "
tree.end

base sd:0xa03c0ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " PCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "RTC"
;==============================================================
base sd:0x80154000
tree "DR"
rgroup 0--3
line.long 0 "DR"
bitfld.long 0 0.--5. " CWSEC "  " "
bitfld.long 0 6.--11. " WMIN "  " "
bitfld.long 0 12.--16. " CWHOUR "  " "
bitfld.long 0 17.--19. " CWDAYW "  " "
bitfld.long 0 20.--24. " CWDAYM "  " "
bitfld.long 0 25.--28. " CWMONTH "  " "
tree.end

base sd:0x80154004
tree "MR"
group 0--3
line.long 0 "MR"
bitfld.long 0 0.--5. " CWSECM "  " "
bitfld.long 0 6.--11. " WMINM "  " "
bitfld.long 0 12.--16. " CWHOURM "  " "
bitfld.long 0 17.--19. " CWDAYWM "  " "
bitfld.long 0 20.--24. " CWDAYMM "  " "
bitfld.long 0 25.--28. " CWMONTHM "  " "
tree.end

base sd:0x80154008
tree "LR"
group 0--3
line.long 0 "LR"
bitfld.long 0 0.--5. " CWSECL "  " "
bitfld.long 0 6.--11. " WMINL "  " "
bitfld.long 0 12.--16. " CWHOURL "  " "
bitfld.long 0 17.--19. " CWDAYWL "  " "
bitfld.long 0 20.--24. " CWDAYML "  " "
bitfld.long 0 25.--28. " CWMONTHL "  " "
tree.end

base sd:0x8015400c
tree "TCR"
group 0--3
line.long 0 "TCR"
bitfld.long 0 0.--15. " CKDIV "  " "
bitfld.long 0 16.--25. " CKDEL "  " "
bitfld.long 0 26. " RTCEN "  "0 ,1 "
bitfld.long 0 27. " SEC "  "0 ,1 "
tree.end

base sd:0x80154010
tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTCIMSC "  "0 ,1 "
bitfld.long 0 1. " RTTIMSC "  "0 ,1 "
tree.end

base sd:0x80154014
tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTCRIS "  "0 ,1 "
bitfld.long 0 1. " RTTRIS "  "0 ,1 "
tree.end

base sd:0x80154018
tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTCMIS "  "0 ,1 "
bitfld.long 0 1. " RTTMIS "  "0 ,1 "
tree.end

base sd:0x8015401c
tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTCIC "  "0 ,1 "
bitfld.long 0 1. " RTTIC "  "0 ,1 "
tree.end

base sd:0x80154020
tree "RTT_DR"
group 0--3
line.long 0 "RTT_DR"
bitfld.long 0 0.--31. " Data "  " "
tree.end

base sd:0x80154024
tree "RTT_LR1"
group 0--3
line.long 0 "RTT_LR1"
bitfld.long 0 0.--31. " Load "  " "
tree.end

base sd:0x8015402c
tree "RTT_LR2"
group 0--3
line.long 0 "RTT_LR2"
bitfld.long 0 0.--31. " Load "  " "
tree.end

base sd:0x8015403c
tree "RTT_PR1"
group 0--3
line.long 0 "RTT_PR1"
bitfld.long 0 0.--31. " Load "  " "
tree.end

base sd:0x80154040
tree "RTT_PR2"
group 0--3
line.long 0 "RTT_PR2"
bitfld.long 0 0.--31. " Load "  " "
tree.end

base sd:0x80154044
tree "RTT_PR3"
group 0--3
line.long 0 "RTT_PR3"
bitfld.long 0 0.--31. " Load "  " "
tree.end

base sd:0x80154048
tree "RTT_PR4"
group 0--3
line.long 0 "RTT_PR4"
bitfld.long 0 0.--31. " Load "  " "
tree.end

base sd:0x8015404c
tree "IN"
rgroup 0--3
line.long 0 "IN"
bitfld.long 0 0.--31. " TINTERRUPT "  " "
tree.end

base sd:0x80154050
tree "WK"
group 0--3
line.long 0 "WK"
bitfld.long 0 0.--31. " TINTERRUPT "  " "
tree.end

base sd:0x80154054
tree "SMIN"
rgroup 0--3
line.long 0 "SMIN"
bitfld.long 0 0.--31. " SINTERRUPT "  " "
tree.end

base sd:0x80154028
tree "RTT_CR"
group 0--3
line.long 0 "RTT_CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
bitfld.long 0 2. " RTTSS "  "0 ,1 "
bitfld.long 0 3. " RTTSM "  "0 ,1 "
bitfld.long 0 4.--10. " RTTPS "  " "
bitfld.long 0 11. " RTTCLK "  "0 ,1 "
tree.end

base sd:0x80154030
tree "YR"
rgroup 0--3
line.long 0 "YR"
bitfld.long 0 0.--13. " CWYEAR "  " "
tree.end

base sd:0x80154034
tree "YMR"
group 0--3
line.long 0 "YMR"
bitfld.long 0 0.--13. " CWYEARM "  " "
tree.end

base sd:0x80154038
tree "YLR"
group 0--3
line.long 0 "YLR"
bitfld.long 0 0.--13. " CWYEARL "  " "
tree.end

base sd:0x80154080
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTCNT "  "0 ,1 "
tree.end

base sd:0x80154084
tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SECMOD "  "0 ,1 "
tree.end

base sd:0x80154088
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTCINTR "  "0 ,1 "
bitfld.long 0 1. " RTCWKUP "  "0 ,1 "
bitfld.long 0 2. " PWLOUT "  "0 ,1 "
bitfld.long 0 3. " RTTINTR "  "0 ,1 "
bitfld.long 0 4. " RTTWKUP "  "0 ,1 "
tree.end

base sd:0x80154fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x80154fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80154fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80154fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80154ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " RTCPCellID0 "  " "
tree.end

base sd:0x80154ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " RTCPCellID1 "  " "
tree.end

base sd:0x80154ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " RTCPCellID2 "  " "
tree.end

base sd:0x80154ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " RTCPCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "RTT0"
;==============================================================
base sd:0x80152000
tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--15. " CKDIV "  " "
tree.end

base sd:0x80152004
tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTTIMSC "  "0 ,1 "
tree.end

base sd:0x80152008
tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTTRIS "  "0 ,1 "
tree.end

base sd:0x8015200c
tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTTMIS "  "0 ,1 "
tree.end

base sd:0x80152010
tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTTIC "  "0 ,1 "
tree.end

base sd:0x80152014
tree "DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--31. " Data "  " "
tree.end

base sd:0x80152018
tree "LR"
group 0--3
line.long 0 "LR"
bitfld.long 0 0.--31. " Load "  " "
tree.end

base sd:0x8015201c
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
bitfld.long 0 2. " RTTENS "  "0 ,1 "
tree.end

base sd:0x80152080
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0x80152084
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTTINTR "  "0 ,1 "
bitfld.long 0 1. " RTTWKUP "  "0 ,1 "
tree.end

base sd:0x80152fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x80152fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80152fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80152fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80152ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " RTCPCellID0 "  " "
tree.end

base sd:0x80152ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " RTCPCellID1 "  " "
tree.end

base sd:0x80152ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " RTCPCellID2 "  " "
tree.end

base sd:0x80152ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " RTCPCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "RTT1"
;==============================================================
base sd:0x80153000
tree "CTCR"
group 0--3
line.long 0 "CTCR"
bitfld.long 0 0.--15. " CKDIV "  " "
tree.end

base sd:0x80153004
tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RTTIMSC "  "0 ,1 "
tree.end

base sd:0x80153008
tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RTTRIS "  "0 ,1 "
tree.end

base sd:0x8015300c
tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RTTMIS "  "0 ,1 "
tree.end

base sd:0x80153010
tree "ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RTTIC "  "0 ,1 "
tree.end

base sd:0x80153014
tree "DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--31. " Data "  " "
tree.end

base sd:0x80153018
tree "LR"
group 0--3
line.long 0 "LR"
bitfld.long 0 0.--31. " Load "  " "
tree.end

base sd:0x8015301c
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " RTTOS "  "0 ,1 "
bitfld.long 0 1. " RTTEN "  "0 ,1 "
bitfld.long 0 2. " RTTENS "  "0 ,1 "
tree.end

base sd:0x80153080
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0x80153084
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " RTTINTR "  "0 ,1 "
bitfld.long 0 1. " RTTWKUP "  "0 ,1 "
tree.end

base sd:0x80153fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x80153fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80153fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80153fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80153ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " RTCPCellID0 "  " "
tree.end

base sd:0x80153ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " RTCPCellID1 "  " "
tree.end

base sd:0x80153ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " RTCPCellID2 "  " "
tree.end

base sd:0x80153ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " RTCPCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "SCR"
;==============================================================
base sd:0x80155000
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " APEDBGEN0 "  "0 ,1 "
bitfld.long 0 1. " APENIDEN0 "  "0 ,1 "
bitfld.long 0 2. " APESPNIDEN0 "  "0 ,1 "
bitfld.long 0 3. " APESPIDEN0 "  "0 ,1 "
bitfld.long 0 4. " APEDBGEN1 "  "0 ,1 "
bitfld.long 0 5. " APENIDEN1 "  "0 ,1 "
bitfld.long 0 6. " APESPNIDEN1 "  "0 ,1 "
bitfld.long 0 7. " APESPIDEN1 "  "0 ,1 "
bitfld.long 0 8. " TOPDBGEN "  "0 ,1 "
bitfld.long 0 9. " MCSBAGEN "  "0 ,1 "
bitfld.long 0 10. " APESTRCEN "  "0 ,1 "
bitfld.long 0 11. " APESTMEN "  "0 ,1 "
bitfld.long 0 12. " SIADBGEN "  "0 ,1 "
bitfld.long 0 13. " TOPAPEDBGEN "  "0 ,1 "
bitfld.long 0 14. " SPRSTEN0 "  "0 ,1 "
bitfld.long 0 15. " SPRSTEN1 "  "0 ,1 "
bitfld.long 0 16. " PRCMUDBGEn "  "0 ,1 "
bitfld.long 0 17. " SFRDIS "  "0 ,1 "
bitfld.long 0 18. " CRRSTEN "  "0 ,1 "
bitfld.long 0 23. " MODEMDIS "  "0 ,1 "
bitfld.long 0 24. " FBVALDIS "  "0 ,1 "
bitfld.long 0 25. " SCRDAF "  "0 ,1 "
bitfld.long 0 26. " SWDGCLK "  "0 ,1 "
bitfld.long 0 27. " APECLKSW "  "0 ,1 "
bitfld.long 0 28. " cJTAGEn "  "0 ,1 "
bitfld.long 0 29. " REMAPDIS "  "0 ,1 "
bitfld.long 0 30. " SECMODDIS "  "0 ,1 "
bitfld.long 0 31. " OPENDEVn "  "0 ,1 "
tree.end

base sd:0x80155004
tree "WDR"
rgroup 0--3
line.long 0 "WDR"
bitfld.long 0 0.--31. " SWDTVAL "  " "
tree.end

base sd:0x80155008
tree "WLR"
group 0--3
line.long 0 "WLR"
bitfld.long 0 0.--31. " SWDTLOAD "  " "
tree.end

base sd:0x8015500c
tree "WCR"
group 0--3
line.long 0 "WCR"
bitfld.long 0 0. " SWDTDIS "  "0 ,1 "
bitfld.long 0 1. " SWDTLDIS "  "0 ,1 "
tree.end

base sd:0x80155010
tree "FVR0"
rgroup 0--3
line.long 0 "FVR0"
bitfld.long 0 0.--31. " FUSE0_VALUE "  " "
tree.end

base sd:0x80155014
tree "FVR1"
rgroup 0--3
line.long 0 "FVR1"
bitfld.long 0 0.--31. " FUSE1_VALUE "  " "
tree.end

base sd:0x80155018
tree "FVR2"
rgroup 0--3
line.long 0 "FVR2"
bitfld.long 0 0.--31. " FUSE2_VALUE "  " "
tree.end

base sd:0x8015501c
tree "FVR3"
rgroup 0--3
line.long 0 "FVR3"
bitfld.long 0 0.--31. " FUSE3_VALUE "  " "
tree.end

base sd:0x80155020
tree "FVR4"
rgroup 0--3
line.long 0 "FVR4"
bitfld.long 0 0.--31. " FUSE4_VALUE "  " "
tree.end

base sd:0x80155024
tree "FVR5"
rgroup 0--3
line.long 0 "FVR5"
bitfld.long 0 0.--31. " FUSE5_VALUE "  " "
tree.end

base sd:0x80155028
tree "FVR6"
rgroup 0--3
line.long 0 "FVR6"
bitfld.long 0 0.--31. " FUSE6_VALUE "  " "
tree.end

base sd:0x8015502c
tree "FVR7"
rgroup 0--3
line.long 0 "FVR7"
bitfld.long 0 0.--31. " FUSE7_VALUE "  " "
tree.end

base sd:0x80155030
tree "FVR8"
rgroup 0--3
line.long 0 "FVR8"
bitfld.long 0 0.--31. " FUSE8_VALUE "  " "
tree.end

base sd:0x80155034
tree "FVR9"
rgroup 0--3
line.long 0 "FVR9"
bitfld.long 0 0.--31. " FUSE9_VALUE "  " "
tree.end

base sd:0x80155038
tree "FVR10"
rgroup 0--3
line.long 0 "FVR10"
bitfld.long 0 0.--31. " FUSE10_VALUE "  " "
tree.end

base sd:0x8015503c
tree "FVR11"
rgroup 0--3
line.long 0 "FVR11"
bitfld.long 0 0.--31. " FUSE11_VALUE "  " "
tree.end

base sd:0x80155040
tree "FVR12"
rgroup 0--3
line.long 0 "FVR12"
bitfld.long 0 0.--31. " FUSE12_VALUE "  " "
tree.end

base sd:0x80155044
tree "FVR13"
rgroup 0--3
line.long 0 "FVR13"
bitfld.long 0 0.--31. " FUSE13_VALUE "  " "
tree.end

base sd:0x80155048
tree "FVR14"
rgroup 0--3
line.long 0 "FVR14"
bitfld.long 0 0.--31. " FUSE14_VALUE "  " "
tree.end

base sd:0x8015504c
tree "FVR15"
rgroup 0--3
line.long 0 "FVR15"
bitfld.long 0 0.--31. " FUSE15_VALUE "  " "
tree.end

base sd:0x80155050
tree "FVR16"
rgroup 0--3
line.long 0 "FVR16"
bitfld.long 0 0.--31. " FUSE16_VALUE "  " "
tree.end

base sd:0x80155054
tree "FVR17"
rgroup 0--3
line.long 0 "FVR17"
bitfld.long 0 0.--31. " FUSE17_VALUE "  " "
tree.end

base sd:0x80155058
tree "FVR18"
rgroup 0--3
line.long 0 "FVR18"
bitfld.long 0 0.--31. " FUSE18_VALUE "  " "
tree.end

base sd:0x8015505c
tree "FVR19"
rgroup 0--3
line.long 0 "FVR19"
bitfld.long 0 0.--31. " FUSE19_VALUE "  " "
tree.end

base sd:0x80155060
tree "FVR20"
rgroup 0--3
line.long 0 "FVR20"
bitfld.long 0 0.--31. " FUSE20_VALUE "  " "
tree.end

base sd:0x80155064
tree "FVR21"
rgroup 0--3
line.long 0 "FVR21"
bitfld.long 0 0.--31. " FUSE21_VALUE "  " "
tree.end

base sd:0x80155068
tree "FVR22"
rgroup 0--3
line.long 0 "FVR22"
bitfld.long 0 0.--31. " FUSE22_VALUE "  " "
tree.end

base sd:0x8015506c
tree "FVR23"
rgroup 0--3
line.long 0 "FVR23"
bitfld.long 0 0.--31. " FUSE23_VALUE "  " "
tree.end

base sd:0x80155070
tree "SRAMPROT0"
group 0--3
line.long 0 "SRAMPROT0"
bitfld.long 0 0.--3. " SRAMPROT0 "  " "
tree.end

base sd:0x80155090
tree "SPR0"
group 0--3
line.long 0 "SPR0"
bitfld.long 0 0.--31. " SSPR0 "  " "
tree.end

base sd:0x80155094
tree "SPR1"
group 0--3
line.long 0 "SPR1"
bitfld.long 0 0.--31. " SSPR1 "  " "
tree.end

base sd:0x80155098
tree "ROSZ"
group 0--3
line.long 0 "ROSZ"
bitfld.long 0 0.--9. " ROSZ0 "  " "
bitfld.long 0 10. " 2 "  "0 ,1 "
bitfld.long 0 11.--20. " R0SZ1 "  " "
tree.end

base sd:0x8015509c
tree "DECPROT"
group 0--3
line.long 0 "DECPROT"
bitfld.long 0 0.--25. " DECPROT "  " "
tree.end

base sd:0x801550d0
tree "DDRSECLOW"
group 0--3
line.long 0 "DDRSECLOW"
bitfld.long 0 0.--31. " DDRSECLOW "  " "
tree.end

base sd:0x801550d4
tree "DDRSECHIGH"
group 0--3
line.long 0 "DDRSECHIGH"
bitfld.long 0 0.--31. " DDRSECHIGH "  " "
tree.end

base sd:0x801550d8
tree "DDRA9LOW"
group 0--3
line.long 0 "DDRA9LOW"
bitfld.long 0 0.--31. " DDRA9LOW "  " "
tree.end

base sd:0x801550dc
tree "DDRA9HIGH"
group 0--3
line.long 0 "DDRA9HIGH"
bitfld.long 0 0.--31. " DDRA9HIGH "  " "
tree.end

base sd:0x801550e0
tree "DDRMODLOW"
group 0--3
line.long 0 "DDRMODLOW"
bitfld.long 0 0.--31. " DDRMODLOW "  " "
tree.end

base sd:0x801550e4
tree "DDRMODHIGH"
group 0--3
line.long 0 "DDRMODHIGH"
bitfld.long 0 0.--31. " DDRMODHIGH "  " "
tree.end

base sd:0x801550e8
tree "DDRSHAREHIGH"
group 0--3
line.long 0 "DDRSHAREHIGH"
bitfld.long 0 0.--31. " DDRSHAREHIGH "  " "
tree.end

base sd:0x801550ec
tree "DDRMAXSPACE"
group 0--3
line.long 0 "DDRMAXSPACE"
bitfld.long 0 0.--31. " DDRMAXSPACE "  " "
tree.end

base sd:0x801550b0
tree "FUSECRC"
group 0--3
line.long 0 "FUSECRC"
bitfld.long 0 0.--7. " CRC0 "  " "
bitfld.long 0 8.--15. " CRC1 "  " "
bitfld.long 0 16.--23. " CRC2 "  " "
tree.end

base sd:0x801550c0
tree "SCRBCTRL"
group 0--3
line.long 0 "SCRBCTRL"
bitfld.long 0 0. " SCRBEN "  "0 ,1 "
tree.end

base sd:0x801550c4
tree "SCRBKEY_L"
group 0--3
line.long 0 "SCRBKEY_L"
bitfld.long 0 0.--31. " SCRAMBLE_KEY "  " "
tree.end

base sd:0x801550c8
tree "SCRBKEY_H"
group 0--3
line.long 0 "SCRBKEY_H"
bitfld.long 0 0.--31. " SCRAMBLE_KEY "  " "
tree.end

base sd:0x80155100
tree "MODEM_CR"
group 0--3
line.long 0 "MODEM_CR"
bitfld.long 0 0. " DBGEN "  "0 ,1 "
bitfld.long 0 1. " NIDEN "  "0 ,1 "
bitfld.long 0 2. " SPNIDEN "  "0 ,1 "
bitfld.long 0 3. " SPIDEN "  "0 ,1 "
bitfld.long 0 10. " STRCEN "  "0 ,1 "
bitfld.long 0 11. " STMDIS "  "0 ,1 "
bitfld.long 0 13. " TOPDBGEN "  "0 ,1 "
bitfld.long 0 16. " TXDIS "  "0 ,1 "
tree.end

base sd:0x80155fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x80155fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80155fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80155fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80155ff0
tree "PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " PCellID0 "  " "
tree.end

base sd:0x80155ff4
tree "PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " PCellID1 "  " "
tree.end

base sd:0x80155ff8
tree "PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " PCellID2 "  " "
tree.end

base sd:0x80155ffc
tree "PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " PCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "SCU"
;==============================================================
base sd:0xa0410000
tree "SCU_CR"
group 0--3
line.long 0 "SCU_CR"
bitfld.long 0 0. " SCUCREN "  "0 ,1 "
bitfld.long 0 1. " SCUCRAFEN "  "0 ,1 "
bitfld.long 0 2. " SCUCRRPE "  "0 ,1 "
tree.end

base sd:0xa0410004
tree "SCU_CONFR"
group 0--3
line.long 0 "SCU_CONFR"
bitfld.long 0 0.--1. " SCUCONFRCPUN "  " "
bitfld.long 0 4.--7. " SCUCONFRCPUSMP "  " "
bitfld.long 0 8.--15. " SCUCONFRTRS "  " "
tree.end

base sd:0xa0410008
tree "SCU_CPUPSR"
group 0--3
line.long 0 "SCU_CPUPSR"
bitfld.long 0 0.--1. " SCUCPUPSRCPU0 "  " "
bitfld.long 0 2.--3. " SCUCPUPSRCPU1 "  " "
bitfld.long 0 4.--5. " SCUCPUPSRCPU2 "  " "
bitfld.long 0 6.--7. " SCUCPUPSRCPU3 "  " "
tree.end

base sd:0xa041000c
tree "SCU_IA"
wgroup 0--3
line.long 0 "SCU_IA"
bitfld.long 0 0.--3. " SCUIACPU0 "  " "
bitfld.long 0 4.--7. " SCUIACPU1 "  " "
bitfld.long 0 8.--11. " SCUIACPU2 "  " "
bitfld.long 0 12.--15. " SCUIACPU3 "  " "
tree.end

base sd:0xa0410040
tree "SCU_FSAR"
group 0--3
line.long 0 "SCU_FSAR"
bitfld.long 0 20.--31. " SCUFSARFSA "  " "
tree.end

base sd:0xa0410044
tree "SCU_FEAR"
group 0--3
line.long 0 "SCU_FEAR"
bitfld.long 0 20.--31. " SCUFEARFEA "  " "
tree.end

base sd:0xa0410050
tree "SCU_ACR"
group 0--3
line.long 0 "SCU_ACR"
bitfld.long 0 0. " SCUACRCPU0 "  "0 ,1 "
bitfld.long 0 1. " SCUACRCPU1 "  "0 ,1 "
bitfld.long 0 2. " SCUACRCPU2 "  "0 ,1 "
bitfld.long 0 3. " SCUACRCPU3 "  "0 ,1 "
tree.end

base sd:0xa0410054
tree "SCU_SACR"
group 0--3
line.long 0 "SCU_SACR"
bitfld.long 0 0. " SCUSACRCPU0 "  "0 ,1 "
bitfld.long 0 1. " SCUSACRCPU1 "  "0 ,1 "
bitfld.long 0 2. " SCUSACRCPU2 "  "0 ,1 "
bitfld.long 0 3. " SCUSACRCPU3 "  "0 ,1 "
bitfld.long 0 4. " SCUSACRTCPU0 "  "0 ,1 "
bitfld.long 0 5. " SCUSACRTCPU1 "  "0 ,1 "
bitfld.long 0 6. " SCUSACRTCPU2 "  "0 ,1 "
bitfld.long 0 7. " SCUSACRTCPU3 "  "0 ,1 "
tree.end

tree.end

;==============================================================
tree "SKE"
;==============================================================
base sd:0x80006000
tree "CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " SKEN0 "  "0 ,1 "
bitfld.long 0 1. " SKEN1 "  "0 ,1 "
bitfld.long 0 2. " KPASEN "  "0 ,1 "
bitfld.long 0 3.--5. " KPCN "  " "
bitfld.long 0 6. " KPMLT "  "0 ,1 "
bitfld.long 0 7. " KPSON "  "0 ,1 "
bitfld.long 0 8. " KPOC0 "  "0 ,1 "
bitfld.long 0 9. " KPOC1 "  "0 ,1 "
bitfld.long 0 10. " KPOC2 "  "0 ,1 "
bitfld.long 0 11. " KPOC3 "  "0 ,1 "
bitfld.long 0 12. " KPOC4 "  "0 ,1 "
bitfld.long 0 13. " KPOC5 "  "0 ,1 "
bitfld.long 0 14. " KPOC6 "  "0 ,1 "
bitfld.long 0 15. " KPOC7 "  "0 ,1 "
tree.end

base sd:0x80006004
tree "VAL0"
group 0--3
line.long 0 "VAL0"
bitfld.long 0 0.--7. " SKEVAL0 "  " "
bitfld.long 0 14. " UDF0 "  "0 ,1 "
bitfld.long 0 15. " OVF0 "  "0 ,1 "
tree.end

base sd:0x80006008
tree "VAL1"
group 0--3
line.long 0 "VAL1"
bitfld.long 0 0.--7. " SKEVAL1 "  " "
bitfld.long 0 14. " UDF1 "  "0 ,1 "
bitfld.long 0 15. " OVF1 "  "0 ,1 "
tree.end

base sd:0x8000600c
tree "DBCR"
group 0--3
line.long 0 "DBCR"
bitfld.long 0 0.--7. " SKEDBC "  " "
bitfld.long 0 8.--15. " KPDBC "  " "
tree.end

base sd:0x80006010
tree "IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " SKEIM0 "  "0 ,1 "
bitfld.long 0 1. " SKEIM1 "  "0 ,1 "
bitfld.long 0 2. " KPIMA "  "0 ,1 "
bitfld.long 0 3. " KPIMS "  "0 ,1 "
tree.end

base sd:0x80006014
tree "RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " SKERIS0 "  "0 ,1 "
bitfld.long 0 1. " SKERIS1 "  "0 ,1 "
bitfld.long 0 2. " KPRISA "  "0 ,1 "
bitfld.long 0 3. " KPRISS "  "0 ,1 "
tree.end

base sd:0x80006018
tree "MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " SKEMIS0 "  "0 ,1 "
bitfld.long 0 1. " SKEMIS1 "  "0 ,1 "
bitfld.long 0 2. " KPMISA "  "0 ,1 "
bitfld.long 0 3. " KPMISS "  "0 ,1 "
tree.end

base sd:0x8000601c
tree "ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " SKEIC0 "  "0 ,1 "
bitfld.long 0 1. " SKEIC1 "  "0 ,1 "
bitfld.long 0 2. " KPICA "  "0 ,1 "
bitfld.long 0 3. " KPICS "  "0 ,1 "
tree.end

base sd:0x80006020
tree "ASR0"
group 0--3
line.long 0 "ASR0"
bitfld.long 0 0.--7. " KPRVAL0 "  " "
bitfld.long 0 8.--15. " KPRVAL1 "  " "
tree.end

base sd:0x80006024
tree "ASR1"
group 0--3
line.long 0 "ASR1"
bitfld.long 0 0.--7. " KPRVAL2 "  " "
bitfld.long 0 8.--15. " KPRVAL3 "  " "
tree.end

base sd:0x80006028
tree "ASR2"
group 0--3
line.long 0 "ASR2"
bitfld.long 0 0.--7. " KPRVAL4 "  " "
bitfld.long 0 8.--15. " KPRVAL5 "  " "
tree.end

base sd:0x8000602c
tree "ASR3"
group 0--3
line.long 0 "ASR3"
bitfld.long 0 0.--7. " KPRVAL6 "  " "
bitfld.long 0 8.--15. " KPRVAL7 "  " "
tree.end

base sd:0x80006080
tree "ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " RITEN "  "0 ,1 "
bitfld.long 0 1. " KBD_ERR "  "0 ,1 "
tree.end

base sd:0x80006084
tree "ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " PKI0 "  "0 ,1 "
bitfld.long 0 1. " PKI1 "  "0 ,1 "
bitfld.long 0 2. " PKI2 "  "0 ,1 "
bitfld.long 0 3. " PKI3 "  "0 ,1 "
bitfld.long 0 4. " PKI4 "  "0 ,1 "
bitfld.long 0 5. " PKI5 "  "0 ,1 "
bitfld.long 0 6. " PKI6 "  "0 ,1 "
bitfld.long 0 7. " PKI7 "  "0 ,1 "
bitfld.long 0 8. " SKA0 "  "0 ,1 "
bitfld.long 0 9. " SKB0 "  "0 ,1 "
bitfld.long 0 10. " SKA1 "  "0 ,1 "
bitfld.long 0 11. " SKB1 "  "0 ,1 "
tree.end

base sd:0x80006088
tree "ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " KPO0 "  "0 ,1 "
bitfld.long 0 1. " KPO1 "  "0 ,1 "
bitfld.long 0 2. " KPO2 "  "0 ,1 "
bitfld.long 0 3. " KPO3 "  "0 ,1 "
bitfld.long 0 4. " KPO4 "  "0 ,1 "
bitfld.long 0 5. " KPO5 "  "0 ,1 "
bitfld.long 0 6. " KPO6 "  "0 ,1 "
bitfld.long 0 7. " KPO7 "  "0 ,1 "
bitfld.long 0 8. " SKEINTR0 "  "0 ,1 "
bitfld.long 0 9. " SKEINTR1 "  "0 ,1 "
bitfld.long 0 10. " KPINTR "  "0 ,1 "
tree.end

base sd:0x80006fe0
tree "SKEPeriphID0"
rgroup 0--3
line.long 0 "SKEPeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x80006fe4
tree "SKEPeriphID1"
rgroup 0--3
line.long 0 "SKEPeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80006fe8
tree "SKEPeriphID2"
rgroup 0--3
line.long 0 "SKEPeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80006fec
tree "SKEPeriphID3"
rgroup 0--3
line.long 0 "SKEPeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80006ff0
tree "SKEPCellID0"
rgroup 0--3
line.long 0 "SKEPCellID0"
bitfld.long 0 0.--7. " SKEPCellID0 "  " "
tree.end

base sd:0x80006ff4
tree "SKEPCellID1"
rgroup 0--3
line.long 0 "SKEPCellID1"
bitfld.long 0 0.--7. " SKEPCellID1 "  " "
tree.end

base sd:0x80006ff8
tree "SKEPCellID2"
rgroup 0--3
line.long 0 "SKEPCellID2"
bitfld.long 0 0.--7. " SKEPCellID2 "  " "
tree.end

base sd:0x80006ffc
tree "SKEPCellID3"
rgroup 0--3
line.long 0 "SKEPCellID3"
bitfld.long 0 0.--7. " SKEPCellID3 "  " "
tree.end

tree.end

;==============================================================
tree "SLIMBUS"
;==============================================================
base sd:0x8012b000
tree "IER"
group 0--3
line.long 0 "IER"
bitfld.long 0 0. " TX_MSG_PACK_EN "  "0 ,1 "
bitfld.long 0 1. " TX_MSG_NACK_EN "  "0 ,1 "
bitfld.long 0 2. " TX_MSG_NORE_EN "  "0 ,1 "
bitfld.long 0 3. " TX_MSG_UDEF_EN "  "0 ,1 "
bitfld.long 0 4. " RX_MSG_PACK_EN "  "0 ,1 "
bitfld.long 0 5. " RX_MSG_NACK_EN "  "0 ,1 "
bitfld.long 0 6. " RX_MSG_NORE_EN "  "0 ,1 "
bitfld.long 0 7. " RX_MSG_UDEF_EN "  "0 ,1 "
bitfld.long 0 8. " RECONFIG_SET_EN "  "0 ,1 "
bitfld.long 0 9. " RECONFIG_CLEAR_EN "  "0 ,1 "
bitfld.long 0 10. " EX_ERROR_EN "  "0 ,1 "
bitfld.long 0 11. " DATA_TX_COL_EN "  "0 ,1 "
bitfld.long 0 12. " UNSPRTD_MSG_EN "  "0 ,1 "
bitfld.long 0 13. " AM_H_INTA_N "  "0 ,1 "
bitfld.long 0 14. " GD0_H_INTA_N "  "0 ,1 "
bitfld.long 0 15. " 4 "  "0 ,1 "
bitfld.long 0 16. " prep_cont_sts_en "  "0 ,1 "
bitfld.long 0 17. " Rx_Msp_OFL_en "  "0 ,1 "
bitfld.long 0 18. " clk_pause_sts_en "  "0 ,1 "
tree.end

base sd:0x8012b004
tree "ISR"
group 0--3
line.long 0 "ISR"
bitfld.long 0 0. " TX_MSG_PACK "  "0 ,1 "
bitfld.long 0 1. " TX_MSG_NACK "  "0 ,1 "
bitfld.long 0 2. " TX_MSG_NORE "  "0 ,1 "
bitfld.long 0 3. " TX_MSG_UDEF "  "0 ,1 "
bitfld.long 0 4. " RX_MSG_PACK "  "0 ,1 "
bitfld.long 0 5. " RX_MSG_NACK "  "0 ,1 "
bitfld.long 0 6. " RX_MSG_NORE "  "0 ,1 "
bitfld.long 0 7. " RX_MSG_UDEF "  "0 ,1 "
bitfld.long 0 8. " RECONFIG_SET "  "0 ,1 "
bitfld.long 0 9. " RECONFIG_CLEAR "  "0 ,1 "
bitfld.long 0 10. " EX_ERROR "  "0 ,1 "
bitfld.long 0 11. " DATA_TX_COL "  "0 ,1 "
bitfld.long 0 12. " UNSPRTD_MSG "  "0 ,1 "
bitfld.long 0 13. " prep_cont_sts "  "0 ,1 "
bitfld.long 0 14. " Rx_Msp_OFL_sts "  "0 ,1 "
bitfld.long 0 15. " clk_pause_sts "  "0 ,1 "
tree.end

base sd:0x8012b008
tree "TA_1"
group 0--3
line.long 0 "TA_1"
bitfld.long 0 0.--2. " ARBITRTION_PRIORITY "  " "
bitfld.long 0 3. " AE "  "0 ,1 "
bitfld.long 0 4.--7. " ARBITRATION_TYPE "  " "
bitfld.long 0 8.--15. " Source_LA_EA "  " "
bitfld.long 0 16.--31. " Source_EA "  " "
tree.end

base sd:0x8012b00c
tree "TA_2"
group 0--3
line.long 0 "TA_2"
bitfld.long 0 0.--23. " Source_EA "  " "
tree.end

base sd:0x8012b010
tree "TMH_1"
group 0--3
line.long 0 "TMH_1"
bitfld.long 0 0.--4. " REMAINING_LENGTH "  " "
bitfld.long 0 5.--7. " MESSAGE_TYPE "  " "
bitfld.long 0 8.--14. " MESSAGE_CODE "  " "
bitfld.long 0 16.--19. " PRIMARY_INTEGRITY "  " "
bitfld.long 0 20.--21. " DESTINATION_TYPE "  " "
bitfld.long 0 24.--31. " DEST_EA "  " "
tree.end

base sd:0x8012b014
tree "TMH_2"
group 0--3
line.long 0 "TMH_2"
bitfld.long 0 0.--31. " DEST_EA "  " "
tree.end

base sd:0x8012b018
tree "TMH_3"
group 0--3
line.long 0 "TMH_3"
bitfld.long 0 0.--7. " DEST_EA "  " "
tree.end

base sd:0x8012b01c
tree "TMP_1"
group 0--3
line.long 0 "TMP_1"
bitfld.long 0 0.--31. " TX_MSG_PAYLOAD1 "  " "
tree.end

base sd:0x8012b020
tree "TMP_2"
group 0--3
line.long 0 "TMP_2"
bitfld.long 0 0.--31. " TX_MSG_PAYLOAD2 "  " "
tree.end

base sd:0x8012b024
tree "TMP_3"
group 0--3
line.long 0 "TMP_3"
bitfld.long 0 0.--7. " TX_MSG_PAYLOAD3 "  " "
bitfld.long 0 8. " MSG_RDY "  "0 ,1 "
tree.end

base sd:0x8012b038
tree "RA_1"
rgroup 0--3
line.long 0 "RA_1"
bitfld.long 0 0.--2. " ARBITRATION_PRIORITY "  " "
bitfld.long 0 3. " AE "  "0 ,1 "
bitfld.long 0 4.--7. " ARBITRATION_TYPE "  " "
bitfld.long 0 8.--15. " SOURCE_LA_EA "  " "
bitfld.long 0 16.--31. " SOURCE_EA "  " "
tree.end

base sd:0x8012b03c
tree "RA_2"
rgroup 0--3
line.long 0 "RA_2"
bitfld.long 0 0.--23. " SOURCE_EA "  " "
bitfld.long 0 24.--27. " msg_resp "  " "
tree.end

base sd:0x8012b040
tree "RMH_1"
rgroup 0--3
line.long 0 "RMH_1"
bitfld.long 0 0.--4. " REMAINING_LENGTH "  " "
bitfld.long 0 5.--7. " MESSAGE_TYPE "  " "
bitfld.long 0 8.--14. " MESSAGE_CODE "  " "
bitfld.long 0 16.--19. " PRIMARY_INTEGRITY "  " "
bitfld.long 0 20.--21. " DESTINATION_TYPE "  " "
bitfld.long 0 24.--31. " DEST_EA "  " "
tree.end

base sd:0x8012b044
tree "RMH_2"
rgroup 0--3
line.long 0 "RMH_2"
bitfld.long 0 0.--31. " DEST_EA "  " "
tree.end

base sd:0x8012b048
tree "RMH_3"
rgroup 0--3
line.long 0 "RMH_3"
bitfld.long 0 0.--7. " DEST_EA "  " "
tree.end

base sd:0x8012b04c
tree "RMP_1"
rgroup 0--3
line.long 0 "RMP_1"
bitfld.long 0 0.--31. " RX_MSG_PAYLOAD1 "  " "
tree.end

base sd:0x8012b050
tree "RMP_2"
rgroup 0--3
line.long 0 "RMP_2"
bitfld.long 0 0.--31. " RX_MSG_PAYLOAD2 "  " "
tree.end

base sd:0x8012b068
tree "IFEA31"
group 0--3
line.long 0 "IFEA31"
bitfld.long 0 0.--31. " IF_EA_31_0 "  " "
tree.end

base sd:0x8012b06c
tree "IFEA47"
group 0--3
line.long 0 "IFEA47"
bitfld.long 0 0.--15. " IF_EA_47_32 "  " "
tree.end

base sd:0x8012b074
tree "FEA31"
group 0--3
line.long 0 "FEA31"
bitfld.long 0 0. " F_EA "  "0 ,1 "
tree.end

base sd:0x8012b078
tree "FEA47"
group 0--3
line.long 0 "FEA47"
bitfld.long 0 0.--15. " F_EA "  " "
tree.end

base sd:0x8012b080
tree "CONFIG"
group 0--3
line.long 0 "CONFIG"
bitfld.long 0 0. " FR_PRI_SEC "  "0 ,1 "
bitfld.long 0 1. " AM_EN "  "0 ,1 "
bitfld.long 0 2. " FR_EN "  "0 ,1 "
bitfld.long 0 3. " GD0_EN "  "0 ,1 "
bitfld.long 0 4.--7. " FR_CLK_FREQ "  " "
bitfld.long 0 8.--12. " FR_CLK_GEAR "  " "
bitfld.long 0 13.--17. " FR_BOOT_MODE "  " "
bitfld.long 0 18.--21. " FR_BOOT_GEAR "  " "
bitfld.long 0 22. " FR_CLK_PAUSE "  "0 ,1 "
bitfld.long 0 23. " if_en "  "0 ,1 "
tree.end

base sd:0x8012b084
tree "SIR"
rgroup 0--3
line.long 0 "SIR"
bitfld.long 0 0. " AM_IF_INT "  "0 ,1 "
bitfld.long 0 1. " GD0_INT "  "0 ,1 "
tree.end

base sd:0x8012b088
tree "RP_PRE_EN"
group 0--3
line.long 0 "RP_PRE_EN"
bitfld.long 0 0. " af_rp_pre_en "  "0 ,1 "
bitfld.long 0 1. " if_rp_pre_en "  "0 ,1 "
bitfld.long 0 2. " gd0_rp_pre_en "  "0 ,1 "
bitfld.long 0 8. " fr_enumeration "  "0 ,1 "
bitfld.long 0 9. " if_enumeration "  "0 ,1 "
bitfld.long 0 10. " gd0_enumeration "  "0 ,1 "
tree.end

base sd:0x8012b150
tree "GD0EA31"
group 0--3
line.long 0 "GD0EA31"
bitfld.long 0 0.--31. " GD0_EA_31_0 "  " "
tree.end

base sd:0x8012b154
tree "GD0EA47"
group 0--3
line.long 0 "GD0EA47"
bitfld.long 0 0.--31. " GD0_EA_47_32 "  " "
tree.end

base sd:0x8012b158
tree "GD0LA"
rgroup 0--3
line.long 0 "GD0LA"
bitfld.long 0 0.--7. " GD0_LA "  " "
tree.end

base sd:0x8012b15c
tree "GD0IE"
group 0--3
line.long 0 "GD0IE"
bitfld.long 0 0. " gd0_p0_int_en "  "0 ,1 "
bitfld.long 0 1. " gd0_p1_int_en "  "0 ,1 "
bitfld.long 0 2. " gd0_p2_int_en "  "0 ,1 "
bitfld.long 0 3. " gd0_p3_int_en "  "0 ,1 "
bitfld.long 0 4. " gd0_p4_int_en "  "0 ,1 "
bitfld.long 0 5. " gd0_p5_int_en "  "0 ,1 "
bitfld.long 0 6. " gd0_p6_int_en "  "0 ,1 "
bitfld.long 0 7. " gd0_p7_int_en "  "0 ,1 "
bitfld.long 0 8. " gd0_p8_int_en "  "0 ,1 "
bitfld.long 0 9. " gd0_p9_int_en "  "0 ,1 "
tree.end

base sd:0x8012b160
tree "GD0IS"
rgroup 0--3
line.long 0 "GD0IS"
bitfld.long 0 0. " gd0_p0_int_sts "  "0 ,1 "
bitfld.long 0 1. " gd0_p1_int_sts "  "0 ,1 "
bitfld.long 0 2. " gd0_p2_int_sts "  "0 ,1 "
bitfld.long 0 3. " gd0_p3_int_sts "  "0 ,1 "
bitfld.long 0 4. " gd0_p4_int_sts "  "0 ,1 "
bitfld.long 0 5. " gd0_p5_int_sts "  "0 ,1 "
bitfld.long 0 6. " gd0_p6_int_sts "  "0 ,1 "
bitfld.long 0 7. " gd0_p7_int_sts "  "0 ,1 "
bitfld.long 0 8. " gd0_p8_int_sts "  "0 ,1 "
bitfld.long 0 9. " gd0_p9_int_sts "  "0 ,1 "
tree.end

base sd:0x8012b164
tree "D0P0_IE"
group 0--3
line.long 0 "D0P0_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
tree.end

base sd:0x8012b168
tree "D0P0_IS"
group 0--3
line.long 0 "D0P0_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
tree.end

base sd:0x8012b16c
tree "D0P0_config"
group 0--3
line.long 0 "D0P0_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  " "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
tree.end

base sd:0x8012b170
tree "D0P0DP"
group 0--3
line.long 0 "D0P0DP"
bitfld.long 0 0.--31. " DATA_PORT "  " "
tree.end

base sd:0x8012b174
tree "D0P1_IE"
group 0--3
line.long 0 "D0P1_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
tree.end

base sd:0x8012b178
tree "D0P1_IS"
group 0--3
line.long 0 "D0P1_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
tree.end

base sd:0x8012b17c
tree "D0P1_config"
group 0--3
line.long 0 "D0P1_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  " "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
tree.end

base sd:0x8012b180
tree "D0P1DP"
group 0--3
line.long 0 "D0P1DP"
bitfld.long 0 0.--31. " DATA_PORT "  " "
tree.end

base sd:0x8012b184
tree "D0P2_IE"
group 0--3
line.long 0 "D0P2_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
tree.end

base sd:0x8012b188
tree "D0P2_IS"
group 0--3
line.long 0 "D0P2_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
tree.end

base sd:0x8012b18c
tree "D0P2_config"
group 0--3
line.long 0 "D0P2_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  " "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
tree.end

base sd:0x8012b190
tree "D0P2DP"
group 0--3
line.long 0 "D0P2DP"
bitfld.long 0 0.--31. " DATA_PORT "  " "
tree.end

base sd:0x8012b194
tree "D0P3_IE"
group 0--3
line.long 0 "D0P3_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
tree.end

base sd:0x8012b198
tree "D0P3_IS"
group 0--3
line.long 0 "D0P3_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
tree.end

base sd:0x8012b19c
tree "D0P3_config"
group 0--3
line.long 0 "D0P3_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  " "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
tree.end

base sd:0x8012b1a0
tree "D0P3DP"
group 0--3
line.long 0 "D0P3DP"
bitfld.long 0 0.--31. " DATA_PORT "  " "
tree.end

base sd:0x8012b1a4
tree "D0P4_IE"
group 0--3
line.long 0 "D0P4_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
tree.end

base sd:0x8012b1a8
tree "D0P4_IS"
group 0--3
line.long 0 "D0P4_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
tree.end

base sd:0x8012b1ac
tree "D0P4_config"
group 0--3
line.long 0 "D0P4_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  " "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
tree.end

base sd:0x8012b1b0
tree "D0P4DP"
group 0--3
line.long 0 "D0P4DP"
bitfld.long 0 0.--31. " DATA_PORT "  " "
tree.end

base sd:0x8012b1b4
tree "D0P5_IE"
group 0--3
line.long 0 "D0P5_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
tree.end

base sd:0x8012b1b8
tree "D0P5_IS"
group 0--3
line.long 0 "D0P5_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
tree.end

base sd:0x8012b1bc
tree "D0P5_config"
group 0--3
line.long 0 "D0P5_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  " "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
tree.end

base sd:0x8012b1c0
tree "D0P5DP"
group 0--3
line.long 0 "D0P5DP"
bitfld.long 0 0.--31. " DATA_PORT "  " "
tree.end

base sd:0x8012b1c4
tree "D0P6_IE"
group 0--3
line.long 0 "D0P6_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
tree.end

base sd:0x8012b1c8
tree "D0P6_IS"
group 0--3
line.long 0 "D0P6_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
tree.end

base sd:0x8012b1cc
tree "D0P6_config"
group 0--3
line.long 0 "D0P6_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  " "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
tree.end

base sd:0x8012b1d0
tree "D0P6DP"
group 0--3
line.long 0 "D0P6DP"
bitfld.long 0 0.--31. " DATA_PORT "  " "
tree.end

base sd:0x8012b1d4
tree "D0P7_IE"
group 0--3
line.long 0 "D0P7_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
tree.end

base sd:0x8012b1d8
tree "D0P7_IS"
group 0--3
line.long 0 "D0P7_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
tree.end

base sd:0x8012b1dc
tree "D0P7_config"
group 0--3
line.long 0 "D0P7_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  " "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
tree.end

base sd:0x8012b1e0
tree "D0P7DP"
group 0--3
line.long 0 "D0P7DP"
bitfld.long 0 0.--31. " DATA_PORT "  " "
tree.end

base sd:0x8012b1e4
tree "D0P8_IE"
group 0--3
line.long 0 "D0P8_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
tree.end

base sd:0x8012b1e8
tree "D0P8_IS"
group 0--3
line.long 0 "D0P8_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
tree.end

base sd:0x8012b1ec
tree "D0P8_config"
group 0--3
line.long 0 "D0P8_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  " "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
tree.end

base sd:0x8012b1f0
tree "D0P8DP"
group 0--3
line.long 0 "D0P8DP"
bitfld.long 0 0.--31. " DATA_PORT "  " "
tree.end

base sd:0x8012b1f4
tree "D0P9_IE"
group 0--3
line.long 0 "D0P9_IE"
bitfld.long 0 0. " src_Threshold "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 16. " SINK_Threshold "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 31. " Timeout_en "  "0 ,1 "
tree.end

base sd:0x8012b1f8
tree "D0P9_IS"
group 0--3
line.long 0 "D0P9_IS"
bitfld.long 0 0. " src_Thresholdreached "  "0 ,1 "
bitfld.long 0 1. " SRC_FIFO_empty "  "0 ,1 "
bitfld.long 0 2. " SRC_FIFO_full "  "0 ,1 "
bitfld.long 0 3. " SRC_FIFO_underrun "  "0 ,1 "
bitfld.long 0 4. " SRC_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 16. " SINK_Thresholdreached "  "0 ,1 "
bitfld.long 0 17. " SINK_FIFO_empty "  "0 ,1 "
bitfld.long 0 18. " SINK_FIFO_full "  "0 ,1 "
bitfld.long 0 19. " SINK_FIFO_overrun "  "0 ,1 "
bitfld.long 0 20. " SINK_FIFO_empty_poll "  "0 ,1 "
bitfld.long 0 31. " Timeout_sts "  "0 ,1 "
tree.end

base sd:0x8012b1fc
tree "D0P9_config"
group 0--3
line.long 0 "D0P9_config"
bitfld.long 0 0.--5. " FIFO_WATER_MARK "  " "
bitfld.long 0 16. " dma_en "  "0 ,1 "
bitfld.long 0 17. " packed_en "  "0 ,1 "
bitfld.long 0 18. " Timeout "  "0 ,1 "
bitfld.long 0 19. " AHB_8_16_32 "  "0 ,1 "
bitfld.long 0 20. " wake_up_ena "  "0 ,1 "
bitfld.long 0 21. " wake_up_sts "  "0 ,1 "
tree.end

base sd:0x8012b200
tree "D0P9DP"
group 0--3
line.long 0 "D0P9DP"
bitfld.long 0 0.--31. " DATA_PORT "  " "
tree.end

base sd:0x8012b400
tree "SDMA0C"
group 0--3
line.long 0 "SDMA0C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  " "
tree.end

base sd:0x8012b404
tree "SDMA1C"
group 0--3
line.long 0 "SDMA1C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  " "
tree.end

base sd:0x8012b408
tree "SDMA2C"
group 0--3
line.long 0 "SDMA2C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  " "
tree.end

base sd:0x8012b40c
tree "SDMA3C"
group 0--3
line.long 0 "SDMA3C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  " "
tree.end

base sd:0x8012b410
tree "SDMA4C"
group 0--3
line.long 0 "SDMA4C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  " "
tree.end

base sd:0x8012b414
tree "SDMA5C"
group 0--3
line.long 0 "SDMA5C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  " "
tree.end

base sd:0x8012b418
tree "SDMA6C"
group 0--3
line.long 0 "SDMA6C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  " "
tree.end

base sd:0x8012b41c
tree "SDMA7C"
group 0--3
line.long 0 "SDMA7C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  " "
tree.end

base sd:0x8012b420
tree "SDMA8C"
group 0--3
line.long 0 "SDMA8C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  " "
tree.end

base sd:0x8012b424
tree "SDMA9C"
group 0--3
line.long 0 "SDMA9C"
bitfld.long 0 4.--23. " DMA_TRANSFER_COUNT "  " "
bitfld.long 0 24.--25. " DMA_BURST_SIZE "  " "
tree.end

base sd:0x8012b900
tree "fl_con_sav_reg1"
group 0--3
line.long 0 "fl_con_sav_reg1"
bitfld.long 0 0.--4. " next_frame_state "  " "
bitfld.long 0 10.--27. " cell1_count "  " "
bitfld.long 0 28.--30. " current_clk_rx_state "  " "
tree.end

base sd:0x8012b934
tree "mh_con_sav_reg1"
group 0--3
line.long 0 "mh_con_sav_reg1"
bitfld.long 0 0.--4. " sig_guide_val "  " "
bitfld.long 0 5.--8. " sig_clk_gear "  " "
bitfld.long 0 9.--12. " sig_root_freq "  " "
bitfld.long 0 13.--17. " sig_subfr_mode "  " "
tree.end

base sd:0x8012b948
tree "af_con_sav_reg1"
group 0--3
line.long 0 "af_con_sav_reg1"
bitfld.long 0 0.--2. " slim_fr_fl_info_cnt "  " "
bitfld.long 0 3.--6. " sig_slim_fr_fl_info "  " "
bitfld.long 0 7.--10. " cur_boot_st "  " "
bitfld.long 0 11.--18. " fr_log_addr "  " "
bitfld.long 0 19.--31. " root_supr_fr_cnt "  " "
tree.end

base sd:0x8012b94c
tree "af_con_sav_reg2"
group 0--3
line.long 0 "af_con_sav_reg2"
bitfld.long 0 0.--1. " curr_enum_st "  " "
bitfld.long 0 2.--3. " cur_fr_st "  " "
bitfld.long 0 4.--6. " core_info "  " "
bitfld.long 0 7.--9. " dev_info "  " "
tree.end

base sd:0x8012b968
tree "if_con_sav_reg1"
group 0--3
line.long 0 "if_con_sav_reg1"
bitfld.long 0 0.--7. " logical_addr "  " "
bitfld.long 0 8. " receive_ala "  "0 ,1 "
bitfld.long 0 9.--11. " arb_pri "  " "
bitfld.long 0 12.--13. " curr_enu_state "  " "
tree.end

base sd:0x8012b978
tree "gd0_msg_con_sav_reg1"
group 0--3
line.long 0 "gd0_msg_con_sav_reg1"
bitfld.long 0 0. " sig_channel_1 "  "0 ,1 "
bitfld.long 0 1. " sig_channel_2 "  "0 ,1 "
bitfld.long 0 2. " sig_channel_3 "  "0 ,1 "
bitfld.long 0 3. " sig_channel_4 "  "0 ,1 "
bitfld.long 0 4. " sig_channel_5 "  "0 ,1 "
bitfld.long 0 5. " sig_channel_6 "  "0 ,1 "
bitfld.long 0 6. " sig_channel_7 "  "0 ,1 "
bitfld.long 0 7. " sig_channel_8 "  "0 ,1 "
bitfld.long 0 8. " sig_channel_9 "  "0 ,1 "
bitfld.long 0 9. " sig_channel_10 "  "0 ,1 "
bitfld.long 0 10. " sig_channel_11 "  "0 ,1 "
bitfld.long 0 11. " sig_channel_12 "  "0 ,1 "
bitfld.long 0 12. " sig_channel_13 "  "0 ,1 "
bitfld.long 0 13. " sig_channel_14 "  "0 ,1 "
bitfld.long 0 14. " sig_channel_15 "  "0 ,1 "
bitfld.long 0 15. " sig_act_channel_1 "  "0 ,1 "
bitfld.long 0 16. " sig_act_channel_2 "  "0 ,1 "
bitfld.long 0 17. " sig_act_channel_3 "  "0 ,1 "
bitfld.long 0 18. " sig_act_channel_4 "  "0 ,1 "
bitfld.long 0 19. " sig_act_channel_5 "  "0 ,1 "
bitfld.long 0 20. " sig_act_channel_6 "  "0 ,1 "
bitfld.long 0 21. " sig_act_channel_7 "  "0 ,1 "
bitfld.long 0 22. " sig_act_channel_8 "  "0 ,1 "
bitfld.long 0 23. " sig_act_channel_9 "  "0 ,1 "
bitfld.long 0 24. " sig_act_channel_10 "  "0 ,1 "
bitfld.long 0 25. " sig_act_channel_11 "  "0 ,1 "
bitfld.long 0 26. " sig_act_channel_12 "  "0 ,1 "
bitfld.long 0 27. " sig_act_channel_13 "  "0 ,1 "
bitfld.long 0 28. " sig_act_channel_14 "  "0 ,1 "
bitfld.long 0 29. " sig_act_channel_15 "  "0 ,1 "
bitfld.long 0 30. " sig_act_channel_16 "  "0 ,1 "
tree.end

base sd:0x8012b97c
tree "gd0_msg_con_sav_reg2"
group 0--3
line.long 0 "gd0_msg_con_sav_reg2"
bitfld.long 0 0.--7. " sig_gd_log_addr "  " "
bitfld.long 0 8. " receive_ala "  "0 ,1 "
bitfld.long 0 9.--11. " arb_pri "  " "
bitfld.long 0 12.--13. " curr_enu_state "  " "
tree.end

base sd:0x8012b980
tree "gd0_port0_con_sav_reg1"
group 0--3
line.long 0 "gd0_port0_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p0_seg_length "  " "
bitfld.long 0 5.--9. " sig_gd_p0_dat_len "  " "
bitfld.long 0 10.--13. " sig_gd_p0_protocol "  " "
bitfld.long 0 14. " sig_gd_p0_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p0_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p0_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p0_ch "  " "
bitfld.long 0 21. " sig_gd_p0_freq_lock "  "0 ,1 "
tree.end

base sd:0x8012b984
tree "gd0_port1_con_sav_reg1"
group 0--3
line.long 0 "gd0_port1_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p1_seg_length "  " "
bitfld.long 0 5.--9. " sig_gd_p1_dat_len "  " "
bitfld.long 0 10.--13. " sig_gd_p1_protocol "  " "
bitfld.long 0 14. " sig_gd_p1_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p1_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p1_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p1_ch "  " "
bitfld.long 0 21. " sig_gd_p1_freq_lock "  "0 ,1 "
tree.end

base sd:0x8012b988
tree "gd0_port2_con_sav_reg1"
group 0--3
line.long 0 "gd0_port2_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p2_seg_length "  " "
bitfld.long 0 5.--9. " sig_gd_p2_dat_len "  " "
bitfld.long 0 10.--13. " sig_gd_p2_protocol "  " "
bitfld.long 0 14. " sig_gd_p2_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p2_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p2_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p2_ch "  " "
bitfld.long 0 21. " sig_gd_p2_freq_lock "  "0 ,1 "
tree.end

base sd:0x8012b98c
tree "gd0_port3_con_sav_reg1"
group 0--3
line.long 0 "gd0_port3_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p3_seg_length "  " "
bitfld.long 0 5.--9. " sig_gd_p3_dat_len "  " "
bitfld.long 0 10.--13. " sig_gd_p3_protocol "  " "
bitfld.long 0 14. " sig_gd_p3_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p3_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p3_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p3_ch "  " "
bitfld.long 0 21. " sig_gd_p3_freq_lock "  "0 ,1 "
tree.end

base sd:0x8012b990
tree "gd0_port4_con_sav_reg1"
group 0--3
line.long 0 "gd0_port4_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p4_seg_length "  " "
bitfld.long 0 5.--9. " sig_gd_p4_dat_len "  " "
bitfld.long 0 10.--13. " sig_gd_p4_protocol "  " "
bitfld.long 0 14. " sig_gd_p4_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p4_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p4_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p4_ch "  " "
bitfld.long 0 21. " sig_gd_p4_freq_lock "  "0 ,1 "
tree.end

base sd:0x8012b994
tree "gd0_port5_con_sav_reg1"
group 0--3
line.long 0 "gd0_port5_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p5_seg_length "  " "
bitfld.long 0 5.--9. " sig_gd_p5_dat_len "  " "
bitfld.long 0 10.--13. " sig_gd_p5_protocol "  " "
bitfld.long 0 14. " sig_gd_p5_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p5_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p5_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p5_ch "  " "
bitfld.long 0 21. " sig_gd_p5_freq_lock "  "0 ,1 "
tree.end

base sd:0x8012b998
tree "gd0_port6_con_sav_reg1"
group 0--3
line.long 0 "gd0_port6_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p6_seg_length "  " "
bitfld.long 0 5.--9. " sig_gd_p6_dat_len "  " "
bitfld.long 0 10.--13. " sig_gd_p6_protocol "  " "
bitfld.long 0 14. " sig_gd_p6_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p6_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p6_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p6_ch "  " "
bitfld.long 0 21. " sig_gd_p6_freq_lock "  "0 ,1 "
tree.end

base sd:0x8012b99c
tree "gd0_port7_con_sav_reg1"
group 0--3
line.long 0 "gd0_port7_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p7_seg_length "  " "
bitfld.long 0 5.--9. " sig_gd_p7_dat_len "  " "
bitfld.long 0 10.--13. " sig_gd_p7_protocol "  " "
bitfld.long 0 14. " sig_gd_p7_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p7_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p7_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p7_ch "  " "
bitfld.long 0 21. " sig_gd_p7_freq_lock "  "0 ,1 "
tree.end

base sd:0x8012b9a0
tree "gd0_port8_con_sav_reg1"
group 0--3
line.long 0 "gd0_port8_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p8_seg_length "  " "
bitfld.long 0 5.--9. " sig_gd_p8_dat_len "  " "
bitfld.long 0 10.--13. " sig_gd_p8_protocol "  " "
bitfld.long 0 14. " sig_gd_p8_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p8_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p8_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p8_ch "  " "
bitfld.long 0 21. " sig_gd_p8_freq_lock "  "0 ,1 "
tree.end

base sd:0x8012b9a4
tree "gd0_port9_con_sav_reg1"
group 0--3
line.long 0 "gd0_port9_con_sav_reg1"
bitfld.long 0 0.--4. " sig_gd_p9_seg_length "  " "
bitfld.long 0 5.--9. " sig_gd_p9_dat_len "  " "
bitfld.long 0 10.--13. " sig_gd_p9_protocol "  " "
bitfld.long 0 14. " sig_gd_p9_src "  "0 ,1 "
bitfld.long 0 15. " sig_gd_p9_src_sink "  "0 ,1 "
bitfld.long 0 16. " sig_gd_p9_rec_bound "  "0 ,1 "
bitfld.long 0 17.--20. " sig_gd_p9_ch "  " "
bitfld.long 0 21. " sig_gd_p9_freq_lock "  "0 ,1 "
tree.end

base sd:0x8012ba00
tree "ch_con_sav_reg1"
group 0--3
line.long 0 "ch_con_sav_reg1"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch1 "  " "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch1 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch1 "  " "
tree.end

base sd:0x8012ba04
tree "GD0_P0_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P0_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p0 "  " "
tree.end

base sd:0x8012ba08
tree "ch_con_sav_reg2"
group 0--3
line.long 0 "ch_con_sav_reg2"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch2 "  " "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch2 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch2 "  " "
tree.end

base sd:0x8012ba0c
tree "GD0_P1_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P1_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p1 "  " "
tree.end

base sd:0x8012ba10
tree "ch_con_sav_reg3"
group 0--3
line.long 0 "ch_con_sav_reg3"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch3 "  " "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch3 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch3 "  " "
tree.end

base sd:0x8012ba14
tree "GD0_P2_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P2_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p2 "  " "
tree.end

base sd:0x8012ba18
tree "ch_con_sav_reg4"
group 0--3
line.long 0 "ch_con_sav_reg4"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch4 "  " "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch4 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch4 "  " "
tree.end

base sd:0x8012ba1c
tree "GD0_P3_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P3_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p3 "  " "
tree.end

base sd:0x8012ba20
tree "ch_con_sav_reg5"
group 0--3
line.long 0 "ch_con_sav_reg5"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch5 "  " "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch5 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch5 "  " "
tree.end

base sd:0x8012ba24
tree "GD0_P4_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P4_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p4 "  " "
tree.end

base sd:0x8012ba28
tree "ch_con_sav_reg6"
group 0--3
line.long 0 "ch_con_sav_reg6"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch6 "  " "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch6 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch6 "  " "
tree.end

base sd:0x8012ba2c
tree "GD0_P5_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P5_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p5 "  " "
tree.end

base sd:0x8012ba30
tree "ch_con_sav_reg7"
group 0--3
line.long 0 "ch_con_sav_reg7"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch7 "  " "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch7 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch7 "  " "
tree.end

base sd:0x8012ba34
tree "GD0_P6_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P6_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p6 "  " "
tree.end

base sd:0x8012ba38
tree "ch_con_sav_reg8"
group 0--3
line.long 0 "ch_con_sav_reg8"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch8 "  " "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch8 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch8 "  " "
tree.end

base sd:0x8012ba3c
tree "GD0_P7_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P7_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p7 "  " "
tree.end

base sd:0x8012ba40
tree "ch_con_sav_reg9"
group 0--3
line.long 0 "ch_con_sav_reg9"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch9 "  " "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch9 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch9 "  " "
tree.end

base sd:0x8012ba44
tree "GD0_P8_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P8_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p8 "  " "
tree.end

base sd:0x8012ba48
tree "ch_con_sav_reg10"
group 0--3
line.long 0 "ch_con_sav_reg10"
bitfld.long 0 0.--4. " sig_slim_x_fl_seg_len_ch10 "  " "
bitfld.long 0 5.--15. " sig_slim_x_fl_seg_off_ch10 "  " "
bitfld.long 0 16.--26. " sig_slim_x_fl_seg_int_ch10 "  " "
tree.end

base sd:0x8012ba4c
tree "GD0_P9_CON_SAVE_REG2"
group 0--3
line.long 0 "GD0_P9_CON_SAVE_REG2"
bitfld.long 0 0.--6. " sig_gd_presence_rate_d0_p9 "  " "
tree.end

tree.end

;==============================================================
;tree "SPI (4 instances)"
;==============================================================
base sd:0x80129000
;********************************************
tree "SPI-3"
;********************************************
base sd:0x80129000
tree "3CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  " "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
bitfld.long 0 8.--15. " SCR "  " "
tree.end

base sd:0x80129004
tree "3CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  " "
bitfld.long 0 10.--12. " TXIFLSEL "  " "
tree.end

base sd:0x80129008
tree "3DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x8012900c
tree "3SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
tree.end

base sd:0x80129010
tree "3CPSR"
group 0--3
line.long 0 "CPSR"
bitfld.long 0 0.--7. " CPSDVSR "  " "
tree.end

base sd:0x80129014
tree "3IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
tree.end

base sd:0x80129018
tree "3RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
tree.end

base sd:0x8012901c
tree "3MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
tree.end

base sd:0x80129020
tree "3ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
tree.end

base sd:0x80129024
tree "3DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
tree.end

base sd:0x80129fe0
tree "3PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80129fe4
tree "3PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80129fe8
tree "3PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80129fec
tree "3PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80129ff0
tree "3PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " SPIPCellID0 "  " "
tree.end

base sd:0x80129ff4
tree "3PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " SPIPCellID1 "  " "
tree.end

base sd:0x80129ff8
tree "3PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " SPIPCellID2 "  " "
tree.end

base sd:0x80129ffc
tree "3PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " SPIPCellID3 "  " "
tree.end

tree.end

base sd:0x80111000
;********************************************
tree "SPI-2"
;********************************************
base sd:0x80111000
tree "2CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  " "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
bitfld.long 0 8.--15. " SCR "  " "
tree.end

base sd:0x80111004
tree "2CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  " "
bitfld.long 0 10.--12. " TXIFLSEL "  " "
tree.end

base sd:0x80111008
tree "2DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x8011100c
tree "2SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
tree.end

base sd:0x80111010
tree "2CPSR"
group 0--3
line.long 0 "CPSR"
bitfld.long 0 0.--7. " CPSDVSR "  " "
tree.end

base sd:0x80111014
tree "2IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
tree.end

base sd:0x80111018
tree "2RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
tree.end

base sd:0x8011101c
tree "2MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
tree.end

base sd:0x80111020
tree "2ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
tree.end

base sd:0x80111024
tree "2DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
tree.end

base sd:0x80111fe0
tree "2PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80111fe4
tree "2PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80111fe8
tree "2PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80111fec
tree "2PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80111ff0
tree "2PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " SPIPCellID0 "  " "
tree.end

base sd:0x80111ff4
tree "2PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " SPIPCellID1 "  " "
tree.end

base sd:0x80111ff8
tree "2PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " SPIPCellID2 "  " "
tree.end

base sd:0x80111ffc
tree "2PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " SPIPCellID3 "  " "
tree.end

tree.end

base sd:0x80112000
;********************************************
tree "SPI-1"
;********************************************
base sd:0x80112000
tree "1CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  " "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
bitfld.long 0 8.--15. " SCR "  " "
tree.end

base sd:0x80112004
tree "1CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  " "
bitfld.long 0 10.--12. " TXIFLSEL "  " "
tree.end

base sd:0x80112008
tree "1DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x8011200c
tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
tree.end

base sd:0x80112010
tree "1CPSR"
group 0--3
line.long 0 "CPSR"
bitfld.long 0 0.--7. " CPSDVSR "  " "
tree.end

base sd:0x80112014
tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
tree.end

base sd:0x80112018
tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
tree.end

base sd:0x8011201c
tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
tree.end

base sd:0x80112020
tree "1ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
tree.end

base sd:0x80112024
tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
tree.end

base sd:0x80112fe0
tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80112fe4
tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80112fe8
tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80112fec
tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80112ff0
tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " SPIPCellID0 "  " "
tree.end

base sd:0x80112ff4
tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " SPIPCellID1 "  " "
tree.end

base sd:0x80112ff8
tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " SPIPCellID2 "  " "
tree.end

base sd:0x80112ffc
tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " SPIPCellID3 "  " "
tree.end

tree.end

base sd:0x8011a000
;********************************************
tree "SPI-0"
;********************************************
base sd:0x8011a000
tree "0CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  " "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
bitfld.long 0 8.--15. " SCR "  " "
tree.end

base sd:0x8011a004
tree "0CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  " "
bitfld.long 0 10.--12. " TXIFLSEL "  " "
tree.end

base sd:0x8011a008
tree "0DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x8011a00c
tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
tree.end

base sd:0x8011a010
tree "0CPSR"
group 0--3
line.long 0 "CPSR"
bitfld.long 0 0.--7. " CPSDVSR "  " "
tree.end

base sd:0x8011a014
tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
tree.end

base sd:0x8011a018
tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
tree.end

base sd:0x8011a01c
tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
tree.end

base sd:0x8011a020
tree "0ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
tree.end

base sd:0x8011a024
tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
tree.end

base sd:0x8011afe0
tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x8011afe4
tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x8011afe8
tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x8011afec
tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x8011aff0
tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " SPIPCellID0 "  " "
tree.end

base sd:0x8011aff4
tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " SPIPCellID1 "  " "
tree.end

base sd:0x8011aff8
tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " SPIPCellID2 "  " "
tree.end

base sd:0x8011affc
tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " SPIPCellID3 "  " "
tree.end

;tree.end

tree.end

;==============================================================
;tree "SSP (2 instances)"
;==============================================================
base sd:0x80002000
;********************************************
tree "SSP-0"
;********************************************
base sd:0x80002000
tree "0CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  " "
bitfld.long 0 5. " HALFDUP "  "0 ,1 "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
bitfld.long 0 8.--15. " SCR "  " "
bitfld.long 0 16.--20. " CSS "  " "
bitfld.long 0 21.--22. " FRF "  " "
tree.end

base sd:0x80002004
tree "0CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " LBM "  "0 ,1 "
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 6. " MWAIT "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  " "
bitfld.long 0 10.--12. " TXIFLSEL "  " "
tree.end

base sd:0x80002008
tree "0DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x8000200c
tree "0SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
tree.end

base sd:0x80002010
tree "0CPSR"
group 0--3
line.long 0 "CPSR"
bitfld.long 0 0.--7. " CPSDVSR "  " "
tree.end

base sd:0x80002014
tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
tree.end

base sd:0x80002018
tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
tree.end

base sd:0x8000201c
tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
tree.end

base sd:0x80002020
tree "0ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
tree.end

base sd:0x80002024
tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
tree.end

base sd:0x80002080
tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
tree.end

base sd:0x80002084
tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SSPRXD "  "0 ,1 "
bitfld.long 0 1. " SSPFSSIN "  "0 ,1 "
bitfld.long 0 2. " SSPCLKIN "  "0 ,1 "
bitfld.long 0 3. " RXDMAC "  "0 ,1 "
bitfld.long 0 4. " TXDMAC "  "0 ,1 "
bitfld.long 0 5. " SSPTXDIN "  "0 ,1 "
tree.end

base sd:0x80002088
tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " SSTXDOUT "  "0 ,1 "
bitfld.long 0 1. " SSPFSSOUT "  "0 ,1 "
bitfld.long 0 2. " SSPCLKOUT "  "0 ,1 "
bitfld.long 0 3. " SSPOEn "  "0 ,1 "
bitfld.long 0 4. " SSPCTLOEn "  "0 ,1 "
bitfld.long 0 5. " RORINTR "  "0 ,1 "
bitfld.long 0 6. " RINTR "  "0 ,1 "
bitfld.long 0 7. " RXINTR "  "0 ,1 "
bitfld.long 0 8. " TXINTR "  "0 ,1 "
bitfld.long 0 9. " INTR "  "0 ,1 "
bitfld.long 0 10. " RXDMABREQ "  "0 ,1 "
bitfld.long 0 11. " RXDMASREQ "  "0 ,1 "
bitfld.long 0 12. " TXDMABREQ "  "0 ,1 "
bitfld.long 0 13. " TXDMASREQ "  "0 ,1 "
tree.end

base sd:0x8000208c
tree "0TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--31. " TestDATA "  " "
tree.end

base sd:0x80002fe0
tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80002fe4
tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80002fe8
tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80002fec
tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80002ff0
tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " SSPPCellID0 "  " "
tree.end

base sd:0x80002ff4
tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " SSPPCellID1 "  " "
tree.end

base sd:0x80002ff8
tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " SSPPCellID2 "  " "
tree.end

base sd:0x80002ffc
tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " SSPPCellID3 "  " "
tree.end

tree.end

base sd:0x80003000
;********************************************
tree "SSP-1"
;********************************************
base sd:0x80003000
tree "1CR0"
group 0--3
line.long 0 "CR0"
bitfld.long 0 0.--4. " DSS "  " "
bitfld.long 0 5. " HALFDUP "  "0 ,1 "
bitfld.long 0 6. " SPO "  "0 ,1 "
bitfld.long 0 7. " SPH "  "0 ,1 "
bitfld.long 0 8.--15. " SCR "  " "
bitfld.long 0 16.--20. " CSS "  " "
bitfld.long 0 21.--22. " FRF "  " "
tree.end

base sd:0x80003004
tree "1CR1"
group 0--3
line.long 0 "CR1"
bitfld.long 0 0. " LBM "  "0 ,1 "
bitfld.long 0 1. " SSE "  "0 ,1 "
bitfld.long 0 2. " MS "  "0 ,1 "
bitfld.long 0 3. " SOD "  "0 ,1 "
bitfld.long 0 4. " RENDN "  "0 ,1 "
bitfld.long 0 5. " TENDN "  "0 ,1 "
bitfld.long 0 6. " MWAIT "  "0 ,1 "
bitfld.long 0 7.--9. " RXIFLSEL "  " "
bitfld.long 0 10.--12. " TXIFLSEL "  " "
tree.end

base sd:0x80003008
tree "1DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--31. " DATA "  " "
tree.end

base sd:0x8000300c
tree "1SR"
rgroup 0--3
line.long 0 "SR"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TNF "  "0 ,1 "
bitfld.long 0 2. " RNE "  "0 ,1 "
bitfld.long 0 3. " RFF "  "0 ,1 "
bitfld.long 0 4. " BSY "  "0 ,1 "
tree.end

base sd:0x80003010
tree "1CPSR"
group 0--3
line.long 0 "CPSR"
bitfld.long 0 0.--7. " CPSDVSR "  " "
tree.end

base sd:0x80003014
tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RORIM "  "0 ,1 "
bitfld.long 0 1. " RTIM "  "0 ,1 "
bitfld.long 0 2. " RXIM "  "0 ,1 "
bitfld.long 0 3. " TXIM "  "0 ,1 "
tree.end

base sd:0x80003018
tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RORRIS "  "0 ,1 "
bitfld.long 0 1. " RTRIS "  "0 ,1 "
bitfld.long 0 2. " RXRIS "  "0 ,1 "
bitfld.long 0 3. " TXRIS "  "0 ,1 "
tree.end

base sd:0x8000301c
tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RORMIS "  "0 ,1 "
bitfld.long 0 1. " RTMIS "  "0 ,1 "
bitfld.long 0 2. " RXMIS "  "0 ,1 "
bitfld.long 0 3. " TXMIS "  "0 ,1 "
tree.end

base sd:0x80003020
tree "1ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RORIC "  "0 ,1 "
bitfld.long 0 1. " RTIC "  "0 ,1 "
tree.end

base sd:0x80003024
tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
tree.end

base sd:0x80003080
tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
bitfld.long 0 1. " TESTFIFO "  "0 ,1 "
tree.end

base sd:0x80003084
tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " SSPRXD "  "0 ,1 "
bitfld.long 0 1. " SSPFSSIN "  "0 ,1 "
bitfld.long 0 2. " SSPCLKIN "  "0 ,1 "
bitfld.long 0 3. " RXDMAC "  "0 ,1 "
bitfld.long 0 4. " TXDMAC "  "0 ,1 "
bitfld.long 0 5. " SSPTXDIN "  "0 ,1 "
tree.end

base sd:0x80003088
tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " SSTXDOUT "  "0 ,1 "
bitfld.long 0 1. " SSPFSSOUT "  "0 ,1 "
bitfld.long 0 2. " SSPCLKOUT "  "0 ,1 "
bitfld.long 0 3. " SSPOEn "  "0 ,1 "
bitfld.long 0 4. " SSPCTLOEn "  "0 ,1 "
bitfld.long 0 5. " RORINTR "  "0 ,1 "
bitfld.long 0 6. " RINTR "  "0 ,1 "
bitfld.long 0 7. " RXINTR "  "0 ,1 "
bitfld.long 0 8. " TXINTR "  "0 ,1 "
bitfld.long 0 9. " INTR "  "0 ,1 "
bitfld.long 0 10. " RXDMABREQ "  "0 ,1 "
bitfld.long 0 11. " RXDMASREQ "  "0 ,1 "
bitfld.long 0 12. " TXDMABREQ "  "0 ,1 "
bitfld.long 0 13. " TXDMASREQ "  "0 ,1 "
tree.end

base sd:0x8000308c
tree "1TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--31. " TestDATA "  " "
tree.end

base sd:0x80003fe0
tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " Partnumber0 "  " "
tree.end

base sd:0x80003fe4
tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " Partnumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80003fe8
tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80003fec
tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80003ff0
tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " SSPPCellID0 "  " "
tree.end

base sd:0x80003ff4
tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " SSPPCellID1 "  " "
tree.end

base sd:0x80003ff8
tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " SSPPCellID2 "  " "
tree.end

base sd:0x80003ffc
tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " SSPPCellID3 "  " "
tree.end

;tree.end

tree.end

;==============================================================
tree "STM"
;==============================================================
base sd:0x8010f000
tree "CR_L"
group 0--3
line.long 0 "CR_L"
bitfld.long 0 0. " PLP0 "  "0 ,1 "
bitfld.long 0 1. " PLP1 "  "0 ,1 "
bitfld.long 0 2. " PLP2 "  "0 ,1 "
bitfld.long 0 3. " TSnTS "  "0 ,1 "
bitfld.long 0 4.--5. " DWNG "  " "
bitfld.long 0 6.--8. " XCKDIV "  " "
bitfld.long 0 9. " SWAP_PRCMU "  "0 ,1 "
tree.end

base sd:0x8010f004
tree "CR_H"
group 0--3
line.long 0 "CR_H"
tree.end

base sd:0x8010f008
tree "MMCR_L"
group 0--3
line.long 0 "MMCR_L"
bitfld.long 0 0. " HWnSW0 "  "0 ,1 "
bitfld.long 0 1. " HWnSW1 "  "0 ,1 "
bitfld.long 0 2. " HWnSW2 "  "0 ,1 "
bitfld.long 0 3. " HWnSW3 "  "0 ,1 "
bitfld.long 0 4. " HWnSW4 "  "0 ,1 "
bitfld.long 0 5. " HWnSW5 "  "0 ,1 "
tree.end

base sd:0x8010f00c
tree "MMCR_H"
group 0--3
line.long 0 "MMCR_H"
tree.end

base sd:0x8010f010
tree "TER_L"
group 0--3
line.long 0 "TER_L"
bitfld.long 0 0. " TE0 "  "0 ,1 "
bitfld.long 0 2. " TE2 "  "0 ,1 "
bitfld.long 0 3. " TE3 "  "0 ,1 "
bitfld.long 0 4. " TE4 "  "0 ,1 "
bitfld.long 0 5. " TE5 "  "0 ,1 "
bitfld.long 0 9. " TE9 "  "0 ,1 "
tree.end

base sd:0x8010f014
tree "TER_H"
group 0--3
line.long 0 "TER_H"
tree.end

base sd:0x8010f018
tree "TDSR_L"
rgroup 0--3
line.long 0 "TDSR_L"
bitfld.long 0 0. " TDis0 "  "0 ,1 "
bitfld.long 0 1. " TDis1 "  "0 ,1 "
bitfld.long 0 2. " TDis2 "  "0 ,1 "
bitfld.long 0 3. " TDis3 "  "0 ,1 "
bitfld.long 0 4. " TDis4 "  "0 ,1 "
bitfld.long 0 5. " TDis5 "  "0 ,1 "
bitfld.long 0 9. " TDis9 "  "0 ,1 "
tree.end

base sd:0x8010f01c
tree "TDSR_H"
rgroup 0--3
line.long 0 "TDSR_H"
tree.end

base sd:0x8010f020
tree "OFSR_L"
rgroup 0--3
line.long 0 "OFSR_L"
bitfld.long 0 0. " ovF0 "  "0 ,1 "
bitfld.long 0 1. " ovF1 "  "0 ,1 "
bitfld.long 0 2. " ovF2 "  "0 ,1 "
bitfld.long 0 3. " ovF3 "  "0 ,1 "
bitfld.long 0 4. " ovF4 "  "0 ,1 "
bitfld.long 0 5. " ovF5 "  "0 ,1 "
bitfld.long 0 9. " ovF9 "  "0 ,1 "
bitfld.long 0 10. " SecTrej "  "0 ,1 "
bitfld.long 0 11. " DecErr "  "0 ,1 "
bitfld.long 0 12.--16. " AddrErr "  " "
tree.end

base sd:0x8010f024
tree "OFSR_H"
rgroup 0--3
line.long 0 "OFSR_H"
tree.end

base sd:0x8010f028
tree "TFSR_L"
rgroup 0--3
line.long 0 "TFSR_L"
bitfld.long 0 0. " TFE "  "0 ,1 "
bitfld.long 0 1. " TFF "  "0 ,1 "
bitfld.long 0 2. " PRCME "  "0 ,1 "
bitfld.long 0 3. " PRCMF "  "0 ,1 "
bitfld.long 0 4. " CHGCFG "  "0 ,1 "
tree.end

base sd:0x8010f02c
tree "TFSR_H"
rgroup 0--3
line.long 0 "TFSR_H"
tree.end

base sd:0x8010f030
tree "SBSR_L"
rgroup 0--3
line.long 0 "SBSR_L"
bitfld.long 0 0. " SBFE "  "0 ,1 "
bitfld.long 0 1. " SBFF "  "0 ,1 "
bitfld.long 0 2. " SBOv "  "0 ,1 "
bitfld.long 0 3.--7. " SBOvNb "  " "
tree.end

base sd:0x8010f034
tree "SBSR_H"
rgroup 0--3
line.long 0 "SBSR_H"
tree.end

base sd:0x8010f050
tree "TSR_L"
rgroup 0--3
line.long 0 "TSR_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " Stamp "  "0 ,1 "
bitfld.long 0 2. " Time "  "0 ,1 "
tree.end

base sd:0x8010f054
tree "TSR_H"
rgroup 0--3
line.long 0 "TSR_H"
tree.end

base sd:0x8010f058
tree "SCCR_L"
group 0--3
line.long 0 "SCCR_L"
bitfld.long 0 0.--31. " SCC "  " "
tree.end

base sd:0x8010f05c
tree "SCCR_H"
group 0--3
line.long 0 "SCCR_H"
tree.end

base sd:0x8010f038
tree "DBG_L"
group 0--3
line.long 0 "DBG_L"
bitfld.long 0 0. " DBGEn "  "0 ,1 "
bitfld.long 0 1. " DBGM "  "0 ,1 "
bitfld.long 0 3.--5. " PTICSSel "  " "
bitfld.long 0 6.--10. " FTFSel "  " "
bitfld.long 0 12. " FSBFF "  "0 ,1 "
bitfld.long 0 16.--24. " PTI_State "  " "
tree.end

base sd:0x8010f03c
tree "DBG_H"
group 0--3
line.long 0 "DBG_H"
tree.end

base sd:0x8010ffc0
tree "PeriphlD0_L"
rgroup 0--3
line.long 0 "PeriphlD0_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " PartNumber0 "  "0 ,1 "
tree.end

base sd:0x8010ffc4
tree "PeriphlD0_H"
rgroup 0--3
line.long 0 "PeriphlD0_H"
tree.end

base sd:0x8010ffc8
tree "PeriphlD1_L"
rgroup 0--3
line.long 0 "PeriphlD1_L"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x8010ffcc
tree "PeriphlD1_H"
rgroup 0--3
line.long 0 "PeriphlD1_H"
tree.end

base sd:0x8010ffd0
tree "PeriphlD2_L"
rgroup 0--3
line.long 0 "PeriphlD2_L"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x8010ffd4
tree "PeriphlD2_H"
rgroup 0--3
line.long 0 "PeriphlD2_H"
tree.end

base sd:0x8010ffd8
tree "PeriphlD3_L"
rgroup 0--3
line.long 0 "PeriphlD3_L"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x8010ffdc
tree "PeriphD3_H"
rgroup 0--3
line.long 0 "PeriphD3_H"
tree.end

base sd:0x8010ffe0
tree "PCelllD0_L"
rgroup 0--3
line.long 0 "PCelllD0_L"
bitfld.long 0 0.--7. " STMPCelllD0 "  " "
tree.end

base sd:0x8010ffe4
tree "PCelllD0_H"
rgroup 0--3
line.long 0 "PCelllD0_H"
tree.end

base sd:0x8010ffe8
tree "PCelllD1_L"
rgroup 0--3
line.long 0 "PCelllD1_L"
bitfld.long 0 0.--7. " STMPCelllD1 "  " "
tree.end

base sd:0x8010ffec
tree "PCelllD1_H"
rgroup 0--3
line.long 0 "PCelllD1_H"
tree.end

base sd:0x8010fff0
tree "PCelllD2_L"
rgroup 0--3
line.long 0 "PCelllD2_L"
bitfld.long 0 0.--7. " STMPCelllD2 "  " "
tree.end

base sd:0x8010fff4
tree "PCelllD2_H"
rgroup 0--3
line.long 0 "PCelllD2_H"
tree.end

base sd:0x8010fff8
tree "PCelllD3_L"
rgroup 0--3
line.long 0 "PCelllD3_L"
bitfld.long 0 0. " 8 "  "0 ,1 "
bitfld.long 0 1. " STMPCelllD3 "  "0 ,1 "
tree.end

base sd:0x8010fffc
tree "PCelllD3_H"
rgroup 0--3
line.long 0 "PCelllD3_H"
tree.end

tree.end

;==============================================================
;tree "TIMER (2 instances)"
;==============================================================
base sd:0xa03c6000
;********************************************
tree "TIMER-0"
;********************************************
base sd:0xa03c6000
tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " T0IM "  "0 ,1 "
bitfld.long 0 1. " T1IM "  "0 ,1 "
bitfld.long 0 2. " T2IM "  "0 ,1 "
bitfld.long 0 3. " T3IM "  "0 ,1 "
tree.end

base sd:0xa03c6004
tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " T0RIS "  "0 ,1 "
bitfld.long 0 1. " T1RIS "  "0 ,1 "
bitfld.long 0 2. " T2RIS "  "0 ,1 "
bitfld.long 0 3. " T3RIS "  "0 ,1 "
tree.end

base sd:0xa03c6008
tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " T0MIS "  "0 ,1 "
bitfld.long 0 1. " T1MIS "  "0 ,1 "
bitfld.long 0 2. " T2MIS "  "0 ,1 "
bitfld.long 0 3. " T3MIS "  "0 ,1 "
tree.end

base sd:0xa03c600c
tree "0ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " T0IC "  "0 ,1 "
bitfld.long 0 1. " T1IC "  "0 ,1 "
bitfld.long 0 2. " T2IC "  "0 ,1 "
bitfld.long 0 3. " T3IC "  "0 ,1 "
tree.end

base sd:0xa03c6010
tree "0T0LR"
group 0--3
line.long 0 "T0LR"
bitfld.long 0 0.--31. " T0LOAD "  " "
tree.end

base sd:0xa03c6014
tree "0T0VAL"
rgroup 0--3
line.long 0 "T0VAL"
tree.end

base sd:0xa03c6018
tree "0T0CR"
group 0--3
line.long 0 "T0CR"
bitfld.long 0 0. " T0OS "  "0 ,1 "
bitfld.long 0 1. " T0SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T0PRE "  " "
bitfld.long 0 6. " T0MOD "  "0 ,1 "
bitfld.long 0 7. " T0En "  "0 ,1 "
tree.end

base sd:0xa03c601c
tree "0T0BGLR"
group 0--3
line.long 0 "T0BGLR"
bitfld.long 0 0. " T0BGLOAD "  "0 ,1 "
tree.end

base sd:0xa03c6020
tree "0T1LR"
group 0--3
line.long 0 "T1LR"
bitfld.long 0 0.--31. " T1LOAD "  " "
tree.end

base sd:0xa03c6024
tree "0T1VAL"
rgroup 0--3
line.long 0 "T1VAL"
tree.end

base sd:0xa03c6028
tree "0T1CR"
group 0--3
line.long 0 "T1CR"
bitfld.long 0 0. " T1OS "  "0 ,1 "
bitfld.long 0 1. " T1SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T1PRE "  " "
bitfld.long 0 6. " T1MOD "  "0 ,1 "
bitfld.long 0 7. " T1En "  "0 ,1 "
tree.end

base sd:0xa03c602c
tree "0T1BGLR"
group 0--3
line.long 0 "T1BGLR"
bitfld.long 0 0. " T1BGLOAD "  "0 ,1 "
tree.end

base sd:0xa03c6030
tree "0T2LR"
group 0--3
line.long 0 "T2LR"
bitfld.long 0 0.--31. " T2LOAD "  " "
tree.end

base sd:0xa03c6034
tree "0T2VAL"
rgroup 0--3
line.long 0 "T2VAL"
tree.end

base sd:0xa03c6038
tree "0T2CR"
group 0--3
line.long 0 "T2CR"
bitfld.long 0 0. " T2OS "  "0 ,1 "
bitfld.long 0 1. " T2SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T2PRE "  " "
bitfld.long 0 6. " T2MOD "  "0 ,1 "
bitfld.long 0 7. " T2En "  "0 ,1 "
tree.end

base sd:0xa03c603c
tree "0T2BGLR"
group 0--3
line.long 0 "T2BGLR"
bitfld.long 0 0. " T2BGLOAD "  "0 ,1 "
tree.end

base sd:0xa03c6040
tree "0T3LR"
group 0--3
line.long 0 "T3LR"
bitfld.long 0 0.--31. " T3LOAD "  " "
tree.end

base sd:0xa03c6044
tree "0T3VAL"
rgroup 0--3
line.long 0 "T3VAL"
tree.end

base sd:0xa03c6048
tree "0T3CR"
group 0--3
line.long 0 "T3CR"
bitfld.long 0 0. " T3OS "  "0 ,1 "
bitfld.long 0 1. " T3SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T3PRE "  " "
bitfld.long 0 6. " T3MOD "  "0 ,1 "
bitfld.long 0 7. " T3En "  "0 ,1 "
tree.end

base sd:0xa03c604c
tree "0T3BGLR"
group 0--3
line.long 0 "T3BGLR"
bitfld.long 0 0. " T3BGLOAD "  "0 ,1 "
tree.end

base sd:0xa03c6f00
tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITME "  "0 ,1 "
tree.end

base sd:0xa03c6f04
tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " INTCT0 "  "0 ,1 "
bitfld.long 0 1. " INTCT1 "  "0 ,1 "
bitfld.long 0 2. " INTCT2 "  "0 ,1 "
bitfld.long 0 3. " INTCT3 "  "0 ,1 "
tree.end

base sd:0xa03c6fe0
tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0xa03c6fe4
tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0xa03c6fe8
tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0xa03c6fec
tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0xa03c6ff0
tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " MTUPCellID0 "  " "
tree.end

base sd:0xa03c6ff4
tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " MTUPCellID1 "  " "
tree.end

base sd:0xa03c6ff8
tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " MTUPCellID2 "  " "
tree.end

base sd:0xa03c6ffc
tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " MTUPCellID3 "  " "
tree.end

tree.end

base sd:0xa03c7000
;********************************************
tree "TIMER-1"
;********************************************
base sd:0xa03c7000
tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " T0IM "  "0 ,1 "
bitfld.long 0 1. " T1IM "  "0 ,1 "
bitfld.long 0 2. " T2IM "  "0 ,1 "
bitfld.long 0 3. " T3IM "  "0 ,1 "
tree.end

base sd:0xa03c7004
tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " T0RIS "  "0 ,1 "
bitfld.long 0 1. " T1RIS "  "0 ,1 "
bitfld.long 0 2. " T2RIS "  "0 ,1 "
bitfld.long 0 3. " T3RIS "  "0 ,1 "
tree.end

base sd:0xa03c7008
tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " T0MIS "  "0 ,1 "
bitfld.long 0 1. " T1MIS "  "0 ,1 "
bitfld.long 0 2. " T2MIS "  "0 ,1 "
bitfld.long 0 3. " T3MIS "  "0 ,1 "
tree.end

base sd:0xa03c700c
tree "1ICR"
wgroup 0--3
line.long 0 "ICR"
bitfld.long 0 0. " T0IC "  "0 ,1 "
bitfld.long 0 1. " T1IC "  "0 ,1 "
bitfld.long 0 2. " T2IC "  "0 ,1 "
bitfld.long 0 3. " T3IC "  "0 ,1 "
tree.end

base sd:0xa03c7010
tree "1T0LR"
group 0--3
line.long 0 "T0LR"
bitfld.long 0 0.--31. " T0LOAD "  " "
tree.end

base sd:0xa03c7014
tree "1T0VAL"
rgroup 0--3
line.long 0 "T0VAL"
tree.end

base sd:0xa03c7018
tree "1T0CR"
group 0--3
line.long 0 "T0CR"
bitfld.long 0 0. " T0OS "  "0 ,1 "
bitfld.long 0 1. " T0SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T0PRE "  " "
bitfld.long 0 6. " T0MOD "  "0 ,1 "
bitfld.long 0 7. " T0En "  "0 ,1 "
tree.end

base sd:0xa03c701c
tree "1T0BGLR"
group 0--3
line.long 0 "T0BGLR"
bitfld.long 0 0. " T0BGLOAD "  "0 ,1 "
tree.end

base sd:0xa03c7020
tree "1T1LR"
group 0--3
line.long 0 "T1LR"
bitfld.long 0 0.--31. " T1LOAD "  " "
tree.end

base sd:0xa03c7024
tree "1T1VAL"
rgroup 0--3
line.long 0 "T1VAL"
tree.end

base sd:0xa03c7028
tree "1T1CR"
group 0--3
line.long 0 "T1CR"
bitfld.long 0 0. " T1OS "  "0 ,1 "
bitfld.long 0 1. " T1SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T1PRE "  " "
bitfld.long 0 6. " T1MOD "  "0 ,1 "
bitfld.long 0 7. " T1En "  "0 ,1 "
tree.end

base sd:0xa03c702c
tree "1T1BGLR"
group 0--3
line.long 0 "T1BGLR"
bitfld.long 0 0. " T1BGLOAD "  "0 ,1 "
tree.end

base sd:0xa03c7030
tree "1T2LR"
group 0--3
line.long 0 "T2LR"
bitfld.long 0 0.--31. " T2LOAD "  " "
tree.end

base sd:0xa03c7034
tree "1T2VAL"
rgroup 0--3
line.long 0 "T2VAL"
tree.end

base sd:0xa03c7038
tree "1T2CR"
group 0--3
line.long 0 "T2CR"
bitfld.long 0 0. " T2OS "  "0 ,1 "
bitfld.long 0 1. " T2SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T2PRE "  " "
bitfld.long 0 6. " T2MOD "  "0 ,1 "
bitfld.long 0 7. " T2En "  "0 ,1 "
tree.end

base sd:0xa03c703c
tree "1T2BGLR"
group 0--3
line.long 0 "T2BGLR"
bitfld.long 0 0. " T2BGLOAD "  "0 ,1 "
tree.end

base sd:0xa03c7040
tree "1T3LR"
group 0--3
line.long 0 "T3LR"
bitfld.long 0 0.--31. " T3LOAD "  " "
tree.end

base sd:0xa03c7044
tree "1T3VAL"
rgroup 0--3
line.long 0 "T3VAL"
tree.end

base sd:0xa03c7048
tree "1T3CR"
group 0--3
line.long 0 "T3CR"
bitfld.long 0 0. " T3OS "  "0 ,1 "
bitfld.long 0 1. " T3SZ "  "0 ,1 "
bitfld.long 0 2.--3. " T3PRE "  " "
bitfld.long 0 6. " T3MOD "  "0 ,1 "
bitfld.long 0 7. " T3En "  "0 ,1 "
tree.end

base sd:0xa03c704c
tree "1T3BGLR"
group 0--3
line.long 0 "T3BGLR"
bitfld.long 0 0. " T3BGLOAD "  "0 ,1 "
tree.end

base sd:0xa03c7f00
tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITME "  "0 ,1 "
tree.end

base sd:0xa03c7f04
tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " INTCT0 "  "0 ,1 "
bitfld.long 0 1. " INTCT1 "  "0 ,1 "
bitfld.long 0 2. " INTCT2 "  "0 ,1 "
bitfld.long 0 3. " INTCT3 "  "0 ,1 "
tree.end

base sd:0xa03c7fe0
tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0xa03c7fe4
tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0xa03c7fe8
tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0xa03c7fec
tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0xa03c7ff0
tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " MTUPCellID0 "  " "
tree.end

base sd:0xa03c7ff4
tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " MTUPCellID1 "  " "
tree.end

base sd:0xa03c7ff8
tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " MTUPCellID2 "  " "
tree.end

base sd:0xa03c7ffc
tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " MTUPCellID3 "  " "
tree.end

;tree.end

tree.end

;==============================================================
tree "TPIU"
;==============================================================
base sd:0x80190000
tree "PortSize"
rgroup 0--3
line.long 0 "PortSize"
bitfld.long 0 0. " PortSize "  "0 ,1 "
tree.end

base sd:0x80190004
tree "CurrPortSize"
group 0--3
line.long 0 "CurrPortSize"
bitfld.long 0 0. " CurrPortSize "  "0 ,1 "
tree.end

base sd:0x80190100
tree "SuppTrigMod"
rgroup 0--3
line.long 0 "SuppTrigMod"
bitfld.long 0 0. " SuppTrigMod "  "0 ,1 "
tree.end

base sd:0x80190104
tree "TrigCountVal"
group 0--3
line.long 0 "TrigCountVal"
bitfld.long 0 0. " TrigCountVal "  "0 ,1 "
tree.end

base sd:0x80190108
tree "TrigMult"
group 0--3
line.long 0 "TrigMult"
bitfld.long 0 0. " TrigMult "  "0 ,1 "
tree.end

base sd:0x80190200
tree "SuppTest"
rgroup 0--3
line.long 0 "SuppTest"
bitfld.long 0 0. " SuppTest "  "0 ,1 "
tree.end

base sd:0x80190204
tree "CurrTest"
group 0--3
line.long 0 "CurrTest"
bitfld.long 0 0. " CurrTest "  "0 ,1 "
tree.end

base sd:0x80190208
tree "TestPatt"
group 0--3
line.long 0 "TestPatt"
bitfld.long 0 0. " TestPatt "  "0 ,1 "
tree.end

base sd:0x80190300
tree "FormatStat"
group 0--3
line.long 0 "FormatStat"
bitfld.long 0 0. " FormatStat "  "0 ,1 "
tree.end

base sd:0x80190304
tree "FormatCtrl"
group 0--3
line.long 0 "FormatCtrl"
bitfld.long 0 0. " FormatCtrl "  "0 ,1 "
tree.end

base sd:0x80190308
tree "FormatSync"
group 0--3
line.long 0 "FormatSync"
bitfld.long 0 0. " FormatSync "  "0 ,1 "
tree.end

base sd:0x80190400
tree "EXTCTLIN"
group 0--3
line.long 0 "EXTCTLIN"
bitfld.long 0 0. " EXTCTLIN "  "0 ,1 "
tree.end

base sd:0x80190404
tree "EXTCTLOUT"
group 0--3
line.long 0 "EXTCTLOUT"
bitfld.long 0 0. " EXTCTLOUT "  "0 ,1 "
tree.end

base sd:0x80190ee4
tree "ITTRFLINACK"
wgroup 0--3
line.long 0 "ITTRFLINACK"
bitfld.long 0 0. " ITTRFLINACK "  "0 ,1 "
tree.end

base sd:0x80190ee8
tree "ITTRFLIN"
group 0--3
line.long 0 "ITTRFLIN"
bitfld.long 0 0. " ITTRFLIN "  "0 ,1 "
tree.end

base sd:0x80190eec
tree "ITATBDATA0"
group 0--3
line.long 0 "ITATBDATA0"
bitfld.long 0 0. " ITATBDATA0 "  "0 ,1 "
tree.end

base sd:0x80190ef0
tree "ITATBCTR2"
wgroup 0--3
line.long 0 "ITATBCTR2"
bitfld.long 0 0. " ITATBCTR2 "  "0 ,1 "
tree.end

base sd:0x80190ef4
tree "ITATBCTR1"
group 0--3
line.long 0 "ITATBCTR1"
bitfld.long 0 0. " ITATBCTR1 "  "0 ,1 "
tree.end

base sd:0x80190ef8
tree "ITATBCTR0"
group 0--3
line.long 0 "ITATBCTR0"
bitfld.long 0 0. " ITATBCTR0 "  "0 ,1 "
tree.end

base sd:0x80190f00
tree "IntModCTRLReg"
group 0--3
line.long 0 "IntModCTRLReg"
bitfld.long 0 0. " IntModCTRLReg "  "0 ,1 "
tree.end

base sd:0x80190fa0
tree "CTS"
group 0--3
line.long 0 "CTS"
bitfld.long 0 0. " CTS "  "0 ,1 "
tree.end

base sd:0x80190fa4
tree "CTC"
group 0--3
line.long 0 "CTC"
bitfld.long 0 0. " CTC "  "0 ,1 "
tree.end

base sd:0x80190fb0
tree "LockA"
wgroup 0--3
line.long 0 "LockA"
bitfld.long 0 0. " LockA "  "0 ,1 "
tree.end

base sd:0x80190fb4
tree "Lock"
rgroup 0--3
line.long 0 "Lock"
bitfld.long 0 0. " Lock "  "0 ,1 "
tree.end

base sd:0x80190fb8
tree "Aut"
rgroup 0--3
line.long 0 "Aut"
bitfld.long 0 0. " Aut "  "0 ,1 "
tree.end

base sd:0x80190fc8
tree "DevID"
rgroup 0--3
line.long 0 "DevID"
bitfld.long 0 0. " DevID "  "0 ,1 "
tree.end

base sd:0x80190fcc
tree "Dev"
rgroup 0--3
line.long 0 "Dev"
bitfld.long 0 0. " Dev "  "0 ,1 "
tree.end

base sd:0x80190fd0
tree "PeriphID4"
rgroup 0--3
line.long 0 "PeriphID4"
bitfld.long 0 0. " PeriphID4 "  "0 ,1 "
tree.end

base sd:0x80190fd4
tree "PeriphID5"
group 0--3
line.long 0 "PeriphID5"
bitfld.long 0 0. " PeriphID5 "  "0 ,1 "
tree.end

base sd:0x80190fd8
tree "PeriphID6"
group 0--3
line.long 0 "PeriphID6"
bitfld.long 0 0. " PeriphID6 "  "0 ,1 "
tree.end

base sd:0x80190fdc
tree "PeriphID7"
group 0--3
line.long 0 "PeriphID7"
bitfld.long 0 0. " PeriphID7 "  "0 ,1 "
tree.end

base sd:0x80190fe0
tree "PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0. " PeriphID0 "  "0 ,1 "
tree.end

base sd:0x80190fe4
tree "PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0. " PeriphID1 "  "0 ,1 "
tree.end

base sd:0x80190fe8
tree "PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0. " PeriphID2 "  "0 ,1 "
tree.end

base sd:0x80190fec
tree "PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0. " PeriphID3 "  "0 ,1 "
tree.end

base sd:0x80190ff0
tree "CompID0"
rgroup 0--3
line.long 0 "CompID0"
bitfld.long 0 0. " CompID0 "  "0 ,1 "
tree.end

base sd:0x80190ff4
tree "CompID1"
rgroup 0--3
line.long 0 "CompID1"
bitfld.long 0 0. " CompID1 "  "0 ,1 "
tree.end

base sd:0x80190ff8
tree "CompID2"
rgroup 0--3
line.long 0 "CompID2"
bitfld.long 0 0. " CompID2 "  "0 ,1 "
tree.end

base sd:0x80190ffc
tree "CompID3"
rgroup 0--3
line.long 0 "CompID3"
bitfld.long 0 0. " CompID3 "  "0 ,1 "
tree.end

tree.end

;==============================================================
;tree "UART (3 instances)"
;==============================================================
base sd:0x80120000
;********************************************
tree "UART-0"
;********************************************
base sd:0x80120000
tree "0DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--7. " DATA "  " "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
tree.end

base sd:0x80120004
tree "0RSR_ECR"
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
tree.end

base sd:0x80120008
tree "0DMAWM"
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  " "
bitfld.long 0 3.--5. " RXDMAWM "  " "
tree.end

base sd:0x8012000c
tree "0TIMEOUT"
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0. " TIMEOUT_PERIOD "  "0 ,1 "
tree.end

base sd:0x80120018
tree "0FR"
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
tree.end

base sd:0x8012001c
tree "0LCRH_RX"
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  " "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
tree.end

base sd:0x80120020
tree "0ILPR"
group 0--3
line.long 0 "ILPR"
bitfld.long 0 0.--7. " ILPDVSR "  " "
tree.end

base sd:0x80120024
tree "0IBRD"
group 0--3
line.long 0 "IBRD"
bitfld.long 0 0.--15. " DIVINT "  " "
tree.end

base sd:0x80120028
tree "0FBRD"
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  " "
tree.end

base sd:0x8012002c
tree "0LCRH_TX"
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  " "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
tree.end

base sd:0x80120030
tree "0CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
tree.end

base sd:0x80120034
tree "0IFLS"
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  " "
bitfld.long 0 3.--5. " RXIFLSEL "  " "
tree.end

base sd:0x80120038
tree "0IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
tree.end

base sd:0x8012003c
tree "0RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
tree.end

base sd:0x80120040
tree "0MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
tree.end

base sd:0x80120044
tree "0ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
tree.end

base sd:0x80120048
tree "0DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
tree.end

base sd:0x80120050
tree "0XFCR"
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  " "
bitfld.long 0 3.--4. " SFTMOD "  " "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
tree.end

base sd:0x80120054
tree "0XON1"
group 0--3
line.long 0 "XON1"
bitfld.long 0 0.--7. " XON1 "  " "
tree.end

base sd:0x80120058
tree "0XON2"
group 0--3
line.long 0 "XON2"
bitfld.long 0 0.--7. " XON2 "  " "
tree.end

base sd:0x8012005c
tree "0XOFF1"
group 0--3
line.long 0 "XOFF1"
bitfld.long 0 0.--7. " XOFF1 "  " "
tree.end

base sd:0x80120060
tree "0XOFF2"
group 0--3
line.long 0 "XOFF2"
bitfld.long 0 0.--7. " XOFF2 "  " "
tree.end

base sd:0x80120080
tree "0ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0x80120084
tree "0ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
tree.end

base sd:0x80120088
tree "0ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
tree.end

base sd:0x8012008c
tree "0TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
tree.end

base sd:0x80120100
tree "0ABCR"
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
tree.end

base sd:0x80120104
tree "0ABSR"
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  " "
bitfld.long 0 3.--7. " BYTE1S "  " "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  " "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
tree.end

base sd:0x80120108
tree "0ABFMT"
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  " "
tree.end

base sd:0x80120150
tree "0ABDR"
rgroup 0--3
line.long 0 "ABDR"
bitfld.long 0 0.--15. " AUTOBAUDBDR "  " "
tree.end

base sd:0x80120154
tree "0ABDFR"
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  " "
tree.end

base sd:0x80120158
tree "0ABMR"
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
tree.end

base sd:0x8012015c
tree "0ABIMSC"
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
tree.end

base sd:0x80120160
tree "0ABRIS"
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
tree.end

base sd:0x80120164
tree "0ABMIS"
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
tree.end

base sd:0x80120168
tree "0ABICR"
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
tree.end

base sd:0x80120fe0
tree "0PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x80120fe4
tree "0PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80120fe8
tree "0PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80120fec
tree "0PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80120ff0
tree "0PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " IDO "  " "
tree.end

base sd:0x80120ff4
tree "0PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " ID1 "  " "
tree.end

base sd:0x80120ff8
tree "0PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " ID2 "  " "
tree.end

base sd:0x80120ffc
tree "0PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " ID3 "  " "
tree.end

tree.end

base sd:0x80121000
;********************************************
tree "UART-1"
;********************************************
base sd:0x80121000
tree "1DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--7. " DATA "  " "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
tree.end

base sd:0x80121004
tree "1RSR_ECR"
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
tree.end

base sd:0x80121008
tree "1DMAWM"
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  " "
bitfld.long 0 3.--5. " RXDMAWM "  " "
tree.end

base sd:0x8012100c
tree "1TIMEOUT"
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0. " TIMEOUT_PERIOD "  "0 ,1 "
tree.end

base sd:0x80121018
tree "1FR"
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
tree.end

base sd:0x8012101c
tree "1LCRH_RX"
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  " "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
tree.end

base sd:0x80121020
tree "1ILPR"
group 0--3
line.long 0 "ILPR"
bitfld.long 0 0.--7. " ILPDVSR "  " "
tree.end

base sd:0x80121024
tree "1IBRD"
group 0--3
line.long 0 "IBRD"
bitfld.long 0 0.--15. " DIVINT "  " "
tree.end

base sd:0x80121028
tree "1FBRD"
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  " "
tree.end

base sd:0x8012102c
tree "1LCRH_TX"
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  " "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
tree.end

base sd:0x80121030
tree "1CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
tree.end

base sd:0x80121034
tree "1IFLS"
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  " "
bitfld.long 0 3.--5. " RXIFLSEL "  " "
tree.end

base sd:0x80121038
tree "1IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
tree.end

base sd:0x8012103c
tree "1RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
tree.end

base sd:0x80121040
tree "1MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
tree.end

base sd:0x80121044
tree "1ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
tree.end

base sd:0x80121048
tree "1DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
tree.end

base sd:0x80121050
tree "1XFCR"
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  " "
bitfld.long 0 3.--4. " SFTMOD "  " "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
tree.end

base sd:0x80121054
tree "1XON1"
group 0--3
line.long 0 "XON1"
bitfld.long 0 0.--7. " XON1 "  " "
tree.end

base sd:0x80121058
tree "1XON2"
group 0--3
line.long 0 "XON2"
bitfld.long 0 0.--7. " XON2 "  " "
tree.end

base sd:0x8012105c
tree "1XOFF1"
group 0--3
line.long 0 "XOFF1"
bitfld.long 0 0.--7. " XOFF1 "  " "
tree.end

base sd:0x80121060
tree "1XOFF2"
group 0--3
line.long 0 "XOFF2"
bitfld.long 0 0.--7. " XOFF2 "  " "
tree.end

base sd:0x80121080
tree "1ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0x80121084
tree "1ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
tree.end

base sd:0x80121088
tree "1ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
tree.end

base sd:0x8012108c
tree "1TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
tree.end

base sd:0x80121100
tree "1ABCR"
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
tree.end

base sd:0x80121104
tree "1ABSR"
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  " "
bitfld.long 0 3.--7. " BYTE1S "  " "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  " "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
tree.end

base sd:0x80121108
tree "1ABFMT"
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  " "
tree.end

base sd:0x80121150
tree "1ABDR"
rgroup 0--3
line.long 0 "ABDR"
bitfld.long 0 0.--15. " AUTOBAUDBDR "  " "
tree.end

base sd:0x80121154
tree "1ABDFR"
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  " "
tree.end

base sd:0x80121158
tree "1ABMR"
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
tree.end

base sd:0x8012115c
tree "1ABIMSC"
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
tree.end

base sd:0x80121160
tree "1ABRIS"
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
tree.end

base sd:0x80121164
tree "1ABMIS"
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
tree.end

base sd:0x80121168
tree "1ABICR"
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
tree.end

base sd:0x80121fe0
tree "1PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x80121fe4
tree "1PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80121fe8
tree "1PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80121fec
tree "1PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80121ff0
tree "1PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " IDO "  " "
tree.end

base sd:0x80121ff4
tree "1PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " ID1 "  " "
tree.end

base sd:0x80121ff8
tree "1PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " ID2 "  " "
tree.end

base sd:0x80121ffc
tree "1PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " ID3 "  " "
tree.end

tree.end

base sd:0x80007000
;********************************************
tree "UART-2"
;********************************************
base sd:0x80007000
tree "2DR"
group 0--3
line.long 0 "DR"
bitfld.long 0 0.--7. " DATA "  " "
bitfld.long 0 8. " FE "  "0 ,1 "
bitfld.long 0 9. " PE "  "0 ,1 "
bitfld.long 0 10. " BE "  "0 ,1 "
bitfld.long 0 11. " OE "  "0 ,1 "
tree.end

base sd:0x80007004
tree "2RSR_ECR"
group 0--3
line.long 0 "RSR_ECR"
bitfld.long 0 0. " FE "  "0 ,1 "
bitfld.long 0 1. " PE "  "0 ,1 "
bitfld.long 0 2. " BE "  "0 ,1 "
bitfld.long 0 3. " OE "  "0 ,1 "
tree.end

base sd:0x80007008
tree "2DMAWM"
group 0--3
line.long 0 "DMAWM"
bitfld.long 0 0.--2. " TXDMAWM "  " "
bitfld.long 0 3.--5. " RXDMAWM "  " "
tree.end

base sd:0x8000700c
tree "2TIMEOUT"
group 0--3
line.long 0 "TIMEOUT"
bitfld.long 0 0. " TIMEOUT_PERIOD "  "0 ,1 "
tree.end

base sd:0x80007018
tree "2FR"
rgroup 0--3
line.long 0 "FR"
bitfld.long 0 0. " CTS "  "0 ,1 "
bitfld.long 0 1. " DSR "  "0 ,1 "
bitfld.long 0 2. " DCD "  "0 ,1 "
bitfld.long 0 3. " BUSY "  "0 ,1 "
bitfld.long 0 4. " RXFE "  "0 ,1 "
bitfld.long 0 5. " TXFF "  "0 ,1 "
bitfld.long 0 6. " RXFF "  "0 ,1 "
bitfld.long 0 7. " TXFE "  "0 ,1 "
bitfld.long 0 8. " RI "  "0 ,1 "
bitfld.long 0 9. " DCTS "  "0 ,1 "
bitfld.long 0 10. " DDSR "  "0 ,1 "
bitfld.long 0 11. " DDCD "  "0 ,1 "
bitfld.long 0 12. " TERI "  "0 ,1 "
bitfld.long 0 13. " RTXDIS "  "0 ,1 "
tree.end

base sd:0x8000701c
tree "2LCRH_RX"
group 0--3
line.long 0 "LCRH_RX"
bitfld.long 0 1. " PEN_RX "  "0 ,1 "
bitfld.long 0 2. " EPS_RX "  "0 ,1 "
bitfld.long 0 3. " STP2_RX "  "0 ,1 "
bitfld.long 0 4. " FEN_RX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_RX "  " "
bitfld.long 0 7. " SPS_RX "  "0 ,1 "
tree.end

base sd:0x80007020
tree "2ILPR"
group 0--3
line.long 0 "ILPR"
bitfld.long 0 0.--7. " ILPDVSR "  " "
tree.end

base sd:0x80007024
tree "2IBRD"
group 0--3
line.long 0 "IBRD"
bitfld.long 0 0.--15. " DIVINT "  " "
tree.end

base sd:0x80007028
tree "2FBRD"
group 0--3
line.long 0 "FBRD"
bitfld.long 0 0.--5. " DIVFRAC "  " "
tree.end

base sd:0x8000702c
tree "2LCRH_TX"
group 0--3
line.long 0 "LCRH_TX"
bitfld.long 0 0. " BRK "  "0 ,1 "
bitfld.long 0 1. " PEN_TX "  "0 ,1 "
bitfld.long 0 2. " EPS_TX "  "0 ,1 "
bitfld.long 0 3. " STP2_TX "  "0 ,1 "
bitfld.long 0 4. " FEN_TX "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN_TX "  " "
bitfld.long 0 7. " SPS_TX "  "0 ,1 "
tree.end

base sd:0x80007030
tree "2CR"
group 0--3
line.long 0 "CR"
bitfld.long 0 0. " UARTEN "  "0 ,1 "
bitfld.long 0 3. " OVSFACT "  "0 ,1 "
bitfld.long 0 7. " LBE "  "0 ,1 "
bitfld.long 0 8. " TXE "  "0 ,1 "
bitfld.long 0 9. " RXE "  "0 ,1 "
bitfld.long 0 10. " DTR "  "0 ,1 "
bitfld.long 0 11. " RTS "  "0 ,1 "
bitfld.long 0 14. " RTSEn "  "0 ,1 "
bitfld.long 0 15. " CTSEn "  "0 ,1 "
tree.end

base sd:0x80007034
tree "2IFLS"
group 0--3
line.long 0 "IFLS"
bitfld.long 0 0.--2. " TXIFLSEL "  " "
bitfld.long 0 3.--5. " RXIFLSEL "  " "
tree.end

base sd:0x80007038
tree "2IMSC"
group 0--3
line.long 0 "IMSC"
bitfld.long 0 0. " RIMIM "  "0 ,1 "
bitfld.long 0 1. " CTSMIM "  "0 ,1 "
bitfld.long 0 2. " DCDMIM "  "0 ,1 "
bitfld.long 0 3. " DSRMIM "  "0 ,1 "
bitfld.long 0 4. " RXIM "  "0 ,1 "
bitfld.long 0 5. " TXIM "  "0 ,1 "
bitfld.long 0 6. " RTIM "  "0 ,1 "
bitfld.long 0 7. " FEIM "  "0 ,1 "
bitfld.long 0 8. " PEIM "  "0 ,1 "
bitfld.long 0 9. " BEIM "  "0 ,1 "
bitfld.long 0 10. " OEIM "  "0 ,1 "
bitfld.long 0 11. " XOFFIM "  "0 ,1 "
bitfld.long 0 12. " TXFEIM "  "0 ,1 "
tree.end

base sd:0x8000703c
tree "2RIS"
rgroup 0--3
line.long 0 "RIS"
bitfld.long 0 0. " RIRMIS "  "0 ,1 "
bitfld.long 0 1. " CTSRMIS "  "0 ,1 "
bitfld.long 0 2. " DCDRMIS "  "0 ,1 "
bitfld.long 0 3. " DSRRMIS "  "0 ,1 "
bitfld.long 0 4. " RXRIS "  "0 ,1 "
bitfld.long 0 5. " TXRIS "  "0 ,1 "
bitfld.long 0 6. " RTRIS "  "0 ,1 "
bitfld.long 0 7. " FERIS "  "0 ,1 "
bitfld.long 0 8. " PERIS "  "0 ,1 "
bitfld.long 0 9. " BERIS "  "0 ,1 "
bitfld.long 0 10. " OERIS "  "0 ,1 "
bitfld.long 0 11. " XOFFRIS "  "0 ,1 "
bitfld.long 0 12. " TXFERIS "  "0 ,1 "
tree.end

base sd:0x80007040
tree "2MIS"
rgroup 0--3
line.long 0 "MIS"
bitfld.long 0 0. " RIMMIS "  "0 ,1 "
bitfld.long 0 1. " CTSMMIS "  "0 ,1 "
bitfld.long 0 2. " DCDMMIS "  "0 ,1 "
bitfld.long 0 3. " DSRMMIS "  "0 ,1 "
bitfld.long 0 4. " RXMIS "  "0 ,1 "
bitfld.long 0 5. " TXMIS "  "0 ,1 "
bitfld.long 0 6. " RTMIS "  "0 ,1 "
bitfld.long 0 7. " FEMIS "  "0 ,1 "
bitfld.long 0 8. " PEMIS "  "0 ,1 "
bitfld.long 0 9. " BEMIS "  "0 ,1 "
bitfld.long 0 10. " OEMIS "  "0 ,1 "
bitfld.long 0 11. " XOFFMIS "  "0 ,1 "
bitfld.long 0 12. " TXFEMIS "  "0 ,1 "
tree.end

base sd:0x80007044
tree "2ICR"
group 0--3
line.long 0 "ICR"
bitfld.long 0 0. " RIMIC "  "0 ,1 "
bitfld.long 0 1. " CTSMIC "  "0 ,1 "
bitfld.long 0 2. " DCDMIC "  "0 ,1 "
bitfld.long 0 3. " DSRMIC "  "0 ,1 "
bitfld.long 0 4. " RXIC "  "0 ,1 "
bitfld.long 0 5. " TXIC "  "0 ,1 "
bitfld.long 0 6. " RTIC "  "0 ,1 "
bitfld.long 0 7. " FEIC "  "0 ,1 "
bitfld.long 0 8. " PEIC "  "0 ,1 "
bitfld.long 0 9. " BEIC "  "0 ,1 "
bitfld.long 0 10. " OEIC "  "0 ,1 "
bitfld.long 0 11. " XOFFIC "  "0 ,1 "
tree.end

base sd:0x80007048
tree "2DMACR"
group 0--3
line.long 0 "DMACR"
bitfld.long 0 0. " RXDMAE "  "0 ,1 "
bitfld.long 0 1. " TXDMAE "  "0 ,1 "
bitfld.long 0 2. " DMAONERR "  "0 ,1 "
tree.end

base sd:0x80007050
tree "2XFCR"
group 0--3
line.long 0 "XFCR"
bitfld.long 0 0. " SFEN "  "0 ,1 "
bitfld.long 0 1.--2. " SFRMOD "  " "
bitfld.long 0 3.--4. " SFTMOD "  " "
bitfld.long 0 5. " XONANY "  "0 ,1 "
bitfld.long 0 6. " SPECHR "  "0 ,1 "
tree.end

base sd:0x80007054
tree "2XON1"
group 0--3
line.long 0 "XON1"
bitfld.long 0 0.--7. " XON1 "  " "
tree.end

base sd:0x80007058
tree "2XON2"
group 0--3
line.long 0 "XON2"
bitfld.long 0 0.--7. " XON2 "  " "
tree.end

base sd:0x8000705c
tree "2XOFF1"
group 0--3
line.long 0 "XOFF1"
bitfld.long 0 0.--7. " XOFF1 "  " "
tree.end

base sd:0x80007060
tree "2XOFF2"
group 0--3
line.long 0 "XOFF2"
bitfld.long 0 0.--7. " XOFF2 "  " "
tree.end

base sd:0x80007080
tree "2ITCR"
group 0--3
line.long 0 "ITCR"
bitfld.long 0 0. " ITEN "  "0 ,1 "
tree.end

base sd:0x80007084
tree "2ITIP"
group 0--3
line.long 0 "ITIP"
bitfld.long 0 0. " RXD "  "0 ,1 "
bitfld.long 0 2. " DSRn "  "0 ,1 "
bitfld.long 0 3. " CTSn "  "0 ,1 "
bitfld.long 0 4. " DCDn "  "0 ,1 "
bitfld.long 0 5. " RIn "  "0 ,1 "
bitfld.long 0 6. " RXDMAC "  "0 ,1 "
bitfld.long 0 7. " TXDMAC "  "0 ,1 "
tree.end

base sd:0x80007088
tree "2ITOP"
group 0--3
line.long 0 "ITOP"
bitfld.long 0 0. " TXD "  "0 ,1 "
bitfld.long 0 2. " DTRn "  "0 ,1 "
bitfld.long 0 3. " RTSn "  "0 ,1 "
bitfld.long 0 4. " OUT1n "  "0 ,1 "
bitfld.long 0 5. " OUT2n "  "0 ,1 "
bitfld.long 0 6. " I "  "0 ,1 "
bitfld.long 0 7. " EI "  "0 ,1 "
bitfld.long 0 8. " RTI "  "0 ,1 "
bitfld.long 0 9. " TXI "  "0 ,1 "
bitfld.long 0 10. " RXI "  "0 ,1 "
bitfld.long 0 11. " MSI "  "0 ,1 "
bitfld.long 0 12. " RXDMABR "  "0 ,1 "
bitfld.long 0 13. " RXDMASR "  "0 ,1 "
bitfld.long 0 14. " TXDMABR "  "0 ,1 "
bitfld.long 0 15. " TXDMASR "  "0 ,1 "
bitfld.long 0 16. " ABERRI "  "0 ,1 "
bitfld.long 0 17. " ABDONEI "  "0 ,1 "
tree.end

base sd:0x8000708c
tree "2TDR"
group 0--3
line.long 0 "TDR"
bitfld.long 0 0.--10. " DATA "  " "
tree.end

base sd:0x80007100
tree "2ABCR"
group 0--3
line.long 0 "ABCR"
bitfld.long 0 0. " ACFGEN "  "0 ,1 "
bitfld.long 0 1. " RESTART "  "0 ,1 "
bitfld.long 0 2. " UPDATEN "  "0 ,1 "
tree.end

base sd:0x80007104
tree "2ABSR"
rgroup 0--3
line.long 0 "ABSR"
bitfld.long 0 0.--2. " BYTE2S "  " "
bitfld.long 0 3.--7. " BYTE1S "  " "
bitfld.long 0 8. " VALFMT "  "0 ,1 "
bitfld.long 0 9.--10. " CMDERR "  " "
bitfld.long 0 11. " BAUDERR "  "0 ,1 "
bitfld.long 0 12. " ACDONE "  "0 ,1 "
tree.end

base sd:0x80007108
tree "2ABFMT"
rgroup 0--3
line.long 0 "ABFMT"
bitfld.long 0 1. " PEN "  "0 ,1 "
bitfld.long 0 2. " EPS "  "0 ,1 "
bitfld.long 0 3. " STP2 "  "0 ,1 "
bitfld.long 0 4. " FEN "  "0 ,1 "
bitfld.long 0 5.--6. " WLEN "  " "
tree.end

base sd:0x80007150
tree "2ABDR"
rgroup 0--3
line.long 0 "ABDR"
bitfld.long 0 0.--15. " AUTOBAUDBDR "  " "
tree.end

base sd:0x80007154
tree "2ABDFR"
rgroup 0--3
line.long 0 "ABDFR"
bitfld.long 0 0.--5. " AUTOBAUDBDFR "  " "
tree.end

base sd:0x80007158
tree "2ABMR"
rgroup 0--3
line.long 0 "ABMR"
bitfld.long 0 0.--19. " AUTOBAUDBMR "  " "
tree.end

base sd:0x8000715c
tree "2ABIMSC"
group 0--3
line.long 0 "ABIMSC"
bitfld.long 0 0. " ABERRIM "  "0 ,1 "
bitfld.long 0 1. " ABDONEIM "  "0 ,1 "
tree.end

base sd:0x80007160
tree "2ABRIS"
rgroup 0--3
line.long 0 "ABRIS"
bitfld.long 0 0. " ABERRRIS "  "0 ,1 "
bitfld.long 0 1. " ABDONERIS "  "0 ,1 "
tree.end

base sd:0x80007164
tree "2ABMIS"
rgroup 0--3
line.long 0 "ABMIS"
bitfld.long 0 0. " ABERRMIS "  "0 ,1 "
bitfld.long 0 1. " ABDONEMIS "  "0 ,1 "
tree.end

base sd:0x80007168
tree "2ABICR"
group 0--3
line.long 0 "ABICR"
bitfld.long 0 0. " ABERRIC "  "0 ,1 "
bitfld.long 0 1. " ABDONEIC "  "0 ,1 "
tree.end

base sd:0x80007fe0
tree "2PeriphID0"
rgroup 0--3
line.long 0 "PeriphID0"
bitfld.long 0 0.--7. " PartNumber0 "  " "
tree.end

base sd:0x80007fe4
tree "2PeriphID1"
rgroup 0--3
line.long 0 "PeriphID1"
bitfld.long 0 0.--3. " PartNumber1 "  " "
bitfld.long 0 4.--7. " Designer0 "  " "
tree.end

base sd:0x80007fe8
tree "2PeriphID2"
rgroup 0--3
line.long 0 "PeriphID2"
bitfld.long 0 0.--3. " Designer1 "  " "
bitfld.long 0 4.--7. " Revision "  " "
tree.end

base sd:0x80007fec
tree "2PeriphID3"
rgroup 0--3
line.long 0 "PeriphID3"
bitfld.long 0 0.--7. " Configuration "  " "
tree.end

base sd:0x80007ff0
tree "2PCellID0"
rgroup 0--3
line.long 0 "PCellID0"
bitfld.long 0 0.--7. " IDO "  " "
tree.end

base sd:0x80007ff4
tree "2PCellID1"
rgroup 0--3
line.long 0 "PCellID1"
bitfld.long 0 0.--7. " ID1 "  " "
tree.end

base sd:0x80007ff8
tree "2PCellID2"
rgroup 0--3
line.long 0 "PCellID2"
bitfld.long 0 0.--7. " ID2 "  " "
tree.end

base sd:0x80007ffc
tree "2PCellID3"
rgroup 0--3
line.long 0 "PCellID3"
bitfld.long 0 0.--7. " ID3 "  " "
tree.end

;tree.end

tree.end

;==============================================================
tree "USB"
;==============================================================
base sd:0xa03e0000
tree "INTTX_PWR_FADDR"
group 0--3
line.long 0 "INTTX_PWR_FADDR"
bitfld.long 0 0.--6. " FADDR "  " "
bitfld.long 0 8. " SUSPEN "  "0 ,1 "
bitfld.long 0 9. " SUSPM "  "0 ,1 "
bitfld.long 0 10. " RSM "  "0 ,1 "
bitfld.long 0 11. " RST "  "0 ,1 "
bitfld.long 0 12. " HSMD "  "0 ,1 "
bitfld.long 0 13. " HSEN "  "0 ,1 "
bitfld.long 0 14. " SFCN "  "0 ,1 "
bitfld.long 0 15. " ISO_UP "  "0 ,1 "
bitfld.long 0 16.--31. " EPTX "  " "
tree.end

base sd:0xa03e0004
tree "INTTXEN_INTRX"
group 0--3
line.long 0 "INTTXEN_INTRX"
bitfld.long 0 1.--15. " EPRX "  " "
bitfld.long 0 16.--31. " EPTXEN "  " "
tree.end

base sd:0xa03e0008
tree "INTRUSB_INTRXEN"
group 0--3
line.long 0 "INTRUSB_INTRXEN"
bitfld.long 0 1.--15. " EPRXEN "  " "
bitfld.long 0 16. " SUSP "  "0 ,1 "
bitfld.long 0 17. " RES "  "0 ,1 "
bitfld.long 0 18. " RST "  "0 ,1 "
bitfld.long 0 19. " SOF "  "0 ,1 "
bitfld.long 0 20. " CONN "  "0 ,1 "
bitfld.long 0 21. " DISCON "  "0 ,1 "
bitfld.long 0 22. " SESSREQ "  "0 ,1 "
bitfld.long 0 23. " VBERR "  "0 ,1 "
bitfld.long 0 24. " SUSPEN "  "0 ,1 "
bitfld.long 0 25. " RESEN "  "0 ,1 "
bitfld.long 0 26. " RSTEN "  "0 ,1 "
bitfld.long 0 27. " SOFEN "  "0 ,1 "
bitfld.long 0 28. " CONNEN "  "0 ,1 "
bitfld.long 0 29. " DISCONEN "  "0 ,1 "
bitfld.long 0 30. " SESSREDEN "  "0 ,1 "
bitfld.long 0 31. " VBERREN "  "0 ,1 "
tree.end

base sd:0xa03e000c
tree "TM_INDX_FMNO"
group 0--3
line.long 0 "TM_INDX_FMNO"
bitfld.long 0 0.--10. " FMNO "  " "
bitfld.long 0 16.--19. " EPNO "  " "
bitfld.long 0 24. " TSTNAK "  "0 ,1 "
bitfld.long 0 25. " TSTJ "  "0 ,1 "
bitfld.long 0 26. " TSTK "  "0 ,1 "
bitfld.long 0 27. " TSTPKT "  "0 ,1 "
bitfld.long 0 28. " FHS "  "0 ,1 "
bitfld.long 0 29. " FFS "  "0 ,1 "
bitfld.long 0 30. " FIFOA "  "0 ,1 "
bitfld.long 0 31. " FRH "  "0 ,1 "
tree.end

base sd:0xa03e0010
tree "TXCSR_TXMAXP"
group 0--3
line.long 0 "TXCSR_TXMAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " TXPKTRDY "  "0 ,1 "
bitfld.long 0 17. " FNOTEM "  "0 ,1 "
bitfld.long 0 18. " URUN "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SDSTALL "  "0 ,1 "
bitfld.long 0 21. " STSTALL "  "0 ,1 "
bitfld.long 0 22. " CLRDTTOG "  "0 ,1 "
bitfld.long 0 23. " INCTX "  "0 ,1 "
bitfld.long 0 26. " DMAREQMD "  "0 ,1 "
bitfld.long 0 27. " FDTTOG "  "0 ,1 "
bitfld.long 0 28. " DMAREQEN "  "0 ,1 "
bitfld.long 0 29. " MODE "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0014
tree "RXCSR_RXMAXP"
group 0--3
line.long 0 "RXCSR_RXMAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " RXPKTRDY "  "0 ,1 "
bitfld.long 0 17. " FF "  "0 ,1 "
bitfld.long 0 18. " ORUN "  "0 ,1 "
bitfld.long 0 19. " DTERR "  "0 ,1 "
bitfld.long 0 20. " FLUSHF "  "0 ,1 "
bitfld.long 0 21. " SDTALL "  "0 ,1 "
bitfld.long 0 22. " STSTALL "  "0 ,1 "
bitfld.long 0 23. " CLRDTTOG "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMAREQMD "  "0 ,1 "
bitfld.long 0 28. " PIDERR "  "0 ,1 "
bitfld.long 0 29. " DMAREQEN "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ACLR "  "0 ,1 "
tree.end

base sd:0xa03e0018
tree "TXIN_TXTYPE_RXCOUNT"
group 0--3
line.long 0 "TXIN_TXTYPE_RXCOUNT"
bitfld.long 0 0.--13. " RXCOUNT "  " "
bitfld.long 0 16.--19. " TEPNO "  " "
bitfld.long 0 20.--21. " PROT "  " "
bitfld.long 0 22.--23. " SPEED "  " "
bitfld.long 0 24.--31. " TXPI "  " "
tree.end

base sd:0xa03e001c
tree "CFG_RXIN_RXTYPE"
group 0--3
line.long 0 "CFG_RXIN_RXTYPE"
bitfld.long 0 0.--3. " TEP "  " "
bitfld.long 0 4.--5. " PROT "  " "
bitfld.long 0 6.--7. " SPEED "  " "
bitfld.long 0 8.--15. " RXPI "  " "
bitfld.long 0 24. " UI "  "0 ,1 "
bitfld.long 0 25. " SC "  "0 ,1 "
bitfld.long 0 26. " DYNF "  "0 ,1 "
bitfld.long 0 27. " HBTXE "  "0 ,1 "
bitfld.long 0 28. " HBRXE "  "0 ,1 "
bitfld.long 0 29. " BE "  "0 ,1 "
bitfld.long 0 30. " MPTXE "  "0 ,1 "
bitfld.long 0 31. " MPRXE "  "0 ,1 "
tree.end

base sd:0xa03e0020
tree "EP0_FIFO"
group 0--3
line.long 0 "EP0_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e0024
tree "EP1_FIFO"
group 0--3
line.long 0 "EP1_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e0028
tree "EP2_FIFO"
group 0--3
line.long 0 "EP2_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e002c
tree "EP3_FIFO"
group 0--3
line.long 0 "EP3_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e0030
tree "EP4_FIFO"
group 0--3
line.long 0 "EP4_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e0034
tree "EP5_FIFO"
group 0--3
line.long 0 "EP5_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e0038
tree "EP6_FIFO"
group 0--3
line.long 0 "EP6_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e003c
tree "EP7_FIFO"
group 0--3
line.long 0 "EP7_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e0040
tree "EP8_FIFO"
group 0--3
line.long 0 "EP8_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e0044
tree "EP9_FIFO"
group 0--3
line.long 0 "EP9_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e0048
tree "EP10_FIFO"
group 0--3
line.long 0 "EP10_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e004c
tree "EP11_FIFO"
group 0--3
line.long 0 "EP11_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e0050
tree "EP12_FIFO"
group 0--3
line.long 0 "EP12_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e0054
tree "EP13_FIFO"
group 0--3
line.long 0 "EP13_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e0058
tree "EP14_FIFO"
group 0--3
line.long 0 "EP14_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e005c
tree "EP15_FIFO"
group 0--3
line.long 0 "EP15_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e0060
tree "FIFOSZ_DEVCTL"
group 0--3
line.long 0 "FIFOSZ_DEVCTL"
bitfld.long 0 0. " SESS "  "0 ,1 "
bitfld.long 0 1. " HREQ "  "0 ,1 "
bitfld.long 0 2. " HOST "  "0 ,1 "
bitfld.long 0 3.--4. " VBUS "  " "
bitfld.long 0 5. " LSDEV "  "0 ,1 "
bitfld.long 0 6. " FSDEV "  "0 ,1 "
bitfld.long 0 7. " BDEV "  "0 ,1 "
bitfld.long 0 8. " RXEDMA "  "0 ,1 "
bitfld.long 0 9. " TXEDMA "  "0 ,1 "
bitfld.long 0 16.--19. " TXFSIZE "  " "
bitfld.long 0 20. " DPBTX "  "0 ,1 "
bitfld.long 0 24.--27. " RXFSIZE "  " "
bitfld.long 0 28. " DPBRX "  "0 ,1 "
tree.end

base sd:0xa03e0064
tree "FIFOADDR"
group 0--3
line.long 0 "FIFOADDR"
bitfld.long 0 0.--13. " TXFADDDR "  " "
bitfld.long 0 16.--29. " RXFADDR "  " "
tree.end

base sd:0xa03e0068
tree "VCNTL"
group 0--3
line.long 0 "VCNTL"
bitfld.long 0 0.--7. " VCNTL "  " "
bitfld.long 0 8.--15. " VSTATUS "  " "
tree.end

base sd:0xa03e006c
tree "HWVER"
rgroup 0--3
line.long 0 "HWVER"
bitfld.long 0 0.--9. " VMIN "  " "
bitfld.long 0 10.--14. " VMAJ "  " "
bitfld.long 0 15. " RC "  "0 ,1 "
tree.end

base sd:0xa03e0070
tree "ULPI_1"
group 0--3
line.long 0 "ULPI_1"
bitfld.long 0 0. " EXTVB "  "0 ,1 "
bitfld.long 0 1. " EXTVI "  "0 ,1 "
bitfld.long 0 2. " STP "  "0 ,1 "
bitfld.long 0 8. " DISU "  "0 ,1 "
bitfld.long 0 9. " CKACT "  "0 ,1 "
bitfld.long 0 10. " ALTINT "  "0 ,1 "
bitfld.long 0 11. " CANCK "  "0 ,1 "
bitfld.long 0 12. " RXCMD "  "0 ,1 "
bitfld.long 0 13. " CKAE "  "0 ,1 "
bitfld.long 0 16. " REGINT_INEN "  "0 ,1 "
bitfld.long 0 17. " ALTINT_INEN "  "0 ,1 "
bitfld.long 0 18. " AEND_INEN "  "0 ,1 "
bitfld.long 0 19. " RXCMD_IE "  "0 ,1 "
bitfld.long 0 24. " REGINTI "  "0 ,1 "
bitfld.long 0 25. " ALTINTI "  "0 ,1 "
bitfld.long 0 26. " AENDI "  "0 ,1 "
bitfld.long 0 27. " RXCMDI "  "0 ,1 "
tree.end

base sd:0xa03e0074
tree "ULPI_2"
group 0--3
line.long 0 "ULPI_2"
bitfld.long 0 0.--7. " UREGDATA "  " "
bitfld.long 0 8.--15. " UREGADDR "  " "
bitfld.long 0 16. " UREGREQ "  "0 ,1 "
bitfld.long 0 17. " UREGC "  "0 ,1 "
bitfld.long 0 18. " URW "  "0 ,1 "
bitfld.long 0 24.--31. " URAWDATA "  " "
tree.end

base sd:0xa03e0078
tree "EP_INFO"
group 0--3
line.long 0 "EP_INFO"
bitfld.long 0 0.--3. " TXEPINFO "  " "
bitfld.long 0 4.--7. " RXEPINFO "  " "
tree.end

base sd:0xa03e007c
tree "EOF_REG"
group 0--3
line.long 0 "EOF_REG"
bitfld.long 0 0.--7. " HSEOF1 "  " "
bitfld.long 0 8.--15. " FSEOF1 "  " "
bitfld.long 0 16.--23. " LSEOF1 "  " "
bitfld.long 0 24.--25. " SRST "  " "
tree.end

base sd:0xa03e0080
tree "TXFUNCADDR_EP0"
group 0--3
line.long 0 "TXFUNCADDR_EP0"
bitfld.long 0 0.--6. " TXADDR0 "  " "
tree.end

base sd:0xa03e0088
tree "TXFUNCADDR_EP1"
group 0--3
line.long 0 "TXFUNCADDR_EP1"
bitfld.long 0 0.--6. " TXADDR "  " "
tree.end

base sd:0xa03e008c
tree "RXFUNCADDR_EP1"
group 0--3
line.long 0 "RXFUNCADDR_EP1"
bitfld.long 0 0.--6. " RXADDR "  " "
tree.end

base sd:0xa03e0090
tree "TXFUNCADDR_EP2"
group 0--3
line.long 0 "TXFUNCADDR_EP2"
bitfld.long 0 0.--6. " TXADDR2 "  " "
tree.end

base sd:0xa03e0094
tree "RXFUNCADDR_EP2"
group 0--3
line.long 0 "RXFUNCADDR_EP2"
bitfld.long 0 0.--6. " RXADDR2 "  " "
tree.end

base sd:0xa03e0098
tree "TXFUNCADDR_EP3"
group 0--3
line.long 0 "TXFUNCADDR_EP3"
bitfld.long 0 0.--6. " TXADDR3 "  " "
tree.end

base sd:0xa03e00a0
tree "RXFUNCADDR_EP3"
group 0--3
line.long 0 "RXFUNCADDR_EP3"
bitfld.long 0 0.--6. " RXADDR3 "  " "
tree.end

base sd:0xa03e00a4
tree "TXFUNCADDR_EP4"
group 0--3
line.long 0 "TXFUNCADDR_EP4"
bitfld.long 0 0.--6. " TXADDR4 "  " "
tree.end

base sd:0xa03e00a8
tree "RXFUNCADDR_EP4"
group 0--3
line.long 0 "RXFUNCADDR_EP4"
bitfld.long 0 0.--6. " RXADDR4 "  " "
tree.end

base sd:0xa03e00ac
tree "TXFUNCADDR_EP5"
group 0--3
line.long 0 "TXFUNCADDR_EP5"
bitfld.long 0 0.--6. " TXADDR5 "  " "
tree.end

base sd:0xa03e00b0
tree "RXFUNCADDR_EP5"
group 0--3
line.long 0 "RXFUNCADDR_EP5"
bitfld.long 0 0.--6. " RXADDR5 "  " "
tree.end

base sd:0xa03e00b4
tree "RXFUNCADDR_EP6"
group 0--3
line.long 0 "RXFUNCADDR_EP6"
bitfld.long 0 0.--6. " RXADDR6 "  " "
tree.end

base sd:0xa03e00bc
tree "RXFUNCADDR_EP7"
group 0--3
line.long 0 "RXFUNCADDR_EP7"
bitfld.long 0 0.--6. " RXADDR7 "  " "
tree.end

base sd:0xa03e00c0
tree "RXFUNCADDR_EP8"
group 0--3
line.long 0 "RXFUNCADDR_EP8"
bitfld.long 0 0.--6. " RXADDR8 "  " "
tree.end

base sd:0xa03e00c8
tree "RXFUNCADDR_EP9"
group 0--3
line.long 0 "RXFUNCADDR_EP9"
bitfld.long 0 0.--6. " RXADDR9 "  " "
tree.end

base sd:0xa03e00d0
tree "RXFUNCADDR_EP10"
group 0--3
line.long 0 "RXFUNCADDR_EP10"
bitfld.long 0 0.--6. " RXADDR10 "  " "
tree.end

base sd:0xa03e00d8
tree "RXFUNCADDR_EP11"
group 0--3
line.long 0 "RXFUNCADDR_EP11"
bitfld.long 0 0.--6. " RXADDR11 "  " "
tree.end

base sd:0xa03e00e0
tree "RXFUNCADDR_EP12"
group 0--3
line.long 0 "RXFUNCADDR_EP12"
bitfld.long 0 0.--6. " RXADDR12 "  " "
tree.end

base sd:0xa03e00e8
tree "RXFUNCADDR_EP13"
group 0--3
line.long 0 "RXFUNCADDR_EP13"
bitfld.long 0 0.--6. " RXADDR13 "  " "
tree.end

base sd:0xa03e00f0
tree "RXFUNCADDR_EP14"
group 0--3
line.long 0 "RXFUNCADDR_EP14"
bitfld.long 0 0.--6. " RXADDR14 "  " "
tree.end

base sd:0xa03e00f8
tree "RXFUNCADDR_EP15"
group 0--3
line.long 0 "RXFUNCADDR_EP15"
bitfld.long 0 0.--6. " RXADDR15 "  " "
tree.end

base sd:0xa03e0200
tree "DMA_INTR"
group 0--3
line.long 0 "DMA_INTR"
bitfld.long 0 0. " DMAINTR "  "0 ,1 "
tree.end

base sd:0xa03e0304
tree "EP1_RQPKTCOUNT"
group 0--3
line.long 0 "EP1_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0308
tree "EP2_RQPKTCOUNT"
group 0--3
line.long 0 "EP2_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e030c
tree "EP3_RQPKTCOUNT"
group 0--3
line.long 0 "EP3_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0310
tree "EP4_RQPKTCOUNT"
group 0--3
line.long 0 "EP4_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0314
tree "EP5_RQPKTCOUNT"
group 0--3
line.long 0 "EP5_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0318
tree "EP6_RQPKTCOUNT"
group 0--3
line.long 0 "EP6_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e031c
tree "EP7_RQPKTCOUNT"
group 0--3
line.long 0 "EP7_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0320
tree "EP8_RQPKTCOUNT"
group 0--3
line.long 0 "EP8_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0324
tree "EP9_RQPKTCOUNT"
group 0--3
line.long 0 "EP9_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0328
tree "EP10_RQPKTCOUNT"
group 0--3
line.long 0 "EP10_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e032c
tree "EP11_RQPKTCOUNT"
group 0--3
line.long 0 "EP11_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0330
tree "EP12_RQPKTCOUNT"
group 0--3
line.long 0 "EP12_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0334
tree "EP13_RQPKTCOUNT"
group 0--3
line.long 0 "EP13_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0338
tree "EP14_RQPKTCOUNT"
group 0--3
line.long 0 "EP14_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e033c
tree "EP15_RQPKTCOUNT"
group 0--3
line.long 0 "EP15_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0340
tree "DPKTBUFDIS"
group 0--3
line.long 0 "DPKTBUFDIS"
bitfld.long 0 1.--15. " EP_RXDIS "  " "
bitfld.long 0 17.--31. " EP_TXDIS "  " "
tree.end

base sd:0xa03e0344
tree "C_T_UCH"
group 0--3
line.long 0 "C_T_UCH"
bitfld.long 0 0.--15. " C_T_UCH "  " "
bitfld.long 0 16.--31. " C_T_HSRTN "  " "
tree.end

base sd:0xa03e0348
tree "C_T_HSBT"
group 0--3
line.long 0 "C_T_HSBT"
bitfld.long 0 0.--3. " HSTADDR "  " "
tree.end

base sd:0xa03e0360
tree "LPM_ATTR"
group 0--3
line.long 0 "LPM_ATTR"
bitfld.long 0 0.--3. " LINKSTATE "  " "
bitfld.long 0 4.--7. " HIRD "  " "
bitfld.long 0 8. " RMTWAK "  "0 ,1 "
bitfld.long 0 12.--15. " EP "  " "
bitfld.long 0 16. " LPMXMT "  "0 ,1 "
bitfld.long 0 17. " LPMRES "  "0 ,1 "
bitfld.long 0 18.--19. " LPMEN "  " "
bitfld.long 0 20. " LPMNAK "  "0 ,1 "
bitfld.long 0 21. " LPMSTEN "  "0 ,1 "
bitfld.long 0 22. " LPMNYEN "  "0 ,1 "
bitfld.long 0 23. " LPMACKEN "  "0 ,1 "
bitfld.long 0 24. " LPMNCEN "  "0 ,1 "
bitfld.long 0 25. " LPMRESEN "  "0 ,1 "
bitfld.long 0 26. " LPMERREN "  "0 ,1 "
tree.end

base sd:0xa03e0364
tree "LPM_INTR"
group 0--3
line.long 0 "LPM_INTR"
bitfld.long 0 0. " LPMST "  "0 ,1 "
bitfld.long 0 1. " LPMNY "  "0 ,1 "
bitfld.long 0 2. " LPMACK "  "0 ,1 "
bitfld.long 0 3. " LPMNC "  "0 ,1 "
bitfld.long 0 4. " LPMRES "  "0 ,1 "
bitfld.long 0 5. " LPMERR "  "0 ,1 "
bitfld.long 0 8.--14. " FADDR "  " "
tree.end

tree.end

;==============================================================
tree "USBOTGM"
;==============================================================
base sd:0xa03e0000
tree "INTTX_PWR_FADDR"
group 0--3
line.long 0 "INTTX_PWR_FADDR"
bitfld.long 0 0.--6. " FADDR "  " "
bitfld.long 0 8. " SUSPM "  "0 ,1 "
bitfld.long 0 9. " SUSP "  "0 ,1 "
bitfld.long 0 10. " RSM "  "0 ,1 "
bitfld.long 0 11. " RST "  "0 ,1 "
bitfld.long 0 12. " HSMD "  "0 ,1 "
bitfld.long 0 13. " HSEN "  "0 ,1 "
bitfld.long 0 14. " SFCN "  "0 ,1 "
bitfld.long 0 15. " ISO_UP "  "0 ,1 "
bitfld.long 0 16.--31. " EPTX "  " "
tree.end

base sd:0xa03e0004
tree "INTTXEN_RX"
group 0--3
line.long 0 "INTTXEN_RX"
bitfld.long 0 0.--15. " EPRX "  " "
bitfld.long 0 16.--31. " EPTXEN "  " "
tree.end

base sd:0xa03e0008
tree "INTRXEN"
group 0--3
line.long 0 "INTRXEN"
bitfld.long 0 0.--15. " EPRXEN "  " "
bitfld.long 0 16.--31. " INTUSB "  " "
tree.end

base sd:0xa03e000c
tree "TM_INDX_FMNO"
group 0--3
