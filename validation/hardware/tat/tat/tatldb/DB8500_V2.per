line.long 0 "TM_INDX_FMNO"
bitfld.long 0 0.--10. " FMNO "  " "
bitfld.long 0 16.--19. " EPNO "  " "
bitfld.long 0 24. " TSTNAK "  "0 ,1 "
bitfld.long 0 25. " TSTJ "  "0 ,1 "
bitfld.long 0 26. " TSTK "  "0 ,1 "
bitfld.long 0 27. " TSTPKT "  "0 ,1 "
bitfld.long 0 28. " FHS "  "0 ,1 "
bitfld.long 0 29. " FFS "  "0 ,1 "
bitfld.long 0 30. " FIFOA "  "0 ,1 "
bitfld.long 0 31. " FRH "  "0 ,1 "
tree.end

base sd:0xa03e0010
tree "INDX_TXCSR"
group 0--3
line.long 0 "INDX_TXCSR"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16.--31. " TXCSR0 "  " "
tree.end

base sd:0xa03e0014
tree "INDX_RXCSR"
group 0--3
line.long 0 "INDX_RXCSR"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16.--31. " RXCSR "  " "
tree.end

base sd:0xa03e0018
tree "INDX_COUNT0"
group 0--3
line.long 0 "INDX_COUNT0"
bitfld.long 0 0.--12. " RXCOUNT "  " "
bitfld.long 0 13.--16. " EP "  " "
bitfld.long 0 17.--18. " PROT "  " "
bitfld.long 0 19.--20. " SPEED "  " "
bitfld.long 0 21.--28. " TXPI "  " "
tree.end

base sd:0xa03e001c
tree "INDX_CFD"
rgroup 0--3
line.long 0 "INDX_CFD"
bitfld.long 0 0. " UI "  "0 ,1 "
bitfld.long 0 1. " SC "  "0 ,1 "
bitfld.long 0 2. " DYNF "  "0 ,1 "
bitfld.long 0 3. " HBTXE "  "0 ,1 "
bitfld.long 0 4. " HBRXE "  "0 ,1 "
bitfld.long 0 5. " BE "  "0 ,1 "
bitfld.long 0 6. " MPTXE "  "0 ,1 "
bitfld.long 0 7. " MPRXE "  "0 ,1 "
tree.end

base sd:0xa03e0020
tree "EP0_FIFO"
group 0--3
line.long 0 "EP0_FIFO"
bitfld.long 0 0.--31. " FIFO "  " "
tree.end

base sd:0xa03e0060
tree "FIFOSZ_DEVCTL"
group 0--3
line.long 0 "FIFOSZ_DEVCTL"
bitfld.long 0 0. " SESS "  "0 ,1 "
bitfld.long 0 1. " HREQ "  "0 ,1 "
bitfld.long 0 2. " HOST "  "0 ,1 "
bitfld.long 0 3.--4. " VBUS "  " "
bitfld.long 0 5. " LSDEV "  "0 ,1 "
bitfld.long 0 6. " FSDEV "  "0 ,1 "
bitfld.long 0 7. " BDEV "  "0 ,1 "
bitfld.long 0 8.--11. " TXSIZE "  " "
bitfld.long 0 12. " TXDPB "  "0 ,1 "
bitfld.long 0 16.--19. " RXSIZE "  " "
bitfld.long 0 20. " RXDPB "  "0 ,1 "
tree.end

base sd:0xa03e0064
tree "FIFOADDR"
group 0--3
line.long 0 "FIFOADDR"
bitfld.long 0 0.--12. " TXAD "  " "
bitfld.long 0 16.--28. " RXAD "  " "
tree.end

base sd:0xa03e0068
tree "VCNTL"
rgroup 0--3
line.long 0 "VCNTL"
bitfld.long 0 0.--7. " VCNTL "  " "
tree.end

base sd:0xa03e006c
tree "HWVER"
rgroup 0--3
line.long 0 "HWVER"
bitfld.long 0 0.--9. " VMIN "  " "
bitfld.long 0 10.--14. " VMAJ "  " "
bitfld.long 0 15. " RC "  "0 ,1 "
tree.end

base sd:0xa03e0070
tree "ULPI_1"
group 0--3
line.long 0 "ULPI_1"
bitfld.long 0 0.--7. " UVBCTRL "  " "
bitfld.long 0 8.--15. " UCKIT "  " "
bitfld.long 0 16.--23. " UINTMASK "  " "
bitfld.long 0 24.--31. " UINT "  " "
tree.end

base sd:0xa03e0074
tree "ULPI_2"
group 0--3
line.long 0 "ULPI_2"
bitfld.long 0 0.--7. " UREGDATA "  " "
bitfld.long 0 8.--15. " UREGADDR "  " "
bitfld.long 0 16.--23. " UREGCTRL "  " "
bitfld.long 0 24.--31. " URAWDATA "  " "
tree.end

base sd:0xa03e0078
tree "INFO_REG"
rgroup 0--3
line.long 0 "INFO_REG"
bitfld.long 0 0.--7. " EPINFO "  " "
bitfld.long 0 8.--15. " RAMINFO "  " "
bitfld.long 0 16.--23. " LINKINFO "  " "
bitfld.long 0 24.--31. " VPLEN "  " "
tree.end

base sd:0xa03e007c
tree "EOF_REG"
group 0--3
line.long 0 "EOF_REG"
bitfld.long 0 0.--7. " HSEOF "  " "
bitfld.long 0 8.--15. " FSEOF "  " "
bitfld.long 0 16.--23. " LSEOF "  " "
bitfld.long 0 24.--25. " SRST "  " "
tree.end

base sd:0xa03e0100
tree "EP0_TXCSR0"
group 0--3
line.long 0 "EP0_TXCSR0"
bitfld.long 0 16.--31. " TXCSR0 "  " "
tree.end

base sd:0xa03e0108
tree "EP0_COUNT0"
rgroup 0--3
line.long 0 "EP0_COUNT0"
bitfld.long 0 0.--6. " RXCOUNT "  " "
tree.end

base sd:0xa03e010c
tree "EP0_CFD"
rgroup 0--3
line.long 0 "EP0_CFD"
bitfld.long 0 24. " UI "  "0 ,1 "
bitfld.long 0 25. " SC "  "0 ,1 "
bitfld.long 0 26. " DYNF "  "0 ,1 "
bitfld.long 0 27. " HBTXE "  "0 ,1 "
bitfld.long 0 28. " HBRXE "  "0 ,1 "
bitfld.long 0 29. " BE "  "0 ,1 "
bitfld.long 0 30. " MPTXE "  "0 ,1 "
bitfld.long 0 31. " MPRXE "  "0 ,1 "
tree.end

base sd:0xa03e0110
tree "EP1_TXCSR_MAXP"
group 0--3
line.long 0 "EP1_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0114
tree "EP1_RXCSR_MAXP"
group 0--3
line.long 0 "EP1_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0118
tree "EP1_RXCOUNT"
rgroup 0--3
line.long 0 "EP1_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base sd:0xa03e011c
tree "EP1_FIFOSZ"
rgroup 0--3
line.long 0 "EP1_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  " "
bitfld.long 0 28.--31. " RXSZ "  " "
tree.end

base sd:0xa03e0120
tree "EP2_TXCSR_MAXP"
group 0--3
line.long 0 "EP2_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0124
tree "EP2_RXCSR_MAXP"
group 0--3
line.long 0 "EP2_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0128
tree "EP2_RXCOUNT"
rgroup 0--3
line.long 0 "EP2_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base sd:0xa03e012c
tree "EP2_FIFOSZ"
rgroup 0--3
line.long 0 "EP2_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  " "
bitfld.long 0 28.--31. " RXSZ "  " "
tree.end

base sd:0xa03e0130
tree "EP3_TXCSR_MAXP"
group 0--3
line.long 0 "EP3_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0134
tree "EP3_RXCSR_MAXP"
group 0--3
line.long 0 "EP3_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0138
tree "EP3_RXCOUNT"
rgroup 0--3
line.long 0 "EP3_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base sd:0xa03e013c
tree "EP3_FIFOSZ"
rgroup 0--3
line.long 0 "EP3_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  " "
bitfld.long 0 28.--31. " RXSZ "  " "
tree.end

base sd:0xa03e0140
tree "EP4_TXCSR_MAXP"
group 0--3
line.long 0 "EP4_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0144
tree "EP4_RXCSR_MAXP"
group 0--3
line.long 0 "EP4_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0148
tree "EP4_RXCOUNT"
rgroup 0--3
line.long 0 "EP4_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base sd:0xa03e014c
tree "EP4_FIFOSZ"
rgroup 0--3
line.long 0 "EP4_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  " "
bitfld.long 0 28.--31. " RXSZ "  " "
tree.end

base sd:0xa03e0150
tree "EP5_TXCSR_MAXP"
group 0--3
line.long 0 "EP5_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0154
tree "EP5_RXCSR_MAXP"
group 0--3
line.long 0 "EP5_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0158
tree "EP5_RXCOUNT"
rgroup 0--3
line.long 0 "EP5_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base sd:0xa03e015c
tree "EP5_FIFOSZ"
rgroup 0--3
line.long 0 "EP5_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  " "
bitfld.long 0 28.--31. " RXSZ "  " "
tree.end

base sd:0xa03e0160
tree "EP6_TXCSR_MAXP"
group 0--3
line.long 0 "EP6_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0164
tree "EP6_RXCSR_MAXP"
group 0--3
line.long 0 "EP6_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0168
tree "EP6_RXCOUNT"
rgroup 0--3
line.long 0 "EP6_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base sd:0xa03e016c
tree "EP6_FIFOSZ"
rgroup 0--3
line.long 0 "EP6_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  " "
bitfld.long 0 28.--31. " RXSZ "  " "
tree.end

base sd:0xa03e0170
tree "EP7_TXCSR_MAXP"
group 0--3
line.long 0 "EP7_TXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " TRDY "  "0 ,1 "
bitfld.long 0 17. " FNE "  "0 ,1 "
bitfld.long 0 18. " UR "  "0 ,1 "
bitfld.long 0 19. " FF "  "0 ,1 "
bitfld.long 0 20. " SND "  "0 ,1 "
bitfld.long 0 21. " SNT "  "0 ,1 "
bitfld.long 0 22. " CLR "  "0 ,1 "
bitfld.long 0 23. " ITX "  "0 ,1 "
bitfld.long 0 26. " DMD "  "0 ,1 "
bitfld.long 0 27. " FDT "  "0 ,1 "
bitfld.long 0 28. " DMR "  "0 ,1 "
bitfld.long 0 29. " MD "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0174
tree "EP7_RXCSR_MAXP"
group 0--3
line.long 0 "EP7_RXCSR_MAXP"
bitfld.long 0 0.--10. " MAXP "  " "
bitfld.long 0 11.--15. " MULT "  " "
bitfld.long 0 16. " RRDY "  "0 ,1 "
bitfld.long 0 17. " FFUL "  "0 ,1 "
bitfld.long 0 18. " OR "  "0 ,1 "
bitfld.long 0 19. " ERR "  "0 ,1 "
bitfld.long 0 20. " FF "  "0 ,1 "
bitfld.long 0 21. " SND "  "0 ,1 "
bitfld.long 0 22. " SNT "  "0 ,1 "
bitfld.long 0 23. " CLR "  "0 ,1 "
bitfld.long 0 24. " IRX "  "0 ,1 "
bitfld.long 0 27. " DMD "  "0 ,1 "
bitfld.long 0 28. " DNY "  "0 ,1 "
bitfld.long 0 29. " DMR "  "0 ,1 "
bitfld.long 0 30. " ISO "  "0 ,1 "
bitfld.long 0 31. " ASET "  "0 ,1 "
tree.end

base sd:0xa03e0178
tree "EP7_RXCOUNT"
rgroup 0--3
line.long 0 "EP7_RXCOUNT"
bitfld.long 0 0.--12. " RXCOUNT "  " "
tree.end

base sd:0xa03e017c
tree "EP7_FIFOSZ"
rgroup 0--3
line.long 0 "EP7_FIFOSZ"
bitfld.long 0 24.--27. " TXSZ "  " "
bitfld.long 0 28.--31. " RXSZ "  " "
tree.end

base sd:0xa03e0204
tree "TOPCTRL"
group 0--3
line.long 0 "TOPCTRL"
bitfld.long 0 0. " ULPI_ON "  "0 ,1 "
bitfld.long 0 3. " XGATE "  "0 ,1 "
bitfld.long 0 4.--5. " FSINTF "  " "
bitfld.long 0 6. " HDEV "  "0 ,1 "
bitfld.long 0 7. " VP_DAT "  "0 ,1 "
bitfld.long 0 8. " USEL "  "0 ,1 "
bitfld.long 0 9. " I2C_OFF "  "0 ,1 "
bitfld.long 0 10. " VBUSLO "  "0 ,1 "
tree.end

base sd:0xa03e0208
tree "IRQMUX"
group 0--3
line.long 0 "IRQMUX"
bitfld.long 0 0.--7. " INTRX "  " "
bitfld.long 0 8.--15. " INTTX "  " "
tree.end

base sd:0xa03e0300
tree "EP0_RQPKTCOUNT"
group 0--3
line.long 0 "EP0_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0304
tree "EP1_RQPKTCOUNT"
group 0--3
line.long 0 "EP1_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0308
tree "EP2_RQPKTCOUNT"
group 0--3
line.long 0 "EP2_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e030c
tree "EP3_RQPKTCOUNT"
group 0--3
line.long 0 "EP3_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0310
tree "EP4_RQPKTCOUNT"
group 0--3
line.long 0 "EP4_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0314
tree "EP5_RQPKTCOUNT"
group 0--3
line.long 0 "EP5_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0318
tree "EP6_RQPKTCOUNT"
group 0--3
line.long 0 "EP6_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e031c
tree "EP7_RQPKTCOUNT"
group 0--3
line.long 0 "EP7_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0320
tree "EP8_RQPKTCOUNT"
group 0--3
line.long 0 "EP8_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0324
tree "EP9_RQPKTCOUNT"
group 0--3
line.long 0 "EP9_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0328
tree "EP10_RQPKTCOUNT"
group 0--3
line.long 0 "EP10_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e032c
tree "EP11_RQPKTCOUNT"
group 0--3
line.long 0 "EP11_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0330
tree "EP12_RQPKTCOUNT"
group 0--3
line.long 0 "EP12_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0334
tree "EP13_RQPKTCOUNT"
group 0--3
line.long 0 "EP13_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0338
tree "EP14_RQPKTCOUNT"
group 0--3
line.long 0 "EP14_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e033c
tree "EP15_RQPKTCOUNT"
group 0--3
line.long 0 "EP15_RQPKTCOUNT"
bitfld.long 0 0.--15. " RQPKTCOUNT "  " "
tree.end

base sd:0xa03e0340
tree "DPKTBUFDIS"
group 0--3
line.long 0 "DPKTBUFDIS"
bitfld.long 0 0.--15. " EP_RXDIS "  " "
bitfld.long 0 16.--31. " EP_TXDIS "  " "
tree.end

base sd:0xa03e0344
tree "C_T_CTRL"
group 0--3
line.long 0 "C_T_CTRL"
bitfld.long 0 0.--15. " C_T_UCH_CTRL "  " "
bitfld.long 0 16.--31. " C_T_HSRTN_CTRL "  " "
tree.end

tree.end

