;SIA macrocell peripherals

width 42


;begin include file crm.h


base a:0xa0254a00
tree "CRM"

  group.long 0x00++0x3
  line.long 0x0 "CRM_EN_CLK_SD_HISPEED"
    textline ""
    bitfld.long 0x0 0. "    EN_CLK_SD_HISPEED_T1_STBUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    EN_CLK_SD_HISPEED_DATA  " "0,1"

  group.long 0x04++0x3
  line.long 0x0 "CRM_EN_CLK_SD_LOSPEED"
    textline ""
    bitfld.long 0x0 0. "    EN_CLK_SD_LOSPEED_T1_STBUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    EN_CLK_SD_LOSPEED_DATA  " "0,1"

  group.long 0x08++0x3
  line.long 0x0 "CRM_EN_CLK_PIPE"
    textline ""
    bitfld.long 0x0 0. "    EN_CLK_PIPE_T1_STBUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    EN_CLK_PIPE_RE_DATA  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    EN_CLK_PIPE_DMCE_DATA  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    EN_CLK_PIPE_CE0_DATA  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    EN_CLK_PIPE_CE1_DATA  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    EN_CLK_PIPE_STATS_DATA  " "0,1"

  group.long 0x0C++0x3
  line.long 0x0 "CRM_EN_CLK_BML"
    textline ""
    bitfld.long 0x0 0. "    EN_CLK_BML  " "0,1"

  group.long 0x10++0x3
  line.long 0x0 "CRM_EN_CLK_BMS"
    textline ""
    bitfld.long 0x0 0. "    EN_CLK_BMS  " "0,1"

  group.long 0x14++0x3
  line.long 0x0 "CRM_EN_CLK_PIPE_IN"
    textline ""
    bitfld.long 0x0 0. "    EN_CLK_PIPE_IN  " "0,1"

  group.long 0x18++0x3
  line.long 0x0 "CRM_EN_CLK_PICTOR_GPIO"
    textline ""
    bitfld.long 0x0 0. "    EN_CLK_PICTOR_GPIO  " "0,1"

  group.long 0x1C++0x3
  line.long 0x0 "CRM_CLK_PIPE_IN_DIV"
    textline ""
    hexmask.long 0x0 0.--4. 1 "    CLK_PIPE_IN_DIV  "

  group.long 0x20++0x3
  line.long 0x0 "CRM_CLK_HOST_IPP_DIV"
    textline ""
    hexmask.long 0x0 0.--6. 1 "    CLK_HOST_IPP_DIV  "

  group.long 0x24++0x3
  line.long 0x0 "CRM_CLK_PICTOR_GPIO_DIV"
    textline ""
    hexmask.long 0x0 0.--6. 1 "    CLK_PICTOR_GPIO_DIV  "

  group.long 0x28++0x3
  line.long 0x0 "CRM_STATIC_SD_CCP_PIXEL_CLOCK_DIV"
    textline ""
    hexmask.long 0x0 0.--4. 1 "    STATIC_SD_CCP_PIXEL_CLOCK_DIV  "

  group.long 0x2C++0x3
  line.long 0x0 "CRM_STATIC_CLK_SD_HISPEED_SOURCE_SEL"
    textline ""
    bitfld.long 0x0 0.--1. "    STATIC_CLK_SD_HISPEED_SOURCE_SEL  " "B_0x0,B_0x1"

  group.long 0x30++0x3
  line.long 0x0 "CRM_STATIC_CLK_SD_LOSPEED_SOURCE_SEL"
    textline ""
    bitfld.long 0x0 0.--1. "    STATIC_CLK_SD_LOSPEED_SOURCE_SEL  " "B_0x0,B_0x1"

  group.long 0x34++0x3
  line.long 0x0 "CRM_STATIC_CLK_PIPE_SOURCE_SEL"
    textline ""
    bitfld.long 0x0 0.--1. "    STATIC_CLK_PIPE_SOURCE_SEL  " "B_0x0,B_0x1"

  group.long 0x38++0x3
  line.long 0x0 "CRM_STATIC_CLK_BMS_SOURCE_SEL"
    textline ""
    bitfld.long 0x0 0.--1. "    STATIC_CLK_BMS_SOURCE_SEL  " "B_0x0,B_0x1"

  group.long 0x3C++0x3
  line.long 0x0 "CRM_STATIC_CLK_PICTOR_GPIO_SOURCE_SEL"
    textline ""
    bitfld.long 0x0 0.--1. "    STATIC_CLK_PICTOR_GPIO_SOURCE_SEL  " "B_0x0,B_0x1"

  group.long 0x50++0x3
  line.long 0x0 "CRM_EMUL_SENSOR_CLOCK"
    textline ""
    bitfld.long 0x0 0. "    EMUL_SENSOR_CLOCK  " "0,1"

  group.long 0x54++0x3
  line.long 0x0 "DEPRECATED1"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    DEPRECATED  "

  group.long 0x58++0x3
  line.long 0x0 "DEPRECATED2"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    DEPRECATED  "

  group.long 0x5C++0x3
  line.long 0x0 "CRM_CHECKER_ITS"
    textline ""
    bitfld.long 0x0 0. "    CKC_OK_ITS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    CKC_LOST_ITS  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    CKC_OK_3D_ITS  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    CKC_LOST_3D_ITS  " "0,1"

  group.long 0x60++0x3
  line.long 0x0 "CRM_CHECKER_ITS_BCLR"
    textline ""
    bitfld.long 0x0 0. "    CKC_OK_ITS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    CKC_LOST_ITS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    CKC_OK_3D_ITS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    CKC_LOST_3D_ITS_BCLR  " "0,1"

  group.long 0x64++0x3
  line.long 0x0 "CRM_CHECKER_ITS_BSET"
    textline ""
    bitfld.long 0x0 0. "    CKC_OK_ITS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    CKC_LOST_ITS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    CKC_OK_3D_ITS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    CKC_LOST_3D_ITS_BSET  " "0,1"

  group.long 0x68++0x3
  line.long 0x0 "CRM_CHECKER_ITM"
    textline ""
    bitfld.long 0x0 0. "    CKC_OK_ITM  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    CKC_LOST_ITM  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    CKC_OK_3D_ITM  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    CKC_LOST_3D_ITM  " "0,1"

  group.long 0x6C++0x3
  line.long 0x0 "CRM_CHECKER_ITM_BCLR"
    textline ""
    bitfld.long 0x0 0. "    CKC_OK_ITM_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    CKC_LOST_ITM_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    CKC_OK_3D_ITM_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    CKC_LOST_3D_ITM_BCLR  " "0,1"

  group.long 0x70++0x3
  line.long 0x0 "CRM_CHECKER_ITM_BSET"
    textline ""
    bitfld.long 0x0 0. "    CKC_OK_ITM_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    CKC_LOST_ITM_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    CKC_OK_3D_ITM_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    CKC_LOST_3D_ITM_BSET  " "0,1"

  group.long 0x74++0x3
  line.long 0x0 "CRM_CHECKER_DETECT_WDW"
    textline ""
    hexmask.long 0x0 0.--10. 1 "    CKC_DETECT_WDW  "

  group.long 0x78++0x3
  line.long 0x0 "CRM_EMUL_SENSOR_CLOCK_3D"
    textline ""
    bitfld.long 0x0 0. "    EMUL_SENSOR_CLOCK_3D  " "0,1"

  group.long 0x80++0x3
  line.long 0x0 "CRM_EN_CLK_SD_3D_HISPEED"
    textline ""
    bitfld.long 0x0 0. "    EN_CLK_SD_3D_HISPEED_T1_STBUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    EN_CLK_SD_3D_HISPEED_DATA  " "0,1"

  group.long 0x84++0x3
  line.long 0x0 "CRM_STATIC_CLK_SD_3D_HISPEED_SOURCE_SEL"
    textline ""
    bitfld.long 0x0 0.--1. "    STATIC_CLK_SD_3D_HISPEED_SOURCE_SEL  " "B_0x0,B_0x1"

  group.long 0x88++0x3
  line.long 0x0 "CRM_STATIC_BMS_CSI2_SEL"
    textline ""
    bitfld.long 0x0 0. "    STATIC_BMS_CSI2_SEL  " "B_0x0,B_0x1"

  group.long 0x90++0x3
  line.long 0x0 "CRM_CLK_SD_HISPEED_SOURCE_STATUS"
    textline ""
    bitfld.long 0x0 0.--1. "    CRM_CLK_SD_HISPEED_SELECTED_SOURCE_STATUS  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    hexmask.long 0x0 8.--10. 1 "    CRM_CLK_SD_HISPEED_ENABLED_SOURCE_STATUS  "

  group.long 0x94++0x3
  line.long 0x0 "CRM_CLK_SD_LOSPEED_SOURCE_STATUS"
    textline ""
    bitfld.long 0x0 0.--1. "    CRM_CLK_SD_LOSPEED_SELECTED_SOURCE_STATUS  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    hexmask.long 0x0 8.--10. 1 "    CRM_CLK_SD_LOSPEED_ENABLED_SOURCE_STATUS  "

  group.long 0x98++0x3
  line.long 0x0 "CRM_CLK_PIPE_SOURCE_STATUS"
    textline ""
    bitfld.long 0x0 0.--1. "    CRM_CLK_PIPE_SELECTED_SOURCE_STATUS  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    hexmask.long 0x0 8.--10. 1 "    CRM_CLK_PIPE_ENABLED_SOURCE_STATUS  "

  group.long 0x9C++0x3
  line.long 0x0 "CRM_CLK_BMS_SOURCE_STATUS"
    textline ""
    bitfld.long 0x0 0.--1. "    CRM_CLK_BMS_SELECTED_SOURCE_STATUS  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    hexmask.long 0x0 8.--10. 1 "    CRM_CLK_BMS_ENABLED_SOURCE_STATUS  "

  group.long 0xA0++0x3
  line.long 0x0 "CRM_CLK_PICTOR_GPIO_SOURCE_STATUS"
    textline ""
    bitfld.long 0x0 0.--1. "    CRM_CLK_PICTOR_GPIO_SELECTED_SOURCE_STATUS  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    hexmask.long 0x0 8.--10. 1 "    CRM_CLK_PICTOR_GPIO_ENABLED_SOURCE_STATUS  "

  group.long 0xA4++0x3
  line.long 0x0 "CRM_CLK_SD_3D_HISPEED_SOURCE_STATUS"
    textline ""
    bitfld.long 0x0 0.--1. "    CRM_CLK_SD_3D_HISPEED_SELECTED_SOURCE_STATUS  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    hexmask.long 0x0 8.--10. 1 "    CRM_CLK_SD_3D_HISPEED_ENABLED_SOURCE_STATUS  "

tree.end


;end include file crm.h


;begin include file dma.h


base a:0xa0254400
tree "DMA"

  group.word 0x00++0x1
  line.word 0x0 "DMA_ENR"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    IRP03_GCF_L_R  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    IRP03_VCP_W  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    IRP03_HCP_W  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    IRP03_HCP_R  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    IRP0_PRA_R  " "0,1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "0,1"

  group.word 0x02++0x1
  line.word 0x0 "DMA_DIR"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    IRP03_GCF_L_R  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    IRP03_VCP_W  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    IRP03_HCP_W  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    IRP03_HCP_R  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    IRP0_PRA_R  " "0,1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "0,1"

  group.word 0x04++0x1
  line.word 0x0 "DMA_PEN"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "B_0x0,B_0x1"

  group.word 0x06++0x1
  line.word 0x0 "DMA_INTERLACE_EN"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 6. "    IRP03_GCF_L_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 12. "    IRP0_PRA_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "B_0x0,B_0x1"

  group.word 0x10++0x1
  line.word 0x0 "DMA_ITS1"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 6. "    IRP03_GCF_L_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 8. "    IRP03_VCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 9. "    IRP03_HCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 10. "    IRP03_HCP_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 12. "    IRP0_PRA_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "B_0x0,B_0x1"

  group.word 0x12++0x1
  line.word 0x0 "DMA_ITS1_BCLR"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    IRP03_GCF_L_R  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    IRP03_VCP_W  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    IRP03_HCP_W  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    IRP03_HCP_R  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    IRP0_PRA_R  " "0,1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "0,1"

  group.word 0x16++0x1
  line.word 0x0 "DMA_IMR1"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 6. "    IRP03_GCF_L_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 8. "    IRP03_VCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 9. "    IRP03_HCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 10. "    IRP03_HCP_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 12. "    IRP0_PRA_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "B_0x0,B_0x1"

  group.word 0x20++0x1
  line.word 0x0 "DMA_ITS2"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 6. "    IRP03_GCF_L_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 8. "    IRP03_VCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 9. "    IRP03_HCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 10. "    IRP03_HCP_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 12. "    IRP0_PRA_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "B_0x0,B_0x1"

  group.word 0x22++0x1
  line.word 0x0 "DMA_ITS2_BCLR"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    IRP03_GCF_L_R  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    IRP03_VCP_W  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    IRP03_HCP_W  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    IRP03_HCP_R  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    IRP0_PRA_R  " "0,1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "0,1"

  group.word 0x24++0x1
  line.word 0x0 "DMA_IMR2"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 6. "    IRP03_GCF_L_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 8. "    IRP03_VCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 9. "    IRP03_HCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 10. "    IRP03_HCP_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 12. "    IRP0_PRA_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "B_0x0,B_0x1"

  group.word 0x30++0x1
  line.word 0x0 "DMA_SOFT_RST"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    IRP03_GCF_L_R  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    IRP03_VCP_W  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    IRP03_HCP_W  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    IRP03_HCP_R  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    IRP0_PRA_R  " "0,1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "0,1"

  group.word 0x32++0x1
  line.word 0x0 "DMA_FIFO_STA"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 8. "    IRP03_VCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 9. "    IRP03_HCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "B_0x0,B_0x1"

  group.word 0x34++0x1
  line.word 0x0 "DMA_FIFO_FLUSH"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "0,1"

  group.word 0x40++0x1
  line.word 0x0 "DMA_IRP03_DLS_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP03_DLS_L  "

  group.word 0x42++0x1
  line.word 0x0 "DMA_IRP03_DLS_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP03_DLS_H  "

  group.word 0x44++0x1
  line.word 0x0 "DMA_IRP03_DCS_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP03_DCS_L  "

  group.word 0x46++0x1
  line.word 0x0 "DMA_IRP03_DCS_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP03_DCS_H  "

  group.word 0x48++0x1
  line.word 0x0 "DMA_IRP03_CLS_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP03_CLS_L  "

  group.word 0x4A++0x1
  line.word 0x0 "DMA_IRP03_CLS_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP03_CLS_H  "

  group.word 0x4C++0x1
  line.word 0x0 "DMA_IRP03_CCS_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP03_CCS_L  "

  group.word 0x4E++0x1
  line.word 0x0 "DMA_IRP03_CCS_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP03_CCS_H  "

  group.word 0x50++0x1
  line.word 0x0 "DMA_IRP03_DC1S_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP03_DC1S_L  "

  group.word 0x52++0x1
  line.word 0x0 "DMA_IRP03_DC1S_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP03_DC1S_H  "

  group.word 0x54++0x1
  line.word 0x0 "DMA_IRP03_DC2S_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP03_DC2S_L  "

  group.word 0x56++0x1
  line.word 0x0 "DMA_IRP03_DC2S_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP03_DC2S_H  "

  group.word 0x58++0x1
  line.word 0x0 "DMA_IRP3_DRS_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP3_DRS_L  "

  group.word 0x5A++0x1
  line.word 0x0 "DMA_IRP3_DRS_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP3_DRS_H  "

  group.word 0x60++0x1
  line.word 0x0 "DMA_IRP03_HPS_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP03_HPS_L  "

  group.word 0x62++0x1
  line.word 0x0 "DMA_IRP03_HPS_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP03_HPS_H  "

  group.word 0x64++0x1
  line.word 0x0 "DMA_IRP03_VPS_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP03_VPS_L  "

  group.word 0x66++0x1
  line.word 0x0 "DMA_IRP03_VPS_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP03_VPS_H  "

  group.word 0x68++0x1
  line.word 0x0 "DMA_IRP3_JPGS_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP03_VPS_L  "

  group.word 0x6A++0x1
  line.word 0x0 "DMA_IRP3_JPGS_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP03_VPS_H  "

  group.word 0x6C++0x1
  line.word 0x0 "DMA_IRP03_DFW"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP03_DFW  "

  group.word 0x6E++0x1
  line.word 0x0 "DMA_IRP03_DWW"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP03_DWW  "

  group.word 0x70++0x1
  line.word 0x0 "DMA_IRP03_DWH"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP03_DWH  "

  group.word 0x72++0x1
  line.word 0x0 "DMA_IRP3_JPG_DBS_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP3_JPG_DBS_L  "

  group.word 0x74++0x1
  line.word 0x0 "DMA_IRP3_JPG_DBS_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP3_JPG_DBS_H  "

  group.word 0x76++0x1
  line.word 0x0 "DMA_IRP03_CFC"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "B_0x0,B_0x1"

  group.word 0x78++0x1
  line.word 0x0 "DMA_IRP03_RASTER"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "B_0x0,B_0x1"

  group.word 0x7A++0x1
  line.word 0x0 "DMA_IRP03_ROTATION"
    textline ""
    bitfld.word 0x0 0.--1. "    ROTATION  " "B_0x0,B_0x1,,B_0x3"

  group.word 0x80++0x1
  line.word 0x0 "DMA_IRP0_SRS_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP0_SRS_L  "

  group.word 0x82++0x1
  line.word 0x0 "DMA_IRP0_SRS_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP0_SRS_H  "

  group.word 0x84++0x1
  line.word 0x0 "DMA_IRP0_SFW"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP0_SFW  "

  group.word 0x86++0x1
  line.word 0x0 "DMA_IRP0_SWW"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP0_SWW  "

  group.word 0x88++0x1
  line.word 0x0 "DMA_IRP0_SWH"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP0_SWH  "

  group.word 0x90++0x1
  line.word 0x0 "DMA_IRP1_DRS_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP1_DRS_L  "

  group.word 0x92++0x1
  line.word 0x0 "DMA_IRP1_DRS_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP1_DRS_H  "

  group.word 0x94++0x1
  line.word 0x0 "DMA_IRP1_DFW"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP1_DFW  "

  group.word 0x96++0x1
  line.word 0x0 "DMA_IRP1_DWW"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP1_DWW  "

  group.word 0x98++0x1
  line.word 0x0 "DMA_IRP1_DWH"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP1_DWH  "

  group.word 0xA0++0x1
  line.word 0x0 "DMA_IRP2_DRS_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP2_DRS_L  "

  group.word 0xA2++0x1
  line.word 0x0 "DMA_IRP2_DRS_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP2_DRS_H  "

  group.word 0xA4++0x1
  line.word 0x0 "DMA_IRP2_DFW"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP2_DFW  "

  group.word 0xA6++0x1
  line.word 0x0 "DMA_IRP2_DWW"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    DMA_IRP2_DWW  "

  group.word 0xA8++0x1
  line.word 0x0 "DMA_IRP2_DWH"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    DMA_IRP2_DWH  "

  group.word 0xB0++0x1
  line.word 0x0 "DMA_TST_CID"
    textline ""
    hexmask.word 0x0 0.--4. 1 "    DMA_TST_CID  "

  group.word 0xB4++0x1
  line.word 0x0 "DMA_TST_SADD_L"
    textline ""
    hexmask.word 0x0 3.--15. 1 "    CURADDR_L  "

  group.word 0xB6++0x1
  line.word 0x0 "DMA_TST_SADD_H"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    CURADDR_H  "

tree.end


;end include file dma.h


;begin include file ipp.h


base a:0xa0254800
tree "IPP"

  group.word 0x00++0x1
  line.word 0x0 "IPP_DPHY_TOP_IF_EN"
    textline ""
    bitfld.word 0x0 0. "    DPHY_TOP_IF_EN  " "0,1"

  group.word 0x02++0x1
  line.word 0x0 "IPP_STATIC_TOP_IF_SEL"
    textline ""
    bitfld.word 0x0 0.--1. "    STATIC_TOP_IF_SEL  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "IPP_STATIC_CCP_IF"
    textline ""
    bitfld.word 0x0 0. "    STATIC_CCP_DSCLK  " "B_0x0,B_0x1"
    textline ""
    hexmask.word 0x0 8.--11. 1 "    STATIC_CCP_BPP  "

  group.word 0x06++0x1
  line.word 0x0 "IPP_INTERNAL_EN_CLK_CCP"
    textline ""
    bitfld.word 0x0 0. "    INTERNAL_EN_CLK_CCP  " "B_0x0,B_0x1"

  group.word 0x08++0x1
  line.word 0x0 "IPP_DPHY_COMPENSATION_CTRL"
    textline ""
    bitfld.word 0x0 0. "    CLK_1_5M_COMPENSATION_EN  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    DPHY_COMPENSATION_START  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    DPHY_COMPENSATION_CALIB_WRITE_EN  " "0,1"
    textline ""
    hexmask.word 0x0 3.--5. 1 "    DPHY_COMPENSATION_CALIB_WRITE_CODE  "

  group.word 0x0A++0x1
  line.word 0x0 "IPP_DPHY_COMPENSATION_STATUS"
    textline ""
    bitfld.word 0x0 0. "    DPHY_COMPENSATION_OK  " "0,1"
    textline ""
    hexmask.word 0x0 1.--3. 1 "    DPHY_COMPENSATION_CALIB_READ_CODE  "
    textline ""
    bitfld.word 0x0 4. "    DPHY_COMPENSATION_DBG_COMP_FLAG  " "0,1"

  group.word 0x0C++0x1
  line.word 0x0 "IPP_STATIC_CSI0_DATA_LANES"
    textline ""
    bitfld.word 0x0 0.--1. "    STATIC_CSI0_DATA_LANES_NB  " ",B_0x1,B_0x2,B_0x3"
    textline ""
    hexmask.word 0x0 4.--12. 1 "    STATIC_CSI0_DATA_LANES_MAP  "

  group.word 0x0E++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_CL_CTRL"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    CSI0_UI_X4  "
    textline ""
    bitfld.word 0x0 8. "    CSI0_SPECS_90_81B  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    CSI0_SWAP_PINS_CL  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    CSI0_HS_INVERT_CL  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    CSI0_HSRX_TERM_SHIFT_UP_CL  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    CSI0_HSRX_TERM_SHIFT_DOWN_CL  " "0,1"
    textline ""
    bitfld.word 0x0 13. "    CSI0_TEST_RESERVED_1_CL  " "0,1"

  group.word 0x10++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_DL1_CTRL"
    textline ""
    bitfld.word 0x0 0. "    CSI0_SWAP_PINS_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CSI0_HS_INVERT_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CSI0_FORCE_RX_MODE_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    CSI0_CD_OFF_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    CSI0_EOT_BYPASS_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    CSI0_HSRX_TERM_SHIFT_UP_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    CSI0_HSRX_TERM_SHIFT_DOWN_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    CSI0_TEST_RESERVED_1_DL1  " "0,1"

  group.word 0x12++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_DL2_CTRL"
    textline ""
    bitfld.word 0x0 0. "    CSI0_SWAP_PINS_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CSI0_HS_INVERT_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CSI0_FORCE_RX_MODE_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    CSI0_CD_OFF_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    CSI0_EOT_BYPASS_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    CSI0_HSRX_TERM_SHIFT_UP_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    CSI0_HSRX_TERM_SHIFT_DOWN_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    CSI0_TEST_RESERVED_1_DL2  " "0,1"

  group.word 0x14++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_DL3_CTRL"
    textline ""
    bitfld.word 0x0 0. "    CSI0_SWAP_PINS_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CSI0_HS_INVERT_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CSI0_FORCE_RX_MODE_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    CSI0_CD_OFF_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    CSI0_EOT_BYPASS_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    CSI0_HSRX_TERM_SHIFT_UP_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    CSI0_HSRX_TERM_SHIFT_DOWN_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    CSI0_TEST_RESERVED_1_DL3  " "0,1"

  group.word 0x16++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_CL_DBG"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    CSI0_HS_RX_OFFSET_CL  "
    textline ""
    bitfld.word 0x0 3. "    CSI0_MIPI_IN_SHORT_CL  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI0_LP_HS_BYPASS_CL  " "0,1"
    textline ""
    hexmask.word 0x0 9.--10. 1 "    CSI0_LP_RX_VIL_CL  "
    textline ""
    bitfld.word 0x0 11. "    CSI0_DIRECT_DYN_ACCESS_CL  " "0,1"

  group.word 0x18++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_DL1_DBG"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    CSI0_HS_RX_OFFSET_DL1  "
    textline ""
    bitfld.word 0x0 3. "    CSI0_MIPI_IN_SHORT_DL1  " "0,1"
    textline ""
    hexmask.word 0x0 4.--6. 1 "    CSI0_SKEW_DL1  "
    textline ""
    bitfld.word 0x0 7. "    CSI0_OVERSAMPLE_BYPASS_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI0_LP_HS_BYPASS_DL1  " "0,1"
    textline ""
    hexmask.word 0x0 9.--10. 1 "    CSI0_LP_RX_VIL_DL1  "
    textline ""
    bitfld.word 0x0 11. "    CSI0_DIRECT_DYN_ACCES_DL1  " "0,1"

  group.word 0x1A++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_DL2_DBG"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    CSI0_HS_RX_OFFSET_DL2  "
    textline ""
    bitfld.word 0x0 3. "    CSI0_MIPI_IN_SHORT_DL2  " "0,1"
    textline ""
    hexmask.word 0x0 4.--6. 1 "    CSI0_SKEW_DL2  "
    textline ""
    bitfld.word 0x0 7. "    CSI0_OVERSAMPLE_BYPASS_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI0_LP_HS_BYPASS_DL2  " "0,1"
    textline ""
    hexmask.word 0x0 9.--10. 1 "    CSI0_LP_RX_VIL_DL2  "
    textline ""
    bitfld.word 0x0 11. "    CSI0_DIRECT_DYN_ACCESS_DL2  " "0,1"

  group.word 0x1C++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_DL3_DBG"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    CSI0_HS_RX_OFFSET_DL3  "
    textline ""
    bitfld.word 0x0 3. "    CSI0_MIPI_IN_SHORT_DL3  " "0,1"
    textline ""
    hexmask.word 0x0 4.--6. 1 "    CSI0_SKEW_DL3  "
    textline ""
    bitfld.word 0x0 7. "    CSI0_OVERSAMPLE_BYPASS_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI0_LP_HS_BYPASS_DL3  " "0,1"
    textline ""
    hexmask.word 0x0 9.--10. 1 "    CSI0_LP_RX_VIL_DL3  "
    textline ""
    bitfld.word 0x0 11. "    CSI0_DIRECT_DYN_ACCESS_DL3  " "0,1"

  group.word 0x1E++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_XL_DBG0_OBS"
    textline ""
    bitfld.word 0x0 0. "    CSI0_OVERSAMPLE_FLAG1_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CSI0_OVERSAMPLE_FLAG1_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CSI0_OVERSAMPLE_FLAG1_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    CSI0_OVERSAMPLE_FLAG2_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    CSI0_OVERSAMPLE_FLAG2_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    CSI0_OVERSAMPLE_FLAG2_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    CSI0_HS_RX_ZM_CL  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    CSI0_HS_RX_ZM_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI0_HS_RX_ZM_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    CSI0_HS_RX_ZM_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    CSI0_RX_INIT_CLK  " "0,1"

  group.word 0x20++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_XL_DBG1_OBS"
    textline ""
    bitfld.word 0x0 0. "    CSI0_STOP_STATE_CL  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CSI0_STOP_STATE_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CSI0_STOP_STATE_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    CSI0_STOP_STATE_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    CSI0_ULP_ACTIVE_NOT_CL  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    CSI0_ULP_ACTIVE_NOT_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    CSI0_ULP_ACTIVE_NOT_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    CSI0_ULP_ACTIVE_NOT_DL3  " "0,1"

  group.word 0x22++0x1
  line.word 0x0 "IPP_CSI2_DPHY1_CL_CTRL"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    CSI1_UI_X4  "
    textline ""
    bitfld.word 0x0 8. "    CSI1_SPECS_90_81B  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    CSI1_SWAP_PINS_CL  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    CSI1_HS_INVERT_CL  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    CSI1_HSRX_TERM_SHIFT_UP_CL  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    CSI1_HSRX_TERM_SHIFT_DOWN_CL  " "0,1"
    textline ""
    bitfld.word 0x0 13. "    CSI1_TEST_RESERVED_1_CL  " "0,1"

  group.word 0x24++0x1
  line.word 0x0 "IPP_CSI2_DPHY1_DL1_CTRL"
    textline ""
    bitfld.word 0x0 0. "    CSI1_SWAP_PINS_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CSI1_HS_INVERT_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CSI1_FORCE_RX_MODE_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    CSI1_CD_OFF_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    CSI1_EOT_BYPASS_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    CSI1_HSRX_TERM_SHIFT_UP_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    CSI1_HSRX_TERM_SHIFT_DOWN_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    CSI1_TEST_RESERVED_1_DL1  " "0,1"

  group.word 0x26++0x1
  line.word 0x0 "IPP_CSI2_DPHY1_CL_DBG"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    CSI1_HS_RX_OFFSET_CL  "
    textline ""
    bitfld.word 0x0 3. "    CSI1_MIPI_IN_SHORT_CL  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI1_LP_HS_BYPASS_CL  " "0,1"
    textline ""
    hexmask.word 0x0 9.--10. 1 "    CSI1_LP_RX_VIL_CL  "
    textline ""
    bitfld.word 0x0 11. "    CSI1_DIRECT_DYN_ACCESS_CL  " "0,1"

  group.word 0x28++0x1
  line.word 0x0 "IPP_CSI2_DPHY1_DL1_DBG"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    CSI1_HS_RX_OFFSET_DL1  "
    textline ""
    bitfld.word 0x0 3. "    CSI1_MIPI_IN_SHORT_DL1  " "0,1"
    textline ""
    hexmask.word 0x0 4.--6. 1 "    CSI1_SKEW_DL1  "
    textline ""
    bitfld.word 0x0 7. "    CSI1_OVERSAMPLE_BYPASS_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI1_LP_HS_BYPASS_DL1  " "0,1"
    textline ""
    hexmask.word 0x0 9.--10. 1 "    CSI1_LP_RX_VIL_DL1  "
    textline ""
    bitfld.word 0x0 11. "    CSI1_DIRECT_DYN_ACCESS_DL1  " "0,1"

  group.word 0x2A++0x1
  line.word 0x0 "IPP_CSI2_DPHY1_XL_DBG_OBS"
    textline ""
    bitfld.word 0x0 0. "    CSI1_OVERSAMPLE_FLAG1_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CSI1_OVERSAMPLE_FLAG2_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CSI1_HS_RX_ZM_CL  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    CSI1_HS_RX_ZM_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    CSI1_RX_INIT_CLK  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI1_STOP_STATE_CL  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    CSI1_STOP_STATE_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    CSI1_ULP_ACTIVE_NOT_CL  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    CSI1_ULP_ACTIVE_NOT_DL1  " "0,1"

  group.word 0x2C++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_DBG_ITS"
    textline ""
    bitfld.word 0x0 0. "    CSI0_ERR_ESC_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CSI0_ERR_ESC_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CSI0_ERR_ESC_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    CSI0_ERR_SYNC_ESC_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    CSI0_ERR_SYNC_ESC_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    CSI0_ERR_SYNC_ESC_DL3  " "0,1"

  group.word 0x2E++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_DBG_ITS_BCLR"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    CSI0_DBG_ITS_BCLR  "

  group.word 0x30++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_DBG_ITS_BSET"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    CSI0_DBG_ITS_BSET  "

  group.word 0x32++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_DBG_ITM"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    CSI0_DBG_ITM  "

  group.word 0x34++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_DBG_ITM_BCLR"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    CSI0_DBG_ITM_BCLR  "

  group.word 0x36++0x1
  line.word 0x0 "IPP_CSI2_DPHY0_DBG_ITM_BSET"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    CSI0_DBG_ITM_BSET  "

  group.word 0x38++0x1
  line.word 0x0 "IPP_CSI2_DPHY1_DBG_ITS"
    textline ""
    bitfld.word 0x0 0. "    CSI1_ERR_ESC_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CSI1_ERR_SYNC_ESC_DL1  " "0,1"

  group.word 0x3A++0x1
  line.word 0x0 "IPP_CSI2_DPHY1_DBG_ITS_BCLR"
    textline ""
    hexmask.word 0x0 0.--1. 1 "    CSI1_DBG_ITS_BCLR  "

  group.word 0x3C++0x1
  line.word 0x0 "IPP_CSI2_DPHY1_DBG_ITS_BSET"
    textline ""
    hexmask.word 0x0 0.--1. 1 "    CSI1_DBG_ITS_BSET  "

  group.word 0x3E++0x1
  line.word 0x0 "IPP_CSI2_DPHY1_DBG_ITM"
    textline ""
    hexmask.word 0x0 0.--1. 1 "    CSI1_DBG_ITM  "

  group.word 0x40++0x1
  line.word 0x0 "IPP_CSI2_DPHY1_DBG_ITM_BCLR"
    textline ""
    hexmask.word 0x0 0.--1. 1 "    CSI1_DBG_ITM_BCLR  "

  group.word 0x42++0x1
  line.word 0x0 "IPP_CSI2_DPHY1_DBG_ITM_BSET"
    textline ""
    hexmask.word 0x0 0.--1. 1 "    CSI1_DBG_ITM_BSET  "

  group.word 0x44++0x1
  line.word 0x0 "IPP_CSI2_PACKET_DBG_ITS"
    textline ""
    bitfld.word 0x0 0. "    CSI2_PACKET_ECC_CORRECTED_DBG  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI2_3D_PACKET_ECC_CORRECTED_DBG  " "0,1"

  group.word 0x46++0x1
  line.word 0x0 "IPP_CSI2_PACKET_DBG_ITS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    CSI2_PACKET_DBG_ITS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI2_3D_PACKET_DBG_ITS_BCLR  " "0,1"

  group.word 0x48++0x1
  line.word 0x0 "IPP_CSI2_PACKET_DBG_ITS_BSET"
    textline ""
    bitfld.word 0x0 0. "    CSI2_PACKET_DBG_ITS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI2_3D_PACKET_DBG_ITS_BSET  " "0,1"

  group.word 0x4A++0x1
  line.word 0x0 "IPP_CSI2_PACKET_DBG_ITM"
    textline ""
    bitfld.word 0x0 0. "    CSI2_PACKET_DBG_ITM  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI2_3D_PACKET_DBG_ITM  " "0,1"

  group.word 0x4C++0x1
  line.word 0x0 "IPP_CSI2_PACKET_DBG_ITM_BCLR"
    textline ""
    bitfld.word 0x0 0. "    CSI2_PACKET_DBG_ITM_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI2_3D_PACKET_DBG_ITM_BCLR  " "0,1"

  group.word 0x4E++0x1
  line.word 0x0 "IPP_CSI2_PACKET_DBG_ITM_BSET"
    textline ""
    bitfld.word 0x0 0. "    CSI2_PACKET_DBG_ITM_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI2_3D_PACKET_DBG_ITM_BSET  " "0,1"

  group.word 0x50++0x1
  line.word 0x0 "DEPRECATED1"

  group.word 0x52++0x1
  line.word 0x0 "DEPRECATED2"

  group.word 0x54++0x1
  line.word 0x0 "DEPRECATED3"

  group.word 0x56++0x1
  line.word 0x0 "DEPRECATED4"

  group.word 0x58++0x1
  line.word 0x0 "DEPRECATED5"

  group.word 0x5A++0x1
  line.word 0x0 "DEPRECATED6"

  group.word 0x5C++0x1
  line.word 0x0 "IPP_CSI2_DPHY_ERROR_ITS"
    textline ""
    bitfld.word 0x0 0. "    CSI0_ERR_EOT_SYNC_HS_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CSI0_ERR_EOT_SYNC_HS_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CSI0_ERR_EOT_SYNC_HS_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    CSI0_ERR_SOT_HS_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    CSI0_ERR_SOT_HS_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    CSI0_ERR_SOT_HS_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    CSI0_ERR_SOT_SYNC_HS_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    CSI0_ERR_SOT_SYNC_HS_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI0_ERR_SOT_SYNC_HS_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    CSI0_ERR_CONTROL_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    CSI0_ERR_CONTROL_DL2  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    CSI0_ERR_CONTROL_DL3  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    CSI1_ERR_EOT_SYNC_HS_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 13. "    CSI1_ERR_SOT_HS_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 14. "    CSI1_ERR_SOT_SYNC_HS_DL1  " "0,1"
    textline ""
    bitfld.word 0x0 15. "    CSI1_ERR_CONTROL_DL1  " "0,1"

  group.word 0x5E++0x1
  line.word 0x0 "IPP_CSI2_DPHY_ERROR_ITS_BCLR"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    CSI_DPHY_ERROR_ITS_BCLR  "

  group.word 0x60++0x1
  line.word 0x0 "IPP_CSI2_DPHY_ERROR_ITS_BSET"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    CSI_DPHY_ERROR_ITS_BSET  "

  group.word 0x62++0x1
  line.word 0x0 "IPP_CSI2_DPHY_ERROR_ITM"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    CSI_DPHY_ERROR_ITM  "

  group.word 0x64++0x1
  line.word 0x0 "IPP_CSI2_DPHY_ERROR_ITM_BCLR"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    CSI_DPHY_ERROR_ITM_BCLR  "

  group.word 0x66++0x1
  line.word 0x0 "IPP_CSI2_DPHY_ERROR_ITM_BSET"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    CSI_DPHY_ERROR_ITM_BSET  "

  group.word 0x68++0x1
  line.word 0x0 "IPP_CSI2_PACKET_ERROR_ITS"
    textline ""
    bitfld.word 0x0 0. "    CSI2_PACKET_PAYLOAD_CRC_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CSI2_PACKET_HEADER_ECC_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CSI2_EOF  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CSI2_3D_PACKET_PAYLOAD_CRC_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    CSI2_3D_PACKET_HEADER_ECC_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    CSI2_3D_EOF  " "0,1"

  group.word 0x6A++0x1
  line.word 0x0 "IPP_CSI2_PACKET_ERROR_ITS_BCLR"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    CSI_PACKET_ERROR_ITS_BCLR  "
    textline ""
    hexmask.word 0x0 8.--10. 1 "    CSI_3D_PACKET_ERROR_ITS_BCLR  "

  group.word 0x6C++0x1
  line.word 0x0 "IPP_CSI2_PACKET_ERROR_ITS_BSET"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    CSI_PACKET_ERROR_ITS_BSET  "
    textline ""
    hexmask.word 0x0 8.--10. 1 "    CSI_3D_PACKET_ERROR_ITS_BSET  "

  group.word 0x6E++0x1
  line.word 0x0 "IPP_CSI2_PACKET_ERROR_ITM"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    CSI_PACKET_ERROR_ITM  "
    textline ""
    hexmask.word 0x0 8.--10. 1 "    CSI_3D_PACKET_ERROR_ITM  "

  group.word 0x70++0x1
  line.word 0x0 "IPP_CSI2_PACKET_ERROR_ITM_BCLR"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    CSI_PACKET_ERROR_ITM_BCLR  "
    textline ""
    hexmask.word 0x0 8.--10. 1 "    CSI_3D_PACKET_ERROR_ITM_BCLR  "

  group.word 0x72++0x1
  line.word 0x0 "IPP_CSI2_PACKET_ERROR_ITM_BSET"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    CSI_PACKET_ERROR_ITM_BSET  "
    textline ""
    hexmask.word 0x0 8.--10. 1 "    CSI_3D_PACKET_ERROR_ITM_BSET  "

  group.word 0x74++0x1
  line.word 0x0 "IPP_STATIC_OPIPE03_SEL"
    textline ""
    bitfld.word 0x0 0. "    STATIC_OPIPE03_SEL  " "0,1"

  group.word 0x80++0x1
  line.word 0x0 "IPP_ISP_ASYNC_RESET"

  group.word 0x82++0x1
  line.word 0x0 "IPP_SD_RESET"
    textline ""
    bitfld.word 0x0 0. "    ALL  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    BRML  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    SDI  " "0,1"

  group.word 0x84++0x1
  line.word 0x0 "IPP_SD_STATIC_CCP_EN"
    textline ""
    bitfld.word 0x0 0. "    STATIC_SD_CCP_EN  " "B_0x0,B_0x1"

  group.word 0x86++0x1
  line.word 0x0 "IPP_SD_STATIC_SDG_CSI_MODE"
    textline ""
    bitfld.word 0x0 0. "    STATIC_CDG_CSI_MODE  " "B_0x0,B_0x1"

  group.word 0x88++0x1
  line.word 0x0 "IPP_SD_PRY0_ENABLE_SET"

  group.word 0x8A++0x1
  line.word 0x0 "IPP_SD_PRY1_ENABLE_SET"

  group.word 0x8C++0x1
  line.word 0x0 "IPP_SD_PRY0_ENABLE_CLR"

  group.word 0x8E++0x1
  line.word 0x0 "IPP_SD_PRY1_ENABLE_CLR"

  group.word 0x90++0x1
  line.word 0x0 "IPP_SD_PRY0_ENABLE_STATUS"
    textline ""
    bitfld.word 0x0 0. "    PRY0_ENABLE_STATUS  " "0,1"

  group.word 0x92++0x1
  line.word 0x0 "IPP_SD_PRY1_ENABLE_STATUS"
    textline ""
    bitfld.word 0x0 0. "    PRY1_ENABLE_STATUS  " "0,1"

  group.word 0x94++0x1
  line.word 0x0 "IPP_SD_BMS_ENABLE_SET"

  group.word 0x96++0x1
  line.word 0x0 "IPP_SD_BMS_ENABLE_CLR"

  group.word 0x98++0x1
  line.word 0x0 "IPP_SD_BMS_ENABLE_STATUS"
    textline ""
    bitfld.word 0x0 0. "    BMS_ENABLE_STATUS  " "0,1"

  group.word 0x9A++0x1
  line.word 0x0 "IPP_SD_PRY0_FORMAT"
    textline ""
    bitfld.word 0x0 8.--11. "    PRY0_FORMAT  " ",B_0x1,B_0x2,,,,B_0x6,B_0x7,,,,,B_0xC,,B_0xE"

  group.word 0x9C++0x1
  line.word 0x0 "IPP_SD_PRY1_FORMAT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    PRY1_ALPHA  "
    textline ""
    bitfld.word 0x0 8.--11. "    PRY1_FORMAT  " ",B_0x1,,,,,,,B_0x8,B_0x9,B_0xA,,B_0xC,B_0xD"

  group.word 0x9E++0x1
  line.word 0x0 "IPP_SD_BMS_FORMAT"
    textline ""
    bitfld.word 0x0 0. "    BMS_RAW_FORMAT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1.--2. "    BMS_RAW_SEL  " "B_0x0,B_0x1,B_0x2,B_0x3"

  group.word 0xA0++0x1
  line.word 0x0 "IPP_SD_STATIC_MEM_LOAD_EN"
    textline ""
    bitfld.word 0x0 0. "    STATIC_MEM_LOAD_EN  " "0,1"

  group.word 0xA2++0x1
  line.word 0x0 "IPP_SD_STATIC_LOAD_FORMAT"
    textline ""
    bitfld.word 0x0 0.--1. "    STATIC_LOAD_FORMAT  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    bitfld.word 0x0 2. "    STATIC_LOAD_RAW_SEL  " "B_0x0,B_0x1"

  group.word 0xA4++0x1
  line.word 0x0 "IPP_SD_STATIC_LOAD_LINE_TIME_LSB_EN"
    textline ""
    bitfld.word 0x0 0. "    STATIC_INTERLINE_TIME_EN  " "0,1"
    textline ""
    hexmask.word 0x0 1.--15. 1 "    STATIC_INTERLINE_TIME_LSB  "

  group.word 0xA6++0x1
  line.word 0x0 "IPP_SD_STATIC_LOAD_LINE_TIME_MSB"
    textline ""
    hexmask.word 0x0 0.--4. 1 "    STATIC_INTERLINE_TIME_MSB  "

  group.word 0xA8++0x1
  line.word 0x0 "IPP_SD_STATIC_LOAD_WW"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    STATIC_LOAD_WW  "

  group.word 0xAA++0x1
  line.word 0x0 "IPP_SD_STATIC_LOAD_BML_PIXEL_ORDER"
    textline ""
    bitfld.word 0x0 0.--1. "    STATIC_LOAD_BML_PIXEL_ORDER  " "B_0x0,B_0x1,B_0x2,B_0x3"

  group.word 0xAC++0x1
  line.word 0x0 "IPP_SD_STATIC_LOAD_LINETYPE0"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    STATIC_LOAD_LINETYPE_HEIGHT0  "
    textline ""
    bitfld.word 0x0 12.--15. "    STATIC_LOAD_LINETYPE_ID0  " ",B_0x1,B_0x2,B_0x3,,,,,,,,,,,B_0xE"

  group.word 0xAE++0x1
  line.word 0x0 "IPP_SD_STATIC_LOAD_LINETYPE1"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    STATIC_LOAD_LINETYPE_HEIGHT1  "
    textline ""
    bitfld.word 0x0 12.--15. "    STATIC_LOAD_LINETYPE_ID1  " ",B_0x1,B_0x2,B_0x3,,,,,,,,,,,B_0xE"

  group.word 0xB0++0x1
  line.word 0x0 "IPP_SD_STATIC_LOAD_LINETYPE2"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    STATIC_LOAD_LINETYPE_HEIGHT2  "
    textline ""
    bitfld.word 0x0 12.--15. "    STATIC_LOAD_LINETYPE_ID2  " ",B_0x1,B_0x2,B_0x3,,,,,,,,,,,B_0xE"

  group.word 0xB2++0x1
  line.word 0x0 "IPP_SD_STATIC_LOAD_LINETYPE3"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    STATIC_LOAD_LINETYPE_HEIGHT3  "
    textline ""
    bitfld.word 0x0 12.--15. "    STATIC_LOAD_LINETYPE_ID3  " ",B_0x1,B_0x2,B_0x3,,,,,,,,,,,B_0xE"

  group.word 0xB4++0x1
  line.word 0x0 "IPP_SD_STATIC_LOAD_LINETYPE4"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    STATIC_LOAD_LINETYPE_HEIGHT4  "
    textline ""
    bitfld.word 0x0 12.--15. "    STATIC_LOAD_LINETYPE_ID4  " ",B_0x1,B_0x2,B_0x3,,,,,,,,,,,B_0xE"

  group.word 0xB6++0x1
  line.word 0x0 "IPP_SD_STATIC_LOAD_LINETYPE5"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    STATIC_LOAD_LINETYPE_HEIGHT5  "
    textline ""
    bitfld.word 0x0 12.--15. "    STATIC_LOAD_LINETYPE_ID5  " ",B_0x1,B_0x2,B_0x3,,,,,,,,,,,B_0xE"

  group.word 0xB8++0x1
  line.word 0x0 "IPP_SD_STATIC_LOAD_LINETYPE6"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    STATIC_LOAD_LINETYPE_HEIGHT6  "
    textline ""
    bitfld.word 0x0 12.--15. "    STATIC_LOAD_LINETYPE_ID6  " ",B_0x1,B_0x2,B_0x3,,,,,,,,,,,B_0xE"

  group.word 0xBA++0x1
  line.word 0x0 "IPP_SD_STATIC_LOAD_LINETYPE7"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    STATIC_LOAD_LINETYPE_HEIGHT7  "
    textline ""
    bitfld.word 0x0 12.--15. "    STATIC_LOAD_LINETYPE_ID7  " ",B_0x1,B_0x2,B_0x3,,,,,,,,,,,B_0xE"

  group.word 0xBC++0x1
  line.word 0x0 "IPP_SD_ERROR_ITS"
    textline ""
    bitfld.word 0x0 0. "    CCP_SHIFT_SYNC  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CCP_FALSE_SYNC  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CCP_CRC_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    OPIPE0_CH0_OVERFLOW  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    OPIPE0_CH1_OVERFLOW  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    OPIPE0_CH2_OVERFLOW  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    OPIPE1_OVERFLOW  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    OPIPE2_OVERFLOW  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    OPIPE0_MULT_ERR  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    OPIPE1_MULT_ERR  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    SD_CSI2_PACKET_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    SD_CSI2_DPHY_ERROR  " "0,1"

  group.word 0xBE++0x1
  line.word 0x0 "IPP_SD_ERROR_ITS_BCLR"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    SD_ERROR_ITS_BCLR  "

  group.word 0xC0++0x1
  line.word 0x0 "IPP_SD_ERROR_ITS_BSET"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    SD_ERROR_ITS_BSET  "

  group.word 0xC2++0x1
  line.word 0x0 "IPP_SD_ERROR_ITM"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    SD_ERROR_ITM  "

  group.word 0xC4++0x1
  line.word 0x0 "IPP_SD_ERROR_ITM_BCLR"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    SD_ERROR_ITM_BCLR  "

  group.word 0xC6++0x1
  line.word 0x0 "IPP_SD_ERROR_ITM_BSET"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    SD_ERROR_ITM_BSET  "

  group.word 0xC8++0x1
  line.word 0x0 "IPP_SD_OPIPE0_MULT_ERR_DBG"
    textline ""
    bitfld.word 0x0 0. "    OPIPE0_CH0_MULT_ERR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    OPIPE0_CH1_MULT_ERR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    OPIPE0_CH2_MULT_ERR  " "0,1"

  group.word 0xD0++0x1
  line.word 0x0 "IPP_CD_RESET"

  group.word 0xD2++0x1
  line.word 0x0 "IPP_CD_START"

  group.word 0xD4++0x1
  line.word 0x0 "IPP_CD_STATIC_EN"
    textline ""
    bitfld.word 0x0 0. "    STATIC_CD_EN  " "B_0x0,B_0x1"

  group.word 0xD6++0x1
  line.word 0x0 "IPP_CD_STATIC_CDG_CSI_PADD_EN"
    textline ""
    bitfld.word 0x0 0. "    STATIC_CDG_CSI_PADD_EN  " "B_0x0,B_0x1"

  group.word 0xD8++0x1
  line.word 0x0 "IPP_CD_STATIC_CCP_FC"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    STATIC_CCP_FS  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    STATIC_CCP_FE  "

  group.word 0xDA++0x1
  line.word 0x0 "IPP_CD_STATIC_CCP_LC"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    STATIC_CCP_LS  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    STATIC_CCP_LE  "

  group.word 0xDC++0x1
  line.word 0x0 "IPP_CD_RAW"
    textline ""
    bitfld.word 0x0 0. "    JPEG_PADD_EN  " "0,1"
    textline ""
    bitfld.word 0x0 1.--2. "    CCP_RAW_SWAP  " ",,B_0x2,B_0x3"

  group.word 0xDE++0x1
  line.word 0x0 "IPP_CD_PIPE3_FORMAT"
    textline ""
    bitfld.word 0x0 0.--2. "    PIPE3_FORMAT  " "B_0x0,B_0x1,B_0x2,,B_0x4"
    textline ""
    bitfld.word 0x0 3. "    BT601_EN  " "0,1"

  group.word 0xE0++0x1
  line.word 0x0 "IPP_CD_CROP_EN"
    textline ""
    bitfld.word 0x0 0. "    CROP_EN  " "0,1"

  group.word 0xE2++0x1
  line.word 0x0 "IPP_CD_CROP_H0"
    textline ""
    hexmask.word 0x0 1.--11. 1 "    CROP_H0  "

  group.word 0xE4++0x1
  line.word 0x0 "IPP_CD_CROP_V0"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    CROP_V0  "

  group.word 0xE6++0x1
  line.word 0x0 "IPP_CD_CROP_H1"
    textline ""
    hexmask.word 0x0 1.--11. 1 "    CROP_H1  "

  group.word 0xE8++0x1
  line.word 0x0 "IPP_CD_CROP_V1"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    CROP_V1  "

  group.word 0xEA++0x1
  line.word 0x0 "IPP_CD_ERROR_ITS"
    textline ""
    bitfld.word 0x0 1. "    CCP_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    RAW_DATA_ERROR_NOT_X8_BYTES  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    RAW_DATA_ERROR_OVERFLOW  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    LUMA_ERROR_NOT_X8_LUMA_BYTES  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    LUMA_ERROR_OVERFLOW  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    CHROMA_ERROR_NOT_X16_BYTES_3BUF  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    CHROMA_ERROR_NOT_X8BYTES_2BUF  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    CHROMA_ERROR_OVERFLOW  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    CD_CSI2_PACKET_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    CD_CSI2_DPHY_ERROR  " "0,1"

  group.word 0xEC++0x1
  line.word 0x0 "IPP_CD_ERROR_ITS_BCLR"
    textline ""
    hexmask.word 0x0 1.--10. 1 "    CD_ERROR_ITS_BCLR  "

  group.word 0xEE++0x1
  line.word 0x0 "IPP_CD_ERROR_ITS_BSET"
    textline ""
    hexmask.word 0x0 1.--10. 1 "    CD_ERROR_ITS_BSET  "

  group.word 0xF0++0x1
  line.word 0x0 "IPP_CD_ERROR_ITM"
    textline ""
    hexmask.word 0x0 1.--10. 1 "    CD_ERROR_ITM  "

  group.word 0xF2++0x1
  line.word 0x0 "IPP_CD_ERROR_ITM_BCLR"
    textline ""
    hexmask.word 0x0 1.--10. 1 "    CD_ERROR_ITM_BCLR  "

  group.word 0xF4++0x1
  line.word 0x0 "IPP_CD_ERROR_ITM_BSET"
    textline ""
    hexmask.word 0x0 1.--10. 1 "    CD_ERROR_ITM_BSET  "

  group.word 0xF6++0x1
  line.word 0x0 "IPP_CD_RAW_EOF_ITS"
    textline ""
    bitfld.word 0x0 0. "    CD_RAW_EOF_ITS  " "0,1"

  group.word 0xF8++0x1
  line.word 0x0 "IPP_CD_RAW_EOF_ITS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    CD_RAW_EOF_ITS_BCLR  " "0,1"

  group.word 0xFA++0x1
  line.word 0x0 "IPP_CD_RAW_EOF_ITS_BSET"
    textline ""
    bitfld.word 0x0 0. "    CD_RAW_EOF_ITS_BSET  " "0,1"

  group.word 0xFC++0x1
  line.word 0x0 "IPP_CD_RAW_EOF_ITM"
    textline ""
    bitfld.word 0x0 0. "    CD_RAW_EOF_ITM  " "0,1"

  group.word 0xFE++0x1
  line.word 0x0 "IPP_CD_RAW_EOF_ITM_BCLR"
    textline ""
    bitfld.word 0x0 0. "    CD_RAW_EOF_ITM_BCLR  " "0,1"

  group.word 0x100++0x1
  line.word 0x0 "IPP_CD_RAW_EOF_ITM_BSET"
    textline ""
    bitfld.word 0x0 0. "    CD_RAW_EOF_ITM_BSET  " "0,1"

  group.word 0x102++0x1
  line.word 0x0 "IPP_CD_CCP_ERR_DBG_ITS"
    textline ""
    bitfld.word 0x0 0.--2. "    CD_CCP_ERR_DBG  " ",B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x120++0x1
  line.word 0x0 "IPP_ISP_INTERNAL_ITS_L"
    textline ""
    bitfld.word 0x0 0. "    USER_IF  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    MASTER_CCI  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    LBE  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    REPIPE  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 5. "    ISP_RX  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 6. "    VIDEO_COMPLETE_PIPE0  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 7. "    VIDEO_COMPLETE_PIPE1  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 8. "    HISTOGRAM_256_BINS  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 9. "    EXPOSURE_6X8  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 10. "    AF_STATS  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    WB_STATS  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 12. "    SKIN_TONE_STATS  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 13. "    DMCEPIPE  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 14. "    ARCTIC  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 15. "    ACCWGZONE  " "B_0x0,B_0x1"

  group.word 0x122++0x1
  line.word 0x0 "IPP_ISP_INTERNAL_ITS_BCLR_L"
    textline ""
    bitfld.word 0x0 0. "    USER_IF  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    MASTER_CCI  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    LBE  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    REPIPE  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    ISP_RX  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    VIDEO_COMPLETE_PIPE0  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    VIDEO_COMPLETE_PIPE1  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    HISTOGRAM_256_BINS  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    EXPOSURE_6X8  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    AF_STATS  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    WB_STATS  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    SKIN_TONE_STATS  " "0,1"
    textline ""
    bitfld.word 0x0 13. "    DMCEPIPE  " "0,1"
    textline ""
    bitfld.word 0x0 14. "    ARCTIC  " "0,1"
    textline ""
    bitfld.word 0x0 15. "    ACCWGZONE  " "0,1"

  group.word 0x124++0x1
  line.word 0x0 "IPP_ISP_INTERNAL_ITS_BSET_L"
    textline ""
    bitfld.word 0x0 0. "    USER_IF  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    MASTER_CCI  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    LBE  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    REPIPE  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    ISP_RX  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    VIDEO_COMPLETE_PIPE0  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    VIDEO_COMPLETE_PIPE1  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    HISTOGRAM_256_BINS  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    EXPOSURE_6X8  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    AF_STATS  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    WB_STATS  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    SKIN_TONE_STATS  " "0,1"
    textline ""
    bitfld.word 0x0 13. "    DMCEPIPE  " "0,1"
    textline ""
    bitfld.word 0x0 14. "    ARCTIC  " "0,1"
    textline ""
    bitfld.word 0x0 15. "    ACCWGZONE  " "0,1"

  group.word 0x126++0x1
  line.word 0x0 "IPP_ISP_INTERNAL_ITM_L"
    textline ""
    bitfld.word 0x0 0. "    USER_IF  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    MASTER_CCI  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    LBE  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    REPIPE  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 5. "    ISP_RX  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 6. "    VIDEO_COMPLETE_PIPE0  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 7. "    VIDEO_COMPLETE_PIPE1  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 8. "    HISTOGRAM_256_BINS  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 9. "    EXPOSURE_6X8  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 10. "    AF_STATS  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    WB_STATS  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 12. "    SKIN_TONE_STATS  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 13. "    DMCEPIPE  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 14. "    ARCTIC  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 15. "    ACCWGZONE  " "B_0x0,B_0x1"

  group.word 0x128++0x1
  line.word 0x0 "IPP_ISP_INTERNAL_ITM_BCLR_L"
    textline ""
    bitfld.word 0x0 0. "    USER_IF  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    MASTER_CCI  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    LBE  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    REPIPE  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    ISP_RX  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    VIDEO_COMPLETE_PIPE0  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    VIDEO_COMPLETE_PIPE1  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    HISTOGRAM_256_BINS  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    EXPOSURE_6X8  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    AF_STATS  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    WB_STATS  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    SKIN_TONE_STATS  " "0,1"
    textline ""
    bitfld.word 0x0 13. "    DMCEPIPE  " "0,1"
    textline ""
    bitfld.word 0x0 14. "    ARCTIC  " "0,1"
    textline ""
    bitfld.word 0x0 15. "    ACCWGZONE  " "0,1"

  group.word 0x12A++0x1
  line.word 0x0 "IPP_ISP_INTERNAL_ITM_BSET_L"
    textline ""
    bitfld.word 0x0 0. "    USER_IF  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    MASTER_CCI  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    LBE  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    REPIPE  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    ISP_RX  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    VIDEO_COMPLETE_PIPE0  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    VIDEO_COMPLETE_PIPE1  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    HISTOGRAM_256_BINS  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    EXPOSURE_6X8  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    AF_STATS  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    WB_STATS  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    SKIN_TONE_STATS  " "0,1"
    textline ""
    bitfld.word 0x0 13. "    DMCEPIPE  " "0,1"
    textline ""
    bitfld.word 0x0 14. "    ARCTIC  " "0,1"
    textline ""
    bitfld.word 0x0 15. "    ACCWGZONE  " "0,1"

  group.word 0x130++0x1
  line.word 0x0 "IPP_ISP_INTERNAL_ITS_H"
    textline ""
    bitfld.word 0x0 0. "    GLACE  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    GPIO  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    DMCE_LBE  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3D  " "B_0x0,B_0x1"

  group.word 0x132++0x1
  line.word 0x0 "IPP_ISP_INTERNAL_ITS_BCLR_H"
    textline ""
    bitfld.word 0x0 0. "    GLACE  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    GPIO  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    DMCE_LBE  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3D  " "0,1"

  group.word 0x134++0x1
  line.word 0x0 "IPP_ISP_INTERNAL_ITS_BSET_H"
    textline ""
    bitfld.word 0x0 0. "    GLACE  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    GPIO  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    DMCE_LBE  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3D  " "0,1"

  group.word 0x136++0x1
  line.word 0x0 "IPP_ISP_INTERNAL_ITM_H"
    textline ""
    bitfld.word 0x0 0. "    GLACE  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    GPIO  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    DMCE_LBE  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3D  " "B_0x0,B_0x1"

  group.word 0x138++0x1
  line.word 0x0 "IPP_ISP_INTERNAL_ITM_BCLR_H"
    textline ""
    bitfld.word 0x0 0. "    GLACE  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    GPIO  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    DMCE_LBE  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3D  " "0,1"

  group.word 0x13A++0x1
  line.word 0x0 "IPP_ISP_INTERNAL_ITM_BSET_H"
    textline ""
    bitfld.word 0x0 0. "    GLACE  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    GPIO  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    DMCE_LBE  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3D  " "0,1"

  group.word 0x140++0x1
  line.word 0x0 "IPP_SIA_ITEXT_ITS"
    textline ""
    bitfld.word 0x0 0. "    ITEXT0  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    ITEXT1  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    ITEXT2  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    ITEXT3  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    ITEXT4  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 5. "    ITEXT5  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 6. "    ITEXT6  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 7. "    ITEXT7  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 8. "    ITEXT8  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 9. "    ITEXT9  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 10. "    ITEXT10  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    ITEXT11  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 12. "    ITEXT12  " "B_0x0,B_0x1"

  group.word 0x142++0x1
  line.word 0x0 "IPP_SIA_ITEXT_ITS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    ITEXT0  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    ITEXT1  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    ITEXT2  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    ITEXT3  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    ITEXT4  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    ITEXT5  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    ITEXT6  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    ITEXT7  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    ITEXT8  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    ITEXT9  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    ITEXT10  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    ITEXT11  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    ITEXT12  " "0,1"

  group.word 0x144++0x1
  line.word 0x0 "IPP_SIA_ITEXT_ITS_BSET"
    textline ""
    bitfld.word 0x0 0. "    ITEXT0  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    ITEXT1  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    ITEXT2  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    ITEXT3  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    ITEXT4  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    ITEXT5  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    ITEXT6  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    ITEXT7  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    ITEXT8  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    ITEXT9  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    ITEXT10  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    ITEXT11  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    ITEXT12  " "0,1"

  group.word 0x146++0x1
  line.word 0x0 "IPP_SIA_ITEXT_ITM"
    textline ""
    bitfld.word 0x0 0. "    ITEXT0  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    ITEXT1  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    ITEXT2  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    ITEXT3  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    ITEXT4  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 5. "    ITEXT5  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 6. "    ITEXT6  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 7. "    ITEXT7  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 8. "    ITEXT8  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 9. "    ITEXT9  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 10. "    ITEXT10  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    ITEXT11  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 12. "    ITEXT12  " "B_0x0,B_0x1"

  group.word 0x148++0x1
  line.word 0x0 "IPP_SIA_ITEXT_ITM_BCLR"
    textline ""
    bitfld.word 0x0 0. "    ITEXT0  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    ITEXT1  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    ITEXT2  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    ITEXT3  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    ITEXT4  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    ITEXT5  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    ITEXT6  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    ITEXT7  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    ITEXT8  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    ITEXT9  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    ITEXT10  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    ITEXT11  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    ITEXT12  " "0,1"

  group.word 0x14A++0x1
  line.word 0x0 "IPP_SIA_ITEXT_ITM_BSET"
    textline ""
    bitfld.word 0x0 0. "    ITEXT0  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    ITEXT1  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    ITEXT2  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    ITEXT3  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    ITEXT4  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    ITEXT5  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    ITEXT6  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    ITEXT7  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    ITEXT8  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    ITEXT9  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    ITEXT10  " "0,1"
    textline ""
    bitfld.word 0x0 11. "    ITEXT11  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    ITEXT12  " "0,1"

  group.word 0x150++0x1
  line.word 0x0 "IPP_EVT_ITS"
    textline ""
    bitfld.word 0x0 0. "    SD_ERROR  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    CD_ERROR  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    CD_RAW_EOF  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    BML_EOF  " "B_0x0,B_0x1"

  group.word 0x152++0x1
  line.word 0x0 "IPP_EVT_ITS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    SD_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CD_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CD_RAW_EOF  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    BML_EOF  " "0,1"

  group.word 0x154++0x1
  line.word 0x0 "IPP_EVT_ITS_BSET"
    textline ""
    bitfld.word 0x0 0. "    SD_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CD_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CD_RAW_EOF  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    BML_EOF  " "0,1"

  group.word 0x156++0x1
  line.word 0x0 "IPP_EVT_ITM"
    textline ""
    bitfld.word 0x0 0. "    SD_ERROR  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    CD_ERROR  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    CD_RAW_EOF  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    BML_EOF  " "B_0x0,B_0x1"

  group.word 0x158++0x1
  line.word 0x0 "IPP_EVT_ITM_BCLR"
    textline ""
    bitfld.word 0x0 0. "    SD_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CD_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CD_RAW_EOF  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    BML_EOF  " "0,1"

  group.word 0x15A++0x1
  line.word 0x0 "IPP_EVT_ITM_BSET"
    textline ""
    bitfld.word 0x0 0. "    SD_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    CD_ERROR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    CD_RAW_EOF  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    BML_EOF  " "0,1"

  group.word 0x160++0x1
  line.word 0x0 "IPP_STATIC_TOP_IF_3D_SEL"
    textline ""
    bitfld.word 0x0 0.--1. "    STATIC_TOP_IF_3D_SEL  " "B_0x0,B_0x1"

  group.word 0x162++0x1
  line.word 0x0 "IPP_CSI2RX_3D_VC_DATA_TYPE_R"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    CSI2RX_3D_DATA_TYPE  "
    textline ""
    hexmask.word 0x0 6.--7. 1 "    CSI2RX_3D_VIRTUAL_CHANNEL  "

  group.word 0x164++0x1
  line.word 0x0 "IPP_STATIC_CSI2RX_3D_DATA_TYPE_1_W"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    STATIC_CSI2RX_3D_DATA_TYPE0  "
    textline ""
    hexmask.word 0x0 8.--13. 1 "    STATIC_CSI2RX_3D_DATA_TYPE1  "

  group.word 0x166++0x1
  line.word 0x0 "IPP_STATIC_CSI2RX_3D_DATA_TYPE_2_W"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    STATIC_CSI2RX_3D_DATA_TYPE2  "

  group.word 0x168++0x1
  line.word 0x0 "IPP_STATIC_CSI2RX_3D_VC_W"
    textline ""
    bitfld.word 0x0 0. "    STATIC_CSI2RX_3D_VC0_EN  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    STATIC_CSI2RX_3D_VC1_EN  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    STATIC_CSI2RX_3D_VC2_EN  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    STATIC_CSI2RX_3D_VC3_EN  " "0,1"

  group.word 0x16A++0x1
  line.word 0x0 "IPP_CSI2RX_3D_FRAME_NB_R"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    CSI2RX_3D_FRAME_NB  "

  group.word 0x16C++0x1
  line.word 0x0 "IPP_CSI2RX_3D_DATA_FIELD_R"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    CSI2RX_3D_DATA_FIELD  "

  group.word 0x16E++0x1
  line.word 0x0 "IPP_STATIC_CSI2RX_3D_PIX_WIDTH_W"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    STATIC_CSI2RX_3D_DATATYPE0_PIXWIDTH  "
    textline ""
    hexmask.word 0x0 4.--7. 1 "    STATIC_CSI2RX_3D_DATATYPE1_PIXWIDTH  "
    textline ""
    hexmask.word 0x0 8.--11. 1 "    STATIC_CSI2RX_3D_DATATYPE2_PIXWIDTH  "

  group.word 0x170++0x1
  line.word 0x0 "IPP_STATIC_DELAYM_EN"
    textline ""
    bitfld.word 0x0 0. "    STATIC_DELAYM_EN  " "0,1"

  group.word 0x172++0x1
  line.word 0x0 "IPP_DELAYM_LINE_DELAY"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    LINE_DELAY_COUNTER  "
    textline ""
    bitfld.word 0x0 15. "    MASTER_ID  " "B_0x0,B_0x1"

  group.word 0x174++0x1
  line.word 0x0 "IPP_DELAYM_PIXEL_DELAY"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    PIXEL_DELAY_COUNTER  "

  group.word 0x176++0x1
  line.word 0x0 "IPP_SD_STATIC_SDG_3D_CSI_MODE"
    textline ""
    bitfld.word 0x0 0. "    STATIC_SDG_3D_CSI_MODE  " "B_0x0,B_0x1"

  group.word 0x1A0++0x1
  line.word 0x0 "IPP_CSI2RX_VC_DATA_TYPE_R"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    CSI2RX_DATA_TYPE  "
    textline ""
    hexmask.word 0x0 6.--7. 1 "    CSI2RX_VIRTUAL_CHANNEL  "

  group.word 0x1A2++0x1
  line.word 0x0 "IPP_STATIC_CSI2RX_DATA_TYPE_1_W"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    STATIC_CSI2RX_DATA_TYPE0  "
    textline ""
    hexmask.word 0x0 8.--13. 1 "    STATIC_CSI2RX_DATA_TYPE1  "

  group.word 0x1A4++0x1
  line.word 0x0 "IPP_STATIC_CSI2RX_DATA_TYPE_2_W"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    STATIC_CSI2RX_DATA_TYPE2  "

  group.word 0x1A6++0x1
  line.word 0x0 "IPP_STATIC_CSI2RX_VC_W"
    textline ""
    bitfld.word 0x0 0. "    STATIC_CSI2RX_VC0_EN  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    STATIC_CSI2RX_VC1_EN  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    STATIC_CSI2RX_VC2_EN  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    STATIC_CSI2RX_VC3_EN  " "0,1"

  group.word 0x1A8++0x1
  line.word 0x0 "IPP_CSI2RX_FRAME_NB_R"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    CSI2RX_FRAME_NB  "

  group.word 0x1AA++0x1
  line.word 0x0 "IPP_CSI2RX_DATA_FIELD_R"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    CSI2RX_DATA_FIELD  "

  group.word 0x1AC++0x1
  line.word 0x0 "IPP_STATIC_CSI2RX_PIX_WIDTH_W"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    STATIC_CSI2RX_DATATYPE0_PIXWIDTH  "
    textline ""
    hexmask.word 0x0 4.--7. 1 "    STATIC_CSI2RX_DATATYPE1_PIXWIDTH  "
    textline ""
    hexmask.word 0x0 8.--11. 1 "    STATIC_CSI2RX_DATATYPE2_PIXWIDTH  "

  group.word 0x1C0++0x1
  line.word 0x0 "IPP_BML_ITS"
    textline ""
    bitfld.word 0x0 0. "    BML_EOF  " "B_0x0,B_0x1"

  group.word 0x1C2++0x1
  line.word 0x0 "IPP_BML_ITS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    BML_EOF  " "B_0x0,B_0x1"

  group.word 0x1C4++0x1
  line.word 0x0 "IPP_BML_ITS_BSET"
    textline ""
    bitfld.word 0x0 0. "    BML_EOF  " "B_0x0,B_0x1"

  group.word 0x1C6++0x1
  line.word 0x0 "IPP_BML_ITM"
    textline ""
    bitfld.word 0x0 0. "    BML_EOF  " "B_0x0,B_0x1"

  group.word 0x1C8++0x1
  line.word 0x0 "IPP_BML_ITM_BCLR"
    textline ""
    bitfld.word 0x0 0. "    BML_EOF  " "B_0x0,B_0x1"

  group.word 0x1CA++0x1
  line.word 0x0 "IPP_BML_ITM_BSET"
    textline ""
    bitfld.word 0x0 0. "    BML_EOF  " "B_0x0,B_0x1"

  group.word 0x1D0++0x1
  line.word 0x0 "IPP_SD_BMS_ISL_TOP_H"
    textline ""
    hexmask.word 0x0 0.--4. 1 "    HEIGHT  "

  group.word 0x1D2++0x1
  line.word 0x0 "IPP_SD_BMS_ISL_BOT_H"
    textline ""
    hexmask.word 0x0 0.--4. 1 "    HEIGHT  "

  group.word 0x1D4++0x1
  line.word 0x0 "IPP_SD_BMS_ISL_FILTER"
    textline ""
    bitfld.word 0x0 0. "    ISL_BOT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    PIX_DATA  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    ISL_TOP  " "B_0x0,B_0x1"

  group.word 0x1D6++0x1
  line.word 0x0 "IPP_SD_BMS_ISL_FMT"
    textline ""
    bitfld.word 0x0 0.--3. "    FORMAT  " ",,,,,,B_0x6,B_0x7,B_0x8,,B_0xA,,B_0xC"

tree.end


;end include file ipp.h


;begin include file pictor.h


base a:0xa0252000
tree "MASTER_CCI"

  group.word 0x00++0x1
  line.word 0x0 "MASTER_CCI_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "0,1"

  group.word 0x04++0x1
  line.word 0x0 "MASTER_CCI_DEVICE_ID"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    device_id_reg  "

  group.word 0x08++0x1
  line.word 0x0 "MASTER_CCI_INDEX"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    index_reg  "

  group.word 0x0C++0x1
  line.word 0x0 "MASTER_CCI_CONTROL"
    textline ""
    bitfld.word 0x0 0. "    write  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    read  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    repeated_start  " "0,1"
    textline ""
    hexmask.word 0x0 3.--7. 1 "    data_count  "
    textline ""
    bitfld.word 0x0 8. "    single_byte_index  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 9. "    single_byte_device_id  " "B_0x0,B_0x1"

  group.word 0x10++0x1
  line.word 0x0 "MASTER_CCI_STATUS"
    textline ""
    bitfld.word 0x0 0. "    busy  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    fifo_full  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    fifo_empty  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    error  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    clr_error  " "0,1"

  group.long 0x14++0x3
  line.long 0x0 "MASTER_CCI_WRITE_DATA0"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    fifo_datastore0  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    fifo_datastore1  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    fifo_datastore2  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    fifo_datastore3  "

  group.long 0x18++0x3
  line.long 0x0 "MASTER_CCI_WRITE_DATA1"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    fifo_datastore0  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    fifo_datastore1  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    fifo_datastore2  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    fifo_datastore3  "

  group.long 0x1C++0x3
  line.long 0x0 "MASTER_CCI_WRITE_DATA2"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    fifo_datastore0  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    fifo_datastore1  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    fifo_datastore2  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    fifo_datastore3  "

  group.long 0x20++0x3
  line.long 0x0 "MASTER_CCI_WRITE_DATA3"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    fifo_datastore0  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    fifo_datastore1  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    fifo_datastore2  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    fifo_datastore3  "

  group.long 0x24++0x3
  line.long 0x0 "MASTER_CCI_READ_DATA0"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    fifo_datastore0  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    fifo_datastore1  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    fifo_datastore2  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    fifo_datastore3  "

  group.long 0x28++0x3
  line.long 0x0 "MASTER_CCI_READ_DATA1"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    fifo_datastore0  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    fifo_datastore1  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    fifo_datastore2  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    fifo_datastore3  "

  group.long 0x2C++0x3
  line.long 0x0 "MASTER_CCI_READ_DATA2"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    fifo_datastore0  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    fifo_datastore1  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    fifo_datastore2  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    fifo_datastore3  "

  group.long 0x30++0x3
  line.long 0x0 "MASTER_CCI_READ_DATA3"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    fifo_datastore0  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    fifo_datastore1  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    fifo_datastore2  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    fifo_datastore3  "

  group.word 0x34++0x1
  line.word 0x0 "MASTER_CCI_FSM_STATE"
    textline ""
    hexmask.word 0x0 0.--4. 1 "    state  "

  group.long 0x38++0x3
  line.long 0x0 "MASTER_CCI_TIMING1"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    time_fall  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    time_rise  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    t_high  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    t_buffer  "

  group.word 0x3C++0x1
  line.word 0x0 "MASTER_CCI_TIMING2"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    t_hd_dat  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    t_su_dat  "

  group.long 0x40++0x3
  line.long 0x0 "MASTER_CCI_TIMING3"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    t_hd_sta  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    t_su_sta  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    t_su_sto  "

  group.word 0x44++0x1
  line.word 0x0 "MASTER_CCI_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    dfv_eop_interrupt  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    dfv_error_interrupt  " "0,1"

  group.word 0x48++0x1
  line.word 0x0 "MASTER_CCI_TRANSFER"
    textline ""
    bitfld.word 0x0 0. "    device_id_valid  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    start_transfer  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    fifo_wr_fill  " "0,1"

  group.word 0x4C++0x1
  line.word 0x0 "MASTER_CCI_ERR_MGMT"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    error_mgmt_value  "

tree.end


base a:0xa0252060
tree "USER_IF"

  group.word 0x00++0x1
  line.word 0x0 "USER_IF_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "USER_IF_PAGE_ELEMENT"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    page_element  "

  group.word 0x08++0x1
  line.word 0x0 "USER_IF_OPC"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    opcode  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    transaction_id  "

  group.long 0x0C++0x3
  line.long 0x0 "USER_IF_WR_DATA"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    wr_data  "

  group.long 0x10++0x3
  line.long 0x0 "USER_IF_RD_DATA"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    rd_data  "

  group.word 0x14++0x1
  line.word 0x0 "USER_IF_ACK"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    opcode_completed  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    transaction_id_completed  "

  group.word 0x18++0x1
  line.word 0x0 "USER_IF_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    dfv_interrupt  " "0,1"

tree.end


base a:0xa0252080
tree "GPIO"

  group.word 0x00++0x1
  line.word 0x0 "GPIO_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    gpio_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "GPIO_TIMER_CTRL"
    textline ""
    bitfld.word 0x0 0. "    timer0_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    timer1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 2. "    timer2_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 3. "    timer3_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    idptimer_enable  " "DISABLE,ENABLE"

  group.word 0x08++0x1
  line.word 0x0 "GPIO_CHANNEL_START"
    textline ""
    bitfld.word 0x0 0. "    channel0_start  " "NO_EFFECT,CHANNEL_START"
    textline ""
    bitfld.word 0x0 1. "    channel1_start  " "NO_EFFECT,CHANNEL_START"
    textline ""
    bitfld.word 0x0 2. "    channel2_start  " "NO_EFFECT,CHANNEL_START"
    textline ""
    bitfld.word 0x0 3. "    channel3_start  " "NO_EFFECT,CHANNEL_START"
    textline ""
    bitfld.word 0x0 4. "    channel4_start  " "NO_EFFECT,CHANNEL_START"
    textline ""
    bitfld.word 0x0 5. "    channel5_start  " "NO_EFFECT,CHANNEL_START"
    textline ""
    bitfld.word 0x0 6. "    channel6_start  " "NO_EFFECT,CHANNEL_START"
    textline ""
    bitfld.word 0x0 7. "    channel7_start  " "NO_EFFECT,CHANNEL_START"

  group.word 0x0C++0x1
  line.word 0x0 "GPIO_CHANNEL_STOP"
    textline ""
    bitfld.word 0x0 0. "    channel0_stop  " "NO_EFFECT,CHANNEL_STOP"
    textline ""
    bitfld.word 0x0 1. "    channel1_stop  " "NO_EFFECT,CHANNEL_STOP"
    textline ""
    bitfld.word 0x0 2. "    channel2_stop  " "NO_EFFECT,CHANNEL_STOP"
    textline ""
    bitfld.word 0x0 3. "    channel3_stop  " "NO_EFFECT,CHANNEL_STOP"
    textline ""
    bitfld.word 0x0 4. "    channel4_stop  " "NO_EFFECT,CHANNEL_STOP"
    textline ""
    bitfld.word 0x0 5. "    channel5_stop  " "NO_EFFECT,CHANNEL_STOP"
    textline ""
    bitfld.word 0x0 6. "    channel6_stop  " "NO_EFFECT,CHANNEL_STOP"
    textline ""
    bitfld.word 0x0 7. "    channel7_stop  " "NO_EFFECT,CHANNEL_STOP"

  group.word 0x10++0x1
  line.word 0x0 "GPIO_CHANNEL_RESET"
    textline ""
    bitfld.word 0x0 0. "    channel0_reset  " "NO_EFFECT,CHANNEL_RESET"
    textline ""
    bitfld.word 0x0 1. "    channel1_reset  " "NO_EFFECT,CHANNEL_RESET"
    textline ""
    bitfld.word 0x0 2. "    channel2_reset  " "NO_EFFECT,CHANNEL_RESET"
    textline ""
    bitfld.word 0x0 3. "    channel3_reset  " "NO_EFFECT,CHANNEL_RESET"
    textline ""
    bitfld.word 0x0 4. "    channel4_reset  " "NO_EFFECT,CHANNEL_RESET"
    textline ""
    bitfld.word 0x0 5. "    channel5_reset  " "NO_EFFECT,CHANNEL_RESET"
    textline ""
    bitfld.word 0x0 6. "    channel6_reset  " "NO_EFFECT,CHANNEL_RESET"
    textline ""
    bitfld.word 0x0 7. "    channel7_reset  " "NO_EFFECT,CHANNEL_RESET"

  group.word 0x14++0x1
  line.word 0x0 "GPIO_CHANNEL_POLARITY"
    textline ""
    bitfld.word 0x0 0. "    channel0_polar  " "ACTIVE_HIGH,ACTIVE_LOW"
    textline ""
    bitfld.word 0x0 1. "    channel1_polar  " "ACTIVE_HIGH,ACTIVE_LOW"
    textline ""
    bitfld.word 0x0 2. "    channel2_polar  " "ACTIVE_HIGH,ACTIVE_LOW"
    textline ""
    bitfld.word 0x0 3. "    channel3_polar  " "ACTIVE_HIGH,ACTIVE_LOW"
    textline ""
    bitfld.word 0x0 4. "    channel4_polar  " "ACTIVE_HIGH,ACTIVE_LOW"
    textline ""
    bitfld.word 0x0 5. "    channel5_polar  " "ACTIVE_HIGH,ACTIVE_LOW"
    textline ""
    bitfld.word 0x0 6. "    channel6_polar  " "ACTIVE_HIGH,ACTIVE_LOW"
    textline ""
    bitfld.word 0x0 7. "    channel7_polar  " "ACTIVE_HIGH,ACTIVE_LOW"

  group.word 0x18++0x1
  line.word 0x0 "GPIO_OUTPUT_CONFIG"
    textline ""
    bitfld.word 0x0 0. "    gpo0_config  " "GPO_CHANNEL,GPO_REGISTER"
    textline ""
    bitfld.word 0x0 1. "    gpo1_config  " "GPO_CHANNEL,GPO_REGISTER"
    textline ""
    bitfld.word 0x0 2. "    gpo2_config  " "GPO_CHANNEL,GPO_REGISTER"
    textline ""
    bitfld.word 0x0 3. "    gpo3_config  " "GPO_CHANNEL,GPO_REGISTER"
    textline ""
    bitfld.word 0x0 4. "    gpo4_config  " "GPO_CHANNEL,GPO_REGISTER"
    textline ""
    bitfld.word 0x0 5. "    gpo5_config  " "GPO_CHANNEL,GPO_REGISTER"
    textline ""
    bitfld.word 0x0 6. "    gpo6_config  " "GPO_CHANNEL,GPO_REGISTER"
    textline ""
    bitfld.word 0x0 7. "    gpo7_config  " "GPO_CHANNEL,GPO_REGISTER"

  group.word 0x1C++0x1
  line.word 0x0 "GPIO_CHANNEL_CONFIG"
    textline ""
    bitfld.word 0x0 0. "    channel0_config  " "CHANNEL_PWM,CHANNEL_SEQSHIFT"
    textline ""
    bitfld.word 0x0 1. "    channel1_config  " "CHANNEL_PWM,CHANNEL_SEQSHIFT"
    textline ""
    bitfld.word 0x0 2. "    channel2_config  " "CHANNEL_PWM,CHANNEL_SEQSHIFT"
    textline ""
    bitfld.word 0x0 3. "    channel3_config  " "CHANNEL_PWM,CHANNEL_SEQSHIFT"
    textline ""
    bitfld.word 0x0 4. "    channel4_config  " "CHANNEL_PWM,CHANNEL_SEQSHIFT"
    textline ""
    bitfld.word 0x0 5. "    channel5_config  " "CHANNEL_PWM,CHANNEL_SEQSHIFT"
    textline ""
    bitfld.word 0x0 6. "    channel6_config  " "CHANNEL_PWM,CHANNEL_SEQSHIFT"
    textline ""
    bitfld.word 0x0 7. "    channel7_config  " "CHANNEL_PWM,CHANNEL_SEQSHIFT"

  group.word 0x20++0x1
  line.word 0x0 "GPIO_CHANNEL_PAIRING"
    textline ""
    bitfld.word 0x0 0.--1. "    channel_pairing0  " "PAIRING_NONE,PAIRING_INVERT,PAIRING_HALFSHIFT,PAIRING_OR"
    textline ""
    bitfld.word 0x0 2.--3. "    channel_pairing1  " "PAIRING_NONE,PAIRING_INVERT,PAIRING_HALFSHIFT,PAIRING_OR"
    textline ""
    bitfld.word 0x0 4.--5. "    channel_pairing2  " "PAIRING_NONE,PAIRING_INVERT,PAIRING_HALFSHIFT,PAIRING_OR"
    textline ""
    bitfld.word 0x0 6.--7. "    channel_pairing3  " "PAIRING_NONE,PAIRING_INVERT,PAIRING_HALFSHIFT,PAIRING_OR"

  group.word 0x24++0x1
  line.word 0x0 "GPIO_INTR_DEBUG"
    textline ""
    bitfld.word 0x0 0. "    intr_debug  " "B_0x0,B_0x1"

  group.long 0x28++0x3
  line.long 0x0 "GPIO_CHANNEL_SRC"
    textline ""
    bitfld.long 0x0 0.--2. "    channel0_src  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    bitfld.long 0x0 3.--5. "    channel1_src  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    bitfld.long 0x0 6.--8. "    channel2_src  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    bitfld.long 0x0 9.--11. "    channel3_src  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    bitfld.long 0x0 12.--14. "    channel4_src  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    bitfld.long 0x0 15.--17. "    channel5_src  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    bitfld.long 0x0 18.--20. "    channel6_src  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    bitfld.long 0x0 21.--23. "    channel7_src  " "B_0x0,B_0x1,B_0x2,B_0x3"

  group.word 0x2C++0x1
  line.word 0x0 "GPIO_INT_SRC"
    textline ""
    bitfld.word 0x0 0.--2. "    int0_src  " "SRC_TIMER0,SRC_TIMER1,SRC_TIMER2,SRC_TIMER3"
    textline ""
    bitfld.word 0x0 3.--5. "    int1_src  " "SRC_TIMER0,SRC_TIMER1,SRC_TIMER2,SRC_TIMER3"
    textline ""
    bitfld.word 0x0 6.--8. "    int2_src  " "SRC_TIMER0,SRC_TIMER1,SRC_TIMER2,SRC_TIMER3"
    textline ""
    bitfld.word 0x0 9.--11. "    int3_src  " "SRC_TIMER0,SRC_TIMER1,SRC_TIMER2,SRC_TIMER3"

  group.long 0x30++0x3
  line.long 0x0 "GPIO_INT0_TRIGGER"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    count_low  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    count_high  "

  group.word 0x34++0x1
  line.word 0x0 "GPIO_INT0_TRIGGER_EX"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    count_ext  "
    textline ""
    bitfld.word 0x0 8.--9. "    repeat  " "B_0x0,B_0x1"

  group.long 0x38++0x3
  line.long 0x0 "GPIO_INT1_TRIGGER"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    count_low  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    count_high  "

  group.word 0x3C++0x1
  line.word 0x0 "GPIO_INT1_TRIGGER_EX"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    count_ext  "
    textline ""
    bitfld.word 0x0 8.--9. "    repeat  " "B_0x0,B_0x1"

  group.long 0x40++0x3
  line.long 0x0 "GPIO_INT2_TRIGGER"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    count_low  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    count_high  "

  group.word 0x44++0x1
  line.word 0x0 "GPIO_INT2_TRIGGER_EX"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    count_ext  "
    textline ""
    bitfld.word 0x0 8.--9. "    repeat  " "B_0x0,B_0x1"

  group.long 0x48++0x3
  line.long 0x0 "GPIO_INT3_TRIGGER"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    count_low  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    count_high  "

  group.word 0x4C++0x1
  line.word 0x0 "GPIO_INT3_TRIGGER_EX"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    count_ext  "
    textline ""
    bitfld.word 0x0 8.--9. "    repeat  " "B_0x0,B_0x1"

  group.word 0x50++0x1
  line.word 0x0 "GPIO_EVENT_TRIGGER"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    event_trigger  "
    textline ""
    bitfld.word 0x0 8. "    event_src  " "EVENT_SRC_ADC,EVENT_SRC_GPI"

  group.word 0x54++0x1
  line.word 0x0 "GPIO_TIMER_PRESCALE"
    textline ""
    bitfld.word 0x0 0.--3. "    timer0_prescale  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7,B_0x8,B_0x9,B_0xA,B_0xB,B_0xC,B_0xD,B_0xE,B_0xF"
    textline ""
    bitfld.word 0x0 4.--7. "    timer1_prescale  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7,B_0x8,B_0x9,B_0xA,B_0xB,B_0xC,B_0xD,B_0xE,B_0xF"
    textline ""
    bitfld.word 0x0 8.--11. "    timer2_prescale  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7,B_0x8,B_0x9,B_0xA,B_0xB,B_0xC,B_0xD,B_0xE,B_0xF"
    textline ""
    bitfld.word 0x0 12.--15. "    timer3_prescale  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7,B_0x8,B_0x9,B_0xA,B_0xB,B_0xC,B_0xD,B_0xE,B_0xF"

  group.word 0x58++0x1
  line.word 0x0 "GPIO_DEBOUNCE_CTRL"
    textline ""
    bitfld.word 0x0 0. "    debounce_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4.--7. "    debounce_prescale  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7,B_0x8,B_0x9,B_0xA,B_0xB,B_0xC,B_0xD,B_0xE,B_0xF"

  group.word 0x5C++0x1
  line.word 0x0 "GPIO_DEBOUNCE_PERIOD"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    debounce_period  "

  group.word 0x60++0x1
  line.word 0x0 "GPIO_IDP_FRAME_COUNT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    frame_count  "

  group.word 0x64++0x1
  line.word 0x0 "GPIO_GPI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    gpi  "

  group.word 0x68++0x1
  line.word 0x0 "GPIO_GPO"
    textline ""
    bitfld.word 0x0 0.--15. "    gpo  " "B_0x0,B_0x1"

  group.word 0x6C++0x1
  line.word 0x0 "GPIO_GPD"
    textline ""
    bitfld.word 0x0 0.--15. "    gpd  " "DIR_INPUT,DIR_OUTPUT"

  group.long 0x70++0x3
  line.long 0x0 "GPIO_CHANNEL0_CTRL0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0x74++0x1
  line.word 0x0 "GPIO_CHANNEL0_CTRL0_EXT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ctrl0_ext  "

  group.long 0x78++0x3
  line.long 0x0 "GPIO_CHANNEL0_CTRL1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0x7C++0x1
  line.word 0x0 "GPIO_CHANNEL0_CTRL1_EXT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ctrl1_ext  "

  group.word 0x80++0x1
  line.word 0x0 "GPIO_CHANNEL0_REPEAT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    repeat  "
    textline ""
    bitfld.word 0x0 8. "    line_mode  " "LINE_REPEAT,FRAME_REPEAT"
    textline ""
    bitfld.word 0x0 9. "    until  " "DISABLE,ENABLE"

  group.long 0x84++0x3
  line.long 0x0 "GPIO_CHANNEL1_CTRL0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0x88++0x1
  line.word 0x0 "GPIO_CHANNEL1_CTRL0_EXT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ctrl0_ext  "

  group.long 0x8C++0x3
  line.long 0x0 "GPIO_CHANNEL1_CTRL1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0x90++0x1
  line.word 0x0 "GPIO_CHANNEL1_CTRL1_EXT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ctrl1_ext  "

  group.word 0x94++0x1
  line.word 0x0 "GPIO_CHANNEL1_REPEAT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    repeat  "
    textline ""
    bitfld.word 0x0 8. "    line_mode  " "LINE_REPEAT,FRAME_REPEAT"
    textline ""
    bitfld.word 0x0 9. "    until  " "DISABLE,ENABLE"

  group.long 0x98++0x3
  line.long 0x0 "GPIO_CHANNEL2_CTRL0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0x9C++0x1
  line.word 0x0 "GPIO_CHANNEL2_CTRL0_EXT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ctrl0_ext  "

  group.long 0xA0++0x3
  line.long 0x0 "GPIO_CHANNEL2_CTRL1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0xA4++0x1
  line.word 0x0 "GPIO_CHANNEL2_CTRL1_EXT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ctrl1_ext  "

  group.word 0xA8++0x1
  line.word 0x0 "GPIO_CHANNEL2_REPEAT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    repeat  "
    textline ""
    bitfld.word 0x0 8. "    line_mode  " "LINE_REPEAT,FRAME_REPEAT"
    textline ""
    bitfld.word 0x0 9. "    until  " "DISABLE,ENABLE"

  group.long 0xAC++0x3
  line.long 0x0 "GPIO_CHANNEL3_CTRL0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0xB0++0x1
  line.word 0x0 "GPIO_CHANNEL3_CTRL0_EXT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ctrl0_ext  "

  group.long 0xB4++0x3
  line.long 0x0 "GPIO_CHANNEL3_CTRL1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0xB8++0x1
  line.word 0x0 "GPIO_CHANNEL3_CTRL1_EXT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ctrl1_ext  "

  group.word 0xBC++0x1
  line.word 0x0 "GPIO_CHANNEL3_REPEAT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    repeat  "
    textline ""
    bitfld.word 0x0 8. "    line_mode  " "LINE_REPEAT,FRAME_REPEAT"
    textline ""
    bitfld.word 0x0 9. "    until  " "DISABLE,ENABLE"

  group.long 0xC0++0x3
  line.long 0x0 "GPIO_CHANNEL4_CTRL0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0xC4++0x1
  line.word 0x0 "GPIO_CHANNEL4_CTRL0_EXT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ctrl0_ext  "

  group.long 0xC8++0x3
  line.long 0x0 "GPIO_CHANNEL4_CTRL1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0xCC++0x1
  line.word 0x0 "GPIO_CHANNEL4_CTRL1_EXT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ctrl1_ext  "

  group.word 0xD0++0x1
  line.word 0x0 "GPIO_CHANNEL4_REPEAT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    repeat  "
    textline ""
    bitfld.word 0x0 8. "    line_mode  " "LINE_REPEAT,FRAME_REPEAT"
    textline ""
    bitfld.word 0x0 9. "    until  " "DISABLE,ENABLE"

  group.long 0xD4++0x3
  line.long 0x0 "GPIO_CHANNEL5_CTRL0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0xD8++0x1
  line.word 0x0 "GPIO_CHANNEL5_CTRL0_EXT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ctrl0_ext  "

  group.long 0xDC++0x3
  line.long 0x0 "GPIO_CHANNEL5_CTRL1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0xE0++0x1
  line.word 0x0 "GPIO_CHANNEL5_CTRL1_EXT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ctrl1_ext  "

  group.word 0xE4++0x1
  line.word 0x0 "GPIO_CHANNEL5_REPEAT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    repeat  "
    textline ""
    bitfld.word 0x0 8. "    line_mode  " "LINE_REPEAT,FRAME_REPEAT"
    textline ""
    bitfld.word 0x0 9. "    until  " "DISABLE,ENABLE"

  group.word 0xE8++0x1
  line.word 0x0 "GPIO_CHANNEL6_STG_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    stage0_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    stage1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 2. "    stage2_enable  " "DISABLE,ENABLE"

  group.long 0xEC++0x3
  line.long 0x0 "GPIO_CHANNEL6_STG0_CTRL0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.long 0xF0++0x3
  line.long 0x0 "GPIO_CHANNEL6_STG0_CTRL1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0xF4++0x1
  line.word 0x0 "GPIO_CHANNEL6_STG0_REPEAT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    repeat  "
    textline ""
    bitfld.word 0x0 8. "    until  " "DISABLE,ENABLE"

  group.long 0xF8++0x3
  line.long 0x0 "GPIO_CHANNEL6_STG1_CTRL0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.long 0xFC++0x3
  line.long 0x0 "GPIO_CHANNEL6_STG1_CTRL1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0x100++0x1
  line.word 0x0 "GPIO_CHANNEL6_STG1_REPEAT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    repeat  "
    textline ""
    bitfld.word 0x0 8. "    until  " "DISABLE,ENABLE"

  group.long 0x104++0x3
  line.long 0x0 "GPIO_CHANNEL6_STG2_CTRL0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.long 0x108++0x3
  line.long 0x0 "GPIO_CHANNEL6_STG2_CTRL1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0x10C++0x1
  line.word 0x0 "GPIO_CHANNEL6_STG2_REPEAT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    repeat  "
    textline ""
    bitfld.word 0x0 8. "    until  " "DISABLE,ENABLE"

  group.word 0x110++0x1
  line.word 0x0 "GPIO_CHANNEL7_STG_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    stage0_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    stage1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 2. "    stage2_enable  " "DISABLE,ENABLE"

  group.long 0x114++0x3
  line.long 0x0 "GPIO_CHANNEL7_STG0_CTRL0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.long 0x118++0x3
  line.long 0x0 "GPIO_CHANNEL7_STG0_CTRL1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0x11C++0x1
  line.word 0x0 "GPIO_CHANNEL7_STG0_REPEAT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    repeat  "
    textline ""
    bitfld.word 0x0 8. "    until  " "DISABLE,ENABLE"

  group.long 0x120++0x3
  line.long 0x0 "GPIO_CHANNEL7_STG1_CTRL0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.long 0x124++0x3
  line.long 0x0 "GPIO_CHANNEL7_STG1_CTRL1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0x128++0x1
  line.word 0x0 "GPIO_CHANNEL7_STG1_REPEAT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    repeat  "
    textline ""
    bitfld.word 0x0 8. "    until  " "DISABLE,ENABLE"

  group.long 0x12C++0x3
  line.long 0x0 "GPIO_CHANNEL7_STG2_CTRL0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.long 0x130++0x3
  line.long 0x0 "GPIO_CHANNEL7_STG2_CTRL1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    lo  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    hi  "

  group.word 0x134++0x1
  line.word 0x0 "GPIO_CHANNEL7_STG2_REPEAT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    repeat  "
    textline ""
    bitfld.word 0x0 8. "    until  " "DISABLE,ENABLE"

  group.long 0x138++0x3
  line.long 0x0 "GPIO_DFV"
    textline ""
    bitfld.long 0x0 0. "    dfv_enable  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    dfv_timer0_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    dfv_timer1_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    dfv_timer2_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    dfv_timer3_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    dfv_trig_pulse_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    dfv_chnl0_comp_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    dfv_chnl1_comp_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    dfv_chnl2_comp_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    dfv_chnl3_comp_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    dfv_chnl4_comp_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    dfv_chnl5_comp_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    dfv_chnl6_comp_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    dfv_chnl7_comp_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    dfv_chnl0_strt_aborted_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    dfv_chnl1_strt_aborted_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    dfv_chnl2_strt_aborted_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    dfv_chnl3_strt_aborted_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    dfv_chnl4_strt_aborted_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    dfv_chnl5_strt_aborted_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    dfv_chnl6_strt_aborted_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    dfv_chnl7_strt_aborted_interrupt_ctrl  " "0,1"

tree.end


base a:0xa02521e0
tree "PERIPH_CTRL"

  group.word 0x04++0x1
  line.word 0x0 "PERIPH_CTRL_CTRL"
    textline ""
    bitfld.word 0x0 0. "    p_fetch_en_i  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    wake_up  " "0,1"

  group.word 0x08++0x1
  line.word 0x0 "PERIPH_CTRL_CONFIG"
    textline ""
    bitfld.word 0x0 0. "    en_idle_state  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    mfu_core_pri_i  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    it_disabling_mode_i  " "0,1"

  group.word 0x0C++0x1
  line.word 0x0 "PERIPH_CTRL_STATUS"
    textline ""
    bitfld.word 0x0 0. "    idle_state  " "0,1"
    textline ""
    hexmask.word 0x0 1.--2. 1 "    idle_level  "
    textline ""
    bitfld.word 0x0 3. "    oce_debug_o  " "0,1"

tree.end


base a:0xa0252200
tree "ITM"

  group.long 0x00++0x3
  line.long 0x0 "ITM_FW_EVENT0_STATUS"
    textline ""
    bitfld.long 0x0 0. "    SRC0_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_STATUS  " "0,1"

  group.long 0x04++0x3
  line.long 0x0 "ITM_FW_EVENT0_EN_STATUS"
    textline ""
    bitfld.long 0x0 0. "    SRC0_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_EN_STATUS  " "0,1"

  group.long 0x08++0x3
  line.long 0x0 "ITM_FW_EVENT0_STATUS_BCLR"
    textline ""
    bitfld.long 0x0 0. "    SRC0_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_STATUS_BCLR  " "0,1"

  group.long 0x0C++0x3
  line.long 0x0 "ITM_FW_EVENT0_STATUS_BSET"
    textline ""
    bitfld.long 0x0 0. "    SRC0_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_STATUS_BSET  " "0,1"

  group.long 0x10++0x3
  line.long 0x0 "ITM_FW_EVENT0_EN_BCLR"
    textline ""
    bitfld.long 0x0 0. "    SRC0_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_EN_BCLR  " "0,1"

  group.long 0x14++0x3
  line.long 0x0 "ITM_FW_EVENT0_EN_BSET"
    textline ""
    bitfld.long 0x0 0. "    SRC0_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_EN_BSET  " "0,1"

  group.long 0x18++0x3
  line.long 0x0 "ITM_FW_EVENT1_STATUS"
    textline ""
    bitfld.long 0x0 0. "    SRC0_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_STATUS  " "0,1"

  group.long 0x1C++0x3
  line.long 0x0 "ITM_FW_EVENT1_EN_STATUS"
    textline ""
    bitfld.long 0x0 0. "    SRC0_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_EN_STATUS  " "0,1"

  group.long 0x20++0x3
  line.long 0x0 "ITM_FW_EVENT1_STATUS_BCLR"
    textline ""
    bitfld.long 0x0 0. "    SRC0_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_STATUS_BCLR  " "0,1"

  group.long 0x24++0x3
  line.long 0x0 "ITM_FW_EVENT1_STATUS_BSET"
    textline ""
    bitfld.long 0x0 0. "    SRC0_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_STATUS_BSET  " "0,1"

  group.long 0x28++0x3
  line.long 0x0 "ITM_FW_EVENT1_EN_BCLR"
    textline ""
    bitfld.long 0x0 0. "    SRC0_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_EN_BCLR  " "0,1"

  group.long 0x2C++0x3
  line.long 0x0 "ITM_FW_EVENT1_EN_BSET"
    textline ""
    bitfld.long 0x0 0. "    SRC0_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_EN_BSET  " "0,1"

  group.long 0x30++0x3
  line.long 0x0 "ITM_FW_EVENT2_STATUS"
    textline ""
    bitfld.long 0x0 0. "    SRC0_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_STATUS  " "0,1"

  group.long 0x34++0x3
  line.long 0x0 "ITM_FW_EVENT2_EN_STATUS"
    textline ""
    bitfld.long 0x0 0. "    SRC0_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_EN_STATUS  " "0,1"

  group.long 0x38++0x3
  line.long 0x0 "ITM_FW_EVENT2_STATUS_BCLR"
    textline ""
    bitfld.long 0x0 0. "    SRC0_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_STATUS_BCLR  " "0,1"

  group.long 0x3C++0x3
  line.long 0x0 "ITM_FW_EVENT2_STATUS_BSET"
    textline ""
    bitfld.long 0x0 0. "    SRC0_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_STATUS_BSET  " "0,1"

  group.long 0x40++0x3
  line.long 0x0 "ITM_FW_EVENT2_EN_BCLR"
    textline ""
    bitfld.long 0x0 0. "    SRC0_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_EN_BCLR  " "0,1"

  group.long 0x44++0x3
  line.long 0x0 "ITM_FW_EVENT2_EN_BSET"
    textline ""
    bitfld.long 0x0 0. "    SRC0_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_EN_BSET  " "0,1"

  group.long 0x48++0x3
  line.long 0x0 "ITM_FW_EVENT3_STATUS"
    textline ""
    bitfld.long 0x0 0. "    SRC0_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_STATUS  " "0,1"

  group.long 0x4C++0x3
  line.long 0x0 "ITM_FW_EVENT3_EN_STATUS"
    textline ""
    bitfld.long 0x0 0. "    SRC0_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_EN_STATUS  " "0,1"

  group.long 0x50++0x3
  line.long 0x0 "ITM_FW_EVENT3_STATUS_BCLR"
    textline ""
    bitfld.long 0x0 0. "    SRC0_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_STATUS_BCLR  " "0,1"

  group.long 0x54++0x3
  line.long 0x0 "ITM_FW_EVENT3_STATUS_BSET"
    textline ""
    bitfld.long 0x0 0. "    SRC0_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_STATUS_BSET  " "0,1"

  group.long 0x58++0x3
  line.long 0x0 "ITM_FW_EVENT3_EN_BCLR"
    textline ""
    bitfld.long 0x0 0. "    SRC0_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_EN_BCLR  " "0,1"

  group.long 0x5C++0x3
  line.long 0x0 "ITM_FW_EVENT3_EN_BSET"
    textline ""
    bitfld.long 0x0 0. "    SRC0_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    SRC1_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    SRC2_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    SRC3_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    SRC4_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    SRC5_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    SRC6_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    SRC7_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    SRC8_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    SRC9_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    SRC10_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    SRC11_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    SRC12_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    SRC13_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    SRC14_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    SRC15_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    SRC16_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    SRC17_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    SRC18_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    SRC19_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    SRC20_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    SRC21_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 22. "    SRC22_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 23. "    SRC23_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    SRC24_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    SRC25_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    SRC26_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    SRC27_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    SRC28_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    SRC29_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 30. "    SRC30_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 31. "    SRC31_EN_BSET  " "0,1"

  group.long 0x60++0x3
  line.long 0x0 "ITM_GPIO_STATUS"
    textline ""
    bitfld.long 0x0 0. "    GPIO_CHNL_0_CMPLT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    GPIO_CHNL_1_CMPLT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    GPIO_CHNL_2_CMPLT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    GPIO_CHNL_3_CMPLT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    GPIO_CHNL_4_CMPLT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    GPIO_CHNL_5_CMPLT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    GPIO_CHNL_6_CMPLT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    GPIO_CHNL_7_CMPLT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    GPIO_CHNL_0_ST_ABORT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    GPIO_CHNL_1_ST_ABORT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    GPIO_CHNL_2_ST_ABORT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    GPIO_CHNL_3_ST_ABORT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    GPIO_CHNL_4_ST_ABORT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    GPIO_CHNL_5_ST_ABORT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    GPIO_CHNL_6_ST_ABORT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    GPIO_CHNL_7_ST_ABORT_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    GPIO_TIMER_0_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    GPIO_TIMER_1_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    GPIO_TIMER_2_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    GPIO_TIMER_3_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    GPIO_INTR_DEBUG_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    GPIO_TRIG_PULSE_STATUS  " "0,1"

  group.long 0x64++0x3
  line.long 0x0 "ITM_GPIO_EN_STATUS"
    textline ""
    bitfld.long 0x0 0. "    GPIO_CHNL_0_CMPLT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    GPIO_CHNL_1_CMPLT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    GPIO_CHNL_2_CMPLT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    GPIO_CHNL_3_CMPLT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    GPIO_CHNL_4_CMPLT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    GPIO_CHNL_5_CMPLT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    GPIO_CHNL_6_CMPLT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    GPIO_CHNL_7_CMPLT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    GPIO_CHNL_0_ST_ABORT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    GPIO_CHNL_1_ST_ABORT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    GPIO_CHNL_2_ST_ABORT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    GPIO_CHNL_3_ST_ABORT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    GPIO_CHNL_4_ST_ABORT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    GPIO_CHNL_5_ST_ABORT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    GPIO_CHNL_6_ST_ABORT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    GPIO_CHNL_7_ST_ABORT_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    GPIO_TIMER_0_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    GPIO_TIMER_1_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    GPIO_TIMER_2_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    GPIO_TIMER_3_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    GPIO_INTR_DEBUG_EN_STATUS  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    GPIO_TRIG_PULSE_EN_STATUS  " "0,1"

  group.long 0x68++0x3
  line.long 0x0 "ITM_GPIO_STATUS_BCLR"
    textline ""
    bitfld.long 0x0 0. "    GPIO_CHNL_0_CMPLT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    GPIO_CHNL_1_CMPLT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    GPIO_CHNL_2_CMPLT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    GPIO_CHNL_3_CMPLT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    GPIO_CHNL_4_CMPLT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    GPIO_CHNL_5_CMPLT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    GPIO_CHNL_6_CMPLT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    GPIO_CHNL_7_CMPLT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    GPIO_CHNL_0_ST_ABORT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    GPIO_CHNL_1_ST_ABORT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    GPIO_CHNL_2_ST_ABORT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    GPIO_CHNL_3_ST_ABORT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    GPIO_CHNL_4_ST_ABORT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    GPIO_CHNL_5_ST_ABORT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    GPIO_CHNL_6_ST_ABORT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    GPIO_CHNL_7_ST_ABORT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    GPIO_TIMER_0_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    GPIO_TIMER_1_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    GPIO_TIMER_2_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    GPIO_TIMER_3_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    GPIO_INTR_DEBUG_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    GPIO_TRIG_PULSE_STATUS_BCLR  " "0,1"

  group.long 0x6C++0x3
  line.long 0x0 "ITM_GPIO_STATUS_BSET"
    textline ""
    bitfld.long 0x0 0. "    GPIO_CHNL_0_CMPLT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    GPIO_CHNL_1_CMPLT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    GPIO_CHNL_2_CMPLT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    GPIO_CHNL_3_CMPLT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    GPIO_CHNL_4_CMPLT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    GPIO_CHNL_5_CMPLT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    GPIO_CHNL_6_CMPLT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    GPIO_CHNL_7_CMPLT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    GPIO_CHNL_0_ST_ABORT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    GPIO_CHNL_1_ST_ABORT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    GPIO_CHNL_2_ST_ABORT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    GPIO_CHNL_3_ST_ABORT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    GPIO_CHNL_4_ST_ABORT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    GPIO_CHNL_5_ST_ABORT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    GPIO_CHNL_6_ST_ABORT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    GPIO_CHNL_7_ST_ABORT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    GPIO_TIMER_0_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    GPIO_TIMER_1_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    GPIO_TIMER_2_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    GPIO_TIMER_3_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    GPIO_INTR_DEBUG_STATUS_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    GPIO_TRIG_PULSE_STATUS_BSET  " "0,1"

  group.long 0x70++0x3
  line.long 0x0 "ITM_GPIO_EN_BCLR"
    textline ""
    bitfld.long 0x0 0. "    GPIO_CHNL_0_CMPLT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    GPIO_CHNL_1_CMPLT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    GPIO_CHNL_2_CMPLT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    GPIO_CHNL_3_CMPLT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    GPIO_CHNL_4_CMPLT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    GPIO_CHNL_5_CMPLT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    GPIO_CHNL_6_CMPLT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    GPIO_CHNL_7_CMPLT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    GPIO_CHNL_0_ST_ABORT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    GPIO_CHNL_1_ST_ABORT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    GPIO_CHNL_2_ST_ABORT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    GPIO_CHNL_3_ST_ABORT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    GPIO_CHNL_4_ST_ABORT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    GPIO_CHNL_5_ST_ABORT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    GPIO_CHNL_6_ST_ABORT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    GPIO_CHNL_7_ST_ABORT_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    GPIO_TIMER_0_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    GPIO_TIMER_1_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    GPIO_TIMER_2_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    GPIO_TIMER_3_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    GPIO_INTR_DEBUG_EN_BCLR  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    GPIO_TRIG_PULSE_EN_BCLR  " "0,1"

  group.long 0x74++0x3
  line.long 0x0 "ITM_GPIO_EN_BSET"
    textline ""
    bitfld.long 0x0 0. "    GPIO_CHNL_0_CMPLT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 1. "    GPIO_CHNL_1_CMPLT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 2. "    GPIO_CHNL_2_CMPLT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 3. "    GPIO_CHNL_3_CMPLT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 4. "    GPIO_CHNL_4_CMPLT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 5. "    GPIO_CHNL_5_CMPLT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 6. "    GPIO_CHNL_6_CMPLT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 7. "    GPIO_CHNL_7_CMPLT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    GPIO_CHNL_0_ST_ABORT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    GPIO_CHNL_1_ST_ABORT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 10. "    GPIO_CHNL_2_ST_ABORT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 11. "    GPIO_CHNL_3_ST_ABORT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 12. "    GPIO_CHNL_4_ST_ABORT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 13. "    GPIO_CHNL_5_ST_ABORT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    GPIO_CHNL_6_ST_ABORT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 15. "    GPIO_CHNL_7_ST_ABORT_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    GPIO_TIMER_0_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 17. "    GPIO_TIMER_1_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 18. "    GPIO_TIMER_2_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 19. "    GPIO_TIMER_3_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 20. "    GPIO_INTR_DEBUG_EN_BSET  " "0,1"
    textline ""
    bitfld.long 0x0 21. "    GPIO_TRIG_PULSE_EN_BSET  " "0,1"

  group.word 0x78++0x1
  line.word 0x0 "ITM_EWB_STATUS"
    textline ""
    bitfld.word 0x0 0. "    EWB_0_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    EWB_1_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    EWB_2_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    EWB_3_STATUS  " "0,1"

  group.word 0x7C++0x1
  line.word 0x0 "ITM_EWB_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    EWB_0_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    EWB_1_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    EWB_2_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    EWB_3_EN_STATUS  " "0,1"

  group.word 0x80++0x1
  line.word 0x0 "ITM_EWB_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    EWB_0_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    EWB_1_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    EWB_2_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    EWB_3_STATUS_BCLR  " "0,1"

  group.word 0x84++0x1
  line.word 0x0 "ITM_EWB_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    EWB_0_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    EWB_1_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    EWB_2_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    EWB_3_STATUS_BSET  " "0,1"

  group.word 0x88++0x1
  line.word 0x0 "ITM_EWB_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    EWB_0_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    EWB_1_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    EWB_2_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    EWB_3_EN_BCLR  " "0,1"

  group.word 0x8C++0x1
  line.word 0x0 "ITM_EWB_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    EWB_0_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    EWB_1_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    EWB_2_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    EWB_3_EN_BSET  " "0,1"

  group.word 0x90++0x1
  line.word 0x0 "ITM_MMWB_STATUS"
    textline ""
    bitfld.word 0x0 0. "    MMWB_STATUS  " "0,1"

  group.word 0x94++0x1
  line.word 0x0 "ITM_MMWB_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    MMWB_EN_STATUS  " "0,1"

  group.word 0x98++0x1
  line.word 0x0 "ITM_MMWB_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    MMWB_STATUS_BCLR  " "0,1"

  group.word 0x9C++0x1
  line.word 0x0 "ITM_MMWB_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    MMWB_STATUS_BSET  " "0,1"

  group.word 0xA0++0x1
  line.word 0x0 "ITM_MMWB_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    MMWB_EN_BCLR  " "0,1"

  group.word 0xA4++0x1
  line.word 0x0 "ITM_MMWB_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    MMWB_EN_BSET  " "0,1"

  group.word 0xA8++0x1
  line.word 0x0 "ITM_GLACE_STATUS"
    textline ""
    bitfld.word 0x0 0. "    GLACE_STATUS  " "0,1"

  group.word 0xAC++0x1
  line.word 0x0 "ITM_GLACE_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    GLACE_EN_STATUS  " "0,1"

  group.word 0xB0++0x1
  line.word 0x0 "ITM_GLACE_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    GLACE_STATUS_BCLR  " "0,1"

  group.word 0xB4++0x1
  line.word 0x0 "ITM_GLACE_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    GLACE_STATUS_BSET  " "0,1"

  group.word 0xB8++0x1
  line.word 0x0 "ITM_GLACE_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    GLACE_EN_BCLR  " "0,1"

  group.word 0xBC++0x1
  line.word 0x0 "ITM_GLACE_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    GLACE_EN_BSET  " "0,1"

  group.word 0xC0++0x1
  line.word 0x0 "ITM_EXP6X8_STATUS"
    textline ""
    bitfld.word 0x0 0. "    EXP6X8_STATUS  " "0,1"

  group.word 0xC4++0x1
  line.word 0x0 "ITM_EXP6X8_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    EXP6X8_EN_STATUS  " "0,1"

  group.word 0xC8++0x1
  line.word 0x0 "ITM_EXP6X8_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    EXP6X8_STATUS_BCLR  " "0,1"

  group.word 0xCC++0x1
  line.word 0x0 "ITM_EXP6X8_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    EXP6X8_STATUS_BSET  " "0,1"

  group.word 0xD0++0x1
  line.word 0x0 "ITM_EXP6X8_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    EXP6X8_EN_BCLR  " "0,1"

  group.word 0xD4++0x1
  line.word 0x0 "ITM_EXP6X8_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    EXP6X8_EN_BSET  " "0,1"

  group.word 0xD8++0x1
  line.word 0x0 "ITM_GHIST_STATUS"
    textline ""
    bitfld.word 0x0 0. "    GHIST_STATUS  " "0,1"

  group.word 0xDC++0x1
  line.word 0x0 "ITM_GHIST_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    GHIST_EN_STATUS  " "0,1"

  group.word 0xE0++0x1
  line.word 0x0 "ITM_GHIST_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    GHIST_STATUS_BCLR  " "0,1"

  group.word 0xE4++0x1
  line.word 0x0 "ITM_GHIST_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    GHIST_STATUS_BSET  " "0,1"

  group.word 0xE8++0x1
  line.word 0x0 "ITM_GHIST_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    GHIST_EN_BCLR  " "0,1"

  group.word 0xEC++0x1
  line.word 0x0 "ITM_GHIST_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    GHIST_EN_BSET  " "0,1"

  group.word 0xF0++0x1
  line.word 0x0 "ITM_AF_STATUS"
    textline ""
    bitfld.word 0x0 0. "    AF_0_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    AF_1_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    AF_2_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    AF_3_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    AF_4_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    AF_5_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    AF_6_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    AF_7_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    AF_8_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    AF_9_STATUS  " "0,1"

  group.word 0xF4++0x1
  line.word 0x0 "ITM_AF_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    AF_0_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    AF_1_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    AF_2_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    AF_3_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    AF_4_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    AF_5_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    AF_6_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    AF_7_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    AF_8_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    AF_9_EN_STATUS  " "0,1"

  group.word 0xF8++0x1
  line.word 0x0 "ITM_AF_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    AF_0_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    AF_1_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    AF_2_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    AF_3_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    AF_4_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    AF_5_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    AF_6_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    AF_7_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    AF_8_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    AF_9_STATUS_BCLR  " "0,1"

  group.word 0xFC++0x1
  line.word 0x0 "ITM_AF_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    AF_0_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    AF_1_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    AF_2_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    AF_3_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    AF_4_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    AF_5_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    AF_6_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    AF_7_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    AF_8_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    AF_9_STATUS_BSET  " "0,1"

  group.word 0x100++0x1
  line.word 0x0 "ITM_AF_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    AF_0_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    AF_1_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    AF_2_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    AF_3_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    AF_4_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    AF_5_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    AF_6_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    AF_7_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    AF_8_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    AF_9_EN_BCLR  " "0,1"

  group.word 0x104++0x1
  line.word 0x0 "ITM_AF_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    AF_0_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    AF_1_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    AF_2_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    AF_3_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    AF_4_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    AF_5_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    AF_6_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    AF_7_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    AF_8_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    AF_9_EN_BSET  " "0,1"

  group.word 0x108++0x1
  line.word 0x0 "ITM_ARCTIC_STATUS"
    textline ""
    bitfld.word 0x0 0. "    ARCTIC_STATUS  " "0,1"

  group.word 0x10C++0x1
  line.word 0x0 "ITM_ARCTIC_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    ARCTIC_EN_STATUS  " "0,1"

  group.word 0x110++0x1
  line.word 0x0 "ITM_ARCTIC_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    ARCTIC_STATUS_BCLR  " "0,1"

  group.word 0x114++0x1
  line.word 0x0 "ITM_ARCTIC_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    ARCTIC_STATUS_BSET  " "0,1"

  group.word 0x118++0x1
  line.word 0x0 "ITM_ARCTIC_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    ARCTIC_EN_BCLR  " "0,1"

  group.word 0x11C++0x1
  line.word 0x0 "ITM_ARCTIC_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    ARCTIC_EN_BSET  " "0,1"

  group.word 0x138++0x1
  line.word 0x0 "ITM_SKIND_STATUS"
    textline ""
    bitfld.word 0x0 0. "    SKIND_STATUS  " "0,1"

  group.word 0x13C++0x1
  line.word 0x0 "ITM_SKIND_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    SKIND_EN_STATUS  " "0,1"

  group.word 0x140++0x1
  line.word 0x0 "ITM_SKIND_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    SKIND_STATUS_BCLR  " "0,1"

  group.word 0x144++0x1
  line.word 0x0 "ITM_SKIND_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    SKIND_STATUS_BSET  " "0,1"

  group.word 0x148++0x1
  line.word 0x0 "ITM_SKIND_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    SKIND_EN_BCLR  " "0,1"

  group.word 0x14C++0x1
  line.word 0x0 "ITM_SKIND_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    SKIND_EN_BSET  " "0,1"

  group.word 0x150++0x1
  line.word 0x0 "ITM_VIDPIPE0_STATUS"
    textline ""
    bitfld.word 0x0 0. "    STATUS  " "0,1"

  group.word 0x154++0x1
  line.word 0x0 "ITM_VIDPIPE0_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    EN_STATUS  " "0,1"

  group.word 0x158++0x1
  line.word 0x0 "ITM_VIDPIPE0_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    STATUS_BCLR  " "0,1"

  group.word 0x15C++0x1
  line.word 0x0 "ITM_VIDPIPE0_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    STATUS_BSET  " "0,1"

  group.word 0x160++0x1
  line.word 0x0 "ITM_VIDPIPE0_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    EN_BCLR  " "0,1"

  group.word 0x164++0x1
  line.word 0x0 "ITM_VIDPIPE0_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    EN_BSET  " "0,1"

  group.word 0x168++0x1
  line.word 0x0 "ITM_VIDPIPE1_STATUS"
    textline ""
    bitfld.word 0x0 0. "    STATUS  " "0,1"

  group.word 0x16C++0x1
  line.word 0x0 "ITM_VIDPIPE1_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    EN_STATUS  " "0,1"

  group.word 0x170++0x1
  line.word 0x0 "ITM_VIDPIPE1_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    STATUS_BCLR  " "0,1"

  group.word 0x174++0x1
  line.word 0x0 "ITM_VIDPIPE1_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    STATUS_BSET  " "0,1"

  group.word 0x178++0x1
  line.word 0x0 "ITM_VIDPIPE1_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    EN_BCLR  " "0,1"

  group.word 0x17C++0x1
  line.word 0x0 "ITM_VIDPIPE1_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    EN_BSET  " "0,1"

  group.word 0x180++0x1
  line.word 0x0 "ITM_SMIARX_STATUS"
    textline ""
    bitfld.word 0x0 0. "    SMIARX_0_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    SMIARX_1_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    SMIARX_2_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    SMIARX_4_STATUS  " "0,1"

  group.word 0x184++0x1
  line.word 0x0 "ITM_SMIARX_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    SMIARX_0_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    SMIARX_1_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    SMIARX_2_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    SMIARX_4_EN_STATUS  " "0,1"

  group.word 0x188++0x1
  line.word 0x0 "ITM_SMIARX_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    SMIARX_0_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    SMIARX_1_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    SMIARX_2_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    SMIARX_4_STATUS_BCLR  " "0,1"

  group.word 0x18C++0x1
  line.word 0x0 "ITM_SMIARX_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    SMIARX_0_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    SMIARX_1_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    SMIARX_2_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    SMIARX_4_STATUS_BSET  " "0,1"

  group.word 0x190++0x1
  line.word 0x0 "ITM_SMIARX_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    SMIARX_0_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    SMIARX_1_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    SMIARX_2_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    SMIARX_4_EN_BCLR  " "0,1"

  group.word 0x194++0x1
  line.word 0x0 "ITM_SMIARX_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    SMIARX_0_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    SMIARX_1_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    SMIARX_2_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    SMIARX_4_EN_BSET  " "0,1"

  group.word 0x198++0x1
  line.word 0x0 "ITM_LBE_STATUS"
    textline ""
    bitfld.word 0x0 0. "    LBE_STATUS  " "0,1"

  group.word 0x19C++0x1
  line.word 0x0 "ITM_LBE_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    LBE_EN_STATUS  " "0,1"

  group.word 0x1A0++0x1
  line.word 0x0 "ITM_LBE_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    LBE_STATUS_BCLR  " "0,1"

  group.word 0x1A4++0x1
  line.word 0x0 "ITM_LBE_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    LBE_STATUS_BSET  " "0,1"

  group.word 0x1A8++0x1
  line.word 0x0 "ITM_LBE_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    LBE_EN_BCLR  " "0,1"

  group.word 0x1AC++0x1
  line.word 0x0 "ITM_LBE_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    LBE_EN_BSET  " "0,1"

  group.word 0x1B0++0x1
  line.word 0x0 "ITM_MCCI_STATUS"
    textline ""
    bitfld.word 0x0 0. "    MCCI_EOP_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    MCCI_ERROR_STATUS  " "0,1"

  group.word 0x1B4++0x1
  line.word 0x0 "ITM_MCCI_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    MCCI_EOP_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    MCCI_ERROR_EN_STATUS  " "0,1"

  group.word 0x1B8++0x1
  line.word 0x0 "ITM_MCCI_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    MCCI_EOP_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    MCCI_ERROR_STATUS_BCLR  " "0,1"

  group.word 0x1BC++0x1
  line.word 0x0 "ITM_MCCI_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    MCCI_EOP_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    MCCI_ERROR_STATUS_BSET  " "0,1"

  group.word 0x1C0++0x1
  line.word 0x0 "ITM_MCCI_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    MCCI_EOP_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    MCCI_ERROR_EN_BCLR  " "0,1"

  group.word 0x1C4++0x1
  line.word 0x0 "ITM_MCCI_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    MCCI_EOP_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    MCCI_ERROR_EN_BSET  " "0,1"

  group.word 0x1C8++0x1
  line.word 0x0 "ITM_HCOM_STATUS"
    textline ""
    bitfld.word 0x0 0. "    HCOM_STATUS  " "0,1"

  group.word 0x1CC++0x1
  line.word 0x0 "ITM_HCOM_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    HCOM_EN_STATUS  " "0,1"

  group.word 0x1D0++0x1
  line.word 0x0 "ITM_HCOM_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    HCOM_STATUS_BCLR  " "0,1"

  group.word 0x1D4++0x1
  line.word 0x0 "ITM_HCOM_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    HCOM_STATUS_BSET  " "0,1"

  group.word 0x1D8++0x1
  line.word 0x0 "ITM_HCOM_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    HCOM_EN_BCLR  " "0,1"

  group.word 0x1DC++0x1
  line.word 0x0 "ITM_HCOM_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    HCOM_EN_BSET  " "0,1"

  group.word 0x1E0++0x1
  line.word 0x0 "ITM_REPIPE_STATUS"
    textline ""
    bitfld.word 0x0 0. "    RE_IN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    RE_POSTGAIN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    RE_OUT_STORE_STATUS  " "0,1"

  group.word 0x1E4++0x1
  line.word 0x0 "ITM_REPIPE_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    RE_IN_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    RE_POSTGAIN_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    RE_OUT_STORE_EN_STATUS  " "0,1"

  group.word 0x1E8++0x1
  line.word 0x0 "ITM_REPIPE_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    RE_IN_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    RE_POSTGAIN_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    RE_OUT_STORE_STATUS_BCLR  " "0,1"

  group.word 0x1EC++0x1
  line.word 0x0 "ITM_REPIPE_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    RE_IN_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    RE_POSTGAIN_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    RE_OUT_STORE_STATUS_BSET  " "0,1"

  group.word 0x1F0++0x1
  line.word 0x0 "ITM_REPIPE_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    RE_IN_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    RE_POSTGAIN_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    RE_OUT_STORE_EN_BCLR  " "0,1"

  group.word 0x1F4++0x1
  line.word 0x0 "ITM_REPIPE_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    RE_IN_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    RE_POSTGAIN_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    RE_OUT_STORE_EN_BSET  " "0,1"

  group.word 0x1F8++0x1
  line.word 0x0 "ITM_DMCEPIPE_STATUS"
    textline ""
    bitfld.word 0x0 0. "    DMCE_IN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    DMCE_OUT_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    RGB_STORE_STATUS  " "0,1"

  group.word 0x1FC++0x1
  line.word 0x0 "ITM_DMCEPIPE_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    DMCE_IN_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    DMCE_OUT_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    RGB_STORE_EN_STATUS  " "0,1"

  group.word 0x200++0x1
  line.word 0x0 "ITM_DMCEPIPE_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    DMCE_IN_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    DMCE_OUT_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    RGB_STORE_STATUS_BCLR  " "0,1"

  group.word 0x204++0x1
  line.word 0x0 "ITM_DMCEPIPE_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    DMCE_IN_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    DMCE_OUT_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    RGB_STORE_STATUS_BSET  " "0,1"

  group.word 0x208++0x1
  line.word 0x0 "ITM_DMCEPIPE_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    DMCE_IN_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    DMCE_OUT_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    RGB_STORE_EN_BCLR  " "0,1"

  group.word 0x20C++0x1
  line.word 0x0 "ITM_DMCEPIPE_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    DMCE_IN_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    DMCE_OUT_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    RGB_STORE_EN_BSET  " "0,1"

  group.word 0x210++0x1
  line.word 0x0 "ITM_3D_SMIARX_STATUS"
    textline ""
    bitfld.word 0x0 0. "    SMIARX_3D_0_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    SMIARX_3D_1_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    SMIARX_3D_2_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3D_3_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    SMIARX_3D_4_STATUS  " "0,1"

  group.word 0x214++0x1
  line.word 0x0 "ITM_3D_SMIARX_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    SMIARX_3D_0_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    SMIARX_3D_1_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    SMIARX_3D_2_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3D_3_EN_STATUS  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    SMIARX_3D_4_EN_STATUS  " "0,1"

  group.word 0x218++0x1
  line.word 0x0 "ITM_3D_SMIARX_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    SMIARX_3D_0_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    SMIARX_3D_1_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    SMIARX_3D_2_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3D_3_STATUS_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    SMIARX_3D_4_STATUS_BCLR  " "0,1"

  group.word 0x21C++0x1
  line.word 0x0 "ITM_3D_SMIARX_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    SMIARX_3D_0_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    SMIARX_3D_1_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    SMIARX_3D_2_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3D_3_STATUS_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    SMIARX_3D_4_STATUS_BSET  " "0,1"

  group.word 0x220++0x1
  line.word 0x0 "ITM_3D_SMIARX_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    SMIARX_3D_0_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    SMIARX_3D_1_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    SMIARX_3D_2_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3D_3_EN_BCLR  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    SMIARX_3D_4_EN_BCLR  " "0,1"

  group.word 0x224++0x1
  line.word 0x0 "ITM_3D_SMIARX_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    SMIARX_3D_0_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    SMIARX_3D_1_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    SMIARX_3D_2_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    SMIARX_3D_3_EN_BSET  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    SMIARX_3D_4_EN_BSET  " "0,1"

  group.word 0x228++0x1
  line.word 0x0 "ITM_LINE_BURSTY_ELIM_STATUS"
    textline ""
    bitfld.word 0x0 0. "    LINE_BURSTY_ELIM_STATUS  " "0,1"

  group.word 0x22C++0x1
  line.word 0x0 "ITM_LINE_BURSTY_ELIM_EN_STATUS"
    textline ""
    bitfld.word 0x0 0. "    LINE_BURSTY_ELIM_EN_STATUS  " "0,1"

  group.word 0x230++0x1
  line.word 0x0 "ITM_LINE_BURSTY_ELIM_STATUS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    LINE_BURSTY_ELIM_STATUS_BCLR  " "0,1"

  group.word 0x234++0x1
  line.word 0x0 "ITM_LINE_BURSTY_ELIM_STATUS_BSET"
    textline ""
    bitfld.word 0x0 0. "    LINE_BURSTY_ELIM_STATUS_BSET  " "0,1"

  group.word 0x238++0x1
  line.word 0x0 "ITM_LINE_BURSTY_ELIM_EN_BCLR"
    textline ""
    bitfld.word 0x0 0. "    LINE_BURSTY_ELIM_EN_BCLR  " "0,1"

  group.word 0x23C++0x1
  line.word 0x0 "ITM_LINE_BURSTY_ELIM_EN_BSET"
    textline ""
    bitfld.word 0x0 0. "    LINE_BURSTY_ELIM_EN_BSET  " "0,1"

tree.end


base a:0xa0252500
tree "ISP_SMIARX"

  group.long 0x00++0x3
  line.long 0x0 "ISP_SMIARX_CTRL"
    textline ""
    bitfld.long 0x0 0. "    rx_start  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    rx_stop  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    rx_abort  " "0,1"

  group.long 0x04++0x3
  line.long 0x0 "ISP_SMIARX_SETUP"
    textline ""
    bitfld.long 0x0 0.--3. "    ip_pix_width  " ",,,,,,B_0x6,B_0x7,B_0x8,,B_0xA,,B_0xC"
    textline ""
    bitfld.long 0x0 4.--7. "    op_pix_width  " ",,,,,,B_0x6,B_0x7,B_0x8,,B_0xA,,B_0xC"
    textline ""
    bitfld.long 0x0 8. "    parallel_enable  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    vsync_polarity  " "ACTIVE_LOW,ACTIVE_HIGH"
    textline ""
    bitfld.long 0x0 10. "    hsync_polarity  " "ACTIVE_LOW,ACTIVE_HIGH"
    textline ""
    bitfld.long 0x0 11. "    ds_mode  " "DISABLE,ENABLE"
    textline ""
    bitfld.long 0x0 12. "    dcpx_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.long 0x0 13. "    ccp_sel  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    reset_ccp_rx_n  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    auto_sync  " "SYNCHRO_SENSOR,SYNCHRO_AUTO"
    textline ""
    bitfld.long 0x0 17.--19. "    pattern_type  " "PATTERN_DISABLE,PATTERN_COLOUR_BAR,PATTERN_GRAD_BAR,PATTERN_DIAG_GREY,PATTERN_PSEUDORANDOM,PATTERN_HOR_GREY,PATTERN_VERT_GREY,PATTERN_SOLID"
    textline ""
    bitfld.long 0x0 20. "    no_sof  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    clr_ccp_shift_sync  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    clr_ccp_crc_error  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    clr_pixel_sync_error  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    clr_aborted_iframe  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    clr_insuff_iline  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    fifo_rd_rst  " "0,1"

  group.long 0x08++0x3
  line.long 0x0 "ISP_SMIARX_FRAME_CTRL"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    latency_lines  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    stream_size  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    start_grab_dly  "
    textline ""
    bitfld.long 0x0 24.--25. "    ffhc_control  " "FFHC_DISABLE,FFHC_FULL_AUTO,FFHC_SEMI_AUTO,FFHC_MANUAL"
    textline ""
    bitfld.long 0x0 26. "    stop_at_interframe  " "0,1"

  group.long 0x0C++0x3
  line.long 0x0 "ISP_SMIARX_STATUS"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    frame_counter  "
    textline ""
    bitfld.long 0x0 8.--9. "    rx_state  " "GEN_IDLE,GEN_WAITVSTART,GEN_RUNNING,GEN_WAITFRAME"
    textline ""
    bitfld.long 0x0 10.--12. "    ff_state  " "FF_IDLE,FF_WAIT_EOSD,FF_FIRSTLINE,FF_TRANSLATE,FF_UPDATE,FF_INTERFRAME"
    textline ""
    bitfld.long 0x0 13.--15. "    snoop_state  " "SNOOP_IDLE,SNOOP_TAG_LSN,SNOOP_TAG,SNOOP_REG_LSM,SNOOP_REG"
    textline ""
    hexmask.long 0x0 16.--20. 1 "    fifo_rd_usedw  "
    textline ""
    bitfld.long 0x0 21. "    fifo_empty  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    pixel_sync_error  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    aborted_iframe  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    insuff_iline  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    fifo_under  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    fifo_over  " "0,1"

  group.long 0x10++0x3
  line.long 0x0 "ISP_SMIARX_TPAT_DATA_RG"
    textline ""
    hexmask.long 0x0 0.--12. 1 "    tpat_data_gir  "
    textline ""
    hexmask.long 0x0 16.--28. 1 "    tpat_data_red  "

  group.long 0x14++0x3
  line.long 0x0 "ISP_SMIARX_TPAT_DATA_BG"
    textline ""
    hexmask.long 0x0 0.--12. 1 "    tpat_data_gib  "
    textline ""
    hexmask.long 0x0 16.--28. 1 "    tpat_data_blu  "

  group.long 0x18++0x3
  line.long 0x0 "ISP_SMIARX_TPAT_HCUR_WP"
    textline ""
    hexmask.long 0x0 0.--12. 1 "    tpat_hcur_posn  "
    textline ""
    hexmask.long 0x0 16.--28. 1 "    tpat_hcur_width  "

  group.long 0x1C++0x3
  line.long 0x0 "ISP_SMIARX_TPAT_VCUR_WP"
    textline ""
    hexmask.long 0x0 0.--12. 1 "    tpat_vcur_posn  "
    textline ""
    hexmask.long 0x0 16.--28. 1 "    tpat_vcur_width  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_SMIARX_CCP_STATUS"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    ccp_channel  "
    textline ""
    bitfld.word 0x0 8. "    ccp_false_sync  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    ccp_shift_sync  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    ccp_crc_error  " "0,1"

  group.word 0x24++0x1
  line.word 0x0 "ISP_SMIARX_HK_REQ_ADDR_0"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hk_req_addr  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_SMIARX_HK_REQ_ADDR_1"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hk_req_addr  "

  group.word 0x2C++0x1
  line.word 0x0 "ISP_SMIARX_HK_REQ_ADDR_2"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hk_req_addr  "

  group.word 0x30++0x1
  line.word 0x0 "ISP_SMIARX_HK_REQ_ADDR_3"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hk_req_addr  "

  group.word 0x34++0x1
  line.word 0x0 "ISP_SMIARX_HK_REQ_DATA_0"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    hk_req_data  "

  group.word 0x38++0x1
  line.word 0x0 "ISP_SMIARX_HK_REQ_DATA_1"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    hk_req_data  "

  group.word 0x3C++0x1
  line.word 0x0 "ISP_SMIARX_HK_REQ_DATA_2"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    hk_req_data  "

  group.word 0x40++0x1
  line.word 0x0 "ISP_SMIARX_HK_REQ_DATA_3"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    hk_req_data  "

  group.long 0x44++0x3
  line.long 0x0 "ISP_SMIARX_INT_COUNT_0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    pix_count  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    line_count  "

  group.long 0x48++0x3
  line.long 0x0 "ISP_SMIARX_INT_COUNT_1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    pix_count  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    line_count  "

  group.long 0x4C++0x3
  line.long 0x0 "ISP_SMIARX_INT_COUNT_2"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    pix_count  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    line_count  "

  group.long 0x50++0x3
  line.long 0x0 "ISP_SMIARX_INT_COUNT_3"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    pix_count  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    line_count  "

  group.word 0x54++0x1
  line.word 0x0 "ISP_SMIARX_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    dfv_count_0_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    dfv_count_1_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    dfv_count_2_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    dfv_count_3_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    dfv_seq_complete_interrupt_ctrl  " "0,1"

  group.word 0x58++0x1
  line.word 0x0 "ISP_SMIARX_COUNT_INT_EN"
    textline ""
    bitfld.word 0x0 0. "    rx_line_count_0_int_en  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    rx_line_count_1_int_en  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    rx_line_count_2_int_en  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    rx_line_count_3_int_en  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    rx_seq_complete_int_en  " "0,1"

  group.long 0x5C++0x3
  line.long 0x0 "ISP_SMIARX_OVERRIDE"
    textline ""
    hexmask.long 0x0 0.--22. 1 "    override  "

  group.word 0x60++0x1
  line.word 0x0 "ISP_SMIARX_SENSOR_ID"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    sensor_id  "

  group.word 0x64++0x1
  line.word 0x0 "ISP_SMIARX_PIXEL_ORDER"
    textline ""
    bitfld.word 0x0 0.--1. "    pixel_order  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    bitfld.word 0x0 8.--9. "    pixel_order_ovr  " "B_0x0,B_0x1,B_0x2,B_0x3"

  group.word 0x68++0x1
  line.word 0x0 "ISP_SMIARX_AUTO_HENV_LENGTH"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    auto_henv_length  "

  group.long 0x6C++0x3
  line.long 0x0 "ISP_SMIARX_FRAME_LENGTH"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    frame_length  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    frame_length_ovr  "

  group.long 0x70++0x3
  line.long 0x0 "ISP_SMIARX_LINE_LENGTH"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    line_length  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    line_length_ovr  "

  group.word 0x74++0x1
  line.word 0x0 "ISP_SMIARX_X_ADDR_START"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_addr_start  "

  group.word 0x78++0x1
  line.word 0x0 "ISP_SMIARX_Y_ADDR_START"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_addr_start  "

  group.word 0x7C++0x1
  line.word 0x0 "ISP_SMIARX_X_ADDR_END"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_addr_end  "

  group.word 0x80++0x1
  line.word 0x0 "ISP_SMIARX_Y_ADDR_END"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_addr_end  "

  group.word 0x84++0x1
  line.word 0x0 "ISP_SMIARX_X_OUTPUT_SIZE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_output_size  "

  group.word 0x88++0x1
  line.word 0x0 "ISP_SMIARX_Y_OUTPUT_SIZE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_output_size  "

  group.word 0x8C++0x1
  line.word 0x0 "ISP_SMIARX_ADDR_INCREMENTS"
    textline ""
    bitfld.word 0x0 0. "    x_even_inc_lsb  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    x_even_inc_lsb_ovr  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    x_odd_inc_lsb  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    x_odd_inc_lsb_ovr  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    y_even_inc_lsb  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    y_even_inc_lsb_ovr  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    y_odd_inc_lsb  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    y_odd_inc_lsb_ovr  " "0,1"

  group.word 0x90++0x1
  line.word 0x0 "ISP_SMIARX_FINE_EXPOSURE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    fine_exposure  "

  group.word 0x94++0x1
  line.word 0x0 "ISP_SMIARX_COARSE_EXPOSURE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    coarse_exposure  "

  group.word 0x98++0x1
  line.word 0x0 "ISP_SMIARX_ANALOG_GAIN"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    analog_gain  "

  group.word 0x9C++0x1
  line.word 0x0 "ISP_SMIARX_MODEL_SUBTYPE"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    frame_format_model_subtype  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    frame_format_model_subtype_ovr  "

  group.word 0xA0++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_0"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xA2++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_1"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xA4++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_2"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xA6++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_3"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xA8++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_4"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xAA++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_5"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xAC++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_6"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xAE++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_7"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xB0++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_8"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xB2++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_9"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xB4++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_10"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xB6++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_11"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xB8++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_12"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xBA++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_13"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xBC++0x1
  line.word 0x0 "ISP_SMIARX_DESCRIPTOR_14"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xBE++0x1
  line.word 0x0 "ISP_SMIARX_TYPE_TRANS_1"
    textline ""
    bitfld.word 0x0 0.--2. "    type_trans_mspec_4  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.word 0x0 4.--6. "    type_trans_mspec_5  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.word 0x0 8.--10. "    type_trans_mspec_6  " "BLANK,BLACK,DARK,ACTIVE"

  group.long 0xC0++0x3
  line.long 0x0 "ISP_SMIARX_TYPE_TRANS_0"
    textline ""
    bitfld.long 0x0 0.--2. "    type_trans_black  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 4.--6. "    type_trans_dark  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 8.--10. "    type_trans_visible  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 12.--14. "    type_trans_dummy  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 16.--18. "    type_trans_mspec_0  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 20.--22. "    type_trans_mspec_1  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 24.--26. "    type_trans_mspec_2  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 28.--30. "    type_trans_mspec_3  " "BLANK,BLACK,DARK,ACTIVE"

  group.long 0xC4++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_0"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xC8++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_1"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xCC++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_2"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xD0++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_3"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xD4++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_4"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xD8++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_5"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xDC++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_6"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xE0++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_7"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xE4++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_8"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xE8++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_9"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xEC++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_10"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xF0++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_11"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xF4++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_12"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xF8++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_13"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xFC++0x3
  line.long 0x0 "ISP_SMIARX_DESCRIPTOR_OVR_14"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

tree.end


base a:0xa0252600
tree "ISP_SD_IDP_GATE"

  group.word 0x00++0x1
  line.word 0x0 "ISP_SD_IDP_GATE_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_SD_IDP_GATE_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252620
tree "ISP_BAYER_STORE_SD_CLK"

  group.word 0x00++0x1
  line.word 0x0 "ISP_BAYER_STORE_SD_CLK_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_BAYER_STORE_SD_CLK_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252640
tree "ISP_LBE"

  group.word 0x00++0x1
  line.word 0x0 "ISP_LBE_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    line_blk_elim_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    line_blk_elim_soft_reset  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_LBE_DFV"
    textline ""
    bitfld.word 0x0 0. "    line_blk_elim_dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    line_blk_elim_dfv_interrupt_ctrl  " "0,1"

  group.word 0x08++0x1
  line.word 0x0 "ISP_LBE_H_SIZE"
    textline ""
    hexmask.word 0x0 0.--13. 1 "    line_blk_elim_h_size  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_LBE_READ_START"
    textline ""
    hexmask.word 0x0 0.--13. 1 "    line_blk_elim_read_start  "

tree.end


base a:0xa0252700
tree "ISP_BAYER_STORE_PIX_CLK"

  group.word 0x00++0x1
  line.word 0x0 "ISP_BAYER_STORE_PIX_CLK_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_BAYER_STORE_PIX_CLK_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252720
tree "ISP_RE_BAYER_LOAD"

  group.word 0x00++0x1
  line.word 0x0 "ISP_RE_BAYER_LOAD_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_RE_BAYER_LOAD_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252740
tree "ISP_RSO"

  group.word 0x00++0x1
  line.word 0x0 "ISP_RSO_SLANT_CTRL"
    textline ""
    bitfld.word 0x0 0. "    rso_en  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_RSO_DC_TERM_GR"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    dc_term_gr  "

  group.long 0x08++0x3
  line.long 0x0 "ISP_RSO_X_COEF_GR"
    textline ""
    hexmask.long 0x0 0.--17. 1 "    x_coef_gr  "

  group.long 0x0C++0x3
  line.long 0x0 "ISP_RSO_Y_COEF_GR"
    textline ""
    hexmask.long 0x0 0.--17. 1 "    y_coef_gr  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_RSO_DC_TERM_RR"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    dc_term_rr  "

  group.long 0x14++0x3
  line.long 0x0 "ISP_RSO_X_COEF_RR"
    textline ""
    hexmask.long 0x0 0.--17. 1 "    x_coef_rr  "

  group.long 0x18++0x3
  line.long 0x0 "ISP_RSO_Y_COEF_RR"
    textline ""
    hexmask.long 0x0 0.--17. 1 "    y_coef_rr  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_RSO_DC_TERM_BB"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    dc_term_bb  "

  group.long 0x20++0x3
  line.long 0x0 "ISP_RSO_X_COEF_BB"
    textline ""
    hexmask.long 0x0 0.--17. 1 "    x_coef_bb  "

  group.long 0x24++0x3
  line.long 0x0 "ISP_RSO_Y_COEF_BB"
    textline ""
    hexmask.long 0x0 0.--17. 1 "    y_coef_bb  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_RSO_DC_TERM_GB"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    dc_term_gb  "

  group.long 0x2C++0x3
  line.long 0x0 "ISP_RSO_X_COEF_GB"
    textline ""
    hexmask.long 0x0 0.--17. 1 "    x_coef_gb  "

  group.long 0x30++0x3
  line.long 0x0 "ISP_RSO_Y_COEF_GB"
    textline ""
    hexmask.long 0x0 0.--17. 1 "    y_coef_gb  "

  group.word 0x34++0x1
  line.word 0x0 "ISP_RSO_X_SLANT_ORIGIN"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    x_slant_origin  "

  group.word 0x38++0x1
  line.word 0x0 "ISP_RSO_Y_SLANT_ORIGIN"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    y_slant_origin  "

tree.end


base a:0xa0252780
tree "ISP_FLEXTF_LINEAR"

  group.word 0x00++0x1
  line.word 0x0 "ISP_FLEXTF_LINEAR_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_FLEXTF_LINEAR_LAST_ELT_GREEN_GIR"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_green_gir  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_FLEXTF_LINEAR_LAST_ELT_RED"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_red  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_FLEXTF_LINEAR_LAST_ELT_BLUE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_blue  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_FLEXTF_LINEAR_LAST_ELT_GIB"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_gib  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_FLEXTF_LINEAR_PIXELIN_SHIFT"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    pixel_shift  "

tree.end


base a:0xa02527a0
tree "ISP_GRIDIRON"

  group.word 0x00++0x1
  line.word 0x0 "ISP_GRIDIRON_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable_gridiron  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "INACTIVE,ACTIVE"

  group.long 0x04++0x3
  line.long 0x0 "ISP_GRIDIRON_CTRL"
    textline ""
    hexmask.long 0x0 0.--3. 1 "    loggridpitch  "
    textline ""
    bitfld.long 0x0 8. "    mem_init  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 16. "    en_cast0  " "DISABLE,ENABLE"
    textline ""
    bitfld.long 0x0 17. "    en_cast1  " "DISABLE,ENABLE"
    textline ""
    bitfld.long 0x0 18. "    en_cast2  " "DISABLE,ENABLE"
    textline ""
    bitfld.long 0x0 19. "    en_cast3  " "DISABLE,ENABLE"
    textline ""
    bitfld.long 0x0 24. "    super_sensitive  " "NORMAL,SUPERSENSITIVE"

  group.long 0x08++0x3
  line.long 0x0 "ISP_GRIDIRON_CR_START"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    cr_h_start  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    cr_v_start  "

  group.long 0x0C++0x3
  line.long 0x0 "ISP_GRIDIRON_IM_SIZE"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    im_h_size  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    im_v_size  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_GRIDIRON_SENSOR_SIZE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    sensor_h_size  "

  group.long 0x14++0x3
  line.long 0x0 "ISP_GRIDIRON_SCALE"
    textline ""
    hexmask.long 0x0 0.--11. 1 "    hscale  "
    textline ""
    hexmask.long 0x0 16.--27. 1 "    vscale  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_GRIDIRON_LIVE_CAST_PHASE"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    fphase  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_GRIDIRON_PIX_ORDER"
    textline ""
    bitfld.word 0x0 0. "    hor_flip  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    ver_flip  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 2. "    wr_pix_order  " "DISABLE,ENABLE"

tree.end


base a:0xa02527e0
tree "ISP_CHG"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CHG_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    chg_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    chg_soft_reset  " "DISABLE_SOFT_RESET,ENABLE_SOFT_RESET"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CHG_SHADOW_COMPS"
    textline ""
    bitfld.word 0x0 0. "    shadow_comps  " "DISABLE_SHADOW,ENABLE_SHADOW"

  group.word 0x08++0x1
  line.word 0x0 "ISP_CHG_G1_COMP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    g1_comp  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CHG_R_COMP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    r_comp  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CHG_B_COMP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    b_comp  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CHG_G2_COMP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    g2_comp  "

tree.end


base a:0xa0252800
tree "ISP_SNAIL_SCORPIO"

  group.word 0x00++0x1
  line.word 0x0 "ISP_SNAIL_SCORPIO_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    snailnorec_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    snailnorec_soft_reset  " "SOFT_RESET_DISABLE,SOFT_RESET_ENABLE"

tree.end


base a:0xa0252820
tree "ISP_SCORPIO"

  group.word 0x00++0x1
  line.word 0x0 "ISP_SCORPIO_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    scorpio_enable_req  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    scorpio_enable_status  " "0,1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_SCORPIO_CONTROL"
    textline ""
    bitfld.word 0x0 0. "    scorpio_soft_reset  " "DISABLE,ENABLE"

  group.word 0x08++0x1
  line.word 0x0 "ISP_SCORPIO_CORING_LVL_REQ"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    scorpio_coring_level_req  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_SCORPIO_CORING_LVL_STATUS"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    scorpio_coring_level_status  "

tree.end


base a:0xa0252840
tree "ISP_SNAIL_DUSTER"

  group.word 0x00++0x1
  line.word 0x0 "ISP_SNAIL_DUSTER_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    snailnorec_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    snailnorec_soft_reset  " "SOFT_RESET_DISABLE,SOFT_RESET_ENABLE"

tree.end


base a:0xa0252880
tree "ISP_BAYER_STORE_POST_GAIN"

  group.word 0x00++0x1
  line.word 0x0 "ISP_BAYER_STORE_POST_GAIN_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_BAYER_STORE_POST_GAIN_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa02528a0
tree "ISP_ITPOINT_RE_IN"

  group.word 0x00++0x1
  line.word 0x0 "ISP_ITPOINT_RE_IN_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_ITPOINT_RE_IN_PIX_POS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    pix_pos  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_ITPOINT_RE_IN_LINE_POS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    line_pos  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_ITPOINT_RE_IN_PIX_CNT"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    pix_cnt  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_ITPOINT_RE_IN_LINE_CNT"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    line_cnt  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_ITPOINT_RE_IN_FRAME_CNT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    frame_cnt  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_ITPOINT_RE_IN_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    dfv_interrupt_ctrl  " "0,1"

tree.end


base a:0xa02528c0
tree "ISP_ITPOINT_POST_GAIN"

  group.word 0x00++0x1
  line.word 0x0 "ISP_ITPOINT_POST_GAIN_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_ITPOINT_POST_GAIN_PIX_POS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    pix_pos  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_ITPOINT_POST_GAIN_LINE_POS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    line_pos  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_ITPOINT_POST_GAIN_PIX_CNT"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    pix_cnt  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_ITPOINT_POST_GAIN_LINE_CNT"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    line_cnt  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_ITPOINT_POST_GAIN_FRAME_CNT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    frame_cnt  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_ITPOINT_POST_GAIN_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    dfv_interrupt_ctrl  " "0,1"

tree.end


base a:0xa02528e0
tree "ISP_ITPOINT_RE_OUT_STORE"

  group.word 0x00++0x1
  line.word 0x0 "ISP_ITPOINT_RE_OUT_STORE_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_ITPOINT_RE_OUT_STORE_PIX_POS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    pix_pos  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_ITPOINT_RE_OUT_STORE_LINE_POS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    line_pos  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_ITPOINT_RE_OUT_STORE_PIX_CNT"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    pix_cnt  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_ITPOINT_RE_OUT_STORE_LINE_CNT"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    line_cnt  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_ITPOINT_RE_OUT_STORE_FRAME_CNT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    frame_cnt  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_ITPOINT_RE_OUT_STORE_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    dfv_interrupt_ctrl  " "0,1"

tree.end


base a:0xa0252900
tree "ISP_DUSTER"

  group.word 0x00++0x1
  line.word 0x0 "ISP_DUSTER_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    duster_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    duster_soft_reset  " "0,1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_DUSTER_DFV"
    textline ""
    bitfld.word 0x0 0. "    duster_dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    duster_dfv_interrupt_ctrl  " "0,1"

  group.word 0x0C++0x1
  line.word 0x0 "ISP_DUSTER_SCYT_RANK_HI"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    duster_scyt_rank_hi  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_DUSTER_SCYT_RANK_LO"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    duster_scyt_rank_lo  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_DUSTER_SCYT_SMOOTH_HI"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    duster_scyt_smooth_hi  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_DUSTER_SCYT_SMOOTH_LO"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    duster_scyt_smooth_lo  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_DUSTER_BYPASS_CTRL"
    textline ""
    bitfld.word 0x0 0. "    duster_rc_bypass  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    duster_cc_bypass  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    duster_detect_cc_bypass  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    duster_defcor_bypass  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    duster_gaussian_bypass  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    duster_rc_use_simplified  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    duster_rc_enablegrad  " "0,1"
    textline ""
    bitfld.word 0x0 8.--9. "    duster_scythe_mode  " "SCYTHEMAP,SCYTHEANDMAP,BYPASSSCYTHE,FORCESCYTHE"

  group.word 0x20++0x1
  line.word 0x0 "ISP_DUSTER_CC_LOCAL_SIGMA_TH"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    duster_cc_local_sigma_th  "

  group.word 0x24++0x1
  line.word 0x0 "ISP_DUSTER_RC_NORM_TH"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    duster_rc_norm_th  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_DUSTER_SIGMA_GAUSSIAN"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    duster_sigma_gaussian  "

  group.word 0x2C++0x1
  line.word 0x0 "ISP_DUSTER_GAUSSIAN_TH1"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    DUSTER_GAUSSIAN_TH1  "

  group.word 0x30++0x1
  line.word 0x0 "ISP_DUSTER_GAUSSIAN_TH2"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    DUSTER_GAUSSIAN_TH2  "

  group.word 0x34++0x1
  line.word 0x0 "ISP_DUSTER_GAUSSIAN_TH3"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    duster_gaussian_th3  "

  group.word 0x38++0x1
  line.word 0x0 "ISP_DUSTER_S0"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    duster_s0  "

  group.word 0x3C++0x1
  line.word 0x0 "ISP_DUSTER_S1"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    duster_s1  "

  group.word 0x40++0x1
  line.word 0x0 "ISP_DUSTER_S2"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    duster_s2  "

  group.word 0x44++0x1
  line.word 0x0 "ISP_DUSTER_SIGMA_SAMPLES"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    duster_sigma_samples  "

  group.word 0x48++0x1
  line.word 0x0 "ISP_DUSTER_ZERO_SAMPLES"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    duster_zero_samples  "

  group.word 0x4C++0x1
  line.word 0x0 "ISP_DUSTER_NLE_HIST0"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    duster_nle_hist0  "

  group.word 0x50++0x1
  line.word 0x0 "ISP_DUSTER_NLE_HIST1"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    duster_nle_hist1  "

  group.word 0x54++0x1
  line.word 0x0 "ISP_DUSTER_ENABLE_STATUS"
    textline ""
    bitfld.word 0x0 0. "    duster_enable_status  " "0,1"

  group.word 0x5C++0x1
  line.word 0x0 "ISP_DUSTER_SCYT_RANK_HI_STATUS"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    duster_scyt_rank_hi_status  "

  group.word 0x60++0x1
  line.word 0x0 "ISP_DUSTER_SCYT_RANK_LO_STATUS"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    duster_scyt_rank_lo_status  "

  group.word 0x64++0x1
  line.word 0x0 "ISP_DUSTER_SCYT_SMOOTH_HI_STATUS"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    duster_scyt_smooth_hi_status  "

  group.word 0x68++0x1
  line.word 0x0 "ISP_DUSTER_SCYT_SMOOTH_LO_STATUS"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    duster_scyt_smooth_lo_status  "

  group.word 0x6C++0x1
  line.word 0x0 "ISP_DUSTER_BYPASS_STATUS"
    textline ""
    bitfld.word 0x0 0. "    duster_rc_bypass_status  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    duster_cc_bypass_status  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    duster_detect_cc_bypass_status  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    duster_defcor_bypass_status  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    duster_gaussian_bypass_status  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    duster_rc_use_simplified_status  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    duster_rc_enablegrad_status  " "0,1"

  group.word 0x70++0x1
  line.word 0x0 "ISP_DUSTER_CC_LOCAL_SIGMA_TH_STATUS"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    duster_cc_local_sigma_th_status  "

  group.word 0x74++0x1
  line.word 0x0 "ISP_DUSTER_RC_NORM_TH_STATUS"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    duster_rc_norm_th_status  "

  group.word 0x78++0x1
  line.word 0x0 "ISP_DUSTER_SIGMA_GAUSSIAN_STATUS"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    duster_sigma_gaussian_status  "

  group.word 0x7C++0x1
  line.word 0x0 "ISP_DUSTER_GAUSSIAN_TH1_STATUS"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    DUSTER_GAUSSIAN_TH1_status  "

  group.word 0x80++0x1
  line.word 0x0 "ISP_DUSTER_GAUSSIAN_TH2_STATUS"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    DUSTER_GAUSSIAN_TH2_status  "

  group.word 0x84++0x1
  line.word 0x0 "ISP_DUSTER_GAUSSIAN_TH3_STATUS"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    duster_gaussian_th3_status  "

  group.word 0x88++0x1
  line.word 0x0 "ISP_DUSTER_S0_STATUS"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    duster_s0_status  "

  group.word 0x8C++0x1
  line.word 0x0 "ISP_DUSTER_S1_STATUS"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    duster_s1_status  "

  group.word 0x90++0x1
  line.word 0x0 "ISP_DUSTER_S2_STATUS"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    duster_s2_status  "

tree.end


base a:0xa0252a00
tree "ISP_SNAIL_BINNING"

  group.word 0x00++0x1
  line.word 0x0 "ISP_SNAIL_BINNING_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    snailnorec_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    snailnorec_soft_reset  " "SOFT_RESET_DISABLE,SOFT_RESET_ENABLE"

tree.end


base a:0xa0252a20
tree "ISP_BINNING_REPAIR"

  group.word 0x00++0x1
  line.word 0x0 "ISP_BINNING_REPAIR_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    binning_repair_enable  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_BINNING_REPAIR_CONTROL"
    textline ""
    bitfld.word 0x0 0. "    soft_reset  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    br_coef_hjog  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 5. "    br_coef_vjog  " "DISABLE,ENABLE"

  group.word 0x08++0x1
  line.word 0x0 "ISP_BINNING_REPAIR_COEF00"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    br_coef00  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_BINNING_REPAIR_COEF01"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    br_coef01  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_BINNING_REPAIR_COEF10"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    br_coef10  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_BINNING_REPAIR_COEF11"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    br_coef11  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_BINNING_REPAIR_COEF_SFT"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    br_coef_sft  "

tree.end


base a:0xa0252a40
tree "ISP_CROP_BAYER"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CROP_BAYER_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    crop_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    crop_soft_reset  " "SOFT_RST_DISABLE,SOFT_RST_ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CROP_BAYER_SOF_RETIMING"
    textline ""
    bitfld.word 0x0 0. "    crop_sof_retiming  " "DISABLE,ENABLE"

  group.word 0x08++0x1
  line.word 0x0 "ISP_CROP_BAYER_SHADOW_CROPS"
    textline ""
    bitfld.word 0x0 0. "    crop_shadow_crops  " "0,1"

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CROP_BAYER_H_START"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_h_start  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CROP_BAYER_V_START"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_v_start  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CROP_BAYER_H_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_h_size  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_CROP_BAYER_V_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_v_size  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_CROP_BAYER_IACTIVE_PIXS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_iactive_pixs  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_CROP_BAYER_IACTIVE_LINES"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_iactive_lines  "

tree.end


base a:0xa0252a80
tree "ISP_BAYER_STORE_RE_OUT"

  group.word 0x00++0x1
  line.word 0x0 "ISP_BAYER_STORE_RE_OUT_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_BAYER_STORE_RE_OUT_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252ac0
tree "ISP_SNAIL_BABYLON"

  group.word 0x00++0x1
  line.word 0x0 "ISP_SNAIL_BABYLON_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    snailnorec_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    snailnorec_soft_reset  " "SOFT_RESET_DISABLE,SOFT_RESET_ENABLE"

tree.end


base a:0xa0252ae0
tree "ISP_BABYLON"

  group.word 0x00++0x1
  line.word 0x0 "ISP_BABYLON_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable_babylon  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_BABYLON_ZIPPERKILL"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    zipperkill  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_BABYLON_FLAT_TH"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    flat_th  "

tree.end


base a:0xa0252b40
tree "ISP_DMCE_BAYER_LOAD"

  group.word 0x00++0x1
  line.word 0x0 "ISP_DMCE_BAYER_LOAD_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_DMCE_BAYER_LOAD_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252b60
tree "ISP_DMCE_RGB_LOAD"

  group.word 0x00++0x1
  line.word 0x0 "ISP_DMCE_RGB_LOAD_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_DMCE_RGB_LOAD_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252b80
tree "ISP_DMCE_RGB_STORE"

  group.word 0x00++0x1
  line.word 0x0 "ISP_DMCE_RGB_STORE_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_DMCE_RGB_STORE_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252ba0
tree "ISP_CHANNELMERGE"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CHANNELMERGE_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    channel_merge_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    channel_merge_soft_reset  " "0,1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CHANNELMERGE_HSIZE"
    textline ""
    hexmask.word 0x0 0.--13. 1 "    channel_merge_hsize  "

tree.end


base a:0xa0252bc0
tree "ISP_DMCE_MUX_DEMOSAIC"

  group.word 0x00++0x1
  line.word 0x0 "ISP_DMCE_MUX_DEMOSAIC_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_DMCE_MUX_DEMOSAIC_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252be0
tree "ISP_LINE_BURSTY_ELIM"

  group.word 0x00++0x1
  line.word 0x0 "ISP_LINE_BURSTY_ELIM_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    line_blk_elim_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    line_blk_elim_soft_reset  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_LINE_BURSTY_ELIM_DFV"
    textline ""
    bitfld.word 0x0 0. "    line_blk_elim_dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    line_blk_elim_dfv_interrupt_ctrl  " "0,1"

  group.word 0x08++0x1
  line.word 0x0 "ISP_LINE_BURSTY_ELIM_H_SIZE"
    textline ""
    hexmask.word 0x0 0.--13. 1 "    line_blk_elim_h_size  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_LINE_BURSTY_ELIM_READ_START"
    textline ""
    hexmask.word 0x0 0.--13. 1 "    line_blk_elim_read_start  "

tree.end


base a:0xa0252c00
tree "ISP_CE0_IDP_GATE"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_IDP_GATE_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_IDP_GATE_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252c20
tree "ISP_CE0_CROP"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_CROP_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    crop_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    crop_soft_reset  " "SOFT_RST_DISABLE,SOFT_RST_ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_CROP_SOF_RETIMING"
    textline ""
    bitfld.word 0x0 0. "    crop_sof_retiming  " "DISABLE,ENABLE"

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE0_CROP_SHADOW_CROPS"
    textline ""
    bitfld.word 0x0 0. "    crop_shadow_crops  " "0,1"

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE0_CROP_H_START"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_h_start  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE0_CROP_V_START"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_v_start  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE0_CROP_H_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_h_size  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_CE0_CROP_V_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_v_size  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_CE0_CROP_IACTIVE_PIXS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_iactive_pixs  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_CE0_CROP_IACTIVE_LINES"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_iactive_lines  "

tree.end


base a:0xa0252c60
tree "ISP_CE0_RADIAL_ADSOC_PK"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_PK_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    ADSOC_ENABLE  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_PK_ADSHARP_EN"
    textline ""
    bitfld.word 0x0 0. "    ADSOC_ADAPTIVE_SHARPENING  " "DISABLE,ENABLE"

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_PK_CORING_LEVEL"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    ADSOC_CORING_LEVEL  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_PK_OSHOOT_CTRL"
    textline ""
    hexmask.word 0x0 0.--4. 1 "    ADSOC_OSHOOT_GAIN_BRIGHT  "
    textline ""
    hexmask.word 0x0 8.--12. 1 "    ADSOC_OSHOOT_GAIN_DARK  "

  group.long 0x10++0x3
  line.long 0x0 "ISP_CE0_RADIAL_ADSOC_PK_EFFECTS"
    textline ""
    hexmask.long 0x0 0.--2. 1 "    ADSOC_EMBOSS_SELECT  "
    textline ""
    hexmask.long 0x0 8.--9. 1 "    ADSOC_FLIPPER  "
    textline ""
    hexmask.long 0x0 16.--17. 1 "    ADSOC_GREYBACK  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_PK_GAIN"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ADSOC_GAIN  "

tree.end


base a:0xa0252c78
tree "ISP_CE0_RADIAL_ADSOC_RP"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_RP_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    rdpk_enable  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_RP_POLYCOEF0"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    rdpk_qvec0  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_RP_POLYCOEF1"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    rdpk_qvec1  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_RP_COF_SHIFT"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    rdpk_cof_shift  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_RP_OUT_SHIFT"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    rdpk_out_shift  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_RP_UNITY"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    rdpk_unity  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_RP_HOFFSET"
    textline ""
    hexmask.word 0x0 0.--13. 1 "    rdpk_hoffset  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_RP_VOFFSET"
    textline ""
    hexmask.word 0x0 0.--13. 1 "    rdpk_voffset  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_RP_SCALE_X"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rdpk_scaling_factor_x  "

  group.word 0x24++0x1
  line.word 0x0 "ISP_CE0_RADIAL_ADSOC_RP_SCALE_Y"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rdpk_scaling_factor_y  "

tree.end


base a:0xa0252ca0
tree "ISP_CE0_MUX_GPS"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_MUX_GPS_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_MUX_GPS_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252cc0
tree "ISP_CE0_MUX_SHARP"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_MUX_SHARP_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_MUX_SHARP_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252ce0
tree "ISP_CE0_MUX_UNSHARP"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_MUX_UNSHARP_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_MUX_UNSHARP_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252d00
tree "ISP_CE0_FLEXTF_SHARP"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_FLEXTF_SHARP_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_FLEXTF_SHARP_LAST_ELT_GREEN_GIR"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_green_gir  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE0_FLEXTF_SHARP_LAST_ELT_RED"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_red  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE0_FLEXTF_SHARP_LAST_ELT_BLUE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_blue  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE0_FLEXTF_SHARP_LAST_ELT_GIB"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_gib  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE0_FLEXTF_SHARP_PIXELIN_SHIFT"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    pixel_shift  "

tree.end


base a:0xa0252d20
tree "ISP_CE0_FLEXTF_UNSHARP"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_FLEXTF_UNSHARP_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_FLEXTF_UNSHARP_LAST_ELT_GREEN_GIR"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_green_gir  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE0_FLEXTF_UNSHARP_LAST_ELT_RED"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_red  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE0_FLEXTF_UNSHARP_LAST_ELT_BLUE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_blue  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE0_FLEXTF_UNSHARP_LAST_ELT_GIB"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_gib  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE0_FLEXTF_UNSHARP_PIXELIN_SHIFT"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    pixel_shift  "

tree.end


base a:0xa0252d40
tree "ISP_CE0_MUX_MATRIX_ADSOC"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_MUX_MATRIX_ADSOC_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_MUX_MATRIX_ADSOC_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252d60
tree "ISP_CE0_SNAIL0_ADSOC"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_SNAIL0_ADSOC_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    snailnorec_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    snailnorec_soft_reset  " "SOFT_RESET_DISABLE,SOFT_RESET_ENABLE"

tree.end


base a:0xa0252d80
tree "ISP_CE0_SNAIL1_ADSOC"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_SNAIL1_ADSOC_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    snailnorec_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    snailnorec_soft_reset  " "SOFT_RESET_DISABLE,SOFT_RESET_ENABLE"

tree.end


base a:0xa0252da0
tree "ISP_CE0_MATRIX"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_MATRIX_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_MATRIX_RCOF00"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof00  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE0_MATRIX_RCOF01"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof01  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE0_MATRIX_RCOF02"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof02  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE0_MATRIX_RCOF10"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof10  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE0_MATRIX_RCOF11"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof11  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_CE0_MATRIX_RCOF12"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof12  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_CE0_MATRIX_RCOF20"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof20  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_CE0_MATRIX_RCOF21"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof21  "

  group.word 0x24++0x1
  line.word 0x0 "ISP_CE0_MATRIX_RCOF22"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof22  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_CE0_MATRIX_R_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    r_offset  "

  group.word 0x2C++0x1
  line.word 0x0 "ISP_CE0_MATRIX_G_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    g_offset  "

  group.word 0x30++0x1
  line.word 0x0 "ISP_CE0_MATRIX_B_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    b_offset  "

tree.end


base a:0xa0252de0
tree "ISP_CE0_PIXDELAY_0"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_PIXDELAY_0_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    pix_delay_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    pix_delay_soft_reset  " "SOFT_RST_DISABLE,SOFT_RST_ENABLE"

tree.end


base a:0xa0252e00
tree "ISP_CE0_PIXDELAY_1"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_PIXDELAY_1_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    pix_delay_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    pix_delay_soft_reset  " "SOFT_RST_DISABLE,SOFT_RST_ENABLE"

tree.end


base a:0xa0252e20
tree "ISP_CE0_SPECIALFX"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_SPECIALFX_SOL_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    sfx_sol_enable  " "DISABLE_SOLAR,ENABLE_SOLAR"
    textline ""
    bitfld.word 0x0 4. "    sfx_soft_reset  " "DISABLE_SOFT_RESET,ENABLE_SOFT_RESET"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_SPECIALFX_NEG_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    sfx_neg_enable  " "DISABLE_NEG,ENABLE_NEG"

tree.end


base a:0xa0252e40
tree "ISP_CE0_DITHER"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_DITHER_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_DITHER_GREEN_BITS"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    iGbits  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE0_DITHER_REDBLUE_BITS"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    iRBbits  "

tree.end


base a:0xa0252e60
tree "ISP_CE0_UV_LOAD"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_UV_LOAD_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_UV_LOAD_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0252f00
tree "ISP_CE0_GPSSCALER"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_GPSSCALER_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    h_gps_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    v_gps_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    gps_soft_reset  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_GPSSCALER_DOWNSCALING"
    textline ""
    bitfld.word 0x0 0. "    gps_downscaling  " "0,1"

  group.long 0x08++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_LR_BORD_PIXS"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    h_left_border_pixs  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    h_right_border_pixs  "

  group.long 0x0C++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_TB_BORD_LINES"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    v_top_border_lines  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    v_bottom_border_lines  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE0_GPSSCALER_H_V_FIRTAPS"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    v_fir_taps  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    h_fir_taps  "

  group.long 0x14++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_H_V_IPSIZES"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    v_input_size  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    h_input_size  "

  group.long 0x18++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_H_V_OPSIZES"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    v_input_size  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    h_input_size  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_CE0_GPSSCALER_H_V_LOGPHYSPOLYS"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    v_log_phys_polys  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    h_log_phys_polys  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_CE0_GPSSCALER_H_V_KICKOFF_DLY"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    v_kickoff_delay  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    h_kickoff_delay  "

  group.long 0x24++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_H_V_CROPFRAC"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    v_crop_frac  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    h_crop_frac  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_CE0_GPSSCALER_H_V_STEPBULK"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    v_step_bulk  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    h_step_bulk  "

  group.long 0x2C++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_H_V_STEPFRAC"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    v_step_frac  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    h_step_frac  "

  group.long 0x30++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_0_3"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr3  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr2  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr1  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr0  "

  group.long 0x34++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_4_7"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr7  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr6  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr5  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr4  "

  group.long 0x38++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_8_11"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr11  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr10  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr9  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr8  "

  group.long 0x3C++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_12_15"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr15  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr14  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr13  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr12  "

  group.long 0x40++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_16_19"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr19  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr18  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr17  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr16  "

  group.long 0x44++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_20_23"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr23  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr22  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr21  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr20  "

  group.long 0x48++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_24_27"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr27  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr26  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr25  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr24  "

  group.long 0x4C++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_28_31"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr31  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr30  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr29  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr28  "

  group.long 0x50++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_32_35"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr35  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr34  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr33  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr32  "

  group.long 0x54++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_36_39"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr39  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr38  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr37  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr36  "

  group.long 0x58++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_40_43"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr43  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr42  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr41  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr40  "

  group.long 0x5C++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_44_47"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr47  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr46  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr45  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr44  "

  group.long 0x60++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_48_51"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr51  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr50  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr49  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr48  "

  group.long 0x64++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_52_55"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr55  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr54  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr53  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr52  "

  group.long 0x68++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_56_59"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr59  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr58  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr57  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr56  "

  group.long 0x6C++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_HCOF_60_63"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr63  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr62  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr61  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr60  "

  group.long 0x70++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_0_3"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr3  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr2  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr1  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr0  "

  group.long 0x74++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_4_7"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr7  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr6  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr5  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr4  "

  group.long 0x78++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_8_11"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr11  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr10  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr9  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr8  "

  group.long 0x7C++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_12_15"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr15  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr14  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr13  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr12  "

  group.long 0x80++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_16_19"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr19  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr18  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr17  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr16  "

  group.long 0x84++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_20_23"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr23  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr22  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr21  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr20  "

  group.long 0x88++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_24_27"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr27  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr26  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr25  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr24  "

  group.long 0x8C++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_28_31"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr31  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr30  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr29  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr28  "

  group.long 0x90++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_32_35"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr35  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr34  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr33  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr32  "

  group.long 0x94++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_36_39"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr39  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr38  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr37  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr36  "

  group.long 0x98++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_40_43"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr43  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr42  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr41  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr40  "

  group.long 0x9C++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_44_47"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr47  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr46  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr45  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr44  "

  group.long 0xA0++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_48_51"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr51  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr50  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr49  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr48  "

  group.long 0xA4++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_52_55"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr55  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr54  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr53  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr52  "

  group.long 0xA8++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_56_59"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr59  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr58  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr57  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr56  "

  group.long 0xAC++0x3
  line.long 0x0 "ISP_CE0_GPSSCALER_VCOF_60_63"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr63  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr62  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr61  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr60  "

tree.end


base a:0xa0253000
tree "ISP_CE0_CODER"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE0_CODER_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE0_CODER_FORMAT"
    textline ""
    bitfld.word 0x0 0.--2. "    yuv_format  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5"

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE0_CODER_Y_COF00"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_y_cof00  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE0_CODER_Y_COF01"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_y_cof01  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE0_CODER_Y_COF02"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_y_cof02  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE0_CODER_CB_COF10"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_cb_cof10  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_CE0_CODER_CB_COF11"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_cb_cof11  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_CE0_CODER_CB_COF12"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_cb_cof12  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_CE0_CODER_CR_COF20"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_cr_cof20  "

  group.word 0x24++0x1
  line.word 0x0 "ISP_CE0_CODER_CR_COF21"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_cr_cof21  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_CE0_CODER_CR_COF22"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_cr_cof22  "

  group.word 0x2C++0x1
  line.word 0x0 "ISP_CE0_CODER_YFLOOR"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    yuv_yfloor  "

  group.word 0x30++0x1
  line.word 0x0 "ISP_CE0_CODER_CBFLOOR"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    yuv_cbfloor  "

  group.word 0x34++0x1
  line.word 0x0 "ISP_CE0_CODER_CRFLOOR"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    yuv_crfloor  "

  group.word 0x38++0x1
  line.word 0x0 "ISP_CE0_CODER_CB_COLOUR_EFFECT"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    yuv_cb_colour_effect_lo  "
    textline ""
    hexmask.word 0x0 8.--10. 1 "    yuv_cb_colour_effect_hi  "

  group.word 0x3C++0x1
  line.word 0x0 "ISP_CE0_CODER_CR_COLOUR_EFFECT"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    yuv_cr_colour_effect_lo  "
    textline ""
    hexmask.word 0x0 8.--10. 1 "    yuv_cr_colour_effect_hi  "

  group.word 0x40++0x1
  line.word 0x0 "ISP_CE0_CODER_CH0_MIN_CLIP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    yuv_ch0_min_clip  "

  group.word 0x44++0x1
  line.word 0x0 "ISP_CE0_CODER_CH0_MAX_CLIP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    yuv_ch0_max_clip  "

  group.word 0x48++0x1
  line.word 0x0 "ISP_CE0_CODER_CH1_MIN_CLIP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    yuv_ch1_min_clip  "

  group.word 0x4C++0x1
  line.word 0x0 "ISP_CE0_CODER_CH1_MAX_CLIP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    yuv_ch1_max_clip  "

  group.word 0x50++0x1
  line.word 0x0 "ISP_CE0_CODER_CH2_MIN_CLIP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    yuv_ch2_min_clip  "

  group.word 0x54++0x1
  line.word 0x0 "ISP_CE0_CODER_CH2_MAX_CLIP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    yuv_ch2_max_clip  "

  group.word 0x58++0x1
  line.word 0x0 "ISP_CE0_CODER_RAW_NONACTIVE"
    textline ""
    bitfld.word 0x0 0. "    yuv_raw_nonactive  " "DISABLE,ENABLE"

tree.end


base a:0xa0253060
tree "ISP_OPF0"

  group.word 0x00++0x1
  line.word 0x0 "ISP_OPF0_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_OPF0_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    dfv_interrupt_ctrl  " "0,1"

  group.word 0x08++0x1
  line.word 0x0 "ISP_OPF0_HSYNC_RISING"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hsync_rising  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_OPF0_HSYNC_FALLING"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hsync_falling  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_OPF0_VSYNC_RISING_FINE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_rising_fine  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_OPF0_VSYNC_FALLING_FINE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_falling_fine  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_OPF0_VSYNC_RISING_COARSE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_rising_coarse  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_OPF0_VSYNC_FALLING_COARSE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_falling_coarse  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_OPF0_HCROP_RISING"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hcrop_rising  "

  group.word 0x24++0x1
  line.word 0x0 "ISP_OPF0_HCROP_FALLING"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hcrop_falling  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_OPF0_VCROP_RISING_COARSE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vcrop_rising_coarse  "

  group.word 0x2C++0x1
  line.word 0x0 "ISP_OPF0_VCROP_FALLING_COARSE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vcrop_falling_coarse  "

  group.long 0x30++0x3
  line.long 0x0 "ISP_OPF0_CONTROL"
    textline ""
    bitfld.long 0x0 0. "    sync_based_pixvalid  " "SYNC_PIX_VALID_DISABLE,SYNC_PIX_VALID_ENABLE"
    textline ""
    bitfld.long 0x0 1. "    toggle_pix_valid  " "PIX_VALID_LEVEL,PIX_VALID_EDGE"
    textline ""
    bitfld.long 0x0 2.--4. "    rgb_flip  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5"
    textline ""
    bitfld.long 0x0 5. "    rgb_bit_flip  " "RGB_BITS_SWAP_DISABLE,RGB_BITS_SWAP_ENABLE"
    textline ""
    bitfld.long 0x0 6. "    embedded_code_en  " "EMB_CODE_DISABLE,EMB_CODE_ENABLE"
    textline ""
    bitfld.long 0x0 7. "    false_sync_code_protect_en  " "FSC_PROTECTION_DISABLE,FSC_PROTECTION_ENABLE"
    textline ""
    bitfld.long 0x0 8. "    invert_hsync  " "HSYNC_DISABLE,HSYNC_ENABLE"
    textline ""
    bitfld.long 0x0 9. "    invert_vsync  " "VSYNC_DISABLE,VSYNC_ENABLE"
    textline ""
    bitfld.long 0x0 10. "    idata_ch0_en  " "OPF_CHANNEL_DISABLE,OPF_CHANNEL_ENABLE"
    textline ""
    bitfld.long 0x0 11. "    idata_ch1_en  " "OPF_CHANNEL_DISABLE,OPF_CHANNEL_ENABLE"
    textline ""
    bitfld.long 0x0 12. "    idata_ch2_en  " "OPF_CHANNEL_DISABLE,OPF_CHANNEL_ENABLE"
    textline ""
    bitfld.long 0x0 13.--15. "    opf_output  " "OPF_RGB101010,OPF_RGB888,OPF_RGB565,OPF_RGB555,OPF_RGB444,OPF_YUV"
    textline ""
    bitfld.long 0x0 16. "    rgb444_format  " "RGB444_NOPACK,RGB444_PACKED"

  group.word 0x34++0x1
  line.word 0x0 "ISP_OPF0_PIXVALID_LTYPES"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    pixvalid_linetypes  "
    textline ""
    bitfld.word 0x0 6. "    eof_blank_only_en  " "0,1"

  group.word 0x38++0x1
  line.word 0x0 "ISP_OPF0_YCBCR_FLIP"
    textline ""
    bitfld.word 0x0 0. "    cbcr_flip  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    y_cbcr_flip  " "B_0x0,B_0x1"

  group.word 0x3C++0x1
  line.word 0x0 "ISP_OPF0_LAST_NONACT_LINE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_nonactive_line  "

  group.word 0x40++0x1
  line.word 0x0 "ISP_OPF0_HSYNC_RISING_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hsync_rising_status  "

  group.word 0x44++0x1
  line.word 0x0 "ISP_OPF0_HSYNC_FALLING_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hsync_falling_status  "

  group.word 0x48++0x1
  line.word 0x0 "ISP_OPF0_VSYNC_RISING_FINE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_rising_fine_status  "

  group.word 0x4C++0x1
  line.word 0x0 "ISP_OPF0_VSYNC_FALLING_FINE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_falling_fine_status  "

  group.word 0x50++0x1
  line.word 0x0 "ISP_OPF0_VSYNC_RISING_COARSE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_rising_coarse_status  "

  group.word 0x54++0x1
  line.word 0x0 "ISP_OPF0_VSYNC_FALLING_COARSE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_falling_coarse_status  "

  group.word 0x58++0x1
  line.word 0x0 "ISP_OPF0_HCROP_RISING_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hcrop_rising_status  "

  group.word 0x5C++0x1
  line.word 0x0 "ISP_OPF0_HCROP_FALLING_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hcrop_falling_status  "

  group.word 0x60++0x1
  line.word 0x0 "ISP_OPF0_VCROP_RISING_COARSE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vcrop_rising_coarse_status  "

  group.word 0x64++0x1
  line.word 0x0 "ISP_OPF0_VCROP_FALLING_COARSE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vcrop_falling_coarse_status  "

  group.long 0x68++0x3
  line.long 0x0 "ISP_OPF0_CONTROL_STATUS"
    textline ""
    bitfld.long 0x0 0. "    sync_based_pixvalid_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 1. "    toggle_pix_valid_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 2.--4. "    rgb_flip_status  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5"
    textline ""
    bitfld.long 0x0 5. "    rgb_bit_flip_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 6. "    embedded_code_en_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 7. "    false_sync_code_protect_en_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 8. "    invert_hsync_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 9. "    invert_vsync_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 10. "    idata_ch0_en_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 11. "    idata_ch1_en_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 12. "    idata_ch2_en_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 13.--15. "    opf_output_status  " "OPF_RGB101010,OPF_RGB888,OPF_RGB565,OPF_RGB555,OPF_RGB444,OPF_YUV"
    textline ""
    bitfld.long 0x0 16. "    rgb444_format_status  " "B_0x0,B_0x1"

  group.word 0x6C++0x1
  line.word 0x0 "ISP_OPF0_PIXVALID_LTYPES_STATUS"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    pixvalid_linetypes_status  "
    textline ""
    bitfld.word 0x0 6. "    eof_blank_only_en_status  " "0,1"

  group.word 0x70++0x1
  line.word 0x0 "ISP_OPF0_YCBCR_FLIP_STATUS"
    textline ""
    bitfld.word 0x0 0. "    cbcr_flip_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    y_cbcr_flip_status  " "B_0x0,B_0x1"

  group.word 0x74++0x1
  line.word 0x0 "ISP_OPF0_LAST_NONACT_LINE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_nonactive_line_status  "

tree.end


base a:0xa0253100
tree "ISP_CE1_IDP_GATE"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_IDP_GATE_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_IDP_GATE_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0253120
tree "ISP_CE1_CROP"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_CROP_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    crop_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    crop_soft_reset  " "SOFT_RST_DISABLE,SOFT_RST_ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_CROP_SOF_RETIMING"
    textline ""
    bitfld.word 0x0 0. "    crop_sof_retiming  " "DISABLE,ENABLE"

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE1_CROP_SHADOW_CROPS"
    textline ""
    bitfld.word 0x0 0. "    crop_shadow_crops  " "0,1"

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE1_CROP_H_START"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_h_start  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE1_CROP_V_START"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_v_start  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE1_CROP_H_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_h_size  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_CE1_CROP_V_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_v_size  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_CE1_CROP_IACTIVE_PIXS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_iactive_pixs  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_CE1_CROP_IACTIVE_LINES"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    crop_iactive_lines  "

tree.end


base a:0xa0253160
tree "ISP_CE1_RADIAL_ADSOC_PK"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_PK_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    ADSOC_ENABLE  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_PK_ADSHARP_EN"
    textline ""
    bitfld.word 0x0 0. "    ADSOC_ADAPTIVE_SHARPENING  " "DISABLE,ENABLE"

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_PK_CORING_LEVEL"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    ADSOC_CORING_LEVEL  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_PK_OSHOOT_CTRL"
    textline ""
    hexmask.word 0x0 0.--4. 1 "    ADSOC_OSHOOT_GAIN_BRIGHT  "
    textline ""
    hexmask.word 0x0 8.--12. 1 "    ADSOC_OSHOOT_GAIN_DARK  "

  group.long 0x10++0x3
  line.long 0x0 "ISP_CE1_RADIAL_ADSOC_PK_EFFECTS"
    textline ""
    hexmask.long 0x0 0.--2. 1 "    ADSOC_EMBOSS_SELECT  "
    textline ""
    hexmask.long 0x0 8.--9. 1 "    ADSOC_FLIPPER  "
    textline ""
    hexmask.long 0x0 16.--17. 1 "    ADSOC_GREYBACK  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_PK_GAIN"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    ADSOC_GAIN  "

tree.end


base a:0xa0253178
tree "ISP_CE1_RADIAL_ADSOC_RP"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_RP_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    rdpk_enable  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_RP_POLYCOEF0"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    rdpk_qvec0  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_RP_POLYCOEF1"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    rdpk_qvec1  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_RP_COF_SHIFT"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    rdpk_cof_shift  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_RP_OUT_SHIFT"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    rdpk_out_shift  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_RP_UNITY"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    rdpk_unity  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_RP_HOFFSET"
    textline ""
    hexmask.word 0x0 0.--13. 1 "    rdpk_hoffset  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_RP_VOFFSET"
    textline ""
    hexmask.word 0x0 0.--13. 1 "    rdpk_voffset  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_RP_SCALE_X"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rdpk_scaling_factor_x  "

  group.word 0x24++0x1
  line.word 0x0 "ISP_CE1_RADIAL_ADSOC_RP_SCALE_Y"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rdpk_scaling_factor_y  "

tree.end


base a:0xa02531a0
tree "ISP_CE1_MUX_GPS"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_MUX_GPS_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_MUX_GPS_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa02531c0
tree "ISP_CE1_MUX_SHARP"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_MUX_SHARP_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_MUX_SHARP_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa02531e0
tree "ISP_CE1_MUX_UNSHARP"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_MUX_UNSHARP_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_MUX_UNSHARP_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0253200
tree "ISP_CE1_FLEXTF_SHARP"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_FLEXTF_SHARP_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_FLEXTF_SHARP_LAST_ELT_GREEN_GIR"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_green_gir  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE1_FLEXTF_SHARP_LAST_ELT_RED"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_red  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE1_FLEXTF_SHARP_LAST_ELT_BLUE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_blue  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE1_FLEXTF_SHARP_LAST_ELT_GIB"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_gib  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE1_FLEXTF_SHARP_PIXELIN_SHIFT"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    pixel_shift  "

tree.end


base a:0xa0253220
tree "ISP_CE1_FLEXTF_UNSHARP"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_FLEXTF_UNSHARP_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_FLEXTF_UNSHARP_LAST_ELT_GREEN_GIR"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_green_gir  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE1_FLEXTF_UNSHARP_LAST_ELT_RED"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_red  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE1_FLEXTF_UNSHARP_LAST_ELT_BLUE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_blue  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE1_FLEXTF_UNSHARP_LAST_ELT_GIB"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_elt_gib  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE1_FLEXTF_UNSHARP_PIXELIN_SHIFT"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    pixel_shift  "

tree.end


base a:0xa0253240
tree "ISP_CE1_MUX_MATRIX_ADSOC"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_MUX_MATRIX_ADSOC_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_MUX_MATRIX_ADSOC_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0253260
tree "ISP_CE1_SNAIL0_ADSOC"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_SNAIL0_ADSOC_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    snailnorec_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    snailnorec_soft_reset  " "SOFT_RESET_DISABLE,SOFT_RESET_ENABLE"

tree.end


base a:0xa0253280
tree "ISP_CE1_SNAIL1_ADSOC"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_SNAIL1_ADSOC_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    snailnorec_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    snailnorec_soft_reset  " "SOFT_RESET_DISABLE,SOFT_RESET_ENABLE"

tree.end


base a:0xa02532a0
tree "ISP_CE1_MATRIX"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_MATRIX_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_MATRIX_RCOF00"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof00  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE1_MATRIX_RCOF01"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof01  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE1_MATRIX_RCOF02"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof02  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE1_MATRIX_RCOF10"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof10  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE1_MATRIX_RCOF11"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof11  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_CE1_MATRIX_RCOF12"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof12  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_CE1_MATRIX_RCOF20"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof20  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_CE1_MATRIX_RCOF21"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof21  "

  group.word 0x24++0x1
  line.word 0x0 "ISP_CE1_MATRIX_RCOF22"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    rcof22  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_CE1_MATRIX_R_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    r_offset  "

  group.word 0x2C++0x1
  line.word 0x0 "ISP_CE1_MATRIX_G_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    g_offset  "

  group.word 0x30++0x1
  line.word 0x0 "ISP_CE1_MATRIX_B_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    b_offset  "

tree.end


base a:0xa02532e0
tree "ISP_CE1_PIXDELAY_0"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_PIXDELAY_0_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    pix_delay_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    pix_delay_soft_reset  " "SOFT_RST_DISABLE,SOFT_RST_ENABLE"

tree.end


base a:0xa0253300
tree "ISP_CE1_PIXDELAY_1"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_PIXDELAY_1_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    pix_delay_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    pix_delay_soft_reset  " "SOFT_RST_DISABLE,SOFT_RST_ENABLE"

tree.end


base a:0xa0253320
tree "ISP_CE1_SPECIALFX"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_SPECIALFX_SOL_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    sfx_sol_enable  " "DISABLE_SOLAR,ENABLE_SOLAR"
    textline ""
    bitfld.word 0x0 4. "    sfx_soft_reset  " "DISABLE_SOFT_RESET,ENABLE_SOFT_RESET"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_SPECIALFX_NEG_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    sfx_neg_enable  " "DISABLE_NEG,ENABLE_NEG"

tree.end


base a:0xa0253340
tree "ISP_CE1_DITHER"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_DITHER_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_DITHER_GREEN_BITS"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    iGbits  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE1_DITHER_REDBLUE_BITS"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    iRBbits  "

tree.end


base a:0xa0253360
tree "ISP_CE1_UV_LOAD"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_UV_LOAD_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_UV_LOAD_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0253400
tree "ISP_CE1_GPSSCALER"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_GPSSCALER_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    h_gps_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    v_gps_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    gps_soft_reset  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_GPSSCALER_DOWNSCALING"
    textline ""
    bitfld.word 0x0 0. "    gps_downscaling  " "0,1"

  group.long 0x08++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_LR_BORD_PIXS"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    h_left_border_pixs  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    h_right_border_pixs  "

  group.long 0x0C++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_TB_BORD_LINES"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    v_top_border_lines  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    v_bottom_border_lines  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE1_GPSSCALER_H_V_FIRTAPS"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    v_fir_taps  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    h_fir_taps  "

  group.long 0x14++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_H_V_IPSIZES"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    v_input_size  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    h_input_size  "

  group.long 0x18++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_H_V_OPSIZES"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    v_input_size  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    h_input_size  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_CE1_GPSSCALER_H_V_LOGPHYSPOLYS"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    v_log_phys_polys  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    h_log_phys_polys  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_CE1_GPSSCALER_H_V_KICKOFF_DLY"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    v_kickoff_delay  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    h_kickoff_delay  "

  group.long 0x24++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_H_V_CROPFRAC"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    v_crop_frac  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    h_crop_frac  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_CE1_GPSSCALER_H_V_STEPBULK"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    v_step_bulk  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    h_step_bulk  "

  group.long 0x2C++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_H_V_STEPFRAC"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    v_step_frac  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    h_step_frac  "

  group.long 0x30++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_0_3"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr3  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr2  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr1  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr0  "

  group.long 0x34++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_4_7"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr7  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr6  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr5  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr4  "

  group.long 0x38++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_8_11"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr11  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr10  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr9  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr8  "

  group.long 0x3C++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_12_15"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr15  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr14  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr13  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr12  "

  group.long 0x40++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_16_19"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr19  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr18  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr17  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr16  "

  group.long 0x44++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_20_23"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr23  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr22  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr21  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr20  "

  group.long 0x48++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_24_27"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr27  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr26  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr25  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr24  "

  group.long 0x4C++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_28_31"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr31  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr30  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr29  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr28  "

  group.long 0x50++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_32_35"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr35  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr34  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr33  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr32  "

  group.long 0x54++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_36_39"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr39  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr38  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr37  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr36  "

  group.long 0x58++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_40_43"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr43  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr42  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr41  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr40  "

  group.long 0x5C++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_44_47"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr47  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr46  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr45  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr44  "

  group.long 0x60++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_48_51"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr51  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr50  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr49  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr48  "

  group.long 0x64++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_52_55"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr55  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr54  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr53  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr52  "

  group.long 0x68++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_56_59"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr59  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr58  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr57  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr56  "

  group.long 0x6C++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_HCOF_60_63"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    h_cof_set_wr63  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    h_cof_set_wr62  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    h_cof_set_wr61  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    h_cof_set_wr60  "

  group.long 0x70++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_0_3"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr3  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr2  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr1  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr0  "

  group.long 0x74++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_4_7"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr7  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr6  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr5  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr4  "

  group.long 0x78++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_8_11"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr11  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr10  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr9  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr8  "

  group.long 0x7C++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_12_15"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr15  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr14  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr13  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr12  "

  group.long 0x80++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_16_19"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr19  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr18  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr17  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr16  "

  group.long 0x84++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_20_23"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr23  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr22  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr21  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr20  "

  group.long 0x88++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_24_27"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr27  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr26  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr25  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr24  "

  group.long 0x8C++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_28_31"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr31  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr30  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr29  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr28  "

  group.long 0x90++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_32_35"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr35  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr34  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr33  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr32  "

  group.long 0x94++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_36_39"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr39  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr38  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr37  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr36  "

  group.long 0x98++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_40_43"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr43  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr42  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr41  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr40  "

  group.long 0x9C++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_44_47"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr47  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr46  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr45  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr44  "

  group.long 0xA0++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_48_51"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr51  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr50  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr49  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr48  "

  group.long 0xA4++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_52_55"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr55  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr54  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr53  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr52  "

  group.long 0xA8++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_56_59"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr59  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr58  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr57  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr56  "

  group.long 0xAC++0x3
  line.long 0x0 "ISP_CE1_GPSSCALER_VCOF_60_63"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    v_cof_set_wr63  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    v_cof_set_wr62  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    v_cof_set_wr61  "
    textline ""
    hexmask.long 0x0 24.--31. 1 "    v_cof_set_wr60  "

tree.end


base a:0xa0253500
tree "ISP_CE1_CODER"

  group.word 0x00++0x1
  line.word 0x0 "ISP_CE1_CODER_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_CE1_CODER_FORMAT"
    textline ""
    bitfld.word 0x0 0.--2. "    yuv_format  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5"

  group.word 0x08++0x1
  line.word 0x0 "ISP_CE1_CODER_Y_COF00"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_y_cof00  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_CE1_CODER_Y_COF01"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_y_cof01  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_CE1_CODER_Y_COF02"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_y_cof02  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_CE1_CODER_CB_COF10"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_cb_cof10  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_CE1_CODER_CB_COF11"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_cb_cof11  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_CE1_CODER_CB_COF12"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_cb_cof12  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_CE1_CODER_CR_COF20"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_cr_cof20  "

  group.word 0x24++0x1
  line.word 0x0 "ISP_CE1_CODER_CR_COF21"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_cr_cof21  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_CE1_CODER_CR_COF22"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    yuv_cr_cof22  "

  group.word 0x2C++0x1
  line.word 0x0 "ISP_CE1_CODER_YFLOOR"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    yuv_yfloor  "

  group.word 0x30++0x1
  line.word 0x0 "ISP_CE1_CODER_CBFLOOR"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    yuv_cbfloor  "

  group.word 0x34++0x1
  line.word 0x0 "ISP_CE1_CODER_CRFLOOR"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    yuv_crfloor  "

  group.word 0x38++0x1
  line.word 0x0 "ISP_CE1_CODER_CB_COLOUR_EFFECT"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    yuv_cb_colour_effect_lo  "
    textline ""
    hexmask.word 0x0 8.--10. 1 "    yuv_cb_colour_effect_hi  "

  group.word 0x3C++0x1
  line.word 0x0 "ISP_CE1_CODER_CR_COLOUR_EFFECT"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    yuv_cr_colour_effect_lo  "
    textline ""
    hexmask.word 0x0 8.--10. 1 "    yuv_cr_colour_effect_hi  "

  group.word 0x40++0x1
  line.word 0x0 "ISP_CE1_CODER_CH0_MIN_CLIP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    yuv_ch0_min_clip  "

  group.word 0x44++0x1
  line.word 0x0 "ISP_CE1_CODER_CH0_MAX_CLIP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    yuv_ch0_max_clip  "

  group.word 0x48++0x1
  line.word 0x0 "ISP_CE1_CODER_CH1_MIN_CLIP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    yuv_ch1_min_clip  "

  group.word 0x4C++0x1
  line.word 0x0 "ISP_CE1_CODER_CH1_MAX_CLIP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    yuv_ch1_max_clip  "

  group.word 0x50++0x1
  line.word 0x0 "ISP_CE1_CODER_CH2_MIN_CLIP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    yuv_ch2_min_clip  "

  group.word 0x54++0x1
  line.word 0x0 "ISP_CE1_CODER_CH2_MAX_CLIP"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    yuv_ch2_max_clip  "

  group.word 0x58++0x1
  line.word 0x0 "ISP_CE1_CODER_RAW_NONACTIVE"
    textline ""
    bitfld.word 0x0 0. "    yuv_raw_nonactive  " "DISABLE,ENABLE"

tree.end


base a:0xa0253560
tree "ISP_OPF1"

  group.word 0x00++0x1
  line.word 0x0 "ISP_OPF1_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_OPF1_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    dfv_interrupt_ctrl  " "0,1"

  group.word 0x08++0x1
  line.word 0x0 "ISP_OPF1_HSYNC_RISING"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hsync_rising  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_OPF1_HSYNC_FALLING"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hsync_falling  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_OPF1_VSYNC_RISING_FINE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_rising_fine  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_OPF1_VSYNC_FALLING_FINE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_falling_fine  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_OPF1_VSYNC_RISING_COARSE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_rising_coarse  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_OPF1_VSYNC_FALLING_COARSE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_falling_coarse  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_OPF1_HCROP_RISING"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hcrop_rising  "

  group.word 0x24++0x1
  line.word 0x0 "ISP_OPF1_HCROP_FALLING"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hcrop_falling  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_OPF1_VCROP_RISING_COARSE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vcrop_rising_coarse  "

  group.word 0x2C++0x1
  line.word 0x0 "ISP_OPF1_VCROP_FALLING_COARSE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vcrop_falling_coarse  "

  group.long 0x30++0x3
  line.long 0x0 "ISP_OPF1_CONTROL"
    textline ""
    bitfld.long 0x0 0. "    sync_based_pixvalid  " "SYNC_PIX_VALID_DISABLE,SYNC_PIX_VALID_ENABLE"
    textline ""
    bitfld.long 0x0 1. "    toggle_pix_valid  " "PIX_VALID_LEVEL,PIX_VALID_EDGE"
    textline ""
    bitfld.long 0x0 2.--4. "    rgb_flip  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5"
    textline ""
    bitfld.long 0x0 5. "    rgb_bit_flip  " "RGB_BITS_SWAP_DISABLE,RGB_BITS_SWAP_ENABLE"
    textline ""
    bitfld.long 0x0 6. "    embedded_code_en  " "EMB_CODE_DISABLE,EMB_CODE_ENABLE"
    textline ""
    bitfld.long 0x0 7. "    false_sync_code_protect_en  " "FSC_PROTECTION_DISABLE,FSC_PROTECTION_ENABLE"
    textline ""
    bitfld.long 0x0 8. "    invert_hsync  " "HSYNC_DISABLE,HSYNC_ENABLE"
    textline ""
    bitfld.long 0x0 9. "    invert_vsync  " "VSYNC_DISABLE,VSYNC_ENABLE"
    textline ""
    bitfld.long 0x0 10. "    idata_ch0_en  " "OPF_CHANNEL_DISABLE,OPF_CHANNEL_ENABLE"
    textline ""
    bitfld.long 0x0 11. "    idata_ch1_en  " "OPF_CHANNEL_DISABLE,OPF_CHANNEL_ENABLE"
    textline ""
    bitfld.long 0x0 12. "    idata_ch2_en  " "OPF_CHANNEL_DISABLE,OPF_CHANNEL_ENABLE"
    textline ""
    bitfld.long 0x0 13.--15. "    opf_output  " "OPF_RGB101010,OPF_RGB888,OPF_RGB565,OPF_RGB555,OPF_RGB444,OPF_YUV"
    textline ""
    bitfld.long 0x0 16. "    rgb444_format  " "RGB444_NOPACK,RGB444_PACKED"

  group.word 0x34++0x1
  line.word 0x0 "ISP_OPF1_PIXVALID_LTYPES"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    pixvalid_linetypes  "
    textline ""
    bitfld.word 0x0 6. "    eof_blank_only_en  " "0,1"

  group.word 0x38++0x1
  line.word 0x0 "ISP_OPF1_YCBCR_FLIP"
    textline ""
    bitfld.word 0x0 0. "    cbcr_flip  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    y_cbcr_flip  " "B_0x0,B_0x1"

  group.word 0x3C++0x1
  line.word 0x0 "ISP_OPF1_LAST_NONACT_LINE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_nonactive_line  "

  group.word 0x40++0x1
  line.word 0x0 "ISP_OPF1_HSYNC_RISING_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hsync_rising_status  "

  group.word 0x44++0x1
  line.word 0x0 "ISP_OPF1_HSYNC_FALLING_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hsync_falling_status  "

  group.word 0x48++0x1
  line.word 0x0 "ISP_OPF1_VSYNC_RISING_FINE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_rising_fine_status  "

  group.word 0x4C++0x1
  line.word 0x0 "ISP_OPF1_VSYNC_FALLING_FINE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_falling_fine_status  "

  group.word 0x50++0x1
  line.word 0x0 "ISP_OPF1_VSYNC_RISING_COARSE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_rising_coarse_status  "

  group.word 0x54++0x1
  line.word 0x0 "ISP_OPF1_VSYNC_FALLING_COARSE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vsync_falling_coarse_status  "

  group.word 0x58++0x1
  line.word 0x0 "ISP_OPF1_HCROP_RISING_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hcrop_rising_status  "

  group.word 0x5C++0x1
  line.word 0x0 "ISP_OPF1_HCROP_FALLING_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hcrop_falling_status  "

  group.word 0x60++0x1
  line.word 0x0 "ISP_OPF1_VCROP_RISING_COARSE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vcrop_rising_coarse_status  "

  group.word 0x64++0x1
  line.word 0x0 "ISP_OPF1_VCROP_FALLING_COARSE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vcrop_falling_coarse_status  "

  group.long 0x68++0x3
  line.long 0x0 "ISP_OPF1_CONTROL_STATUS"
    textline ""
    bitfld.long 0x0 0. "    sync_based_pixvalid_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 1. "    toggle_pix_valid_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 2.--4. "    rgb_flip_status  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5"
    textline ""
    bitfld.long 0x0 5. "    rgb_bit_flip_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 6. "    embedded_code_en_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 7. "    false_sync_code_protect_en_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 8. "    invert_hsync_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 9. "    invert_vsync_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 10. "    idata_ch0_en_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 11. "    idata_ch1_en_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 12. "    idata_ch2_en_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.long 0x0 13.--15. "    opf_output_status  " "OPF_RGB101010,OPF_RGB888,OPF_RGB565,OPF_RGB555,OPF_RGB444,OPF_YUV"
    textline ""
    bitfld.long 0x0 16. "    rgb444_format_status  " "B_0x0,B_0x1"

  group.word 0x6C++0x1
  line.word 0x0 "ISP_OPF1_PIXVALID_LTYPES_STATUS"
    textline ""
    hexmask.word 0x0 0.--5. 1 "    pixvalid_linetypes_status  "
    textline ""
    bitfld.word 0x0 6. "    eof_blank_only_en_status  " "0,1"

  group.word 0x70++0x1
  line.word 0x0 "ISP_OPF1_YCBCR_FLIP_STATUS"
    textline ""
    bitfld.word 0x0 0. "    cbcr_flip_status  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    y_cbcr_flip_status  " "B_0x0,B_0x1"

  group.word 0x74++0x1
  line.word 0x0 "ISP_OPF1_LAST_NONACT_LINE_STATUS"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    last_nonactive_line_status  "

tree.end


base a:0xa0253600
tree "ISP_STATS_ACCWZ"

  group.word 0x00++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "DISABLE_SOFTRESET,ENABLE_SOFTRESET"

  group.long 0x04++0x3
  line.long 0x0 "ISP_STATS_ACCWZ_ZONE_GAINS"
    textline ""
    bitfld.long 0x0 0.--1. "    gain_zone0  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 2.--3. "    gain_zone1  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 4.--5. "    gain_zone2  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 6.--7. "    gain_zone3  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 8.--9. "    gain_zone4  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 10.--11. "    gain_zone5  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 12.--13. "    gain_zone6  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 14.--15. "    gain_zone7  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 16.--17. "    gain_zone8  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 18.--19. "    gain_zone9  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 20.--21. "    gain_zone10  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 22.--23. "    gain_zone11  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 24.--25. "    gain_zone12  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 26.--27. "    gain_zone13  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 28.--29. "    gain_zone14  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"
    textline ""
    bitfld.long 0x0 30.--31. "    gain_zone15  " "GAIN_0X,GAIN_1X,GAIN_2X,GAIN_4X"

  group.word 0x08++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC0_THRESH_LO"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    thresh_lo  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC0_THRESH_HI"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    thresh_hi  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC0_CTRL"
    textline ""
    bitfld.word 0x0 0.--1. "    mode  " "FULL_PIXELVAL,CLIP_PIXELVAL,HISTOGRAM,ZERO"
    textline ""
    bitfld.word 0x0 2.--3. "    type  " "ACC_ZONED,ACC_FLAT,ACC_BLACK,ACC_DARK"
    textline ""
    bitfld.word 0x0 4.--5. "    color  " "GIR,RED,BLU,GIB"
    textline ""
    bitfld.word 0x0 6.--7. "    src  " "SRC_IDP_0,SRC_IDP_1,SRC_IDP_2,SRC_IDP_3"

  group.word 0x14++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC1_THRESH_LO"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    thresh_lo  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC1_THRESH_HI"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    thresh_hi  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC1_CTRL"
    textline ""
    bitfld.word 0x0 0.--1. "    mode  " "FULL_PIXELVAL,CLIP_PIXELVAL,HISTOGRAM,ZERO"
    textline ""
    bitfld.word 0x0 2.--3. "    type  " "ACC_ZONED,ACC_FLAT,ACC_BLACK,ACC_DARK"
    textline ""
    bitfld.word 0x0 4.--5. "    color  " "GIR,RED,BLU,GIB"
    textline ""
    bitfld.word 0x0 6.--7. "    src  " "SRC_IDP_0,SRC_IDP_1,SRC_IDP_2,SRC_IDP_3"

  group.word 0x20++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC2_THRESH_LO"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    thresh_lo  "

  group.word 0x24++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC2_THRESH_HI"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    thresh_hi  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC2_CTRL"
    textline ""
    bitfld.word 0x0 0.--1. "    mode  " "FULL_PIXELVAL,CLIP_PIXELVAL,HISTOGRAM,ZERO"
    textline ""
    bitfld.word 0x0 2.--3. "    type  " "ACC_ZONED,ACC_FLAT,ACC_BLACK,ACC_DARK"
    textline ""
    bitfld.word 0x0 4.--5. "    color  " "GIR,RED,BLU,GIB"
    textline ""
    bitfld.word 0x0 6.--7. "    src  " "SRC_IDP_0,SRC_IDP_1,SRC_IDP_2,SRC_IDP_3"

  group.word 0x2C++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC3_THRESH_LO"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    thresh_lo  "

  group.word 0x30++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC3_THRESH_HI"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    thresh_hi  "

  group.word 0x34++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC3_CTRL"
    textline ""
    bitfld.word 0x0 0.--1. "    mode  " "FULL_PIXELVAL,CLIP_PIXELVAL,HISTOGRAM,ZERO"
    textline ""
    bitfld.word 0x0 2.--3. "    type  " "ACC_ZONED,ACC_FLAT,ACC_BLACK,ACC_DARK"
    textline ""
    bitfld.word 0x0 4.--5. "    color  " "GIR,RED,BLU,GIB"
    textline ""
    bitfld.word 0x0 6.--7. "    src  " "SRC_IDP_0,SRC_IDP_1,SRC_IDP_2,SRC_IDP_3"

  group.word 0x38++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC0_ZONE_X_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_x_offset  "

  group.word 0x3C++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC0_ZONE_Y_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_y_offset  "

  group.word 0x40++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC1_ZONE_X_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_x_offset  "

  group.word 0x44++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC1_ZONE_Y_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_y_offset  "

  group.word 0x48++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC2_ZONE_X_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_x_offset  "

  group.word 0x4C++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC2_ZONE_Y_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_y_offset  "

  group.word 0x50++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC3_ZONE_X_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_x_offset  "

  group.word 0x54++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC3_ZONE_Y_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_y_offset  "

  group.word 0x58++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC0_ZONE_X_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_x_size  "

  group.word 0x5C++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC0_ZONE_Y_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_y_size  "

  group.word 0x60++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC1_ZONE_X_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_x_size  "

  group.word 0x64++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC1_ZONE_Y_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_y_size  "

  group.word 0x68++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC2_ZONE_X_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_x_size  "

  group.word 0x6C++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC2_ZONE_Y_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_y_size  "

  group.word 0x70++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC3_ZONE_X_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_x_size  "

  group.word 0x74++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ACC3_ZONE_Y_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    zone_y_size  "

  group.long 0x78++0x3
  line.long 0x0 "ISP_STATS_ACCWZ_ACC0"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    accu  "

  group.long 0x7C++0x3
  line.long 0x0 "ISP_STATS_ACCWZ_ACC1"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    accu  "

  group.long 0x80++0x3
  line.long 0x0 "ISP_STATS_ACCWZ_ACC2"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    accu  "

  group.long 0x84++0x3
  line.long 0x0 "ISP_STATS_ACCWZ_ACC3"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    accu  "

  group.word 0x88++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_ZONE_STATUS"
    textline ""
    bitfld.word 0x0 0. "    acc0_zones_error  " "NO_ERROR,ERROR"
    textline ""
    bitfld.word 0x0 1. "    acc1_zones_error  " "NO_ERROR,ERROR"
    textline ""
    bitfld.word 0x0 2. "    acc2_zones_error  " "NO_ERROR,ERROR"
    textline ""
    bitfld.word 0x0 3. "    acc3_zones_error  " "NO_ERROR,ERROR"

  group.word 0x8C++0x1
  line.word 0x0 "ISP_STATS_ACCWZ_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DFV_DISABLE,B_0x1"
    textline ""
    hexmask.word 0x0 1.--4. 1 "    dfv_interrupt_ctrl  "

tree.end


base a:0xa0253700
tree "ISP_STATS_ACC_8x6"

  group.word 0x00++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "B_0x0,B_0x1"

  group.long 0x04++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ZONE_GAINS_1_16_REQ"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    zone_gains_1_16_req  "

  group.long 0x08++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ZONE_GAINS_17_32_REQ"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    zone_gains_17_32_req  "

  group.long 0x0C++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ZONE_GAINS_33_48_REQ"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    zone_gains_33_48_req  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_CTRL_REQ"
    textline ""
    bitfld.word 0x0 0.--1. "    acc_mode_req  " "FULL_PIXELVAL,CLIP_PIXELVAL,HISTOGRAM,ZERO"
    textline ""
    bitfld.word 0x0 2.--3. "    acc_type_req  " "ACC_ZONED,ACC_FLAT,ACC_BLACK,ACC_DARK"
    textline ""
    bitfld.word 0x0 4.--5. "    acc_color_req  " "GIR,RED,BLU,GIB"
    textline ""
    bitfld.word 0x0 6.--7. "    acc_src_req  " "SRC_IDP_0,SRC_IDP_1,SRC_IDP_2,SRC_IDP_3"
    textline ""
    bitfld.word 0x0 8. "    acc_staggered_req  " "0,1"

  group.word 0x14++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_ZONE_OFFSETX_REQ"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    acc_zone_x_offset_req  "

  group.word 0x16++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_ZONE_OFFSETY_REQ"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    acc_zone_y_offset_req  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_ZONE_SIZEX_REQ"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    acc_zone_x_size_req  "

  group.word 0x1A++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_ZONE_SIZEY_REQ"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    acc_zone_y_size_req  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_THRESHOLDLO_REQ"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    acc_thresh_lo_req  "

  group.word 0x1E++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_THRESHOLDHI_REQ"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    acc_thresh_hi_req  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    dfv_interrupt_control  " "0,1"

  group.long 0x24++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ZONE_GAINS_1_16_STATUS"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    zone_gains_1_16  "

  group.long 0x28++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ZONE_GAINS_17_32_STATUS"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    zone_gains_17_32  "

  group.long 0x2C++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ZONE_GAINS_33_48_STATUS"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    zone_gains_33_48  "

  group.word 0x30++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_CTRL_STATUS"
    textline ""
    hexmask.word 0x0 0.--1. 1 "    acc_mode  "
    textline ""
    hexmask.word 0x0 2.--3. 1 "    acc_type  "
    textline ""
    hexmask.word 0x0 4.--5. 1 "    acc_color  "
    textline ""
    hexmask.word 0x0 6.--7. 1 "    acc_src  "
    textline ""
    bitfld.word 0x0 8. "    acc_staggered  " "0,1"

  group.word 0x34++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_ZONE_OFFSETX_STATUS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    acc_zone_x_offset  "

  group.word 0x36++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_ZONE_OFFSETY_STATUS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    acc_zone_y_offset  "

  group.word 0x38++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_ZONE_SIZEX_STATUS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    acc_zone_x_size  "

  group.word 0x3A++0x1
  line.word 0x0 "ISP_STATS_ACC_8x6_ZONE_SIZEY_STATUS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    acc_zone_y_size  "

  group.long 0x3C++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_TOTAL"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_total  "

  group.long 0x40++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_1"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x44++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_2"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x48++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_3"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x4C++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_4"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x50++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_5"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x54++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_6"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x58++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_7"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x5C++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_8"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x60++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_9"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x64++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_10"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x68++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_11"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x6C++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_12"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x70++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_13"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x74++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_14"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x78++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_15"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x7C++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_16"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x80++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_17"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x84++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_18"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x88++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_19"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x8C++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_20"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x90++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_21"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x94++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_22"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x98++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_23"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0x9C++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_24"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xA0++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_25"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xA4++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_26"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xA8++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_27"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xAC++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_28"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xB0++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_29"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xB4++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_30"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xB8++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_31"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xBC++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_32"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xC0++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_33"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xC4++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_34"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xC8++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_35"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xCC++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_36"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xD0++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_37"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xD4++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_38"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xD8++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_39"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xDC++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_40"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xE0++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_41"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xE4++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_42"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xE8++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_43"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xEC++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_44"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xF0++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_45"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xF4++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_46"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xF8++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_47"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

  group.long 0xFC++0x3
  line.long 0x0 "ISP_STATS_ACC_8x6_ACC_ZONE_48"
    textline ""
    hexmask.long 0x0 0.--28. 1 "    accu  "

tree.end


base a:0xa0253800
tree "ISP_STATS_MUX_MWWB"

  group.word 0x00++0x1
  line.word 0x0 "ISP_STATS_MUX_MWWB_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_STATS_MUX_MWWB_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0253820
tree "ISP_STATS_MPSS"

  group.word 0x00++0x1
  line.word 0x0 "ISP_STATS_MPSS_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_STATS_MPSS_CTRL"
    textline ""
    bitfld.word 0x0 0. "    stgrd  " "B_0x0,B_0x1"

  group.word 0x08++0x1
  line.word 0x0 "ISP_STATS_MPSS_PARAM_HOR"
    textline ""
    bitfld.word 0x0 0.--3. "    iqval_h  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5"

  group.word 0x0C++0x1
  line.word 0x0 "ISP_STATS_MPSS_PARAM_VER"
    textline ""
    bitfld.word 0x0 0.--3. "    iqval_v  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5"

  group.word 0x10++0x1
  line.word 0x0 "ISP_STATS_MPSS_OFIRSTMIN4_OFFSET_CNT"
    textline ""
    hexmask.word 0x0 0.--6. 1 "    ofirstmin4_offset_cnt  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_STATS_MPSS_NUM_ACTIVE_SS_LINES"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    num_active_subsampled_lines  "

tree.end


base a:0xa0253840
tree "ISP_STATS_SNAIL_MWWB"

  group.word 0x00++0x1
  line.word 0x0 "ISP_STATS_SNAIL_MWWB_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    snailnorec_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    snailnorec_soft_reset  " "SOFT_RESET_DISABLE,SOFT_RESET_ENABLE"

tree.end


base a:0xa0253860
tree "ISP_STATS_MWWB"

  group.word 0x00++0x1
  line.word 0x0 "ISP_STATS_MWWB_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_STATS_MWWB_CTRL_STATUS"
    textline ""
    bitfld.word 0x0 0. "    fresh_stale_stats  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    zones_error  " "0,1"

  group.word 0x08++0x1
  line.word 0x0 "ISP_STATS_MWWB_ZONE_OFFSET_VER"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vert_offset  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_STATS_MWWB_ZONE_OFFSET_HOR"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    horz_offset  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_STATS_MWWB_ZONE_SIZE_VER"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    vert_size  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_STATS_MWWB_ZONE_SIZE_HOR"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    horz_size  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_STATS_MWWB_SATUR_THRESH"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    Satur_Thresh  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_STATS_MWWB_RED_TILT_GAIN"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    iRedTiltGain  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_STATS_MWWB_GREEN1_TILT_GAIN"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    iGrn1TiltGain  "

  group.word 0x24++0x1
  line.word 0x0 "ISP_STATS_MWWB_GREEN2_TILT_GAIN"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    iGrn2TiltGain  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_STATS_MWWB_BLUE_TILT_GAIN"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    iBluTiltGain  "

  group.long 0x2C++0x3
  line.long 0x0 "ISP_STATS_MWWB_RED_ENERGY"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    oRedEnergy  "

  group.long 0x30++0x3
  line.long 0x0 "ISP_STATS_MWWB_GREEN1_ENERGY"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    oGrn1Energy  "

  group.long 0x34++0x3
  line.long 0x0 "ISP_STATS_MWWB_GREEN2_ENERGY"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    oGrn2Energy  "

  group.long 0x38++0x3
  line.long 0x0 "ISP_STATS_MWWB_BLUE_ENERGY"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    oBluEnergy  "

  group.long 0x3C++0x3
  line.long 0x0 "ISP_STATS_MWWB_TOTAL_PIXELS"
    textline ""
    hexmask.long 0x0 0.--23. 1 "    total_pixels  "

  group.word 0x40++0x1
  line.word 0x0 "ISP_STATS_MWWB_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    dfv_interrupt_ctrl  " "0,1"

tree.end


base a:0xa02538c0
tree "ISP_STATS_MUX_HIST"

  group.word 0x00++0x1
  line.word 0x0 "ISP_STATS_MUX_HIST_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_STATS_MUX_HIST_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0253900
tree "ISP_STATS_HIST"

  group.word 0x00++0x1
  line.word 0x0 "ISP_STATS_HIST_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_STATS_HIST_CMD"
    textline ""
    bitfld.word 0x0 0.--1. "    cmd_rwp  " "IDLE,GRAB,STILL"

  group.word 0x08++0x1
  line.word 0x0 "ISP_STATS_HIST_X_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    x_size  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_STATS_HIST_Y_SIZE"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    y_size  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_STATS_HIST_X_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    x_offset  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_STATS_HIST_Y_OFFSET"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    y_offset  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_STATS_HIST_PIXELIN_SHIFT"
    textline ""
    hexmask.word 0x0 0.--2. 1 "    pixel_shift  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_STATS_HIST_DARKEST_G"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    g_dark_bin  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_STATS_HIST_BRIGHTEST_G"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    g_bright_bin  "

  group.word 0x24++0x1
  line.word 0x0 "ISP_STATS_HIST_HIGHEST_G"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    g_highest_bin  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_STATS_HIST_DARKEST_R"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    red_dark_bin  "

  group.word 0x2C++0x1
  line.word 0x0 "ISP_STATS_HIST_BRIGHTEST_R"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    red_bright_bin  "

  group.word 0x30++0x1
  line.word 0x0 "ISP_STATS_HIST_HIGHEST_R"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    red_highest_bin  "

  group.word 0x34++0x1
  line.word 0x0 "ISP_STATS_HIST_DARKEST_B"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    blue_dark_bin  "

  group.word 0x38++0x1
  line.word 0x0 "ISP_STATS_HIST_BRIGHTEST_B"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    blue_bright_bin  "

  group.word 0x3C++0x1
  line.word 0x0 "ISP_STATS_HIST_HIGHEST_B"
    textline ""
    hexmask.word 0x0 0.--11. 1 "    blue_highest_bin  "

  group.word 0x40++0x1
  line.word 0x0 "ISP_STATS_HIST_STATUS"
    textline ""
    bitfld.word 0x0 0.--2. "    status  " "IDLE,READY,ON_PROGRESS,COMPLETED"

  group.word 0x44++0x1
  line.word 0x0 "ISP_STATS_HIST_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    dfv_interrupt_control  " "0,1"

tree.end


base a:0xa0253960
tree "ISP_STATS_MUX_GLACE"

  group.word 0x00++0x1
  line.word 0x0 "ISP_STATS_MUX_GLACE_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_STATS_MUX_GLACE_SELECT"
    textline ""
    bitfld.word 0x0 0. "    mux2to1_select  " "IDP0,IDP1"
    textline ""
    bitfld.word 0x0 4. "    mux2to1_shadow_en  " "B_0x0,B_0x1"

tree.end


base a:0xa0253a00
tree "ISP_STATS_GLACE"

  group.word 0x00++0x1
  line.word 0x0 "ISP_STATS_GLACE_ACC_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    GLACE_ACC_ENABLE  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    SOFT_RESET  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_STATS_GLACE_DFV"
    textline ""
    bitfld.word 0x0 0. "    GLACE_DFV_ENABLE  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    GLACE_DFV_INTERRUPT_ENABLE  " "0,1"

  group.word 0x08++0x1
  line.word 0x0 "ISP_STATS_GLACE_H_ROI_START"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    GLACE_H_ROI_START  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_STATS_GLACE_V_ROI_START"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    GLACE_V_ROI_START  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_STATS_GLACE_H_BLK_SIZE"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    GLACE_H_BLK_SIZE  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_STATS_GLACE_V_BLK_SIZE"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    GLACE_V_BLK_SIZE  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_STATS_GLACE_H_GRID_SIZE"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    GLACE_H_GRID_SIZE  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_STATS_GLACE_V_GRID_SIZE"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    GLACE_V_GRID_SIZE  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_STATS_GLACE_SAT_LEVEL_R"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    GLACE_SAT_LEVEL_R  "

  group.word 0x24++0x1
  line.word 0x0 "ISP_STATS_GLACE_SAT_LEVEL_G"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    GLACE_SAT_LEVEL_G  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_STATS_GLACE_SAT_LEVEL_B"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    GLACE_SAT_LEVEL_B  "

  group.long 0x2C++0x3
  line.long 0x0 "ISP_STATS_GLACE_AV_MULT"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    GLACE_AV_MULT  "

  group.long 0x30++0x3
  line.long 0x0 "ISP_STATS_GLACE_AV_SHIFT"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    GLACE_AV_SHIFT  "

  group.word 0x34++0x1
  line.word 0x0 "ISP_STATS_GLACE_AV_MULT_WIDTH"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    GLACE_AV_MULT_WIDTH  "

  group.word 0x38++0x1
  line.word 0x0 "ISP_STATS_GLACE_AV_SHIFT_WIDTH"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    GLACE_AV_SHIFT_WIDTH  "

tree.end


base a:0xa0253ac0
tree "ISP_STATS_MPSS_GLACE"

  group.word 0x00++0x1
  line.word 0x0 "ISP_STATS_MPSS_GLACE_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_STATS_MPSS_GLACE_CTRL"
    textline ""
    bitfld.word 0x0 0. "    stgrd  " "B_0x0,B_0x1"

  group.word 0x08++0x1
  line.word 0x0 "ISP_STATS_MPSS_GLACE_PARAM_HOR"
    textline ""
    bitfld.word 0x0 0.--3. "    iqval_h  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5"

  group.word 0x0C++0x1
  line.word 0x0 "ISP_STATS_MPSS_GLACE_PARAM_VER"
    textline ""
    bitfld.word 0x0 0.--3. "    iqval_v  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5"

  group.word 0x10++0x1
  line.word 0x0 "ISP_STATS_MPSS_GLACE_OFIRSTMIN4_OFFSET_CNT"
    textline ""
    hexmask.word 0x0 0.--6. 1 "    ofirstmin4_offset_cnt  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_STATS_MPSS_GLACE_NUM_ACTIVE_SS_LINES"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    num_active_subsampled_lines  "

tree.end


base a:0xa0253b00
tree "ISP_STATS_AF"

  group.word 0x00++0x1
  line.word 0x0 "ISP_STATS_AF_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_STATS_AF_STATS_ZONE_CTRL"
    textline ""
    bitfld.word 0x0 0. "    coring_en  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    abs_square_en  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    light_change_stats_en  " "DISABLE,Enable"

  group.word 0x08++0x1
  line.word 0x0 "ISP_STATS_AF_STATS_ZONE_ENABLE"
    textline ""
    bitfld.word 0x0 0.--9. "    zone_enable  " "DISABLE,Enable"

  group.word 0x0C++0x1
  line.word 0x0 "ISP_STATS_AF_CORING"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    coring_value  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_START_OFFSET_0"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_start  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_START_OFFSET_0"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_start  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_END_OFFSET_0"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_end  "

  group.word 0x1C++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_END_OFFSET_0"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_end  "

  group.long 0x20++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_FOCUS_0"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_focus  "

  group.long 0x24++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_LIGHT_CHANGE_0"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_light_change  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_START_OFFSET_1"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_start  "

  group.word 0x2C++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_START_OFFSET_1"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_start  "

  group.word 0x30++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_END_OFFSET_1"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_end  "

  group.word 0x34++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_END_OFFSET_1"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_end  "

  group.long 0x38++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_FOCUS_1"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_focus  "

  group.long 0x3C++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_LIGHT_CHANGE_1"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_light_change  "

  group.word 0x40++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_START_OFFSET_2"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_start  "

  group.word 0x44++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_START_OFFSET_2"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_start  "

  group.word 0x48++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_END_OFFSET_2"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_end  "

  group.word 0x4C++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_END_OFFSET_2"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_end  "

  group.long 0x50++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_FOCUS_2"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_focus  "

  group.long 0x54++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_LIGHT_CHANGE_2"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_light_change  "

  group.word 0x58++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_START_OFFSET_3"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_start  "

  group.word 0x5C++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_START_OFFSET_3"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_start  "

  group.word 0x60++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_END_OFFSET_3"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_end  "

  group.word 0x64++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_END_OFFSET_3"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_end  "

  group.long 0x68++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_FOCUS_3"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_focus  "

  group.long 0x6C++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_LIGHT_CHANGE_3"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_light_change  "

  group.word 0x70++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_START_OFFSET_4"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_start  "

  group.word 0x74++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_START_OFFSET_4"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_start  "

  group.word 0x78++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_END_OFFSET_4"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_end  "

  group.word 0x7C++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_END_OFFSET_4"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_end  "

  group.long 0x80++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_FOCUS_4"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_focus  "

  group.long 0x84++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_LIGHT_CHANGE_4"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_light_change  "

  group.word 0x88++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_START_OFFSET_5"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_start  "

  group.word 0x8C++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_START_OFFSET_5"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_start  "

  group.word 0x90++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_END_OFFSET_5"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_end  "

  group.word 0x94++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_END_OFFSET_5"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_end  "

  group.long 0x98++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_FOCUS_5"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_focus  "

  group.long 0x9C++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_LIGHT_CHANGE_5"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_light_change  "

  group.word 0xA0++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_START_OFFSET_6"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_start  "

  group.word 0xA4++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_START_OFFSET_6"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_start  "

  group.word 0xA8++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_END_OFFSET_6"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_end  "

  group.word 0xAC++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_END_OFFSET_6"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_end  "

  group.long 0xB0++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_FOCUS_6"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_focus  "

  group.long 0xB4++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_LIGHT_CHANGE_6"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_light_change  "

  group.word 0xB8++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_START_OFFSET_7"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_start  "

  group.word 0xBC++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_START_OFFSET_7"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_start  "

  group.word 0xC0++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_END_OFFSET_7"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_end  "

  group.word 0xC4++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_END_OFFSET_7"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_end  "

  group.long 0xC8++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_FOCUS_7"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_focus  "

  group.long 0xCC++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_LIGHT_CHANGE_7"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_light_change  "

  group.word 0xD0++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_START_OFFSET_8"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_start  "

  group.word 0xD4++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_START_OFFSET_8"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_start  "

  group.word 0xD8++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_END_OFFSET_8"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_end  "

  group.word 0xDC++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_END_OFFSET_8"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_end  "

  group.long 0xE0++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_FOCUS_8"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_focus  "

  group.long 0xE4++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_LIGHT_CHANGE_8"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_light_change  "

  group.word 0xE8++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_START_OFFSET_9"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_start  "

  group.word 0xEC++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_START_OFFSET_9"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_start  "

  group.word 0xF0++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_X_END_OFFSET_9"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_end  "

  group.word 0xF4++0x1
  line.word 0x0 "ISP_STATS_AF_ZONE_Y_END_OFFSET_9"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_end  "

  group.long 0xF8++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_FOCUS_9"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_focus  "

  group.long 0xFC++0x3
  line.long 0x0 "ISP_STATS_AF_ZONE_ACC_VALUE_LIGHT_CHANGE_9"
    textline ""
    hexmask.long 0x0 0.--31. 1 "    acc_value_light_change  "

  group.word 0x100++0x1
  line.word 0x0 "ISP_STATS_AF_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    dfv_0_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    dfv_1_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    dfv_2_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    dfv_3_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    dfv_4_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    dfv_5_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    dfv_6_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    dfv_7_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    dfv_8_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    dfv_9_interrupt_ctrl  " "0,1"

tree.end


base a:0xa0253d00
tree "ISP_STATS_SKINTONE"

  group.word 0x00++0x1
  line.word 0x0 "ISP_STATS_SKINTONE_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"

  group.word 0x04++0x1
  line.word 0x0 "ISP_STATS_SKINTONE_ZONE_VERT_OFFSET"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    zone_y_offset  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_STATS_SKINTONE_ZONE_HOR_OFFSET"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    zone_x_offset  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_STATS_SKINTONE_ZONE_VERT_SIZE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    zone_y_size  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_STATS_SKINTONE_ZONE_HOR_SIZE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    zone_x_size  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_STATS_SKINTONE_THRESHOLD"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    skinTresh  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_STATS_SKINTONE_PATTERN"
    textline ""
    hexmask.word 0x0 0.--1. 1 "    pattern  "

  group.long 0x1C++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_0"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x20++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_1"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x24++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_2"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x28++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_3"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x2C++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_4"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x30++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_5"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x34++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_6"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x38++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_7"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x3C++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_8"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x40++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_9"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x44++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_10"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x48++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_11"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x4C++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_12"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x50++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_13"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x54++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_14"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.long 0x58++0x3
  line.long 0x0 "ISP_STATS_SKINTONE_ACC_SKIN_15"
    textline ""
    hexmask.long 0x0 0.--25. 1 "    acc_skin  "

  group.word 0x5C++0x1
  line.word 0x0 "ISP_STATS_SKINTONE_STATUS"
    textline ""
    bitfld.word 0x0 0. "    zones_error  " "0,1"

  group.word 0x60++0x1
  line.word 0x0 "ISP_STATS_SKINTONE_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    dfv_interrupt_ctrl  " "0,1"

tree.end


base a:0xa0253e40
tree "ISP_ITPOINT_DMCE_IN"

  group.word 0x00++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_IN_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_IN_PIX_POS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    pix_pos  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_IN_LINE_POS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    line_pos  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_IN_PIX_CNT"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    pix_cnt  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_IN_LINE_CNT"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    line_cnt  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_IN_FRAME_CNT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    frame_cnt  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_IN_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    dfv_interrupt_ctrl  " "0,1"

tree.end


base a:0xa0253e60
tree "ISP_ITPOINT_DMCE_OUT"

  group.word 0x00++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_OUT_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_OUT_PIX_POS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    pix_pos  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_OUT_LINE_POS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    line_pos  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_OUT_PIX_CNT"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    pix_cnt  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_OUT_LINE_CNT"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    line_cnt  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_OUT_FRAME_CNT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    frame_cnt  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_ITPOINT_DMCE_OUT_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    dfv_interrupt_ctrl  " "0,1"

tree.end


base a:0xa0253e80
tree "ISP_ITPOINT_RGB_STORE"

  group.word 0x00++0x1
  line.word 0x0 "ISP_ITPOINT_RGB_STORE_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 4. "    soft_reset  " "B_0x0,B_0x1"

  group.word 0x04++0x1
  line.word 0x0 "ISP_ITPOINT_RGB_STORE_PIX_POS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    pix_pos  "

  group.word 0x08++0x1
  line.word 0x0 "ISP_ITPOINT_RGB_STORE_LINE_POS"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    line_pos  "

  group.word 0x0C++0x1
  line.word 0x0 "ISP_ITPOINT_RGB_STORE_PIX_CNT"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    pix_cnt  "

  group.word 0x10++0x1
  line.word 0x0 "ISP_ITPOINT_RGB_STORE_LINE_CNT"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    line_cnt  "

  group.word 0x14++0x1
  line.word 0x0 "ISP_ITPOINT_RGB_STORE_FRAME_CNT"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    frame_cnt  "

  group.word 0x18++0x1
  line.word 0x0 "ISP_ITPOINT_RGB_STORE_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.word 0x0 1. "    dfv_interrupt_ctrl  " "0,1"

tree.end


base a:0xa0255800
tree "ISP_SMIARX3D"

  group.long 0x00++0x3
  line.long 0x0 "ISP_SMIARX3D_CTRL"
    textline ""
    bitfld.long 0x0 0. "    rx_start  " "0,1"
    textline ""
    bitfld.long 0x0 8. "    rx_stop  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    rx_abort  " "0,1"

  group.long 0x04++0x3
  line.long 0x0 "ISP_SMIARX3D_SETUP"
    textline ""
    bitfld.long 0x0 0.--3. "    ip_pix_width  " ",,,,,,B_0x6,B_0x7,B_0x8,,B_0xA,,B_0xC"
    textline ""
    bitfld.long 0x0 4.--7. "    op_pix_width  " ",,,,,,B_0x6,B_0x7,B_0x8,,B_0xA,,B_0xC"
    textline ""
    bitfld.long 0x0 8. "    parallel_enable  " "0,1"
    textline ""
    bitfld.long 0x0 9. "    vsync_polarity  " "ACTIVE_LOW,ACTIVE_HIGH"
    textline ""
    bitfld.long 0x0 10. "    hsync_polarity  " "ACTIVE_LOW,ACTIVE_HIGH"
    textline ""
    bitfld.long 0x0 11. "    ds_mode  " "DISABLE,ENABLE"
    textline ""
    bitfld.long 0x0 12. "    dcpx_enable  " "DISABLE,ENABLE"
    textline ""
    bitfld.long 0x0 13. "    ccp_sel  " "0,1"
    textline ""
    bitfld.long 0x0 14. "    reset_ccp_rx_n  " "0,1"
    textline ""
    bitfld.long 0x0 16. "    auto_sync  " "SYNCHRO_SENSOR,SYNCHRO_AUTO"
    textline ""
    bitfld.long 0x0 17.--19. "    pattern_type  " "PATTERN_DISABLE,PATTERN_COLOUR_BAR,PATTERN_GRAD_BAR,PATTERN_DIAG_GREY,PATTERN_PSEUDORANDOM,PATTERN_HOR_GREY,PATTERN_VERT_GREY,PATTERN_SOLID"
    textline ""
    bitfld.long 0x0 20. "    no_sof  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    clr_ccp_shift_sync  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    clr_ccp_crc_error  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    clr_pixel_sync_error  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    clr_aborted_iframe  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    clr_insuff_iline  " "0,1"
    textline ""
    bitfld.long 0x0 29. "    fifo_rd_rst  " "0,1"

  group.long 0x08++0x3
  line.long 0x0 "ISP_SMIARX3D_FRAME_CTRL"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    latency_lines  "
    textline ""
    hexmask.long 0x0 8.--15. 1 "    stream_size  "
    textline ""
    hexmask.long 0x0 16.--23. 1 "    start_grab_dly  "
    textline ""
    bitfld.long 0x0 24.--25. "    ffhc_control  " "FFHC_DISABLE,FFHC_FULL_AUTO,FFHC_SEMI_AUTO,FFHC_MANUAL"
    textline ""
    bitfld.long 0x0 26. "    stop_at_interframe  " "0,1"

  group.long 0x0C++0x3
  line.long 0x0 "ISP_SMIARX3D_STATUS"
    textline ""
    hexmask.long 0x0 0.--7. 1 "    frame_counter  "
    textline ""
    bitfld.long 0x0 8.--9. "    rx_state  " "GEN_IDLE,GEN_WAITVSTART,GEN_RUNNING,GEN_WAITFRAME"
    textline ""
    bitfld.long 0x0 10.--12. "    ff_state  " "FF_IDLE,FF_WAIT_EOSD,FF_FIRSTLINE,FF_TRANSLATE,FF_UPDATE,FF_INTERFRAME"
    textline ""
    bitfld.long 0x0 13.--15. "    snoop_state  " "SNOOP_IDLE,SNOOP_TAG_LSN,SNOOP_TAG,SNOOP_REG_LSM,SNOOP_REG"
    textline ""
    hexmask.long 0x0 16.--20. 1 "    fifo_rd_usedw  "
    textline ""
    bitfld.long 0x0 21. "    fifo_empty  " "0,1"
    textline ""
    bitfld.long 0x0 24. "    pixel_sync_error  " "0,1"
    textline ""
    bitfld.long 0x0 25. "    aborted_iframe  " "0,1"
    textline ""
    bitfld.long 0x0 26. "    insuff_iline  " "0,1"
    textline ""
    bitfld.long 0x0 27. "    fifo_under  " "0,1"
    textline ""
    bitfld.long 0x0 28. "    fifo_over  " "0,1"

  group.long 0x10++0x3
  line.long 0x0 "ISP_SMIARX3D_TPAT_DATA_RG"
    textline ""
    hexmask.long 0x0 0.--12. 1 "    tpat_data_gir  "
    textline ""
    hexmask.long 0x0 16.--28. 1 "    tpat_data_red  "

  group.long 0x14++0x3
  line.long 0x0 "ISP_SMIARX3D_TPAT_DATA_BG"
    textline ""
    hexmask.long 0x0 0.--12. 1 "    tpat_data_gib  "
    textline ""
    hexmask.long 0x0 16.--28. 1 "    tpat_data_blu  "

  group.long 0x18++0x3
  line.long 0x0 "ISP_SMIARX3D_TPAT_HCUR_WP"
    textline ""
    hexmask.long 0x0 0.--12. 1 "    tpat_hcur_posn  "
    textline ""
    hexmask.long 0x0 16.--28. 1 "    tpat_hcur_width  "

  group.long 0x1C++0x3
  line.long 0x0 "ISP_SMIARX3D_TPAT_VCUR_WP"
    textline ""
    hexmask.long 0x0 0.--12. 1 "    tpat_vcur_posn  "
    textline ""
    hexmask.long 0x0 16.--28. 1 "    tpat_vcur_width  "

  group.word 0x20++0x1
  line.word 0x0 "ISP_SMIARX3D_CCP_STATUS"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    ccp_channel  "
    textline ""
    bitfld.word 0x0 8. "    ccp_false_sync  " "0,1"
    textline ""
    bitfld.word 0x0 9. "    ccp_shift_sync  " "0,1"
    textline ""
    bitfld.word 0x0 10. "    ccp_crc_error  " "0,1"

  group.word 0x24++0x1
  line.word 0x0 "ISP_SMIARX3D_HK_REQ_ADDR_0"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hk_req_addr  "

  group.word 0x28++0x1
  line.word 0x0 "ISP_SMIARX3D_HK_REQ_ADDR_1"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hk_req_addr  "

  group.word 0x2C++0x1
  line.word 0x0 "ISP_SMIARX3D_HK_REQ_ADDR_2"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hk_req_addr  "

  group.word 0x30++0x1
  line.word 0x0 "ISP_SMIARX3D_HK_REQ_ADDR_3"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    hk_req_addr  "

  group.word 0x34++0x1
  line.word 0x0 "ISP_SMIARX3D_HK_REQ_DATA_0"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    hk_req_data  "

  group.word 0x38++0x1
  line.word 0x0 "ISP_SMIARX3D_HK_REQ_DATA_1"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    hk_req_data  "

  group.word 0x3C++0x1
  line.word 0x0 "ISP_SMIARX3D_HK_REQ_DATA_2"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    hk_req_data  "

  group.word 0x40++0x1
  line.word 0x0 "ISP_SMIARX3D_HK_REQ_DATA_3"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    hk_req_data  "

  group.long 0x44++0x3
  line.long 0x0 "ISP_SMIARX3D_INT_COUNT_0"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    pix_count  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    line_count  "

  group.long 0x48++0x3
  line.long 0x0 "ISP_SMIARX3D_INT_COUNT_1"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    pix_count  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    line_count  "

  group.long 0x4C++0x3
  line.long 0x0 "ISP_SMIARX3D_INT_COUNT_2"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    pix_count  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    line_count  "

  group.long 0x50++0x3
  line.long 0x0 "ISP_SMIARX3D_INT_COUNT_3"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    pix_count  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    line_count  "

  group.word 0x54++0x1
  line.word 0x0 "ISP_SMIARX3D_DFV"
    textline ""
    bitfld.word 0x0 0. "    dfv_enable  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    dfv_count_0_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    dfv_count_1_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    dfv_count_2_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    dfv_count_3_interrupt_ctrl  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    dfv_seq_complete_interrupt_ctrl  " "0,1"

  group.word 0x58++0x1
  line.word 0x0 "ISP_SMIARX3D_COUNT_INT_EN"
    textline ""
    bitfld.word 0x0 0. "    rx_line_count_0_int_en  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    rx_line_count_1_int_en  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    rx_line_count_2_int_en  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    rx_line_count_3_int_en  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    rx_seq_complete_int_en  " "0,1"

  group.long 0x5C++0x3
  line.long 0x0 "ISP_SMIARX3D_OVERRIDE"
    textline ""
    hexmask.long 0x0 0.--22. 1 "    override  "

  group.word 0x60++0x1
  line.word 0x0 "ISP_SMIARX3D_SENSOR_ID"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    sensor_id  "

  group.word 0x64++0x1
  line.word 0x0 "ISP_SMIARX3D_PIXEL_ORDER"
    textline ""
    bitfld.word 0x0 0.--1. "    pixel_order  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    bitfld.word 0x0 8.--9. "    pixel_order_ovr  " "B_0x0,B_0x1,B_0x2,B_0x3"

  group.word 0x68++0x1
  line.word 0x0 "ISP_SMIARX3D_AUTO_HENV_LENGTH"
    textline ""
    hexmask.word 0x0 0.--12. 1 "    auto_henv_length  "

  group.long 0x6C++0x3
  line.long 0x0 "ISP_SMIARX3D_FRAME_LENGTH"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    frame_length  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    frame_length_ovr  "

  group.long 0x70++0x3
  line.long 0x0 "ISP_SMIARX3D_LINE_LENGTH"
    textline ""
    hexmask.long 0x0 0.--15. 1 "    line_length  "
    textline ""
    hexmask.long 0x0 16.--31. 1 "    line_length_ovr  "

  group.word 0x74++0x1
  line.word 0x0 "ISP_SMIARX3D_X_ADDR_START"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_addr_start  "

  group.word 0x78++0x1
  line.word 0x0 "ISP_SMIARX3D_Y_ADDR_START"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_addr_start  "

  group.word 0x7C++0x1
  line.word 0x0 "ISP_SMIARX3D_X_ADDR_END"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_addr_end  "

  group.word 0x80++0x1
  line.word 0x0 "ISP_SMIARX3D_Y_ADDR_END"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_addr_end  "

  group.word 0x84++0x1
  line.word 0x0 "ISP_SMIARX3D_X_OUTPUT_SIZE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    x_output_size  "

  group.word 0x88++0x1
  line.word 0x0 "ISP_SMIARX3D_Y_OUTPUT_SIZE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    y_output_size  "

  group.word 0x8C++0x1
  line.word 0x0 "ISP_SMIARX3D_ADDR_INCREMENTS"
    textline ""
    bitfld.word 0x0 0. "    x_even_inc_lsb  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    x_even_inc_lsb_ovr  " "0,1"
    textline ""
    bitfld.word 0x0 2. "    x_odd_inc_lsb  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    x_odd_inc_lsb_ovr  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    y_even_inc_lsb  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    y_even_inc_lsb_ovr  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    y_odd_inc_lsb  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    y_odd_inc_lsb_ovr  " "0,1"

  group.word 0x90++0x1
  line.word 0x0 "ISP_SMIARX3D_FINE_EXPOSURE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    fine_exposure  "

  group.word 0x94++0x1
  line.word 0x0 "ISP_SMIARX3D_COARSE_EXPOSURE"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    coarse_exposure  "

  group.word 0x98++0x1
  line.word 0x0 "ISP_SMIARX3D_ANALOG_GAIN"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    analog_gain  "

  group.word 0x9C++0x1
  line.word 0x0 "ISP_SMIARX3D_MODEL_SUBTYPE"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    frame_format_model_subtype  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    frame_format_model_subtype_ovr  "

  group.word 0xA0++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_0"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xA2++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_1"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xA4++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_2"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xA6++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_3"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xA8++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_4"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xAA++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_5"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xAC++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_6"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xAE++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_7"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xB0++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_8"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xB2++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_9"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xB4++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_10"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xB6++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_11"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xB8++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_12"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xBA++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_13"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xBC++0x1
  line.word 0x0 "ISP_SMIARX3D_DESCRIPTOR_14"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    frame_format_descriptor  "

  group.word 0xBE++0x1
  line.word 0x0 "ISP_SMIARX3D_TYPE_TRANS_1"
    textline ""
    bitfld.word 0x0 0.--2. "    type_trans_mspec_4  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.word 0x0 4.--6. "    type_trans_mspec_5  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.word 0x0 8.--10. "    type_trans_mspec_6  " "BLANK,BLACK,DARK,ACTIVE"

  group.long 0xC0++0x3
  line.long 0x0 "ISP_SMIARX3D_TYPE_TRANS_0"
    textline ""
    bitfld.long 0x0 0.--2. "    type_trans_black  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 4.--6. "    type_trans_dark  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 8.--10. "    type_trans_visible  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 12.--14. "    type_trans_dummy  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 16.--18. "    type_trans_mspec_0  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 20.--22. "    type_trans_mspec_1  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 24.--26. "    type_trans_mspec_2  " "BLANK,BLACK,DARK,ACTIVE"
    textline ""
    bitfld.long 0x0 28.--30. "    type_trans_mspec_3  " "BLANK,BLACK,DARK,ACTIVE"

  group.long 0xC4++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_0"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xC8++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_1"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xCC++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_2"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xD0++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_3"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xD4++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_4"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xD8++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_5"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xDC++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_6"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xE0++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_7"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xE4++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_8"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xE8++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_9"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xEC++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_10"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xF0++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_11"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xF4++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_12"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xF8++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_13"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

  group.long 0xFC++0x3
  line.long 0x0 "ISP_SMIARX3D_DESCRIPTOR_OVR_14"
    textline ""
    hexmask.long 0x0 0.--16. 1 "    frame_format_descriptor_ovr  "

tree.end


;end include file pictor.h


;begin include file proj.h


base a:0xa0254200
tree "PROJ"

  group.word 0x00++0x1
  line.word 0x0 "PROJ_ENR"
    textline ""
    bitfld.word 0x0 0. "    HCP  " "0,1"
    textline ""
    bitfld.word 0x0 1. "    VCP  " "0,1"

  group.word 0x10++0x1
  line.word 0x0 "PROJ_ITS"
    textline ""
    bitfld.word 0x0 0. "    HCP_EOT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    VCP_EOT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    VCP_ERR  " "B_0x0,B_0x1"

  group.word 0x12++0x1
  line.word 0x0 "PROJ_ITS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    HCP_EOT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    VCP_EOT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    VCP_ERR  " "B_0x0,B_0x1"

  group.word 0x14++0x1
  line.word 0x0 "PROJ_ITS_BSET"
    textline ""
    bitfld.word 0x0 0. "    HCP_EOT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    VCP_EOT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    VCP_ERR  " "B_0x0,B_0x1"

  group.word 0x16++0x1
  line.word 0x0 "PROJ_ITM"
    textline ""
    bitfld.word 0x0 0. "    HCP_EOT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    VCP_EOT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    VCP_ERR  " "B_0x0,B_0x1"

  group.word 0x18++0x1
  line.word 0x0 "PROJ_ITM_BCLR"
    textline ""
    bitfld.word 0x0 0. "    HCP_EOT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    VCP_EOT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    VCP_ERR  " "B_0x0,B_0x1"

  group.word 0x1A++0x1
  line.word 0x0 "PROJ_ITM_BSET"
    textline ""
    bitfld.word 0x0 0. "    HCP_EOT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    VCP_EOT  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    VCP_ERR  " "B_0x0,B_0x1"

  group.word 0x20++0x1
  line.word 0x0 "PROJ_HSIZE"
    textline ""
    hexmask.word 0x0 4.--12. 1 "    HSIZE  "

  group.word 0x22++0x1
  line.word 0x0 "PROJ_VSIZE"
    textline ""
    hexmask.word 0x0 4.--12. 1 "    VSIZE  "

  group.word 0x30++0x1
  line.word 0x0 "PROJ_GCF_W_DIS"
    textline ""
    bitfld.word 0x0 0. "    GCF_W_DIS  " "B_0x0,B_0x1"

  group.word 0x40++0x1
  line.word 0x0 "PROJ_ENDIAN"
    textline ""
    bitfld.word 0x0 0. "    ENDIAN  " "B_0x0,B_0x1"

tree.end


;end include file proj.h


;begin include file sia.h


base a:0xa0254000
tree "SIA"

  group.word 0x00++0x1
  line.word 0x0 "SIA_RESET"
    textline ""
    bitfld.word 0x0 0. "    SIA_CORE  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    IPP  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    VCF  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    PROJ  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    ROT  " "B_0x0,B_0x1"

  group.word 0x10++0x1
  line.word 0x0 "SIA_CLK_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    DMA  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    STBP  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    IPP  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    VCF  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    PROJ  " "B_0x0,B_0x1"

  group.word 0x20++0x1
  line.word 0x0 "SIA_IDN_HRV"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    R0  "
    textline ""
    hexmask.word 0x0 4.--7. 1 "    R1  "
    textline ""
    bitfld.word 0x0 8.--11. "    R2  " ",B_0x1,B_0x2,B_0x3,B_0x4"

  group.word 0x30++0x1
  line.word 0x0 "SIA_VCF_ENABLE"
    textline ""
    bitfld.word 0x0 0. "    EN  " "B_0x0,B_0x1"

  group.word 0x32++0x1
  line.word 0x0 "SIA_ROTATION"
    textline ""
    bitfld.word 0x0 0.--1. "    ROTATION  " "B_0x0,B_0x1,,B_0x3"

  group.word 0x40++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_0_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x42++0x1
  line.word 0x0 "ISP_MCU_SYS_SIZE0"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x44++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_1_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x46++0x1
  line.word 0x0 "ISP_MCU_SYS_SIZE1"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x48++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_2_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x4A++0x1
  line.word 0x0 "ISP_MCU_SYS_SIZE2"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x4C++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_3_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x4E++0x1
  line.word 0x0 "ISP_MCU_SYS_SIZE3"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x50++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_4_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x52++0x1
  line.word 0x0 "ISP_MCU_SYS_SIZE4"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x54++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_5_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x56++0x1
  line.word 0x0 "ISP_MCU_SYS_SIZE5"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x58++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_6_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x5A++0x1
  line.word 0x0 "ISP_MCU_SYS_SIZE6"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x5C++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_7_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x5E++0x1
  line.word 0x0 "ISP_MCU_SYS_SIZE7"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x60++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_0_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x62++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_1_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x64++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_2_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x66++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_3_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x68++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_4_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x6A++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_5_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x6C++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_6_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x6E++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_7_HI"
    textline ""
    hexmask.word 0x0 0.--15. 1 "    REGION_BA_HI  "

  group.word 0x70++0x1
  line.word 0x0 "ISP_MEM_PAGE"
    textline ""
    bitfld.word 0x0 0.--5. "    INDEX  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7,B_0x8,B_0x9,B_0xA,B_0xB,B_0xC,B_0xD,B_0xE,B_0xF,B_0x10,B_0x11,B_0x12,B_0x13,B_0x14,B_0x15,B_0x16,B_0x17,B_0x18,B_0x19,,,,,,,B_0x20,B_0x21,B_0x22,B_0x23,B_0x24,B_0x25,B_0x26,B_0x27,,,,,,,,,B_0x30"

  group.word 0x72++0x1
  line.word 0x0 "SIA_XBUS_BYTE_ENABLE"
    textline ""
    bitfld.word 0x0 0.--1. "    BE0  " "B_0x0,B_0x1,B_0x2,B_0x3"
    textline ""
    bitfld.word 0x0 8.--9. "    BE1  " "B_0x0,B_0x1,B_0x2,B_0x3"

  group.word 0x80++0x1
  line.word 0x0 "SIA_PIPE03_SELECT"
    textline ""
    bitfld.word 0x0 0. "    AP  " "B_0x0,B_0x1"

  group.word 0x90++0x1
  line.word 0x0 "LICN_ITS"
    textline ""
    bitfld.word 0x0 0. "    BUSERR  " "B_0x0,B_0x1"

  group.word 0x92++0x1
  line.word 0x0 "LICN_ITS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    BUSERR  " "B_0x0,B_0x1"

  group.word 0x94++0x1
  line.word 0x0 "LICN_ITS_BSET"
    textline ""
    bitfld.word 0x0 0. "    BUSERR  " "B_0x0,B_0x1"

  group.word 0x96++0x1
  line.word 0x0 "LICN_ITM"
    textline ""
    bitfld.word 0x0 0. "    BUSERR  " "B_0x0,B_0x1"

  group.word 0x98++0x1
  line.word 0x0 "LICN_ITM_BCLR"
    textline ""
    bitfld.word 0x0 0. "    BUSERR  " "B_0x0,B_0x1"

  group.word 0x9A++0x1
  line.word 0x0 "LICN_ITM_BSET"
    textline ""
    bitfld.word 0x0 0. "    BUSERR  " "B_0x0,B_0x1"

  group.word 0xA0++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_0_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xA2++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_1_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xA4++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_2_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xA6++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_3_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xA8++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_4_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xAA++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_5_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xAC++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_6_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xAE++0x1
  line.word 0x0 "ISP_MCU_SYS_ADDR_7_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xC0++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_0_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xC2++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_1_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xC4++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_2_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xC6++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_3_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xC8++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_4_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xCA++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_5_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xCC++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_6_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xCE++0x1
  line.word 0x0 "ISP_MCU_IO_ADDR_7_LO"
    textline ""
    hexmask.word 0x0 12.--15. 1 "    REGION_BA_LO  "

  group.word 0xE0++0x1
  line.word 0x0 "ISP_MCU_IO_SIZE0"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0xE2++0x1
  line.word 0x0 "ISP_MCU_IO_SIZE1"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0xE4++0x1
  line.word 0x0 "ISP_MCU_IO_SIZE2"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0xE6++0x1
  line.word 0x0 "ISP_MCU_IO_SIZE3"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0xE8++0x1
  line.word 0x0 "ISP_MCU_IO_SIZE4"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0xEA++0x1
  line.word 0x0 "ISP_MCU_IO_SIZE5"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0xEC++0x1
  line.word 0x0 "ISP_MCU_IO_SIZE6"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0xEE++0x1
  line.word 0x0 "ISP_MCU_IO_SIZE7"
    textline ""
    bitfld.word 0x0 0.--2. "    REGION_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

tree.end


;end include file sia.h


;begin include file stbp.h


base a:0xa0254600
tree "STBP"

  group.word 0x00++0x1
  line.word 0x0 "STBP_BSM"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 6. "    IRP03_GCF_L_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 8. "    IRP03_VCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 9. "    IRP03_HCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 10. "    IRP03_HCP_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 12. "    IRP0_PRA_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "B_0x0,B_0x1"

  group.word 0x02++0x1
  line.word 0x0 "STBP_MIN_OPC_SZ"
    textline ""
    bitfld.word 0x0 0.--2. "    MIN_OPC_SZ  " ",,,B_0x3"

  group.word 0x04++0x1
  line.word 0x0 "STBP_PAGE_SZ_SRAM"
    textline ""
    bitfld.word 0x0 0.--3. "    PSIZE  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7,B_0x8"

  group.word 0x06++0x1
  line.word 0x0 "STBP_PAGE_SZ_DRAM"
    textline ""
    bitfld.word 0x0 0.--3. "    PSIZE  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7,B_0x8"

  group.word 0x08++0x1
  line.word 0x0 "STBP_MAX_PRI"
    textline ""
    hexmask.word 0x0 0.--3. 1 "    PRI  "

  group.word 0x20++0x1
  line.word 0x0 "STBP_PEAK_LEVEL0"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    PEAK  "

  group.word 0x22++0x1
  line.word 0x0 "STBP_PEAK_LEVEL1"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    PEAK  "

  group.word 0x24++0x1
  line.word 0x0 "STBP_PEAK_LEVEL2"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    PEAK  "

  group.word 0x26++0x1
  line.word 0x0 "STBP_PEAK_LEVEL3"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    PEAK  "

  group.word 0x28++0x1
  line.word 0x0 "STBP_PEAK_LEVEL4"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    PEAK  "

  group.word 0x2A++0x1
  line.word 0x0 "STBP_PEAK_LEVEL5"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    PEAK  "

  group.word 0x2C++0x1
  line.word 0x0 "STBP_PEAK_LEVEL6"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    PEAK  "

  group.word 0x2E++0x1
  line.word 0x0 "STBP_PEAK_LEVEL7"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    PEAK  "

  group.word 0x30++0x1
  line.word 0x0 "STBP_PEAK_LEVEL8"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    PEAK  "

  group.word 0x32++0x1
  line.word 0x0 "STBP_PEAK_LEVEL9"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    PEAK  "

  group.word 0x34++0x1
  line.word 0x0 "STBP_PEAK_LEVEL10"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    PEAK  "

  group.word 0x36++0x1
  line.word 0x0 "STBP_PEAK_LEVEL11"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    PEAK  "

  group.word 0x38++0x1
  line.word 0x0 "STBP_PEAK_LEVEL12"
    textline ""
    hexmask.word 0x0 0.--8. 1 "    PEAK  "

  group.word 0x40++0x1
  line.word 0x0 "STBP_MAX_OPC_SZ0"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_OPC_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6"

  group.word 0x42++0x1
  line.word 0x0 "STBP_MAX_OPC_SZ1"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_OPC_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6"

  group.word 0x44++0x1
  line.word 0x0 "STBP_MAX_OPC_SZ2"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_OPC_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6"

  group.word 0x46++0x1
  line.word 0x0 "STBP_MAX_OPC_SZ3"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_OPC_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6"

  group.word 0x48++0x1
  line.word 0x0 "STBP_MAX_OPC_SZ4"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_OPC_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6"

  group.word 0x4A++0x1
  line.word 0x0 "STBP_MAX_OPC_SZ5"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_OPC_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6"

  group.word 0x4C++0x1
  line.word 0x0 "STBP_MAX_OPC_SZ6"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_OPC_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6"

  group.word 0x4E++0x1
  line.word 0x0 "STBP_MAX_OPC_SZ7"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_OPC_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6"

  group.word 0x50++0x1
  line.word 0x0 "STBP_MAX_OPC_SZ8"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_OPC_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6"

  group.word 0x52++0x1
  line.word 0x0 "STBP_MAX_OPC_SZ9"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_OPC_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6"

  group.word 0x54++0x1
  line.word 0x0 "STBP_MAX_OPC_SZ10"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_OPC_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6"

  group.word 0x56++0x1
  line.word 0x0 "STBP_MAX_OPC_SZ11"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_OPC_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6"

  group.word 0x58++0x1
  line.word 0x0 "STBP_MAX_OPC_SZ12"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_OPC_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6"

  group.word 0x60++0x1
  line.word 0x0 "STBP_MAX_CHCK_SZ0"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_CHK_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x62++0x1
  line.word 0x0 "STBP_MAX_CHCK_SZ1"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_CHK_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x64++0x1
  line.word 0x0 "STBP_MAX_CHCK_SZ2"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_CHK_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x66++0x1
  line.word 0x0 "STBP_MAX_CHCK_SZ3"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_CHK_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x68++0x1
  line.word 0x0 "STBP_MAX_CHCK_SZ4"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_CHK_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x6A++0x1
  line.word 0x0 "STBP_MAX_CHCK_SZ5"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_CHK_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x6C++0x1
  line.word 0x0 "STBP_MAX_CHCK_SZ6"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_CHK_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x6E++0x1
  line.word 0x0 "STBP_MAX_CHCK_SZ7"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_CHK_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x70++0x1
  line.word 0x0 "STBP_MAX_CHCK_SZ8"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_CHK_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x72++0x1
  line.word 0x0 "STBP_MAX_CHCK_SZ9"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_CHK_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x74++0x1
  line.word 0x0 "STBP_MAX_CHCK_SZ10"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_CHK_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x76++0x1
  line.word 0x0 "STBP_MAX_CHCK_SZ11"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_CHK_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x78++0x1
  line.word 0x0 "STBP_MAX_CHCK_SZ12"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_CHK_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x80++0x1
  line.word 0x0 "STBP_MAX_MSSG_SZ0"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_MSG_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x82++0x1
  line.word 0x0 "STBP_MAX_MSSG_SZ1"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_MSG_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x84++0x1
  line.word 0x0 "STBP_MAX_MSSG_SZ2"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_MSG_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x86++0x1
  line.word 0x0 "STBP_MAX_MSSG_SZ3"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_MSG_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x88++0x1
  line.word 0x0 "STBP_MAX_MSSG_SZ4"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_MSG_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x8A++0x1
  line.word 0x0 "STBP_MAX_MSSG_SZ5"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_MSG_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x8C++0x1
  line.word 0x0 "STBP_MAX_MSSG_SZ6"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_MSG_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x8E++0x1
  line.word 0x0 "STBP_MAX_MSSG_SZ7"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_MSG_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x90++0x1
  line.word 0x0 "STBP_MAX_MSSG_SZ8"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_MSG_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x92++0x1
  line.word 0x0 "STBP_MAX_MSSG_SZ9"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_MSG_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x94++0x1
  line.word 0x0 "STBP_MAX_MSSG_SZ10"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_MSG_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x96++0x1
  line.word 0x0 "STBP_MAX_MSSG_SZ11"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_MSG_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0x98++0x1
  line.word 0x0 "STBP_MAX_MSSG_SZ12"
    textline ""
    bitfld.word 0x0 0.--2. "    MAX_MSG_SZ  " "B_0x0,B_0x1,B_0x2,B_0x3,B_0x4,B_0x5,B_0x6,B_0x7"

  group.word 0xA0++0x1
  line.word 0x0 "STBP_PRIO_LEVEL0"
    textline ""
    hexmask.word 0x0 0.--10. 1 "    FIXED_PRIO  "
    textline ""
    hexmask.word 0x0 11.--13. 1 "    DYNAMIC_PRIO  "

  group.word 0xA2++0x1
  line.word 0x0 "STBP_PRIO_LEVEL1"
    textline ""
    hexmask.word 0x0 0.--10. 1 "    FIXED_PRIO  "
    textline ""
    hexmask.word 0x0 11.--13. 1 "    DYNAMIC_PRIO  "

  group.word 0xA4++0x1
  line.word 0x0 "STBP_PRIO_LEVEL2"
    textline ""
    hexmask.word 0x0 0.--10. 1 "    FIXED_PRIO  "
    textline ""
    hexmask.word 0x0 11.--13. 1 "    DYNAMIC_PRIO  "

  group.word 0xA6++0x1
  line.word 0x0 "STBP_PRIO_LEVEL3"
    textline ""
    hexmask.word 0x0 0.--10. 1 "    FIXED_PRIO  "
    textline ""
    hexmask.word 0x0 11.--13. 1 "    DYNAMIC_PRIO  "

  group.word 0xA8++0x1
  line.word 0x0 "STBP_PRIO_LEVEL4"
    textline ""
    hexmask.word 0x0 0.--10. 1 "    FIXED_PRIO  "
    textline ""
    hexmask.word 0x0 11.--13. 1 "    DYNAMIC_PRIO  "

  group.word 0xAA++0x1
  line.word 0x0 "STBP_PRIO_LEVEL5"
    textline ""
    hexmask.word 0x0 0.--10. 1 "    FIXED_PRIO  "
    textline ""
    hexmask.word 0x0 11.--13. 1 "    DYNAMIC_PRIO  "

  group.word 0xAC++0x1
  line.word 0x0 "STBP_PRIO_LEVEL6"
    textline ""
    hexmask.word 0x0 0.--10. 1 "    FIXED_PRIO  "
    textline ""
    hexmask.word 0x0 11.--13. 1 "    DYNAMIC_PRIO  "

  group.word 0xAE++0x1
  line.word 0x0 "STBP_PRIO_LEVEL7"
    textline ""
    hexmask.word 0x0 0.--10. 1 "    FIXED_PRIO  "
    textline ""
    hexmask.word 0x0 11.--13. 1 "    DYNAMIC_PRIO  "

  group.word 0xB0++0x1
  line.word 0x0 "STBP_PRIO_LEVEL8"
    textline ""
    hexmask.word 0x0 0.--10. 1 "    FIXED_PRIO  "
    textline ""
    hexmask.word 0x0 11.--13. 1 "    DYNAMIC_PRIO  "

  group.word 0xB2++0x1
  line.word 0x0 "STBP_PRIO_LEVEL9"
    textline ""
    hexmask.word 0x0 0.--10. 1 "    FIXED_PRIO  "
    textline ""
    hexmask.word 0x0 11.--13. 1 "    DYNAMIC_PRIO  "

  group.word 0xB4++0x1
  line.word 0x0 "STBP_PRIO_LEVEL10"
    textline ""
    hexmask.word 0x0 0.--10. 1 "    FIXED_PRIO  "
    textline ""
    hexmask.word 0x0 11.--13. 1 "    DYNAMIC_PRIO  "

  group.word 0xB6++0x1
  line.word 0x0 "STBP_PRIO_LEVEL11"
    textline ""
    hexmask.word 0x0 0.--10. 1 "    FIXED_PRIO  "
    textline ""
    hexmask.word 0x0 11.--13. 1 "    DYNAMIC_PRIO  "

  group.word 0xB8++0x1
  line.word 0x0 "STBP_PRIO_LEVEL12"
    textline ""
    hexmask.word 0x0 0.--10. 1 "    FIXED_PRIO  "
    textline ""
    hexmask.word 0x0 11.--13. 1 "    DYNAMIC_PRIO  "

  group.word 0xC0++0x1
  line.word 0x0 "STBP_PROCESS_EN"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 6. "    IRP03_GCF_L_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 8. "    IRP03_VCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 9. "    IRP03_HCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 10. "    IRP03_HCP_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 12. "    IRP0_PRA_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "B_0x0,B_0x1"

  group.word 0xC2++0x1
  line.word 0x0 "STBP_PORT_CTRL"
    textline ""
    bitfld.word 0x0 0. "    IRP03_L_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 1. "    IRP03_C_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 2. "    IRP03_C1_W  " "0,1"
    textline ""
    bitfld.word 0x0 3. "    IRP03_C2_W  " "0,1"
    textline ""
    bitfld.word 0x0 4. "    IRP03_GCF_L_W  " "0,1"
    textline ""
    bitfld.word 0x0 5. "    IRP03_GCF_C_W  " "0,1"
    textline ""
    bitfld.word 0x0 6. "    IRP03_GCF_L_R  " "0,1"
    textline ""
    bitfld.word 0x0 7. "    IRP03_GCF_C_R  " "0,1"
    textline ""
    bitfld.word 0x0 8. "    IRP03_VCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 9. "    IRP03_HCP_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 10. "    IRP03_HCP_R  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 11. "    IRP03_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 12. "    IRP0_PRA_R  " "0,1"
    textline ""
    bitfld.word 0x0 13. "    IRP1_PRA_W  " "0,1"
    textline ""
    bitfld.word 0x0 14. "    IRP2_PRA_W  " "B_0x0,B_0x1"
    textline ""
    bitfld.word 0x0 15. "    IRP3_JPG_W  " "0,1"

  group.word 0xD0++0x1
  line.word 0x0 "STBP_ERR_ITS"
    textline ""
    bitfld.word 0x0 0. "    ERR  " "B_0x0,B_0x1"

  group.word 0xD2++0x1
  line.word 0x0 "STBP_ERR_ITS_BSET"
    textline ""
    bitfld.word 0x0 0. "    ERR  " "0,1"

  group.word 0xD4++0x1
  line.word 0x0 "STBP_ERR_ITS_BCLR"
    textline ""
    bitfld.word 0x0 0. "    ERR  " "0,1"

  group.word 0xD6++0x1
  line.word 0x0 "STBP_ERR_ITM"
    textline ""
    bitfld.word 0x0 0. "    ERR  " "B_0x0,B_0x1"

  group.word 0xD8++0x1
  line.word 0x0 "STBP_ERR_ITM_BSET"
    textline ""
    bitfld.word 0x0 0. "    ERR  " "0,1"

  group.word 0xDA++0x1
  line.word 0x0 "STBP_ERR_ITM_BCLR"
    textline ""
    bitfld.word 0x0 0. "    ERR  " "0,1"

  group.word 0xDC++0x1
  line.word 0x0 "STBP_ERR_INFO"
    textline ""
    hexmask.word 0x0 0.--7. 1 "    R_OPC  "
    textline ""
    hexmask.word 0x0 8.--15. 1 "    R_SRC  "

  group.word 0xDE++0x1
  line.word 0x0 "STBP_ERR_INFO_CLR"
    textline ""
    bitfld.word 0x0 0. "    CLR  " "B_0x0,B_0x1"

tree.end


;end include file stbp.h
